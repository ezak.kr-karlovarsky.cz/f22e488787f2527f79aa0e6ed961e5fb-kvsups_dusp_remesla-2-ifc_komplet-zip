Properties of the parts of a building model (IFC4), part 7 of 9

# IfcDistributionPort (2266)
Name | PredefinedType | SystemType
Port_1066213_1 | CABLE | DATA
Port_1066239_1 | CABLE | DATA
Port_1066240_1 | CABLE | DATA
Port_1066241_1 | CABLE | DATA
Port_1066253_1 | CABLE | DATA
Port_1066254_1 | CABLE | DATA
Port_1066255_1 | CABLE | DATA
Port_1066267_1 | CABLE | DATA
Port_1066268_1 | CABLE | DATA
Port_1066269_1 | CABLE | DATA
Port_1066281_1 | CABLE | DATA
Port_1066282_1 | CABLE | DATA
Port_1066283_1 | CABLE | DATA
Port_1066295_1 | CABLE | DATA
Port_1066296_1 | CABLE | DATA
Port_1066297_1 | CABLE | DATA
Port_1066309_1 | CABLE | DATA
Port_1066310_1 | CABLE | DATA
Port_1066311_1 | CABLE | DATA
Port_1066337_1 | CABLE | DATA
Port_1066338_1 | CABLE | DATA
Port_1066339_1 | CABLE | DATA
Port_1066351_1 | CABLE | DATA
Port_1066352_1 | CABLE | DATA
Port_1066353_1 | CABLE | DATA
Port_1066365_1 | CABLE | DATA
Port_1066366_1 | CABLE | DATA
Port_1066367_1 | CABLE | DATA
Port_1066437_1 | CABLE | DATA
Port_1066438_1 | CABLE | DATA
Port_1066480_1 | CABLE | DATA
Port_1066481_1 | CABLE | DATA
Port_1066541_1 | CABLE | DATA
Port_1066542_1 | CABLE | DATA
Port_1070405_1 | CABLE | DATA
Port_1070406_1 | CABLE | DATA
Port_1070407_1 | CABLE | DATA
Port_1070524_1 | CABLE | DATA
Port_1070525_1 | CABLE | DATA
Port_1070535_1 | CABLE | DATA
Port_1070536_1 | CABLE | DATA
Port_1070551_1 | CABLE | DATA
Port_1070552_1 | CABLE | DATA
Port_1070597_1 | CABLE | DATA
Port_1070598_1 | CABLE | DATA
Port_1070599_1 | CABLE | DATA
Port_1079112_1 | CABLE | VENTILATION
Port_1079116_1 | CABLE | VENTILATION
Port_1079143_1 | CABLE | VENTILATION
Port_1079144_1 | CABLE | VENTILATION
Port_1079152_1 | CABLE | VENTILATION
Port_1079153_1 | CABLE | VENTILATION
Port_1079163_1 | CABLE | VENTILATION
Port_1079164_1 | CABLE | VENTILATION
Port_1079172_1 | CABLE | VENTILATION
Port_1079173_1 | CABLE | VENTILATION
Port_1079181_1 | CABLE | VENTILATION
Port_1079182_1 | CABLE | VENTILATION
Port_1079192_1 | CABLE | VENTILATION
Port_1079193_1 | CABLE | VENTILATION
Port_1079819_1 | CABLE | VENTILATION
Port_1079823_1 | CABLE | VENTILATION
Port_1079827_1 | CABLE | VENTILATION
Port_1079831_1 | CABLE | VENTILATION
Port_1079835_1 | CABLE | VENTILATION
Port_1079839_1 | CABLE | VENTILATION
Port_1079843_1 | CABLE | VENTILATION
Port_1079847_1 | CABLE | VENTILATION
Port_1079851_1 | CABLE | VENTILATION
Port_1079855_1 | CABLE | VENTILATION
Port_1079983_1 | CABLE | DATA
Port_1079984_1 | CABLE | DATA
Port_1080019_1 | CABLE | DATA
Port_1080020_1 | CABLE | DATA
Port_1080030_1 | CABLE | DATA
Port_1080031_1 | CABLE | DATA
Port_1080041_1 | CABLE | DATA
Port_1080042_1 | CABLE | DATA
Port_1080052_1 | CABLE | DATA
Port_1080053_1 | CABLE | DATA
Port_1080072_1 | CABLE | DATA
Port_1080073_1 | CABLE | DATA
Port_1080124_1 | CABLE | DATA
Port_1080125_1 | CABLE | DATA
Port_1080157_1 | CABLE | DATA
Port_1080158_1 | CABLE | DATA
Port_1080278_1 | CABLE | DATA
Port_1080279_1 | CABLE | DATA
Port_1080316_1 | CABLE | DATA
Port_1080317_1 | CABLE | DATA
Port_1080330_1 | CABLE | DATA
Port_1080331_1 | CABLE | DATA
Port_1080548_1 | CABLE | VENTILATION
Port_1080552_1 | CABLE | VENTILATION
Port_1080556_1 | CABLE | VENTILATION
Port_1080560_1 | CABLE | VENTILATION
Port_1080564_1 | CABLE | VENTILATION
Port_1080568_1 | CABLE | VENTILATION
Port_1080578_1 | CABLE | VENTILATION
Port_1080582_1 | CABLE | VENTILATION
Port_1080725_1 | CABLE | VENTILATION
Port_1080729_1 | CABLE | VENTILATION
Port_1080733_1 | CABLE | VENTILATION
Port_1080737_1 | CABLE | VENTILATION
Port_1080741_1 | CABLE | VENTILATION
Port_1080745_1 | CABLE | VENTILATION
Port_1080749_1 | CABLE | VENTILATION
Port_1080753_1 | CABLE | VENTILATION
Port_1080757_1 | CABLE | VENTILATION
Port_1080761_1 | CABLE | VENTILATION
Port_1080765_1 | CABLE | VENTILATION
Port_1080769_1 | CABLE | VENTILATION
Port_1081399_0 | CABLECARRIER | CONVEYING
Port_1081399_1 | CABLECARRIER | CONVEYING
Port_1081407_0 | CABLECARRIER | CONVEYING
Port_1081407_1 | CABLECARRIER | CONVEYING
Port_1081415_0 | CABLECARRIER | CONVEYING
Port_1081415_1 | CABLECARRIER | CONVEYING
Port_1081423_0 | CABLECARRIER | CONVEYING
Port_1081423_1 | CABLECARRIER | CONVEYING
Port_1081663_1 | CABLE | DATA
Port_1081688_1 | CABLE | DATA
Port_1081695_1 | CABLE | DATA
Port_1081702_1 | CABLE | DATA
Port_1081708_1 | CABLE | DATA
Port_1081714_1 | CABLE | DATA
Port_1081720_1 | CABLE | DATA
Port_1081726_1 | CABLE | DATA
Port_1081732_1 | CABLE | DATA
Port_1081755_1 | CABLE | DATA
Port_1081762_1 | CABLE | DATA
Port_1081791_1 | CABLE | DATA
Port_1081798_1 | CABLE | DATA
Port_1081822_1 | CABLE | DATA
Port_1081829_1 | CABLE | DATA
Port_1081836_1 | CABLE | DATA
Port_1081842_1 | CABLE | DATA
Port_1081848_1 | CABLE | DATA
Port_1081854_1 | CABLE | DATA
Port_1081860_1 | CABLE | DATA
Port_1081885_0 | CABLECARRIER | CONVEYING
Port_1081885_1 | CABLECARRIER | CONVEYING
Port_1082060_0 | CABLECARRIER | CONVEYING
Port_1096353_2 | CABLECARRIER | CONVEYING
Port_1082060_1 | CABLECARRIER | CONVEYING
Port_1090682_1 | CABLECARRIER | CONVEYING
Port_1082093_1 | CABLE | DATA
Port_1082114_1 | CABLE | DATA
Port_1082121_1 | CABLE | DATA
Port_1082128_1 | CABLE | DATA
Port_1082193_0 | CABLECARRIER | CONVEYING
Port_1090454_1 | CABLECARRIER | CONVEYING
Port_1082193_1 | CABLECARRIER | CONVEYING
Port_1082315_1 | CABLE | DATA
Port_1082344_1 | CABLE | DATA
Port_1089182_1 | CABLE | SECURITY
Port_1089190_1 | CABLE | SECURITY
Port_1089212_1 | CABLE | SECURITY
Port_1089212_2 | CABLE | ELECTRICAL
Port_1089220_1 | CABLE | SECURITY
Port_1089220_2 | CABLE | ELECTRICAL
Port_1089264_1 | CABLE | SECURITY
Port_1089273_1 | CABLE | SECURITY
Port_1089296_1 | CABLE | SECURITY
Port_1089296_2 | CABLE | ELECTRICAL
Port_1089296_3 | CABLE | DATA
Port_1089405_1 | CABLE | SECURITY
Port_1089405_2 | CABLE | ELECTRICAL
Port_1089405_3 | CABLE | DATA
Port_1089439_1 | CABLE | DATA
Port_1089439_2 | CABLE | ELECTRICAL
Port_1089471_1 | CABLE | SECURITY
Port_1089471_2 | CABLE | ELECTRICAL
Port_1089472_1 | CABLE | SECURITY
Port_1089508_1 | CABLE | DATA
Port_1089508_2 | CABLE | ELECTRICAL
Port_1089534_1 | CABLE | SECURITY
Port_1089555_1 | CABLE | DATA
Port_1089555_2 | CABLE | ELECTRICAL
Port_1089800_1 | CABLE | SECURITY
Port_1089926_1 | CABLE | SECURITY
Port_1089926_2 | CABLE | ELECTRICAL
Port_1089927_1 | CABLE | SECURITY
Port_1089927_2 | CABLE | ELECTRICAL
Port_1089928_1 | CABLE | SECURITY
Port_1089928_2 | CABLE | ELECTRICAL
Port_1089929_1 | CABLE | SECURITY
Port_1089929_2 | CABLE | ELECTRICAL
Port_1089930_1 | CABLE | SECURITY
Port_1089930_2 | CABLE | ELECTRICAL
Port_1089931_1 | CABLE | SECURITY
Port_1089931_2 | CABLE | ELECTRICAL
Port_1090040_1 | CABLE | SECURITY
Port_1090040_2 | CABLE | ELECTRICAL
Port_1090041_1 | CABLE | SECURITY
Port_1090043_1 | CABLE | SECURITY
Port_1090044_1 | CABLE | SECURITY
Port_1090053_1 | CABLE | SECURITY
Port_1090053_2 | CABLE | ELECTRICAL
Port_1090054_1 | CABLE | SECURITY
Port_1090055_1 | CABLE | SECURITY
Port_1090056_1 | CABLE | SECURITY
Port_1090102_1 | CABLE | SECURITY
Port_1090102_2 | CABLE | ELECTRICAL
Port_1090103_1 | CABLE | SECURITY
Port_1090103_2 | CABLE | ELECTRICAL
Port_1090104_1 | CABLE | SECURITY
Port_1090105_1 | CABLE | SECURITY
Port_1090106_1 | CABLE | SECURITY
Port_1090454_2 | CABLECARRIER | CONVEYING
Port_1090568_0 | CABLECARRIER | CONVEYING
Port_1090682_2 | CABLECARRIER | CONVEYING
Port_1090568_1 | CABLECARRIER | CONVEYING
Port_1090731_1 | CABLE | DATA
Port_1090738_1 | CABLE | DATA
Port_1090783_1 | CABLE | SECURITY
Port_1090783_2 | CABLE | ELECTRICAL
Port_1090784_1 | CABLE | SECURITY
Port_1090785_1 | CABLE | SECURITY
Port_1090786_1 | CABLE | SECURITY
Port_1090817_1 | CABLE | SECURITY
Port_1090817_2 | CABLE | ELECTRICAL
Port_1090818_1 | CABLE | SECURITY
Port_1090819_1 | CABLE | SECURITY
Port_1090841_1 | CABLE | SECURITY
Port_1090841_2 | CABLE | ELECTRICAL
Port_1090842_1 | CABLE | SECURITY
Port_1090843_1 | CABLE | SECURITY
Port_1090872_1 | CABLE | SECURITY
Port_1090872_2 | CABLE | ELECTRICAL
Port_1090873_1 | CABLE | SECURITY
Port_1090874_1 | CABLE | SECURITY
Port_1090875_1 | CABLE | SECURITY
Port_1090906_1 | CABLECARRIER | CONVEYING
Port_1090906_2 | CABLECARRIER | CONVEYING
Port_1090906_3 | CABLECARRIER | CONVEYING
Port_1090908_1 | CABLE | SECURITY
Port_1090908_2 | CABLE | ELECTRICAL
Port_1090909_1 | CABLE | SECURITY
Port_1090910_1 | CABLE | SECURITY
Port_1090928_1 | CABLE | SECURITY
Port_1090972_1 | CABLE | SECURITY
Port_1090972_2 | CABLE | ELECTRICAL
Port_1090973_1 | CABLE | SECURITY
Port_1090974_1 | CABLE | SECURITY
Port_1090983_1 | CABLE | SECURITY
Port_1090983_2 | CABLE | ELECTRICAL
Port_1090984_1 | CABLE | SECURITY
Port_1090985_1 | CABLE | SECURITY
Port_1091073_1 | CABLE | DATA
Port_1091106_1 | CABLE | DATA
Port_1091113_1 | CABLE | DATA
Port_1091119_1 | CABLE | DATA
Port_1091125_1 | CABLE | DATA
Port_1091131_1 | CABLE | DATA
Port_1091137_1 | CABLE | DATA
Port_1091143_1 | CABLE | DATA
Port_1091149_1 | CABLE | DATA
Port_1091155_1 | CABLE | DATA
Port_1091172_1 | CABLE | SECURITY
Port_1091201_1 | CABLE | SECURITY
Port_1091226_1 | CABLE | SECURITY
Port_1091241_1 | CABLE | SECURITY
Port_1091241_2 | CABLE | ELECTRICAL
Port_1091272_1 | CABLE | SECURITY
Port_1091292_1 | CABLE | SECURITY
Port_1091355_1 | CABLE | DATA
Port_1091380_1 | CABLE | DATA
Port_1091423_1 | CABLE | SECURITY
Port_1091445_1 | CABLE | SECURITY
Port_1091490_1 | CABLE | SECURITY
Port_1091490_2 | CABLE | ELECTRICAL
Port_1091523_1 | CABLE | SECURITY
Port_1091523_2 | CABLE | ELECTRICAL
Port_1091524_1 | CABLE | SECURITY
Port_1091526_1 | CABLE | SECURITY
Port_1091527_1 | CABLE | SECURITY
Port_1091536_1 | CABLE | SECURITY
Port_1091536_2 | CABLE | ELECTRICAL
Port_1091537_1 | CABLE | SECURITY
Port_1091538_1 | CABLE | SECURITY
Port_1091548_1 | CABLE | SECURITY
Port_1091548_2 | CABLE | ELECTRICAL
Port_1091549_1 | CABLE | SECURITY
Port_1091550_1 | CABLE | SECURITY
Port_1091551_1 | CABLE | SECURITY
Port_1096352_0 | CABLECARRIER | CONVEYING
Port_1096352_1 | CABLECARRIER | CONVEYING
Port_1096353_1 | CABLECARRIER | CONVEYING
Port_1144959_6 | CABLE | DATA
Port_1144959_7 | CABLE | ELECTRICAL
Port_1157577_2 | CABLECARRIER | CONVEYING
Port_1157578_1 | CABLECARRIER | CONVEYING
Port_1159667_1 | CABLECARRIER | CONVEYING
Port_1160226_2 | CABLECARRIER | CONVEYING
Port_1160227_1 | CABLECARRIER | CONVEYING
Port_1160237_2 | CABLECARRIER | CONVEYING
Port_1160238_1 | CABLECARRIER | CONVEYING
Port_1161882_1 | CABLECARRIER | CONVEYING
Port_1162737_1 | CABLECARRIER | CONVEYING
Port_1163578_0 | CABLECARRIER | CONVEYING
Port_1163578_1 | CABLECARRIER | CONVEYING
Port_1166112_1 | CABLECARRIER | CONVEYING
Port_1166428_1 | CABLECARRIER | CONVEYING
Port_1168678_1 | CABLECARRIER | CONVEYING
Port_1168710_1 | CABLECARRIER | CONVEYING
Port_1169422_1 | CABLECARRIER | CONVEYING
Port_1172274_1 | CABLECARRIER | CONVEYING
Port_1172320_1 | CABLECARRIER | CONVEYING
Port_1173050_1 | CABLECARRIER | CONVEYING
Port_1173566_1 | CABLECARRIER | CONVEYING
Port_1173834_0 | CABLECARRIER | CONVEYING
Port_1173834_1 | CABLECARRIER | CONVEYING
Port_1174265_1 | CABLECARRIER | CONVEYING
Port_1174627_1 | CABLECARRIER | CONVEYING
Port_1175483_1 | CABLECARRIER | CONVEYING
Port_1175861_1 | CABLECARRIER | CONVEYING
Port_1177337_1 | CABLECARRIER | CONVEYING
Port_1178077_1 | CABLECARRIER | CONVEYING

# IfcElectricAppliance: Datová zásuvka RJ45.CC:Dvojzásuvka (12)
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - DÉLKA: 20 mm; ŠÍŘKA: 80 mm; VÝŠKA: 80 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZZ03; Komentáře k typům: Datová dvojzásuvka, RJ 45; Model: Model; Název typu: Dvojzásuvka; Označení typu: 05; Popis: Zásuvka; Popis sestavy: Datová; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - Kategorie: Datová zařízení; d: -20 mm; l2: -28 mm; -l2: 28 mm; Název rodiny: Datová zásuvka RJ45.CC; R: 5 mm; Symbol: Datová dvojzásuvka 2x RJ45.CC
Classification: ZZ03 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Vazby - Podlaží: 1.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000147409 m3
Jiné - Rodina: Datová zásuvka RJ45.CC; Id typu: 286800; Rodina a typ: Datová zásuvka RJ45.CC: Dvojzásuvka; Typ: Dvojzásuvka; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
Name (Datová zásuvka RJ45.CC:Dvojzásuvka:...) | ID_import | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
971058 | 971058 | Podlaží : 1.NP_SO-102 | 1200 | ZZ03.05.0146 | 0146
971062 | 971062 | Podlaží : 1.NP_SO-102 | 1200 | ZZ03.05.0147 | 0147
971066 | 971066 | Podlaží : 1.NP_SO-102 | 1200 | ZZ03.05.0148 | 0148
971070 | 971070 | Podlaží : 1.NP_SO-102 | 1200 | ZZ03.05.0149 | 0149
971080 | 971080 | Kabelová lávka s tvarovkami : Parapetní žlab | 500 | ZZ03.05.0150 | 0150
971084 | 971084 | Kabelová lávka s tvarovkami : Parapetní žlab | 500 | ZZ03.05.0151 | 0151
971090 | 971090 | Podlaží : 1.NP_SO-102 | 500 | ZZ03.05.0152 | 0152
971096 | 971096 | Kabelová lávka s tvarovkami : Parapetní žlab | 500 | ZZ03.05.0153 | 0153
971106 | 971106 | Podlaží : 1.NP_SO-102 | 1200 | ZZ03.05.0154 | 0154
971110 | 971110 | Podlaží : 1.NP_SO-102 | 1200 | ZZ03.05.0155 | 0155
971122 | 971122 | Podlaží : 1.NP_SO-102 | 1200 | ZZ03.05.0156 | 0156
971128 | 971128 | Kabelová lávka s tvarovkami : Parapetní žlab | 1200 | ZZ03.05.0157 | 0157

# IfcElectricAppliance: Datová zásuvka RJ45.CC:Jednozásuvka (122)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - DÉLKA: 20 mm; ŠÍŘKA: 80 mm; VÝŠKA: 80 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZZ03; Komentáře k typům: Datová jednozásuvka, RJ 45; Model: Model; Název typu: Jednozásuvka; Označení typu: 01; Popis: Zásuvka; Popis sestavy: Datová; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - Kategorie: Datová zařízení; d: -20 mm; l2: -28 mm; -l2: 28 mm; Název rodiny: Datová zásuvka RJ45.CC; R: 5 mm; Symbol: Datová jednozásuvka 1x RJ45.CC
Classification: ZZ03 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000147409 m3
Jiné - Id typu: 286798; Rodina: Datová zásuvka RJ45.CC; Rodina a typ: Datová zásuvka RJ45.CC: Jednozásuvka; Typ: Jednozásuvka; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
Name (Datová zásuvka RJ45.CC:Jednozásuvka:...) | In | ID_import | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
965530 | -2.PP_SO-102 | 965530 | 0 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | Fáze 1 | ZZ03.01.0001 | 0001
965534 | -2.PP_SO-102 | 965534 | 0 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | Fáze 1 | ZZ03.01.0002 | 0002
965538 | -2.PP_SO-102 | 965538 | 0 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | Fáze 1 | ZZ03.01.0003 | 0003
965542 | -2.PP_SO-102 | 965542 | 0 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | Fáze 1 | ZZ03.01.0004 | 0004
965546 | -2.PP_SO-102 | 965546 | 0 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | Fáze 1 | ZZ03.01.0005 | 0005
965550 | -2.PP_SO-102 | 965550 | 0 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | Fáze 1 | ZZ03.01.0006 | 0006
965554 | -2.PP_SO-102 | 965554 | 0 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | Fáze 1 | ZZ03.01.0007 | 0007
965558 | -2.PP_SO-102 | 965558 | 0 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | Fáze 1 | ZZ03.01.0008 | 0008
965562 | -2.PP_SO-102 | 965562 | 0 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | Fáze 1 | ZZ03.01.0009 | 0009
966833 | -1.PP_SO-102 | 966833 | 2500 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZZ03.01.0011 | 0011
966852 | -1.PP_SO-102 | 966852 | 2500 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZZ03.01.0013 | 0013
966863 | -1.PP_SO-102 | 966863 | 2500 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZZ03.01.0015 | 0015
966872 | -1.PP_SO-102 | 966872 | 2500 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZZ03.01.0017 | 0017
966883 | -1.PP_SO-102 | 966883 | 2500 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZZ03.01.0019 | 0019
966902 | -1.PP_SO-102 | 966902 | 2500 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | ZZ03.01.0021 | 0021
966923 | -1.PP_SO-102 | 966923 | 2500 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZZ03.01.0023 | 0023
966953 | -1.PP_SO-102 | 966953 | 2500 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZZ03.01.0025 | 0025
966962 | -1.PP_SO-102 | 966962 | 2500 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZZ03.01.0027 | 0027
966982 | 1.NP_SO-102 | 966982 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.01.0029 | 0029
967007 | 1.NP_SO-102 | 967007 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.01.0031 | 0031
967016 | 1.NP_SO-102 | 967016 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.01.0033 | 0033
967029 | 1.NP_SO-102 | 967029 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.01.0035 | 0035
967038 | 1.NP_SO-102 | 967038 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.01.0037 | 0037
967049 | 1.NP_SO-102 | 967049 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.01.0039 | 0039
967060 | 1.NP_SO-102 | 967060 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.01.0041 | 0041
967071 | 1.NP_SO-102 | 967071 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.01.0043 | 0043
967082 | 1.NP_SO-102 | 967082 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.01.0045 | 0045
967093 | 1.NP_SO-102 | 967093 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.01.0047 | 0047
967102 | 1.NP_SO-102 | 967102 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.01.0049 | 0049
967115 | 1.NP_SO-102 | 967115 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.01.0051 | 0051
967124 | 1.NP_SO-102 | 967124 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.01.0053 | 0053
967133 | 1.NP_SO-102 | 967133 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.01.0055 | 0055
967142 | 1.NP_SO-102 | 967142 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.01.0057 | 0057
967151 | 1.NP_SO-102 | 967151 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.01.0059 | 0059
967160 | 1.NP_SO-102 | 967160 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.01.0061 | 0061
967171 | 1.NP_SO-102 | 967171 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.01.0063 | 0063
967935 | 1.NP_SO-102 | 967935 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.01.0127 | 0127
992619 | 2.NP_SO-102 | 992619 | 2500 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.01.0296 | 0296
992627 | 2.NP_SO-102 | 992627 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.01.0298 | 0298
992667 | 2.NP_SO-102 | 992667 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.01.0300 | 0300
992678 | 2.NP_SO-102 | 992678 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.01.0302 | 0302
992689 | 2.NP_SO-102 | 992689 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.01.0304 | 0304
992702 | 2.NP_SO-102 | 992702 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.01.0306 | 0306
992740 | 2.NP_SO-102 | 992740 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.01.0308 | 0308
992749 | 2.NP_SO-102 | 992749 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.01.0310 | 0310
992760 | 2.NP_SO-102 | 992760 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.01.0312 | 0312
992769 | 2.NP_SO-102 | 992769 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.01.0314 | 0314
992778 | 2.NP_SO-102 | 992778 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.01.0316 | 0316
992787 | 2.NP_SO-102 | 992787 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.01.0318 | 0318
992798 | 2.NP_SO-102 | 992798 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.01.0320 | 0320
992814 | 2.NP_SO-102 | 992814 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.01.0322 | 0322
992816 | 2.NP_SO-102 | 992816 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.01.0324 | 0324
992818 | 2.NP_SO-102 | 992818 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.01.0326 | 0326
992846 | 2.NP_SO-102 | 992846 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.01.0328 | 0328
992855 | 2.NP_SO-102 | 992855 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.01.0330 | 0330
992882 | 2.NP_SO-102 | 992882 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.01.0332 | 0332
992904 | 2.NP_SO-102 | 992904 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.01.0334 | 0334
993062 | 2.NP_SO-102 | 993062 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.01.0337 | 0337
993077 | 2.NP_SO-102 | 993077 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.01.0339 | 0339
993086 | 2.NP_SO-102 | 993086 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.01.0341 | 0341
993095 | 2.NP_SO-102 | 993095 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.01.0343 | 0343
993104 | 2.NP_SO-102 | 993104 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.01.0345 | 0345
993117 | 2.NP_SO-102 | 993117 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.01.0347 | 0347
993126 | 2.NP_SO-102 | 993126 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.01.0349 | 0349
997190 | 3.NP_SO-102 | 997190 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.01.0391 | 0391
997198 | 4.NP_SO-102 | 997198 | 3000 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.01.0393 | 0393
998167 | -1.PP_SO-102 | 998167 | 2500 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZZ03.01.0398 | 0398
998204 | -1.PP_SO-102 | 998204 | 2500 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZZ03.01.0399 | 0399
998214 | -1.PP_SO-102 | 998214 | 2500 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZZ03.01.0400 | 0400
998242 | -1.PP_SO-102 | 998242 | 2500 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZZ03.01.0401 | 0401
998252 | -1.PP_SO-102 | 998252 | 2500 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZZ03.01.0402 | 0402
998260 | -1.PP_SO-102 | 998260 | 2500 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | ZZ03.01.0403 | 0403
998272 | -1.PP_SO-102 | 998272 | 2500 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | ZZ03.01.0404 | 0404
999345 | 1.NP_SO-102 | 999345 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.01.0412 | 0412
1006771 | 3.NP_SO-102 | 1006771 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.01.0830 | 0830
1006779 | 4.NP_SO-102 | 1006779 | 3000 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.01.0832 | 0832
1006798 | 3.NP_SO-102 | 1006798 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.01.0834 | 0834
1006823 | 4.NP_SO-102 | 1006823 | 3000 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.01.0836 | 0836
1006838 | 3.NP_SO-102 | 1006838 | 2500 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.01.0838 | 0838
1006840 | 3.NP_SO-102 | 1006840 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.01.0840 | 0840
1006842 | 3.NP_SO-102 | 1006842 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.01.0842 | 0842
1006844 | 3.NP_SO-102 | 1006844 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.01.0844 | 0844
1006846 | 3.NP_SO-102 | 1006846 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.01.0846 | 0846
1006848 | 3.NP_SO-102 | 1006848 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.01.0848 | 0848
1006850 | 3.NP_SO-102 | 1006850 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.01.0850 | 0850
1006858 | 4.NP_SO-102 | 1006858 | 2500 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.01.0852 | 0852
1006860 | 4.NP_SO-102 | 1006860 | 3000 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.01.0854 | 0854
1006862 | 4.NP_SO-102 | 1006862 | 3000 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.01.0856 | 0856
1006864 | 4.NP_SO-102 | 1006864 | 3000 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.01.0858 | 0858
1006866 | 4.NP_SO-102 | 1006866 | 3000 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.01.0860 | 0860
1006868 | 4.NP_SO-102 | 1006868 | 3000 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.01.0862 | 0862
1006870 | 4.NP_SO-102 | 1006870 | 3000 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.01.0864 | 0864
1006884 | 3.NP_SO-102 | 1006884 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.01.0866 | 0866
1006899 | 3.NP_SO-102 | 1006899 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.01.0868 | 0868
1006910 | 3.NP_SO-102 | 1006910 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.01.0870 | 0870
1006921 | 3.NP_SO-102 | 1006921 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.01.0872 | 0872
1006932 | 3.NP_SO-102 | 1006932 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.01.0874 | 0874
1006942 | 3.NP_SO-102 | 1006942 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.01.0876 | 0876
1006979 | 3.NP_SO-102 | 1006979 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.01.0878 | 0878
1006992 | 3.NP_SO-102 | 1006992 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.01.0880 | 0880
1007003 | 3.NP_SO-102 | 1007003 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.01.0882 | 0882
1008542 | 4.NP_SO-102 | 1008542 | 3000 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.01.0915 | 0915
1008559 | 4.NP_SO-102 | 1008559 | 3000 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.01.0917 | 0917
1008568 | 4.NP_SO-102 | 1008568 | 3000 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.01.0919 | 0919
1008577 | 4.NP_SO-102 | 1008577 | 3000 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.01.0921 | 0921
1008596 | 4.NP_SO-102 | 1008596 | 3000 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.01.0923 | 0923
1008609 | 4.NP_SO-102 | 1008609 | 3000 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.01.0925 | 0925
1008618 | 4.NP_SO-102 | 1008618 | 3000 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.01.0927 | 0927
1009093 | 4.NP_SO-102 | 1009093 | 2500 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.01.0933 | 0933
1009106 | 4.NP_SO-102 | 1009106 | 2500 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.01.0935 | 0935
1028392 | -1.PP_SO-102 | 1028392 | 1500 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZZ03.01.0940 | 0940
1033187 | -1.PP_SO-102 | 1033187 | 2500 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZZ03.01.0942 | 0942
1033224 | 1.NP_SO-102 | 1033224 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.01.0943 | 0943
1033236 | 1.NP_SO-102 | 1033236 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.01.0944 | 0944
1033248 | 1.NP_SO-102 | 1033248 | 2500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.01.0945 | 0945
1066438 | 3.NP_SO-102 | 1066438 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.01.1028 | 1028
1066481 | 3.NP_SO-102 | 1066481 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.01.1030 | 1030
1066542 | 3.NP_SO-102 | 1066542 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.01.1032 | 1032
1070525 | 3.NP_SO-102 | 1070525 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.01.1037 | 1037
1070536 | 3.NP_SO-102 | 1070536 | 3000 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.01.1039 | 1039
1091355 | 2.NP_SO-102 | 1091355 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.01.1108 | 1108
1091380 | 2.NP_SO-102 | 1091380 | 3000 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.01.1109 | 1109

# IfcElectricAppliance: Datová zásuvka do PK.CC:Dvojzásuvka 2x modul (46)
In: 1.NP_SO-102
Type - Material: Bílá
Type - Vazby - Výchozí výška: 1050 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Grafika - Dvojzásuvka: yes; Jednozásuvka: no; Typ symbolu: Datová dvojzásuvka 2x RJ45.CC
Type - Kóty - HLOUBKA: 10 mm; ŠÍŘKA: 45 mm; VÝŠKA: 45 mm
Type - Identifikační data - Číslo OmniClass: 23.85.50.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZZ03; Komentáře k typům: Datová zásuvka; Model: Model; Nadpis OmniClass: Communication and Data Processing Equipment; Název typu: Dvojzásuvka 2x modul; Označení typu: 04; Popis: Zásuvka; Popis sestavy: Datová; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Datová zařízení; Název rodiny: Datová zásuvka do PK.CC
Classification: ZZ03 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Vazby - Podlaží: 1.NP_SO-102; Vztažné podlaží: 1.NP_SO-102; Výška od podlaží: 1050 mm
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.00002025 m3
Jiné - Rodina: Datová zásuvka do PK.CC; Id typu: 318541; Rodina a typ: Datová zásuvka do PK.CC: Dvojzásuvka 2x modul; Typ: Dvojzásuvka 2x modul
Name (Datová zásuvka do PK.CC:Dvojzásuvka 2x modul:...) | ID_import | Hostitel | Fáze vytvoření | Kód prvku | Označení | UPRAVIL
967944 | 967944 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 2 | ZZ03.04.0128 | 0128 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
967951 | 967951 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 2 | ZZ03.04.0129 | 0129 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
967977 | 967977 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 2 | ZZ03.04.0130 | 0130 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
968078 | 968078 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 2 | ZZ03.04.0131 | 0131 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
968096 | 968096 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 2 | ZZ03.04.0132 | 0132 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
968136 | 968136 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 2 | ZZ03.04.0133 | 0133 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
968166 | 968166 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 1 | ZZ03.04.0134 | 0134 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
968405 | 968405 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 1 | ZZ03.04.0135 | 0135 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
968431 | 968431 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 1 | ZZ03.04.0136 | 0136 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
968482 | 968482 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 1 | ZZ03.04.0137 | 0137 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
968508 | 968508 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 1 | ZZ03.04.0138 | 0138 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
968552 | 968552 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 1 | ZZ03.04.0139 | 0139 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
968576 | 968576 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 1 | ZZ03.04.0140 | 0140 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
968645 | 968645 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 1 | ZZ03.04.0141 | 0141 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
968661 | 968661 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 1 | ZZ03.04.0142 | 0142 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
968704 | 968704 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 1 | ZZ03.04.0143 | 0143 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
968730 | 968730 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 1 | ZZ03.04.0144 | 0144 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
968895 | 968895 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 1 | ZZ03.04.0145 | 0145 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1081663 | 1081663 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 1 | ZZ03.04.1067 | 1067 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1081688 | 1081688 | <nepřiřazeno> | Fáze 1 | ZZ03.04.1068 | 1068 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1081695 | 1081695 | <nepřiřazeno> | Fáze 1 | ZZ03.04.1069 | 1069 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1081702 | 1081702 | <nepřiřazeno> | Fáze 1 | ZZ03.04.1070 | 1070 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1081708 | 1081708 | <nepřiřazeno> | Fáze 1 | ZZ03.04.1071 | 1071 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1081714 | 1081714 | <nepřiřazeno> | Fáze 1 | ZZ03.04.1072 | 1072 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1081720 | 1081720 | <nepřiřazeno> | Fáze 1 | ZZ03.04.1073 | 1073 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1081726 | 1081726 | <nepřiřazeno> | Fáze 1 | ZZ03.04.1074 | 1074 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1081732 | 1081732 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 1 | ZZ03.04.1075 | 1075 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1081755 | 1081755 | <nepřiřazeno> | Fáze 1 | ZZ03.04.1076 | 1076 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1081762 | 1081762 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 1 | ZZ03.04.1077 | 1077 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1081791 | 1081791 | <nepřiřazeno> | Fáze 1 | ZZ03.04.1078 | 1078 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1081798 | 1081798 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 1 | ZZ03.04.1079 | 1079 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1081822 | 1081822 | <nepřiřazeno> | Fáze 1 | ZZ03.04.1080 | 1080 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1081829 | 1081829 | <nepřiřazeno> | Fáze 1 | ZZ03.04.1081 | 1081 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1081836 | 1081836 | <nepřiřazeno> | Fáze 1 | ZZ03.04.1082 | 1082 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1081842 | 1081842 | <nepřiřazeno> | Fáze 1 | ZZ03.04.1083 | 1083 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1081848 | 1081848 | <nepřiřazeno> | Fáze 1 | ZZ03.04.1084 | 1084 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1081854 | 1081854 | <nepřiřazeno> | Fáze 1 | ZZ03.04.1085 | 1085 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1081860 | 1081860 | <nepřiřazeno> | Fáze 1 | ZZ03.04.1086 | 1086 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1082093 | 1082093 | Kabelová lávka s tvarovkami : Parapetní žlab | Fáze 1 | ZZ03.04.1087 | 1087 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1082114 | 1082114 | <nepřiřazeno> | Fáze 1 | ZZ03.04.1088 | 1088 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1082121 | 1082121 | <nepřiřazeno> | Fáze 1 | ZZ03.04.1089 | 1089 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1082128 | 1082128 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | Fáze 1 | ZZ03.04.1090 | 1090 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1082315 | 1082315 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | Fáze 1 | ZZ03.04.1091 | 1091 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1082344 | 1082344 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | Fáze 1 | ZZ03.04.1092 | 1092 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1090731 | 1090731 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | Fáze 1 | ZZ03.04.1096 | 1096 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1090738 | 1090738 | Osamocené | Fáze 1 | ZZ03.04.1097 | 1097 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16

# IfcElectricAppliance: Datová zásuvka do PK.CC:Jednozásuvka 1x modul (469)
Type - Material: Bílá
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Grafika - Dvojzásuvka: no; Jednozásuvka: yes; Typ symbolu: Datová jednozásuvka 1x RJ45.CC
Type - Kóty - HLOUBKA: 10 mm; ŠÍŘKA: 22.5 mm; VÝŠKA: 45 mm
Type - Identifikační data - Číslo OmniClass: 23.85.50.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZZ03; Komentáře k typům: Datová zásuvka; Model: Model; Nadpis OmniClass: Communication and Data Processing Equipment; Název typu: Jednozásuvka 1x modul; Označení typu: 03; Popis: Zásuvka; Popis sestavy: Datová; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Datová zařízení; Název rodiny: Datová zásuvka do PK.CC
Classification: ZZ03 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Vazby - Výška od podlaží: 0 mm
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.000010125 m3
Jiné - Id typu: 318548; Rodina: Datová zásuvka do PK.CC; Rodina a typ: Datová zásuvka do PK.CC: Jednozásuvka 1x modul; Typ: Jednozásuvka 1x modul; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
Name (Datová zásuvka do PK.CC:Jednozásuvka 1x modul:...) | In | ID_import | Podlaží = Vztažné podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
967433 | 1.NP_SO-102 | 967433 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0064 | 0064
967439 | 1.NP_SO-102 | 967439 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0065 | 0065
967445 | 1.NP_SO-102 | 967445 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0066 | 0066
967451 | 1.NP_SO-102 | 967451 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0067 | 0067
967457 | 1.NP_SO-102 | 967457 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0068 | 0068
967463 | 1.NP_SO-102 | 967463 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0069 | 0069
967469 | 1.NP_SO-102 | 967469 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0070 | 0070
967475 | 1.NP_SO-102 | 967475 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0071 | 0071
967481 | 1.NP_SO-102 | 967481 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0072 | 0072
967487 | 1.NP_SO-102 | 967487 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0073 | 0073
967493 | 1.NP_SO-102 | 967493 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0074 | 0074
967499 | 1.NP_SO-102 | 967499 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0075 | 0075
967505 | 1.NP_SO-102 | 967505 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0076 | 0076
967511 | 1.NP_SO-102 | 967511 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0077 | 0077
967517 | 1.NP_SO-102 | 967517 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0078 | 0078
967523 | 1.NP_SO-102 | 967523 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0079 | 0079
967529 | 1.NP_SO-102 | 967529 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0080 | 0080
967535 | 1.NP_SO-102 | 967535 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0081 | 0081
967541 | 1.NP_SO-102 | 967541 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0082 | 0082
967547 | 1.NP_SO-102 | 967547 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0083 | 0083
967553 | 1.NP_SO-102 | 967553 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0084 | 0084
967559 | 1.NP_SO-102 | 967559 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0085 | 0085
967565 | 1.NP_SO-102 | 967565 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0086 | 0086
967571 | 1.NP_SO-102 | 967571 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0087 | 0087
967577 | 1.NP_SO-102 | 967577 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0088 | 0088
967583 | 1.NP_SO-102 | 967583 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0089 | 0089
967589 | 1.NP_SO-102 | 967589 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0090 | 0090
967595 | 1.NP_SO-102 | 967595 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0091 | 0091
967601 | 1.NP_SO-102 | 967601 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0092 | 0092
967607 | 1.NP_SO-102 | 967607 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0093 | 0093
967613 | 1.NP_SO-102 | 967613 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0094 | 0094
967619 | 1.NP_SO-102 | 967619 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0095 | 0095
967625 | 1.NP_SO-102 | 967625 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0096 | 0096
967631 | 1.NP_SO-102 | 967631 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0097 | 0097
967637 | 1.NP_SO-102 | 967637 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0098 | 0098
967643 | 1.NP_SO-102 | 967643 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZZ03.03.0099 | 0099
967714 | 1.NP_SO-102 | 967714 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0100 | 0100
967720 | 1.NP_SO-102 | 967720 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0101 | 0101
967726 | 1.NP_SO-102 | 967726 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0102 | 0102
967732 | 1.NP_SO-102 | 967732 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0103 | 0103
967738 | 1.NP_SO-102 | 967738 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0104 | 0104
967744 | 1.NP_SO-102 | 967744 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0105 | 0105
967750 | 1.NP_SO-102 | 967750 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0106 | 0106
967756 | 1.NP_SO-102 | 967756 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0107 | 0107
967762 | 1.NP_SO-102 | 967762 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0108 | 0108
967768 | 1.NP_SO-102 | 967768 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0109 | 0109
967774 | 1.NP_SO-102 | 967774 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0110 | 0110
967780 | 1.NP_SO-102 | 967780 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0111 | 0111
967786 | 1.NP_SO-102 | 967786 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0112 | 0112
967792 | 1.NP_SO-102 | 967792 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0113 | 0113
967798 | 1.NP_SO-102 | 967798 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0114 | 0114
967804 | 1.NP_SO-102 | 967804 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0115 | 0115
967810 | 1.NP_SO-102 | 967810 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0116 | 0116
967816 | 1.NP_SO-102 | 967816 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0117 | 0117
967822 | 1.NP_SO-102 | 967822 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0118 | 0118
967828 | 1.NP_SO-102 | 967828 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0119 | 0119
967845 | 1.NP_SO-102 | 967845 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0120 | 0120
967851 | 1.NP_SO-102 | 967851 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0121 | 0121
967857 | 1.NP_SO-102 | 967857 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0122 | 0122
967863 | 1.NP_SO-102 | 967863 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0123 | 0123
967869 | 1.NP_SO-102 | 967869 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0124 | 0124
967875 | 1.NP_SO-102 | 967875 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0125 | 0125
974014 | 2.NP_SO-102 | 974014 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0161 | 0161
974020 | 2.NP_SO-102 | 974020 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0162 | 0162
974026 | 2.NP_SO-102 | 974026 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0163 | 0163
974032 | 2.NP_SO-102 | 974032 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0164 | 0164
974038 | 2.NP_SO-102 | 974038 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0165 | 0165
974044 | 2.NP_SO-102 | 974044 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0166 | 0166
974050 | 2.NP_SO-102 | 974050 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0167 | 0167
974056 | 2.NP_SO-102 | 974056 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0168 | 0168
974062 | 2.NP_SO-102 | 974062 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0169 | 0169
974068 | 2.NP_SO-102 | 974068 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0170 | 0170
974074 | 2.NP_SO-102 | 974074 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0171 | 0171
974080 | 2.NP_SO-102 | 974080 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0172 | 0172
974086 | 2.NP_SO-102 | 974086 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0173 | 0173
974092 | 2.NP_SO-102 | 974092 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0174 | 0174
974098 | 2.NP_SO-102 | 974098 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0175 | 0175
974104 | 2.NP_SO-102 | 974104 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0176 | 0176
974110 | 2.NP_SO-102 | 974110 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0177 | 0177
974116 | 2.NP_SO-102 | 974116 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0178 | 0178
974122 | 2.NP_SO-102 | 974122 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0179 | 0179
974128 | 2.NP_SO-102 | 974128 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0180 | 0180
974134 | 2.NP_SO-102 | 974134 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0181 | 0181
974140 | 2.NP_SO-102 | 974140 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0182 | 0182
974146 | 2.NP_SO-102 | 974146 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0183 | 0183
974152 | 2.NP_SO-102 | 974152 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0184 | 0184
974158 | 2.NP_SO-102 | 974158 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0185 | 0185
974164 | 2.NP_SO-102 | 974164 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0186 | 0186
974170 | 2.NP_SO-102 | 974170 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0187 | 0187
974176 | 2.NP_SO-102 | 974176 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0188 | 0188
974182 | 2.NP_SO-102 | 974182 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.03.0189 | 0189
974188 | 2.NP_SO-102 | 974188 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.03.0190 | 0190
974194 | 2.NP_SO-102 | 974194 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.03.0191 | 0191
974200 | 2.NP_SO-102 | 974200 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.03.0192 | 0192
974218 | 2.NP_SO-102 | 974218 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.03.0193 | 0193
974224 | 2.NP_SO-102 | 974224 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.03.0194 | 0194
974230 | 2.NP_SO-102 | 974230 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.03.0195 | 0195
974236 | 2.NP_SO-102 | 974236 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.03.0196 | 0196
974242 | 2.NP_SO-102 | 974242 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.03.0197 | 0197
974254 | 2.NP_SO-102 | 974254 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0198 | 0198
974260 | 2.NP_SO-102 | 974260 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0199 | 0199
974266 | 2.NP_SO-102 | 974266 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0200 | 0200
974272 | 2.NP_SO-102 | 974272 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0201 | 0201
974278 | 2.NP_SO-102 | 974278 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0202 | 0202
974284 | 2.NP_SO-102 | 974284 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0203 | 0203
994129 | 2.NP_SO-102 | 994129 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0350 | 0350
994135 | 2.NP_SO-102 | 994135 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0351 | 0351
994141 | 2.NP_SO-102 | 994141 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0352 | 0352
994147 | 2.NP_SO-102 | 994147 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0353 | 0353
994153 | 2.NP_SO-102 | 994153 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0354 | 0354
994159 | 2.NP_SO-102 | 994159 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0355 | 0355
994165 | 2.NP_SO-102 | 994165 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0356 | 0356
994171 | 2.NP_SO-102 | 994171 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0357 | 0357
994177 | 2.NP_SO-102 | 994177 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0358 | 0358
994183 | 2.NP_SO-102 | 994183 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0359 | 0359
994189 | 2.NP_SO-102 | 994189 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0360 | 0360
994195 | 2.NP_SO-102 | 994195 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0361 | 0361
994201 | 2.NP_SO-102 | 994201 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0362 | 0362
994207 | 2.NP_SO-102 | 994207 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0363 | 0363
994213 | 2.NP_SO-102 | 994213 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0364 | 0364
994219 | 2.NP_SO-102 | 994219 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0365 | 0365
994225 | 2.NP_SO-102 | 994225 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0366 | 0366
994231 | 2.NP_SO-102 | 994231 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0367 | 0367
994237 | 2.NP_SO-102 | 994237 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0368 | 0368
994243 | 2.NP_SO-102 | 994243 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0369 | 0369
994249 | 2.NP_SO-102 | 994249 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0370 | 0370
994255 | 2.NP_SO-102 | 994255 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0371 | 0371
994261 | 2.NP_SO-102 | 994261 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0372 | 0372
994267 | 2.NP_SO-102 | 994267 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0373 | 0373
994273 | 2.NP_SO-102 | 994273 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0374 | 0374
994279 | 2.NP_SO-102 | 994279 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0375 | 0375
994285 | 2.NP_SO-102 | 994285 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0376 | 0376
994291 | 2.NP_SO-102 | 994291 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0377 | 0377
994297 | 2.NP_SO-102 | 994297 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0378 | 0378
994303 | 2.NP_SO-102 | 994303 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0379 | 0379
994309 | 2.NP_SO-102 | 994309 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0380 | 0380
994315 | 2.NP_SO-102 | 994315 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0381 | 0381
994321 | 2.NP_SO-102 | 994321 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0382 | 0382
994327 | 2.NP_SO-102 | 994327 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0383 | 0383
994333 | 2.NP_SO-102 | 994333 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0384 | 0384
994339 | 2.NP_SO-102 | 994339 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0385 | 0385
994345 | 2.NP_SO-102 | 994345 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0386 | 0386
994351 | 2.NP_SO-102 | 994351 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0387 | 0387
994357 | 2.NP_SO-102 | 994357 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0388 | 0388
994363 | 2.NP_SO-102 | 994363 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.0389 | 0389
997294 | 2.NP_SO-102 | 997294 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.03.0394 | 0394
997295 | 2.NP_SO-102 | 997295 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.03.0395 | 0395
998484 | 1.NP_SO-102 | 998484 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0405 | 0405
998485 | 1.NP_SO-102 | 998485 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0406 | 0406
998486 | 1.NP_SO-102 | 998486 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0407 | 0407
998487 | 1.NP_SO-102 | 998487 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0408 | 0408
998488 | 1.NP_SO-102 | 998488 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0409 | 0409
998489 | 1.NP_SO-102 | 998489 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZZ03.03.0410 | 0410
1000241 | 3.NP_SO-102 | 1000241 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0413 | 0413
1000242 | 3.NP_SO-102 | 1000242 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0414 | 0414
1000278 | 4.NP_SO-102 | 1000278 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0416 | 0416
1000279 | 4.NP_SO-102 | 1000279 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0417 | 0417
1000322 | 3.NP_SO-102 | 1000322 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0419 | 0419
1000323 | 3.NP_SO-102 | 1000323 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0420 | 0420
1000340 | 3.NP_SO-102 | 1000340 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0422 | 0422
1000341 | 3.NP_SO-102 | 1000341 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0423 | 0423
1000358 | 3.NP_SO-102 | 1000358 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0425 | 0425
1000359 | 3.NP_SO-102 | 1000359 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0426 | 0426
1000376 | 3.NP_SO-102 | 1000376 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0428 | 0428
1000377 | 3.NP_SO-102 | 1000377 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0429 | 0429
1000394 | 3.NP_SO-102 | 1000394 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0431 | 0431
1000395 | 3.NP_SO-102 | 1000395 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0432 | 0432
1000412 | 3.NP_SO-102 | 1000412 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0434 | 0434
1000413 | 3.NP_SO-102 | 1000413 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0435 | 0435
1000434 | 3.NP_SO-102 | 1000434 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0437 | 0437
1000435 | 3.NP_SO-102 | 1000435 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0438 | 0438
1000452 | 3.NP_SO-102 | 1000452 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0440 | 0440
1000453 | 3.NP_SO-102 | 1000453 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0441 | 0441
1000472 | 3.NP_SO-102 | 1000472 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0443 | 0443
1000473 | 3.NP_SO-102 | 1000473 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0444 | 0444
1000492 | 3.NP_SO-102 | 1000492 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0446 | 0446
1000493 | 3.NP_SO-102 | 1000493 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0447 | 0447
1000510 | 3.NP_SO-102 | 1000510 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0449 | 0449
1000511 | 3.NP_SO-102 | 1000511 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0450 | 0450
1000552 | 3.NP_SO-102 | 1000552 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0452 | 0452
1000553 | 3.NP_SO-102 | 1000553 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0453 | 0453
1000570 | 3.NP_SO-102 | 1000570 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0454 | 0454
1000571 | 3.NP_SO-102 | 1000571 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0455 | 0455
1000588 | 3.NP_SO-102 | 1000588 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0456 | 0456
1000589 | 3.NP_SO-102 | 1000589 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0457 | 0457
1000682 | 3.NP_SO-102 | 1000682 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0458 | 0458
1000690 | 3.NP_SO-102 | 1000690 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0459 | 0459
1000698 | 3.NP_SO-102 | 1000698 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0460 | 0460
1000706 | 3.NP_SO-102 | 1000706 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0461 | 0461
1000714 | 3.NP_SO-102 | 1000714 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0462 | 0462
1000722 | 3.NP_SO-102 | 1000722 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0463 | 0463
1000745 | 3.NP_SO-102 | 1000745 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0464 | 0464
1000753 | 3.NP_SO-102 | 1000753 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0465 | 0465
1000761 | 3.NP_SO-102 | 1000761 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0466 | 0466
1000769 | 3.NP_SO-102 | 1000769 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0467 | 0467
1000779 | 3.NP_SO-102 | 1000779 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0468 | 0468
1000787 | 3.NP_SO-102 | 1000787 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0469 | 0469
1000797 | 3.NP_SO-102 | 1000797 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0470 | 0470
1000805 | 3.NP_SO-102 | 1000805 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0471 | 0471
1000813 | 3.NP_SO-102 | 1000813 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0472 | 0472
1000823 | 3.NP_SO-102 | 1000823 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0473 | 0473
1000833 | 3.NP_SO-102 | 1000833 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0474 | 0474
1000841 | 3.NP_SO-102 | 1000841 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.03.0475 | 0475
1001008 | 4.NP_SO-102 | 1001008 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0476 | 0476
1001009 | 4.NP_SO-102 | 1001009 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0477 | 0477
1001026 | 4.NP_SO-102 | 1001026 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0479 | 0479
1001027 | 4.NP_SO-102 | 1001027 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0480 | 0480
1001046 | 4.NP_SO-102 | 1001046 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0482 | 0482
1001047 | 4.NP_SO-102 | 1001047 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0483 | 0483
1001064 | 4.NP_SO-102 | 1001064 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0485 | 0485
1001065 | 4.NP_SO-102 | 1001065 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0486 | 0486
1001082 | 4.NP_SO-102 | 1001082 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0488 | 0488
1001083 | 4.NP_SO-102 | 1001083 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0489 | 0489
1001100 | 4.NP_SO-102 | 1001100 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0491 | 0491
1001101 | 4.NP_SO-102 | 1001101 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0492 | 0492
1001131 | 4.NP_SO-102 | 1001131 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0493 | 0493
1001132 | 4.NP_SO-102 | 1001132 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0494 | 0494
1001172 | 4.NP_SO-102 | 1001172 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0495 | 0495
1001173 | 4.NP_SO-102 | 1001173 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0496 | 0496
1001283 | 4.NP_SO-102 | 1001283 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0497 | 0497
1001293 | 4.NP_SO-102 | 1001293 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0498 | 0498
1001370 | 4.NP_SO-102 | 1001370 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0499 | 0499
1001371 | 4.NP_SO-102 | 1001371 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0500 | 0500
1001372 | 4.NP_SO-102 | 1001372 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0501 | 0501
1001373 | 4.NP_SO-102 | 1001373 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0502 | 0502
1001451 | 4.NP_SO-102 | 1001451 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0503 | 0503
1001452 | 4.NP_SO-102 | 1001452 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0504 | 0504
1001460 | 4.NP_SO-102 | 1001460 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0505 | 0505
1001461 | 4.NP_SO-102 | 1001461 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0506 | 0506
1001462 | 4.NP_SO-102 | 1001462 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0507 | 0507
1001463 | 4.NP_SO-102 | 1001463 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0508 | 0508
1001468 | 4.NP_SO-102 | 1001468 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0509 | 0509
1001469 | 4.NP_SO-102 | 1001469 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0510 | 0510
1001477 | 4.NP_SO-102 | 1001477 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0511 | 0511
1001478 | 4.NP_SO-102 | 1001478 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0512 | 0512
1001479 | 4.NP_SO-102 | 1001479 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0513 | 0513
1001480 | 4.NP_SO-102 | 1001480 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0514 | 0514
