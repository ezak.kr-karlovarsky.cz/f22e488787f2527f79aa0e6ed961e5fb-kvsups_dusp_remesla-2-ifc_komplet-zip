Properties of the parts of a building model (IFC4), part 5 of 9

# IfcCableCarrierSegment: Kabelová lávka s tvarovkami:KOPOS JUPITER POZINKOVÁNO SENDZIMIR (201)
Name (Kabelová lávka s tvarovkami:KOPOS JUPITER POZINKOVÁNO SENDZIMIR:...) | In | Length (mm) | CrossSectionArea (m2) | OuterSurfaceArea (m2) | ID_import | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Spodní výška (mm) | Fáze vytvoření | Délka (mm) | Šířka (mm) | Velikost | Kód prvku | Označení | Páteřní trasa | UPRAVIL
930253 | 3.NP_SO-102 | 50 | 0.673143 | 0.254381 | 930253 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 2243.81 | 300 | 300 mmx50 mmø | KZ03.01.0012 | 0012 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
930258 | 3.NP_SO-102 | 50 | 1.77951 | 0.62317 | 930258 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 5931.7 | 300 | 300 mmx50 mmø | KZ03.01.0013 | 0013 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
930267 | 3.NP_SO-102 | 50 | 0.933584 | 0.486792 | 930267 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 2 | 4667.92 | 200 | 200 mmx50 mmø | KZ03.01.0014 | 0014 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
930334 | 3.NP_SO-102 | 50 | 1.17086 | 0.60543 | 930334 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 2 | 5854.3 | 200 | 200 mmx50 mmø | KZ03.01.0015 | 0015 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:42
930341 | 3.NP_SO-102 | 50 | 1.32293 | 0.681464 | 930341 | 3226.41 | 3201.41 | 3201.41 | 3.NP_SO-102 | 3176.41 | Fáze 2 | 6614.64 | 200 | 200 mmx50 mmø | KZ03.01.0016 | 0016 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:47
930370 | 3.NP_SO-102 | 50 | 0.6729 | 0.35645 | 930370 | 2765 | 2740 | 2740 | 3.NP_SO-102 | 2715 | Fáze 1 | 3364.5 | 200 | 200 mmx50 mmø | KZ03.01.0017 | 0017 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
930409 | 3.NP_SO-102 | 50 | 0.773851 | 0.783851 | 930409 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 7738.51 | 100 | 100 mmx50 mmø | KZ03.01.0018 | 0018 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
930424 | 3.NP_SO-102 | 50 | 5.84551 | 1.9785 | 930424 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 19485 | 300 | 300 mmx50 mmø | KZ03.01.0019 | 0019 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
930435 | 3.NP_SO-102 | 50 | 2.07254 | 2.08254 | 930435 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 20725.4 | 100 | 100 mmx50 mmø | KZ03.01.0020 | 0020 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
930469 | 3.NP_SO-102 | 50 | 0.309622 | 0.319622 | 930469 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 3096.22 | 100 | 100 mmx50 mmø | KZ03.01.0021 | 0021 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
930478 | 3.NP_SO-102 | 50 | 0.161526 | 0.0838421 | 930478 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 538.421 | 300 | 300 mmx50 mmø | KZ03.01.0022 | 0022 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
930502 | 4.NP_SO-102 | 50 | 2.14 | 1.09 | 930502 | 3675 | 3650 | 3650 | 4.NP_SO-102 | 3625 | Fáze 1 | 10700 | 200 | 200 mmx50 mmø | KZ03.01.0023 | 0023 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
930510 | 4.NP_SO-102 | 50 | 1.9698 | 1.0049 | 930510 | 3675 | 3650 | 3650 | 4.NP_SO-102 | 3625 | Fáze 1 | 9849 | 200 | 200 mmx50 mmø | KZ03.01.0024 | 0024 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
930523 | 4.NP_SO-102 | 50 | 0.04 | 0.04 | 930523 | 3675 | 3650 | 3650 | 4.NP_SO-102 | 3625 | Fáze 1 | 200 | 200 | 200 mmx50 mmø | KZ03.01.0025 | 0025 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
930529 | 4.NP_SO-102 | 50 | 0.26 | 0.15 | 930529 | 3675 | 3650 | 3650 | 4.NP_SO-102 | 3625 | Fáze 1 | 1300 | 200 | 200 mmx50 mmø | KZ03.01.0026 | 0026 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
930537 | 4.NP_SO-102 | 50 | 0.5396 | 0.2898 | 930537 | 3675 | 3650 | 3650 | 4.NP_SO-102 | 3625 | Fáze 1 | 2698 | 200 | 200 mmx50 mmø | KZ03.01.0027 | 0027 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
930774 | 2.NP_SO-102 | 50 | 0.996422 | 0.518211 | 930774 | 3325 | 3300 | 3300 | 2.NP_SO-102 | 3275 | Fáze 1 | 4982.11 | 200 | 200 mmx50 mmø | KZ03.01.0028 | 0028 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 12:55
930777 | 2.NP_SO-102 | 50 | 4.54 | 2.29 | 930777 | 3325 | 3300 | 3300 | 2.NP_SO-102 | 3275 | Fáze 1 | 22700 | 200 | 200 mmx50 mmø | KZ03.01.0029 | 0029 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 12:55
930781 | 2.NP_SO-102 | 50 | 0.84 | 0.44 | 930781 | 3291.59 | 3266.59 | 3266.59 | 2.NP_SO-102 | 3241.59 | Fáze 2 | 4200 | 200 | 200 mmx50 mmø | KZ03.01.0030 | 0030 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 12:55
930782 | 2.NP_SO-102 | 50 | 0.84 | 0.44 | 930782 | 3291.59 | 3266.59 | 3266.59 | 2.NP_SO-102 | 3241.59 | Fáze 2 | 4200 | 200 | 200 mmx50 mmø | KZ03.01.0031 | 0031 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 12:55
930788 | 2.NP_SO-102 | 50 | 0.996422 | 0.518211 | 930788 | 3291.59 | 3266.59 | 3266.59 | 2.NP_SO-102 | 3241.59 | Fáze 2 | 4982.11 | 200 | 200 mmx50 mmø | KZ03.01.0032 | 0032 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 12:59
930790 | 2.NP_SO-102 | 50 | 0.827221 | 0.43361 | 930790 | 3250 | 3225 | 3225 | 2.NP_SO-102 | 3200 | Fáze 2 | 4136.1 | 200 | 200 mmx50 mmø | KZ03.01.0033 | 0033 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 09:03
930796 | 2.NP_SO-102 | 50 | 4.3 | 2.17 | 930796 | 3325 | 3300 | 3300 | 2.NP_SO-102 | 3275 | Fáze 1 | 21500 | 200 | 200 mmx50 mmø | KZ03.01.0034 | 0034 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 12:55
931000 | 2.NP_SO-102 | 50 | 1.89683 | 0.968415 | 931000 | 3235 | 3210 | 3210 | 2.NP_SO-102 | 3185 | Fáze 1 | 9484.15 | 200 | 200 mmx50 mmø | KZ03.01.0035 | 0035 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 12:51
931081 | 2.NP_SO-102 | 50 | 0.328 | 0.184 | 931081 | 3275 | 3250 | 3250 | 2.NP_SO-102 | 3225 | Fáze 1 | 1640 | 200 | 200 mmx50 mmø | KZ03.01.0036 | 0036 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 08:09
931114 | 2.NP_SO-102 | 50 | 0.0174628 | 0.0287314 | 931114 | 3275 | 3250 | 3250 | 2.NP_SO-102 | 3225 | Fáze 1 | 87.3141 | 200 | 200 mmx50 mmø | KZ03.01.0037 | 0037 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 07:53
931125 | 2.NP_SO-102 | 50 | 0.569011 | 0.579011 | 931125 | 3295 | 3270 | 3270 | 2.NP_SO-102 | 3245 | Fáze 1 | 5690.11 | 100 | 100 mmx50 mmø | KZ03.01.0038 | 0038 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 08:27
931131 | 2.NP_SO-102 | 50 | 0.598372 | 0.608372 | 931131 | 3295 | 3270 | 3270 | 2.NP_SO-102 | 3245 | Fáze 1 | 5983.72 | 100 | 100 mmx50 mmø | KZ03.01.0039 | 0039 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 08:27
931158 | 2.NP_SO-102 | 50 | 0.626 | 0.636 | 931158 | 3275 | 3250 | 3250 | 2.NP_SO-102 | 3225 | Fáze 1 | 6260 | 100 | 100 mmx50 mmø | KZ03.01.0040 | 0040 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 08:28
931166 | 2.NP_SO-102 | 50 | 1.084 | 1.094 | 931166 | 3305 | 3280 | 3280 | 2.NP_SO-102 | 3255 | Fáze 1 | 10840 | 100 | 100 mmx50 mmø | KZ03.01.0041 | 0041 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 08:00
931199 | 2.NP_SO-102 | 50 | 0.12215 | 0.13215 | 931199 | 3305 | 3280 | 3280 | 2.NP_SO-102 | 3255 | Fáze 1 | 1221.5 | 100 | 100 mmx50 mmø | KZ03.01.0042 | 0042 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 07:55
931211 | 2.NP_SO-102 | 50 | 0.44 | 0.45 | 931211 | 3305 | 3280 | 3280 | 2.NP_SO-102 | 3255 | Fáze 1 | 4400 | 100 | 100 mmx50 mmø | KZ03.01.0043 | 0043 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 07:55
931217 | 2.NP_SO-102 | 50 | 0.145 | 0.155 | 931217 | 3305 | 3280 | 3280 | 2.NP_SO-102 | 3255 | Fáze 1 | 1450 | 100 | 100 mmx50 mmø | KZ03.01.0044 | 0044 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 07:55
931226 | 2.NP_SO-102 | 50 | 2.37451 | 1.20726 | 931226 | 3275 | 3250 | 3250 | 2.NP_SO-102 | 3225 | Fáze 1 | 11872.6 | 200 | 200 mmx50 mmø | KZ03.01.0045 | 0045 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 07:53
931247 | 2.NP_SO-102 | 50 | 0.1685 | 0.1785 | 931247 | 3295 | 3270 | 3270 | 2.NP_SO-102 | 3245 | Fáze 1 | 1685 | 100 | 100 mmx50 mmø | KZ03.01.0046 | 0046 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 01:16
931307 | 2.NP_SO-102 | 50 | 0.28 | 0.29 | 931307 | 3295 | 3270 | 3270 | 2.NP_SO-102 | 3245 | Fáze 1 | 2800 | 100 | 100 mmx50 mmø | KZ03.01.0047 | 0047 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 08:27
931317 | 2.NP_SO-102 | 50 | 0.539 | 0.549 | 931317 | 3295 | 3270 | 3270 | 2.NP_SO-102 | 3245 | Fáze 1 | 5390 | 100 | 100 mmx50 mmø | KZ03.01.0048 | 0048 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 08:27
931323 | 2.NP_SO-102 | 50 | 0.2799 | 0.2899 | 931323 | 3295 | 3270 | 3270 | 2.NP_SO-102 | 3245 | Fáze 1 | 2799 | 100 | 100 mmx50 mmø | KZ03.01.0049 | 0049 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 08:27
931334 | 2.NP_SO-102 | 50 | 0.248372 | 0.258372 | 931334 | 3295 | 3270 | 3270 | 2.NP_SO-102 | 3245 | Fáze 1 | 2483.72 | 100 | 100 mmx50 mmø | KZ03.01.0050 | 0050 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 08:27
931362 | 2.NP_SO-102 | 50 | 0.854962 | 0.447481 | 931362 | 3235 | 3210 | 3210 | 2.NP_SO-102 | 3185 | Fáze 1 | 4274.81 | 200 | 200 mmx50 mmø | KZ03.01.0051 | 0051 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 12:45
931392 | 1.NP_SO-102 | 50 | 1.59316 | 0.816582 | 931392 | 3347.5 | 3322.5 | 3322.5 | 1.NP_SO-102 | 3297.5 | Fáze 1 | 7965.82 | 200 | 200 mmx50 mmø | KZ03.01.0052 | 0052 | yes | Fruhauf.vinarice@seznam.cz 2023.07.21 10:20
931440 | 1.NP_SO-102 | 50 | 0.247709 | 0.143854 | 931440 | 3345 | 3320 | 3320 | 1.NP_SO-102 | 3295 | Fáze 1 | 1238.54 | 200 | 200 mmx50 mmø | KZ03.01.0053 | 0053 | yes | Fruhauf.vinarice@seznam.cz 2023.07.21 10:20
931448 | 1.NP_SO-102 | 50 | 0.288243 | 0.164122 | 931448 | 3345 | 3320 | 3320 | 1.NP_SO-102 | 3295 | Fáze 1 | 1441.22 | 200 | 200 mmx50 mmø | KZ03.01.0054 | 0054 | yes | Fruhauf.vinarice@seznam.cz 2023.07.21 10:20
931454 | 1.NP_SO-102 | 50 | 1.2 | 0.62 | 931454 | 3345 | 3320 | 3320 | 1.NP_SO-102 | 3295 | Fáze 1 | 6000 | 200 | 200 mmx50 mmø | KZ03.01.0055 | 0055 | yes | Fruhauf.vinarice@seznam.cz 2023.07.21 10:20
931462 | 1.NP_SO-102 | 50 | 1.22532 | 0.63266 | 931462 | 3345 | 3320 | 3320 | 1.NP_SO-102 | 3295 | Fáze 1 | 6126.6 | 200 | 200 mmx50 mmø | KZ03.01.0056 | 0056 | yes | Fruhauf.vinarice@seznam.cz 2023.07.21 10:20
931484 | 1.NP_SO-102 | 50 | 0.214231 | 0.224231 | 931484 | 3145.01 | 3120.01 | 3120.01 | 1.NP_SO-102 | 3095.01 | Fáze 1 | 2142.31 | 100 | 100 mmx50 mmø | KZ03.01.0057 | 0057 | yes | Fruhauf.vinarice@seznam.cz 2023.07.21 10:20
931489 | 1.NP_SO-102 | 50 | 0.049278 | 0.044639 | 931489 | 3345 | 3320 | 3320 | 1.NP_SO-102 | 3295 | Fáze 1 | 246.39 | 200 | 200 mmx50 mmø | KZ03.01.0058 | 0058 | yes | Fruhauf.vinarice@seznam.cz 2023.07.21 10:20
931507 | 1.NP_SO-102 | 50 | 0.792 | 0.416 | 931507 | 3345 | 3320 | 3320 | 1.NP_SO-102 | 3295 | Fáze 1 | 3960 | 200 | 200 mmx50 mmø | KZ03.01.0059 | 0059 | yes | Fruhauf.vinarice@seznam.cz 2023.07.21 10:20
931529 | 1.NP_SO-102 | 7548.35 | 0.005 | 2.26451 | 931529 | 3344.97 | 3319.98 | 3120.02 | 1.NP_SO-102 | 3095.03 | Fáze 1 | 7548.35 | 100 | 100 mmx50 mmø | KZ03.01.0060 | 0060 | yes | Fruhauf.vinarice@seznam.cz 2023.07.21 10:20
931551 | 2.NP_SO-102 | 50 | 0.276966 | 0.286966 | 931551 | 3305 | 3280 | 3280 | 2.NP_SO-102 | 3255 | Fáze 1 | 2769.66 | 100 | 100 mmx50 mmø | KZ03.01.0061 | 0061 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 07:55
931556 | 2.NP_SO-102 | 50 | 1.00581 | 1.01581 | 931556 | 3305 | 3280 | 3280 | 2.NP_SO-102 | 3255 | Fáze 1 | 10058.1 | 100 | 100 mmx50 mmø | KZ03.01.0062 | 0062 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 07:55
931565 | 2.NP_SO-102 | 50 | 0.276966 | 0.286966 | 931565 | 3305 | 3280 | 3280 | 2.NP_SO-102 | 3255 | Fáze 1 | 2769.66 | 100 | 100 mmx50 mmø | KZ03.01.0063 | 0063 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 07:55
931572 | 2.NP_SO-102 | 50 | 0.0746801 | 0.0846801 | 931572 | 3305 | 3280 | 3280 | 2.NP_SO-102 | 3255 | Fáze 1 | 746.801 | 100 | 100 mmx50 mmø | KZ03.01.0064 | 0064 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 07:55
931581 | 2.NP_SO-102 | 50 | 1.00581 | 1.01581 | 931581 | 3305 | 3280 | 3280 | 2.NP_SO-102 | 3255 | Fáze 1 | 10058.1 | 100 | 100 mmx50 mmø | KZ03.01.0065 | 0065 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 07:55
931588 | 2.NP_SO-102 | 50 | 0.61 | 0.62 | 931588 | 3305 | 3280 | 3280 | 2.NP_SO-102 | 3255 | Fáze 1 | 6100 | 100 | 100 mmx50 mmø | KZ03.01.0066 | 0066 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 12:45
931590 | 2.NP_SO-102 | 50 | 0.612 | 0.622 | 931590 | 3305 | 3280 | 3280 | 2.NP_SO-102 | 3255 | Fáze 1 | 6120 | 100 | 100 mmx50 mmø | KZ03.01.0067 | 0067 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 12:49
931621 | 3.NP_SO-102 | 50 | 0.319822 | 0.329822 | 931621 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 3198.22 | 100 | 100 mmx50 mmø | KZ03.01.0068 | 0068 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
931633 | 3.NP_SO-102 | 50 | 1.1975 | 1.2075 | 931633 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 11975 | 100 | 100 mmx50 mmø | KZ03.01.0069 | 0069 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
931639 | 3.NP_SO-102 | 50 | 0.53652 | 0.54652 | 931639 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 5365.2 | 100 | 100 mmx50 mmø | KZ03.01.0070 | 0070 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:50
931647 | 3.NP_SO-102 | 50 | 1.35708 | 1.36708 | 931647 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 13570.8 | 100 | 100 mmx50 mmø | KZ03.01.0071 | 0071 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
931660 | 3.NP_SO-102 | 50 | 0.637526 | 0.647526 | 931660 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 6375.26 | 100 | 100 mmx50 mmø | KZ03.01.0072 | 0072 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
931698 | 3.NP_SO-102 | 50 | 0.154624 | 0.164624 | 931698 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 1546.24 | 100 | 100 mmx50 mmø | KZ03.01.0073 | 0073 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
931842 | 3.NP_SO-102 | 50 | 0.15874 | 0.16874 | 931842 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 1587.4 | 100 | 100 mmx50 mmø | KZ03.01.0074 | 0074 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
931922 | 4.NP_SO-102 | 50 | 1.9598 | 0.9999 | 931922 | 3675 | 3650 | 3650 | 4.NP_SO-102 | 3625 | Fáze 1 | 9799 | 200 | 200 mmx50 mmø | KZ03.01.0075 | 0075 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
931928 | 4.NP_SO-102 | 50 | 1.058 | 0.549 | 931928 | 3675 | 3650 | 3650 | 4.NP_SO-102 | 3625 | Fáze 1 | 5290 | 200 | 200 mmx50 mmø | KZ03.01.0076 | 0076 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
931936 | 4.NP_SO-102 | 50 | 0.7296 | 0.3848 | 931936 | 3675 | 3650 | 3650 | 4.NP_SO-102 | 3625 | Fáze 1 | 3648 | 200 | 200 mmx50 mmø | KZ03.01.0077 | 0077 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
931951 | 4.NP_SO-102 | 50 | 1.3398 | 0.6899 | 931951 | 3675 | 3650 | 3650 | 4.NP_SO-102 | 3625 | Fáze 1 | 6699 | 200 | 200 mmx50 mmø | KZ03.01.0078 | 0078 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
931958 | 4.NP_SO-102 | 50 | 1.9598 | 0.9999 | 931958 | 3675 | 3650 | 3650 | 4.NP_SO-102 | 3625 | Fáze 1 | 9799 | 200 | 200 mmx50 mmø | KZ03.01.0079 | 0079 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
931981 | 4.NP_SO-102 | 50 | 1.0576 | 0.5488 | 931981 | 3675 | 3650 | 3650 | 4.NP_SO-102 | 3625 | Fáze 1 | 5288 | 200 | 200 mmx50 mmø | KZ03.01.0080 | 0080 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
932011 | 4.NP_SO-102 | 50 | 2.4796 | 1.2598 | 932011 | 3675 | 3650 | 3650 | 4.NP_SO-102 | 3625 | Fáze 1 | 12398 | 200 | 200 mmx50 mmø | KZ03.01.0081 | 0081 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
932018 | 4.NP_SO-102 | 50 | 0.5698 | 0.3049 | 932018 | 3675 | 3650 | 3650 | 4.NP_SO-102 | 3625 | Fáze 1 | 2849 | 200 | 200 mmx50 mmø | KZ03.01.0082 | 0082 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
932021 | 4.NP_SO-102 | 50 | 0.6898 | 0.3649 | 932021 | 3675 | 3650 | 3650 | 4.NP_SO-102 | 3625 | Fáze 1 | 3449 | 200 | 200 mmx50 mmø | KZ03.01.0083 | 0083 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
932023 | 4.NP_SO-102 | 50 | 0.0105 | 0.0205 | 932023 | 3675 | 3650 | 3650 | 4.NP_SO-102 | 3625 | Fáze 1 | 105 | 100 | 100 mmx50 mmø | KZ03.01.0084 | 0084 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
932034 | 4.NP_SO-102 | 50 | 0.29 | 0.3 | 932034 | 3675 | 3650 | 3650 | 4.NP_SO-102 | 3625 | Fáze 1 | 2900 | 100 | 100 mmx50 mmø | KZ03.01.0085 | 0085 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
932040 | 4.NP_SO-102 | 50 | 0.009 | 0.019 | 932040 | 3675 | 3650 | 3650 | 4.NP_SO-102 | 3625 | Fáze 1 | 90 | 100 | 100 mmx50 mmø | KZ03.01.0086 | 0086 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
932179 | 3.NP_SO-102 | 50 | 0.0231279 | 0.0331279 | 932179 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 231.279 | 100 | 100 mmx50 mmø | KZ03.01.0087 | 0087 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
932180 | 3.NP_SO-102 | 50 | 0.58478 | 0.59478 | 932180 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 5847.8 | 100 | 100 mmx50 mmø | KZ03.01.0088 | 0088 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
932249 | 3.NP_SO-102 | 50 | 0.591216 | 0.601216 | 932249 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 5912.16 | 100 | 100 mmx50 mmø | KZ03.01.0089 | 0089 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
932272 | 1.NP_SO-102 | 50 | 0.720345 | 0.380173 | 932272 | 3345 | 3320 | 3320 | 1.NP_SO-102 | 3295 | Fáze 1 | 3601.73 | 200 | 200 mmx50 mmø | KZ03.01.0090 | 0090 | yes | Fruhauf.vinarice@seznam.cz 2023.07.21 10:20
932277 | 1.NP_SO-102 | 50 | 0.5 | 0.27 | 932277 | 3345 | 3320 | 3320 | 1.NP_SO-102 | 3295 | Fáze 1 | 2500 | 200 | 200 mmx50 mmø | KZ03.01.0091 | 0091 | yes | Fruhauf.vinarice@seznam.cz 2023.07.21 10:21
993844 | 2.NP_SO-102 | 50 | 0.306906 | 0.173453 | 993844 | 3325 | 3300 | 3300 | 2.NP_SO-102 | 3275 | Fáze 1 | 1534.53 | 200 | 200 mmx50 mmø | KZ03.01.0129 | 0129 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 12:55
995146 | 3.NP_SO-102 | 50 | 0.217137 | 0.102379 | 995146 | 2825 | 2800 | 2800 | 3.NP_SO-102 | 2775 | Fáze 1 | 723.789 | 300 | 300 mmx50 mmø | KZ03.01.0130 | 0130 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:21
995881 | 2.NP_SO-102 | 50 | 0.155392 | 0.0976962 | 995881 | 3291.59 | 3266.59 | 3266.59 | 2.NP_SO-102 | 3241.59 | Fáze 2 | 776.962 | 200 | 200 mmx50 mmø | KZ03.01.0131 | 0131 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 01:01
996053 | 4.NP_SO-102 | 50 | 1.21847 | 0.629236 | 996053 | 3265 | 3240 | 3240 | 4.NP_SO-102 | 3215 | Fáze 2 | 6092.36 | 200 | 200 mmx50 mmø | KZ03.01.0132 | 0132 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
996916 | 3.NP_SO-102 | 50 | 0.372925 | 0.154308 | 996916 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 1243.08 | 300 | 300 mmx50 mmø | KZ03.01.0133 | 0133 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:21
996951 | 3.NP_SO-102 | 50 | 0.399175 | 0.163058 | 996951 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 1330.58 | 300 | 300 mmx50 mmø | KZ03.01.0134 | 0134 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:21
1063376 | 2.NP_SO-102 | 50 | 1.34492 | 0.692459 | 1063376 | 3325 | 3300 | 3300 | 2.NP_SO-102 | 3275 | Fáze 1 | 6724.59 | 200 | 200 mmx50 mmø | KZ03.01.0145 | 0145 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 09:11
1063433 | 2.NP_SO-102 | 50 | 1.47597 | 0.757986 | 1063433 | 3325 | 3300 | 3300 | 2.NP_SO-102 | 3275 | Fáze 1 | 7379.86 | 200 | 200 mmx50 mmø | KZ03.01.0146 | 0146 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 09:06
1063545 | 3.NP_SO-102 | 50 | 1.528 | 0.784 | 1063545 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 7640 | 200 | 200 mmx50 mmø | KZ03.01.0147 | 0147 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:40
1063579 | 3.NP_SO-102 | 50 | 3.0865 | 1.56325 | 1063579 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 15432.5 | 200 | 200 mmx50 mmø | KZ03.01.0148 | 0148 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 09:12
1063677 | 4.NP_SO-102 | 50 | 3.23047 | 1.63523 | 1063677 | 3265 | 3240 | 3240 | 4.NP_SO-102 | 3215 | Fáze 2 | 16152.3 | 200 | 200 mmx50 mmø | KZ03.01.0149 | 0149 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 01:02
1063696 | 4.NP_SO-102 | 50 | 3.65416 | 1.84708 | 1063696 | 3265 | 3240 | 3240 | 4.NP_SO-102 | 3215 | Fáze 2 | 18270.8 | 200 | 200 mmx50 mmø | KZ03.01.0150 | 0150 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
1157578 | 2.NP_SO-102 | 50 | 0.872596 | 0.456298 | 931114 | 3275 | 3250 | 3250 | 2.NP_SO-102 | 3225 | Fáze 1 | 4362.98 | 200 | 200 mmx50 mmø | KZ03.01.0160 | 0160 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 07:53
1157785 | 2.NP_SO-102 | 50 | 0.244179 | 0.14209 | 931000 | 2965 | 2940 | 2940 | 2.NP_SO-102 | 2915 | Fáze 1 | 1220.9 | 200 | 200 mmx50 mmø | KZ03.01.0161 | 0161 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 12:48
1157831 | 2.NP_SO-102 | 50 | 1.43718 | 0.738588 | 931000 | 3235 | 3210 | 3210 | 2.NP_SO-102 | 3185 | Fáze 1 | 7185.88 | 200 | 200 mmx50 mmø | KZ03.01.0162 | 0162 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 12:48
1158118 | 2.NP_SO-102 | 200 | 0.0244 | 0.2152 |  | 3223.92 | 3202.62 | 2947.38 | 2.NP_SO-102 | 2926.08 | Fáze 1 | 488.001 | 200 | 200 mmx50 mmø | KZ03.01.0163 | 0163 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 12:48
1158157 | 2.NP_SO-102 | 200 | 0.0170208 | 0.156167 |  | 3213.03 | 3195.36 | 2954.64 | 2.NP_SO-102 | 2936.97 | Fáze 1 | 340.416 | 200 | 200 mmx50 mmø | KZ03.01.0164 | 0164 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 12:51
1158390 | 2.NP_SO-102 | 50 | 0.0416393 | 0.0408197 | 931000 | 3275 | 3250 | 3250 | 2.NP_SO-102 | 3225 | Fáze 1 | 208.197 | 200 | 200 mmx50 mmø | KZ03.01.0165 | 0165 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 07:53
1158532 | 2.NP_SO-102 | 50 | 0.146612 | 0.0933058 | 931000 | 3115 | 3090 | 3090 | 2.NP_SO-102 | 3065 | Fáze 1 | 733.058 | 200 | 200 mmx50 mmø | KZ03.01.0166 | 0166 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 12:51
1158661 | 2.NP_SO-102 | 200 | 0.0167082 | 0.153666 |  | 3267.08 | 3244.72 | 3095.28 | 2.NP_SO-102 | 3072.92 | Fáze 1 | 334.164 | 200 | 200 mmx50 mmø | KZ03.01.0167 | 0167 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 07:53
1158700 | 2.NP_SO-102 | 200 | 0.00930278 | 0.0944222 |  | 3222.4 | 3098.4 | 3201.6 | 2.NP_SO-102 | 3077.6 | Fáze 1 | 186.056 | 200 | 200 mmx50 mmø | KZ03.01.0168 | 0168 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 12:51
1158837 | 2.NP_SO-102 | 50 | 0.114893 | 0.0774464 | 993835 | 3375 | 3350 | 3350 | 2.NP_SO-102 | 3325 | Fáze 1 | 574.464 | 200 | 200 mmx50 mmø | KZ03.01.0169 | 0169 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 12:56
1159330 | 2.NP_SO-102 | 200 | 0.0131456 | 0.125165 |  | 3365.6 | 3216.27 | 3343.73 | 2.NP_SO-102 | 3194.4 | Fáze 1 | 262.911 | 200 | 200 mmx50 mmø | KZ03.01.0170 | 0170 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 12:56
1159356 | 2.NP_SO-102 | 50 | 1.79719 | 0.918596 |  | 3235 | 3210 | 3210 | 2.NP_SO-102 | 3185 | Fáze 1 | 8985.96 | 200 | 200 mmx50 mmø | KZ03.01.0171 | 0171 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 12:56
1159411 | 2.NP_SO-102 | 200 | 0.00309534 | 0.0447627 |  | 3362.84 | 3341.9 | 3308.1 | 2.NP_SO-102 | 3287.16 | Fáze 1 | 61.9068 | 200 | 200 mmx50 mmø | KZ03.01.0172 | 0172 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 12:56
1159440 | 2.NP_SO-102 | 50 | 0.0932302 | 0.0666151 |  | 3325 | 3300 | 3300 | 2.NP_SO-102 | 3275 | Fáze 1 | 466.151 | 200 | 200 mmx50 mmø | KZ03.01.0173 | 0173 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 12:56
1159667 | 2.NP_SO-102 | 50 | 1.2826 | 0.6613 | 995881 | 3250 | 3225 | 3225 | 2.NP_SO-102 | 3200 | Fáze 2 | 6413 | 200 | 200 mmx50 mmø | KZ03.01.0174 | 0174 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 09:02
1160006 | 2.NP_SO-102 | 722.969 | 0.01 | 0.361484 |  | 3377 | 3287.6 | 3352.1 | 2.NP_SO-102 | 3262.7 | Fáze 2 | 722.969 | 200 | 200 mmx50 mmø | KZ03.01.0175 | 0175 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:54
1160227 | 1.NP_SO-102 | 50 | 0.332635 | 0.186317 | 931440 | 3345 | 3320 | 3320 | 1.NP_SO-102 | 3295 | Fáze 1 | 1663.17 | 200 | 200 mmx50 mmø | KZ03.01.0176 | 0176 | yes | Fruhauf.vinarice@seznam.cz 2023.07.21 10:20
1160238 | 1.NP_SO-102 | 50 | 1.39803 | 0.719015 | 931507 | 3345 | 3320 | 3320 | 1.NP_SO-102 | 3295 | Fáze 1 | 6990.15 | 200 | 200 mmx50 mmø | KZ03.01.0177 | 0177 | yes | Fruhauf.vinarice@seznam.cz 2023.07.21 10:20
1160803 | 1.NP_SO-102 | 50 | 0.167285 | 0.103642 | 998574 | 3110 | 3085 | 3085 | 1.NP_SO-102 | 3060 | Fáze 1 | 836.424 | 200 | 200 mmx50 mmø | KZ03.01.0178 | 0178 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 10:18
1160876 | 1.NP_SO-102 | 50 | 0.401482 | 0.220741 | 998574 | 3345 | 3320 | 3320 | 1.NP_SO-102 | 3295 | Fáze 1 | 2007.41 | 200 | 200 mmx50 mmø | KZ03.01.0179 | 0179 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 10:18
1161314 | 1.NP_SO-102 | 261.863 | 0.01 | 0.130932 |  | 3329.87 | 3314.91 | 3105.09 | 1.NP_SO-102 | 3090.13 | Fáze 1 | 261.863 | 200 | 200 mmx50 mmø | KZ03.01.0180 | 0180 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 10:17
1161405 | 1.NP_SO-102 | 216.055 | 0.01 | 0.108028 |  | 3308.2 | 3295.47 | 3109.53 | 1.NP_SO-102 | 3096.8 | Fáze 1 | 216.055 | 200 | 200 mmx50 mmø | KZ03.01.0181 | 0181 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 10:18
1161882 | 4.NP_SO-102 | 50 | 0.28696 | 0.16348 | 1002243 | 3365 | 3340 | 3340 | 4.NP_SO-102 | 3315 | Fáze 1 | 1434.8 | 200 | 200 mmx50 mmø | KZ03.01.0182 | 0182 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 01:08
1161955 | 4.NP_SO-102 | 50 | 1.75842 | 0.899208 | 1002243 | 3265 | 3240 | 3240 | 4.NP_SO-102 | 3215 | Fáze 1 | 8792.08 | 200 | 200 mmx50 mmø | KZ03.01.0183 | 0183 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 01:02
1162323 | 4.NP_SO-102 | 200 | 0.00436719 | 0.0549375 |  | 3314.97 | 3293.75 | 3247.56 | 4.NP_SO-102 | 3226.34 | Fáze 1 | 87.3438 | 200 | 200 mmx50 mmø | KZ03.01.0184 | 0184 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 01:08
1162362 | 4.NP_SO-102 | 200 | 0.00805 | 0.0844 |  | 3353.71 | 3332.47 | 3247.53 | 4.NP_SO-102 | 3226.29 | Fáze 1 | 161 | 200 | 200 mmx50 mmø | KZ03.01.0185 | 0185 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 01:02
1163578 | 3.NP_SO-102 | 50 | 1.4518 | 0.745902 | 1063545 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 7259.02 | 200 | 200 mmx50 mmø | KZ03.01.0187 | 0187 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:39
1164018 | 3.NP_SO-102 | 50 | 0.148311 | 0.0941557 | 930174 | 3355 | 3330 | 3330 | 3.NP_SO-102 | 3305 | Fáze 2 | 741.557 | 200 | 200 mmx50 mmø | KZ03.01.0188 | 0188 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:43
1164103 | 3.NP_SO-102 | 50 | 0.0863212 | 0.0631606 | 930174 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 2 | 431.606 | 200 | 200 mmx50 mmø | KZ03.01.0189 | 0189 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:43
1164211 | 3.NP_SO-102 | 238.69 | 0.01 | 0.119345 |  | 3350.24 | 3243.17 | 3326.83 | 3.NP_SO-102 | 3219.76 | Fáze 2 | 238.69 | 200 | 200 mmx50 mmø | KZ03.01.0190 | 0190 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:43
1164247 | 3.NP_SO-102 | 258.821 | 0.01 | 0.129411 |  | 3350.89 | 3327.26 | 3242.74 | 3.NP_SO-102 | 3219.11 | Fáze 2 | 258.821 | 200 | 200 mmx50 mmø | KZ03.01.0191 | 0191 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:43
1164404 | 3.NP_SO-102 | 50 | 0.137304 | 0.0886518 | 930341 | 3145 | 3120 | 3120 | 3.NP_SO-102 | 3095 | Fáze 2 | 686.518 | 200 | 200 mmx50 mmø | KZ03.01.0192 | 0192 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:47
1164441 | 3.NP_SO-102 | 50 | 1.91838 | 0.979188 | 930341 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 2 | 9591.88 | 200 | 200 mmx50 mmø | KZ03.01.0193 | 0193 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:47
1164608 | 3.NP_SO-102 | 373.574 | 0.01 | 0.186787 |  | 3224.71 | 3200.28 | 3121.13 | 3.NP_SO-102 | 3096.7 | Fáze 2 | 373.574 | 200 | 200 mmx50 mmø | KZ03.01.0194 | 0194 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:47
1164677 | 3.NP_SO-102 | 362.75 | 0.01 | 0.181375 |  | 3261.14 | 3237.43 | 3122.57 | 3.NP_SO-102 | 3098.86 | Fáze 2 | 362.75 | 200 | 200 mmx50 mmø | KZ03.01.0195 | 0195 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:47
1165516 | 3.NP_SO-102 | 50 | 0.0566006 | 0.0666006 | 931639 | 2830.82 | 2805.82 | 2805.82 | 3.NP_SO-102 | 2780.82 | Fáze 1 | 566.006 | 100 | 100 mmx50 mmø | KZ03.01.0196 | 0196 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:51
1165567 | 3.NP_SO-102 | 50 | 0.49568 | 0.50568 | 931639 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 4956.8 | 100 | 100 mmx50 mmø | KZ03.01.0197 | 0197 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:51
1165711 | 3.NP_SO-102 | 495.756 | 0.005 | 0.148727 |  | 3235.38 | 2825.56 | 3220.26 | 3.NP_SO-102 | 2810.44 | Fáze 1 | 495.756 | 100 | 100 mmx50 mmø | KZ03.01.0198 | 0198 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:51
1165876 | 3.NP_SO-102 | 100 | 0.0426672 | 0.180669 |  | 3255.23 | 2812.33 | 3233.49 | 3.NP_SO-102 | 2790.59 | Fáze 1 | 853.344 | 100 | 100 mmx50 mmø | KZ03.01.0199 | 0199 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:51
1166112 | 2.NP_SO-102 | 50 | 1.42813 | 0.734063 | 995881 | 3312.4 | 3287.4 | 3287.4 | 2.NP_SO-102 | 3262.4 | Fáze 2 | 7140.63 | 200 | 200 mmx50 mmø | KZ03.01.0200 | 0200 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 09:02
1166428 | 2.NP_SO-102 | 50 | 1.6718 | 0.8559 | 1063433 | 3325 | 3300 | 3300 | 2.NP_SO-102 | 3275 | Fáze 1 | 8359 | 200 | 200 mmx50 mmø | KZ03.01.0201 | 0201 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 09:06
1166717 | 2.NP_SO-102 | 50 | 1.42063 | 0.730314 | 1063376 | 3325 | 3300 | 3300 | 2.NP_SO-102 | 3275 | Fáze 1 | 7103.14 | 200 | 200 mmx50 mmø | KZ03.01.0202 | 0202 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 09:11
1166832 | 2.NP_SO-102 | 50 | 0.329273 | 0.184636 | 1063376 | 3005 | 2980 | 2980 | 2.NP_SO-102 | 2955 | Fáze 1 | 1646.36 | 200 | 200 mmx50 mmø | KZ03.01.0203 | 0203 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 09:11
1167138 | 2.NP_SO-102 | 494.69 | 0.01 | 0.247345 |  | 3309.68 | 2990.21 | 3289.79 | 2.NP_SO-102 | 2970.32 | Fáze 1 | 494.69 | 200 | 200 mmx50 mmø | KZ03.01.0204 | 0204 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 09:11
1167175 | 2.NP_SO-102 | 511.106 | 0.01 | 0.255553 |  | 3310.63 | 2989.58 | 3290.42 | 2.NP_SO-102 | 2969.37 | Fáze 1 | 511.106 | 200 | 200 mmx50 mmø | KZ03.01.0205 | 0205 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 09:11
1168543 | 4.NP_SO-102 | 50 | 0.44 | 0.24 | 1002243 | 3365 | 3340 | 3340 | 4.NP_SO-102 | 3315 | Fáze 1 | 2200 | 200 | 200 mmx50 mmø | KZ03.01.0206 | 0206 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 01:08
1168670 | 4.NP_SO-102 | 50 | 0.02 | 0.03 |  | 3365 | 3340 | 3340 | 4.NP_SO-102 | 3315 | Fáze 1 | 100 | 200 | 200 mmx50 mmø | KZ03.01.0207 | 0207 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 01:08
1168678 | 4.NP_SO-102 | 50 | 0.0451396 | 0.0425698 |  | 3265 | 3240 | 3240 | 4.NP_SO-102 | 3215 | Fáze 1 | 225.698 | 200 | 200 mmx50 mmø | KZ03.01.0208 | 0208 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 01:07
1168700 | 4.NP_SO-102 | 50 | 0.02 | 0.03 |  | 3365 | 3340 | 3340 | 4.NP_SO-102 | 3315 | Fáze 1 | 100 | 200 | 200 mmx50 mmø | KZ03.01.0209 | 0209 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 01:08
1168710 | 4.NP_SO-102 | 50 | 0.592 | 0.316 |  | 3265 | 3240 | 3240 | 4.NP_SO-102 | 3215 | Fáze 1 | 2960 | 200 | 200 mmx50 mmø | KZ03.01.0210 | 0210 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 01:07
1169422 | 2.NP_SO-102 | 50 | 0.3485 | 0.3585 | 931247 | 3295 | 3270 | 3270 | 2.NP_SO-102 | 3245 | Fáze 1 | 3485 | 100 | 100 mmx50 mmø | KZ03.01.0211 | 0211 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 01:16
1172274 | 3.NP_SO-102 | 50 | 0.672 | 0.682 |  | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 6720 | 100 | 100 mmx50 mmø | KZ03.01.0212 | 0212
1172281 | 3.NP_SO-102 | 180.175 | 0.005 | 0.0540525 |  | 3105 | 3105 | 2924.82 | 3.NP_SO-102 | 2924.82 | Fáze 1 | 180.175 | 100 | 100 mmx50 mmø | KZ03.01.0213 | 0213
1172320 | 3.NP_SO-102 | 50 | 0.047 | 0.057 |  | 2774.82 | 2749.82 | 2749.82 | 3.NP_SO-102 | 2724.82 | Fáze 1 | 470 | 100 | 100 mmx50 mmø | KZ03.01.0214 | 0214
1172325 | 3.NP_SO-102 | 180.175 | 0.005 | 0.0540525 |  | 3105 | 2924.82 | 3105 | 3.NP_SO-102 | 2924.82 | Fáze 1 | 180.175 | 100 | 100 mmx50 mmø | KZ03.01.0215 | 0215
1172895 | 2.NP_SO-102 | 50 | 0.20032 | 0.12016 |  | 3291.59 | 3266.59 | 3266.59 | 2.NP_SO-102 | 3241.59 | Fáze 2 | 1001.6 | 200 | 200 mmx50 mmø | KZ03.01.0216 | 0216
1172929 | 2.NP_SO-102 | 200 | 0.00616025 | 0.069282 |  | 3314.95 | 3293.3 | 3231.7 | 2.NP_SO-102 | 3210.05 | Fáze 2 | 123.205 | 200 | 200 mmx50 mmø | KZ03.01.0217 | 0217
1173050 | 3.NP_SO-102 | 50 | 0.1649 | 0.10245 | 1063579 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 824.5 | 200 | 200 mmx50 mmø | KZ03.01.0218 | 0218 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 09:12
1174265 | 2.NP_SO-102 | 50 | 0.15944 | 0.0997199 |  | 3325 | 3300 | 3300 | 2.NP_SO-102 | 3275 | Fáze 2 | 797.199 | 200 | 200 mmx50 mmø | KZ03.01.0225 | 0225
1174272 | 2.NP_SO-102 | 200 | 0.00616025 | 0.069282 |  | 3314.95 | 3293.3 | 3231.7 | 2.NP_SO-102 | 3210.05 | Fáze 2 | 123.205 | 200 | 200 mmx50 mmø | KZ03.01.0226 | 0226
1174804 | 4.NP_SO-102 | 50 | 0.206377 | 0.123188 | 1002243 | 3326.31 | 3301.31 | 3301.31 | 4.NP_SO-102 | 3276.31 | Fáze 1 | 1031.88 | 200 | 200 mmx50 mmø | KZ03.01.0232 | 0232 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 01:08
1174890 | 4.NP_SO-102 | 50 | 0.213053 | 0.126526 |  | 3365 | 3340 | 3340 | 4.NP_SO-102 | 3315 | Fáze 1 | 1065.26 | 200 | 200 mmx50 mmø | KZ03.01.0233 | 0233
1174916 | 4.NP_SO-102 | 200 | 0.00252881 | 0.0402304 |  | 3354.95 | 3333.3 | 3308.01 | 4.NP_SO-102 | 3286.36 | Fáze 1 | 50.5761 | 200 | 200 mmx50 mmø | KZ03.01.0234 | 0234
1176509 | 4.NP_SO-102 | 180 | 0.01 | 0.09 |  | 3105 | 3105 | 2925 | 4.NP_SO-102 | 2925 | Fáze 1 | 180 | 200 | 200 mmx50 mmø | KZ03.01.0244 | 0244
1176851 | 4.NP_SO-102 | 50 | 1.72912 | 0.88456 | 996706 | 3265 | 3240 | 3240 | 4.NP_SO-102 | 3215 | Fáze 1 | 8645.6 | 200 | 200 mmx50 mmø | KZ03.01.0245 | 0245 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
1177123 | 4.NP_SO-102 | 50 | 0.876878 | 0.458439 | 996706 | 3265 | 3240 | 3240 | 4.NP_SO-102 | 3215 | Fáze 1 | 4384.39 | 200 | 200 mmx50 mmø | KZ03.01.0246 | 0246 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
1177188 | 4.NP_SO-102 | 50 | 4.22251 | 2.13126 |  | 3265 | 3240 | 3240 | 4.NP_SO-102 | 3215 | Fáze 1 | 21112.6 | 200 | 200 mmx50 mmø | KZ03.01.0247 | 0247
1177337 | 4.NP_SO-102 | 50 | 0.333958 | 0.186979 |  | 3395 | 3370 | 3370 | 4.NP_SO-102 | 3345 | Fáze 1 | 1669.79 | 200 | 200 mmx50 mmø | KZ03.01.0248 | 0248
1177357 | 4.NP_SO-102 | 200 | 0.00712132 | 0.0769706 |  | 3373.03 | 3355.36 | 3254.64 | 4.NP_SO-102 | 3236.97 | Fáze 1 | 142.426 | 200 | 200 mmx50 mmø | KZ03.01.0249 | 0249
1177376 | 4.NP_SO-102 | 50 | 0.253958 | 0.146979 |  | 3395 | 3370 | 3370 | 4.NP_SO-102 | 3345 | Fáze 1 | 1269.79 | 200 | 200 mmx50 mmø | KZ03.01.0250 | 0250
1177383 | 4.NP_SO-102 | 200 | 0.00712132 | 0.0769706 |  | 3373.03 | 3355.36 | 3254.64 | 4.NP_SO-102 | 3236.97 | Fáze 1 | 142.426 | 200 | 200 mmx50 mmø | KZ03.01.0251 | 0251
1177402 | 4.NP_SO-102 | 50 | 0.257958 | 0.148979 |  | 3395 | 3370 | 3370 | 4.NP_SO-102 | 3345 | Fáze 1 | 1289.79 | 200 | 200 mmx50 mmø | KZ03.01.0252 | 0252
1177407 | 4.NP_SO-102 | 200 | 0.00712132 | 0.0769706 |  | 3373.03 | 3355.36 | 3254.64 | 4.NP_SO-102 | 3236.97 | Fáze 1 | 142.426 | 200 | 200 mmx50 mmø | KZ03.01.0253 | 0253
1177437 | 4.NP_SO-102 | 200 | 0.00932163 | 0.0945731 |  | 3361.57 | 3339.92 | 3246.7 | 4.NP_SO-102 | 3225.05 | Fáze 1 | 186.433 | 200 | 200 mmx50 mmø | KZ03.01.0254 | 0254
1177456 | 4.NP_SO-102 | 50 | 0.377077 | 0.208538 |  | 3371.61 | 3346.61 | 3346.61 | 4.NP_SO-102 | 3321.61 | Fáze 1 | 1885.38 | 200 | 200 mmx50 mmø | KZ03.01.0255 | 0255
1177461 | 4.NP_SO-102 | 200 | 0.00932163 | 0.0945731 |  | 3361.57 | 3339.92 | 3246.7 | 4.NP_SO-102 | 3225.05 | Fáze 1 | 186.433 | 200 | 200 mmx50 mmø | KZ03.01.0256 | 0256
1177648 | 3.NP_SO-102 | 50 | 4.42291 | 2.23146 |  | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 22114.6 | 200 | 200 mmx50 mmø | KZ03.01.0257 | 0257
1177653 | 3.NP_SO-102 | 310 | 0.01 | 0.155 |  | 3105 | 3105 | 2795 | 3.NP_SO-102 | 2795 | Fáze 1 | 310 | 200 | 200 mmx50 mmø | KZ03.01.0258 | 0258
1177977 | 4.NP_SO-102 | 50 | 1.20676 | 0.623379 | 996208 | 3265 | 3240 | 3240 | 4.NP_SO-102 | 3215 | Fáze 1 | 6033.79 | 200 | 200 mmx50 mmø | KZ03.01.0259 | 0259 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
1178077 | 4.NP_SO-102 | 50 | 4.04321 | 2.04161 |  | 3422.02 | 3397.02 | 3397.02 | 4.NP_SO-102 | 3372.02 | Fáze 1 | 20216.1 | 200 | 200 mmx50 mmø | KZ03.01.0260 | 0260
1178084 | 4.NP_SO-102 | 200 | 0.00903207 | 0.0922566 |  | 3400.06 | 3382.38 | 3254.64 | 4.NP_SO-102 | 3236.97 | Fáze 1 | 180.641 | 200 | 200 mmx50 mmø | KZ03.01.0261 | 0261
1178432 | 2.NP_SO-102 | 50 | 0.269013 | 0.154506 |  | 3377.3 | 3352.3 | 3352.3 | 2.NP_SO-102 | 3327.3 | Fáze 2 | 1345.06 | 200 | 200 mmx50 mmø | KZ03.01.0262 | 0262
1178439 | 2.NP_SO-102 | 200 | 0.00723067 | 0.0778453 |  | 3367.25 | 3345.6 | 3273.29 | 2.NP_SO-102 | 3251.64 | Fáze 2 | 144.613 | 200 | 200 mmx50 mmø | KZ03.01.0263 | 0263
1178520 | 2.NP_SO-102 | 50 | 2.54725 | 1.29362 |  | 3325 | 3300 | 3300 | 2.NP_SO-102 | 3275 | Fáze 2 | 12736.2 | 200 | 200 mmx50 mmø | KZ03.01.0264 | 0264
1178534 | 2.NP_SO-102 | 200 | 0.00200089 | 0.0360071 |  | 3314.95 | 3293.3 | 3273.29 | 2.NP_SO-102 | 3251.64 | Fáze 2 | 40.0178 | 200 | 200 mmx50 mmø | KZ03.01.0265 | 0265
1178779 | 3.NP_SO-102 | 50 | 0.1269 | 0.08345 |  | 2825 | 2800 | 2800 | 3.NP_SO-102 | 2775 | Fáze 1 | 634.5 | 200 | 200 mmx50 mmø | KZ03.01.0266 | 0266
1178786 | 3.NP_SO-102 | 190 | 0.01 | 0.095 |  | 3105 | 3105 | 2915 | 3.NP_SO-102 | 2915 | Fáze 1 | 190 | 200 | 200 mmx50 mmø | KZ03.01.0267 | 0267
1179086 | 3.NP_SO-102 | 50 | 0.476013 | 0.188671 |  | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 1586.71 | 300 | 300 mmx50 mmø | KZ03.01.0268 | 0268
1179110 | 3.NP_SO-102 | 580.833 | 0.015 | 0.406583 |  | 3243.03 | 3225.36 | 2814.64 | 3.NP_SO-102 | 2796.97 | Fáze 1 | 580.833 | 300 | 300 mmx50 mmø | KZ03.01.0269 | 0269
1179141 | 3.NP_SO-102 | 50 | 4.006 | 2.023 |  | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 20030 | 200 | 200 mmx50 mmø | KZ03.01.0270 | 0270
1179146 | 3.NP_SO-102 | 130 | 0.01 | 0.065 |  | 3105 | 3105 | 2975 | 3.NP_SO-102 | 2975 | Fáze 1 | 130 | 200 | 200 mmx50 mmø | KZ03.01.0271 | 0271
1179169 | 3.NP_SO-102 | 50 | 0.0725573 | 0.0541858 |  | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 241.858 | 300 | 300 mmx50 mmø | KZ03.01.0272 | 0272
1179174 | 3.NP_SO-102 | 580.833 | 0.015 | 0.406583 |  | 3243.03 | 3225.36 | 2814.64 | 3.NP_SO-102 | 2796.97 | Fáze 1 | 580.833 | 300 | 300 mmx50 mmø | KZ03.01.0273 | 0273
1179226 | 1.NP_SO-102 | 50 | 6.34026 | 3.19013 |  | 3360 | 3335 | 3335 | 1.NP_SO-102 | 3310 | Fáze 1 | 31701.3 | 200 | 200 mmx50 mmø | KZ03.01.0274 | 0274
1179253 | 1.NP_SO-102 | 50 | 0.0536 | 0.0534 |  | 3250 | 3225 | 3225 | 1.NP_SO-102 | 3200 | Fáze 1 | 134 | 400 | 400 mmx50 mmø | KZ03.01.0275 | 0275
1179254 | 1.NP_SO-102 | 200 | 0.00570711 | 0.0656569 |  | 3338.03 | 3320.36 | 3239.64 | 1.NP_SO-102 | 3221.97 | Fáze 1 | 114.142 | 200 | 200 mmx50 mmø | KZ03.01.0276 | 0276
1179974 | 1.NP_SO-102 | 50 | 0.0139338 | 0.0239338 | 931529 | 3345 | 3320 | 3320 | 1.NP_SO-102 | 3295 | Fáze 1 | 139.338 | 100 | 100 mmx50 mmø | KZ03.01.0277 | 0277 | yes | Fruhauf.vinarice@seznam.cz 2023.07.21 10:20
1180479 | 1.NP_SO-102 | 50 | 0.0479402 | 0.0579402 |  | 3145.01 | 3120.01 | 3120.01 | 1.NP_SO-102 | 3095.01 | Fáze 1 | 479.402 | 100 | 100 mmx50 mmø | KZ03.01.0278 | 0278 | yes

# IfcCableCarrierSegment: Kabelová lávka s tvarovkami:KOPOS JUPITER POZINKOVÁNO SENDZIMIR, NEDĚROVANÝ (36)
In: 1.NP_SO-102
Type - PredefinedType: CABLETRAYSEGMENT
Type - Tvarovky - Horizontální ohyb: KOPOS JUPITER_oblouk 90°.CC: zinkování Sendzimir; Kříž: KOPOS JUPITER_kříž.CC: zinkování Sendzimir; Přechod: KOPOS JUPITER_redukce.CC: zinkování Sendzimir; Spojení: KOPOS JUPITER_spojka.CC: zinkování Sendzimir; T-spoj: KOPOS JUPITER_T-kus.CC: žárové zinkování Sendzimir; Vertikální vnější ohyb: KOPOS JUPITER_oblouk klesající 90°.CC: zinkování Sendzimir; Vertikální vnitřní ohyb: KOPOS JUPITER_oblouk stoupající 90°.CC: zinkování Sendzimir
Type - Elektroinstalace - Násobitel poloměru ohybu: 1
Type - Identifikační data - Kód sestavy: KZ03; Komentáře k typům: 3 m;-1PP; Model: KZIN_S; Název typu: KOPOS JUPITER POZINKOVÁNO SENDZIMIR, NEDĚROVANÝ; Označení typu: 03; Popis: Kabelové žlaby JUPITER; Popis sestavy: Kabelová lávka a žebřík; URL: https://www.kopos.cz/cs; Výrobce: KOPOS KOLÍN a.s.
Type - Jiné - Kategorie: Kabelové lávky; Název rodiny: Kabelová lávka s tvarovkami
Classification: KZ03 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed; Referenční podlaží: 1.NP_SO-102
Jiné - Rodina: Kabelová lávka s tvarovkami; Id typu: 560976; Rodina a typ: Kabelová lávka s tvarovkami: KOPOS JUPITER POZINKOVÁNO SENDZIMIR, NEDĚROVANÝ; Typ: KOPOS JUPITER POZINKOVÁNO SENDZIMIR, NEDĚROVANÝ
Name (Kabelová lávka s tvarovkami:KOPOS JUPITER POZINKOVÁNO SENDZIMIR, NEDĚROVANÝ:...) | Length (mm) | CrossSectionArea (m2) | OuterSurfaceArea (m2) | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Délka (mm) | Šířka (mm) | Velikost | Výška (mm) | Kód prvku | Označení | Páteřní trasa | UPRAVIL
933798 | 50 | 3.04 | 0.8 | 3367.57 | 3342.57 | 3342.57 | 3317.57 | Fáze 1 | 7600 | 400 | 400 mmx50 mmø | 50 | KZ03.03.0098 | 0098 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 10:17 | Text - ID_import: 933798
969676 | 50 | 1.51411 | 0.418527 | 3250 | 3225 | 3225 | 3200 | Fáze 1 | 3785.27 | 400 | 400 mmx50 mmø | 50 | KZ03.03.0099 | 0099 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 09:56 | Text - ID_import: 969676
969761 | 100 | 1.2683 | 0.905533 | 3200 | 3150 | 3150 | 3100 | Fáze 2 | 4227.67 | 300 | 300 mmx100 mmø | 100 | KZ03.03.0100 | 0100 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 11:50 | Text - ID_import: 969761
969809 | 50 | 1.79696 | 0.628985 | 3365 | 3340 | 3340 | 3315 | Fáze 2 | 5989.85 | 300 | 300 mmx50 mmø | 50 | KZ03.03.0101 | 0101 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 10:00 | Text - ID_import: 969809
972460 | 60 | 0.015346 | 0.0304152 | 3370 | 3340 | 3340 | 3310 | Fáze 2 | 153.46 | 100 | 100 mmx60 mmø | 60 | KZ03.03.0121 | 0121 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 11:50 | Text - ID_import: 972460
972483 | 50 | 3.64203 | 1.24401 | 3365 | 3340 | 3340 | 3315 | Fáze 2 | 12140.1 | 300 | 300 mmx50 mmø | 50 | KZ03.03.0122 | 0122 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 11:50 | Text - ID_import: 972483
972574 | 60 | 0.0365 | 0.0558 | 3370 | 3340 | 3340 | 3310 | Fáze 2 | 365 | 100 | 100 mmx60 mmø | 60 | KZ03.03.0123 | 0123 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 11:50 | Text - ID_import: 972574
972608 | 60 | 0.17092 | 0.217104 | 3370 | 3340 | 3340 | 3310 | Fáze 2 | 1709.2 | 100 | 100 mmx60 mmø | 60 | KZ03.03.0124 | 0124 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 11:50 | Text - ID_import: 972608
972615 | 60 | 0.015426 | 0.0305112 | 3370 | 3340 | 3340 | 3310 | Fáze 2 | 154.26 | 100 | 100 mmx60 mmø | 60 | KZ03.03.0125 | 0125 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 11:50 | Text - ID_import: 972615
972623 | 60 | 0.1235 | 0.1602 | 3370 | 3340 | 3340 | 3310 | Fáze 2 | 1235 | 100 | 100 mmx60 mmø | 60 | KZ03.03.0126 | 0126 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 11:50 | Text - ID_import: 972623
972701 | 60 | 0.0125 | 0.027 | 3370 | 3340 | 3340 | 3310 | Fáze 2 | 125 | 100 | 100 mmx60 mmø | 60 | KZ03.03.0127 | 0127 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 11:50 | Text - ID_import: 972701
972900 | 50 | 6.45 | 2.18 | 3325 | 3300 | 3300 | 3275 | Fáze 1 | 21500 | 300 | 300 mmx50 mmø | 50 | KZ03.03.0128 | 0128 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02 | Text - ID_import: 972900
998667 | 50 | 0.079286 | 0.0598215 | 3250 | 3225 | 3225 | 3200 | Fáze 1 | 198.215 | 400 | 400 mmx50 mmø | 50 | KZ03.03.0135 | 0135 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 11:53 | Text - ID_import: 998667
999738 | 60 | 0.335391 | 0.414469 | 3370 | 3340 | 3340 | 3310 | Fáze 2 | 3353.91 | 100 | 100 mmx60 mmø | 60 | KZ03.03.0136 | 0136 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 11:50 | Text - ID_import: 999738
999798 | 60 | 0.54569 | 0.666827 | 3370 | 3340 | 3340 | 3310 | Fáze 2 | 5456.9 | 100 | 100 mmx60 mmø | 60 | KZ03.03.0137 | 0137 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 11:50 | Text - ID_import: 999798
1162737 | 400 | 0.0168699 | 0.309919 | 3354 | 3140 | 3333.52 | 3119.52 | Fáze 1 | 337.399 | 400 | 400 mmx50 mmø | 50 | KZ03.03.0186 | 0186 | yes | Fruhauf.vinarice@seznam.cz 2023.07.25 09:56
1173566 | 60 | 0.0280147 | 0.0456177 | 3265 | 3235 | 3235 | 3205 | Fáze 2 | 280.147 | 100 | 100 mmx60 mmø | 60 | KZ03.03.0219 | 0219 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 11:50 | Text - ID_import: 972701
1173631 | 60 | 0.274142 | 0.340971 | 3370 | 3340 | 3340 | 3310 | Fáze 2 | 2741.42 | 100 | 100 mmx60 mmø | 60 | KZ03.03.0220 | 0220
1173667 | 100 | 0.00592721 | 0.0317574 | 3343.64 | 3322.43 | 3252.57 | 3231.36 | Fáze 2 | 98.7868 | 100 | 100 mmx60 mmø | 60 | KZ03.03.0221 | 0221
1173834 | 100 | 0.00592721 | 0.0317574 | 3343.64 | 3322.43 | 3252.57 | 3231.36 | Fáze 2 | 98.7868 | 100 | 100 mmx60 mmø | 60 | KZ03.03.0222 | 0222
1174043 | 100 | 0.437724 | 0.351816 | 3390 | 3340 | 3340 | 3290 | Fáze 2 | 1459.08 | 300 | 300 mmx100 mmø | 100 | KZ03.03.0223 | 0223
1174083 | 300 | 0.0185858 | 0.171515 | 3346.07 | 3310.71 | 3179.29 | 3143.93 | Fáze 2 | 185.858 | 300 | 300 mmx100 mmø | 100 | KZ03.03.0224 | 0224
1174452 | 50 | 3.27015 | 1.12005 | 3365 | 3340 | 3340 | 3315 | Fáze 2 | 10900.5 | 300 | 300 mmx50 mmø | 50 | KZ03.03.0227 | 0227
1174482 | 403.205 | 0.015 | 0.282244 | 3354.95 | 3333.3 | 3131.7 | 3110.05 | Fáze 2 | 403.205 | 300 | 300 mmx50 mmø | 50 | KZ03.03.0228 | 0228
1174552 | 50 | 0.696 | 0.262 | 3150 | 3125 | 3125 | 3100 | Fáze 2 | 2320 | 300 | 300 mmx50 mmø | 50 | KZ03.03.0229 | 0229 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 10:02
1174627 | 50 | 1.37515 | 0.488383 | 3365 | 3340 | 3340 | 3315 | Fáze 2 | 4583.83 | 300 | 300 mmx50 mmø | 50 | KZ03.03.0230 | 0230
1174634 | 403.205 | 0.015 | 0.282244 | 3354.95 | 3333.3 | 3131.7 | 3110.05 | Fáze 2 | 403.205 | 300 | 300 mmx50 mmø | 50 | KZ03.03.0231 | 0231
1175127 | 50 | 1.5724 | 0.554132 | 3250 | 3225 | 3225 | 3200 | Fáze 1 | 5241.32 | 300 | 300 mmx50 mmø | 50 | KZ03.03.0235 | 0235 | yes | Fruhauf.vinarice@seznam.cz 2023.07.19 11:53 | Text - ID_import: 969665
1175308 | 50 | 0.247773 | 0.112591 | 3300 | 3275 | 3275 | 3250 | Fáze 1 | 825.91 | 300 | 300 mmx50 mmø | 50 | KZ03.03.0236 | 0236 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02 | Text - ID_import: 969651
1175444 | 50 | 0.956323 | 0.348774 | 3325 | 3300 | 3300 | 3275 | Fáze 1 | 3187.74 | 300 | 300 mmx50 mmø | 50 | KZ03.03.0237 | 0237
1175464 | 300 | 0.00116025 | 0.043923 | 3314.95 | 3293.3 | 3281.7 | 3260.05 | Fáze 1 | 23.2051 | 300 | 300 mmx50 mmø | 50 | KZ03.03.0238 | 0238
1175483 | 50 | 1.15017 | 0.41339 | 3350 | 3325 | 3325 | 3300 | Fáze 1 | 3833.9 | 300 | 300 mmx50 mmø | 50 | KZ03.03.0239 | 0239
1175488 | 300 | 0.00366025 | 0.073923 | 3339.95 | 3318.3 | 3281.7 | 3260.05 | Fáze 1 | 73.2051 | 300 | 300 mmx50 mmø | 50 | KZ03.03.0240 | 0240
1175543 | 50 | 0.172269 | 0.087423 | 3325 | 3300 | 3300 | 3275 | Fáze 1 | 574.23 | 300 | 300 mmx50 mmø | 50 | KZ03.03.0241 | 0241
1175564 | 300 | 0.00323223 | 0.0687868 | 3303.03 | 3285.36 | 3239.64 | 3221.97 | Fáze 1 | 64.6447 | 300 | 300 mmx50 mmø | 50 | KZ03.03.0242 | 0242
1175861 | 50 | 8.77682 | 2.2342 | 3250 | 3225 | 3225 | 3200 | Fáze 1 | 21942 | 400 | 400 mmx50 mmø | 50 | KZ03.03.0243 | 0243

# IfcCableCarrierSegment: Kabelová lávka s tvarovkami:Kabelový žlab - hranaté tvarovky (12)
In: 1.NP_SO-102
Type - PredefinedType: CABLETRAYSEGMENT
Type - Tvarovky - Horizontální ohyb: Hranaté_žlab_horizontální koleno.CC: Standardní; Kříž: Hranaté_žlab_horizontální křížení.CC: Standardní; Přechod: Hranaté_žlab_přechodka.CC: Standardní; Spojení: Hranaté_žlab_spojení.CC: Standardní; T-spoj: Hranaté_žlab_horizontální spoj T.CC: Standardní; Vertikální vnější ohyb: Hranaté_žlab_vertikální vnější ohyb.CC: Standardní; Vertikální vnitřní ohyb: Hranaté_žlab_vertikální vnitřní ohyb.CC: Standardní
Type - Elektroinstalace - Násobitel poloměru ohybu: 10
Type - Identifikační data - Kód sestavy: KZ03; Název typu: Kabelový žlab - hranaté tvarovky; Označení typu: 04; Popis sestavy: Kabelová lávka a žebřík
Type - Jiné - Kategorie: Kabelové lávky; Název rodiny: Kabelová lávka s tvarovkami
Classification: KZ03 Uniformat (Uniformat)
Qto_CableCarrierSegmentBaseQuantities - Length: 100 mm
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed; Referenční podlaží: 1.NP_SO-102; Horní výška: -10 mm; Koncová střední výška: -60 mm; Počáteční střední výška: -60 mm; Spodní výška: -110 mm; Střední výška: -60 mm
Kóty - Šířka: 200 mm; Velikost: 200 mmx100 mmø; Výška: 100 mm
Jiné - Páteřní trasa: yes; Rodina: Kabelová lávka s tvarovkami; Id typu: 16037; Rodina a typ: Kabelová lávka s tvarovkami: Kabelový žlab - hranaté tvarovky; Typ: Kabelový žlab - hranaté tvarovky; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
Name (Kabelová lávka s tvarovkami:Kabelový žlab - hranaté tvarovky:...) | CrossSectionArea (m2) | OuterSurfaceArea (m2) | ID_import | Fáze vytvoření | Délka (mm) | Kód prvku | Označení
971295 | 1.54839 | 1.58839 | 971295 | Fáze 1 | 7741.95 | KZ03.04.0112 | 0112
971595 | 0.092 | 0.132 | 971595 | Fáze 2 | 460 | KZ03.04.0113 | 0113
971605 | 1.317 | 1.357 | 971605 | Fáze 2 | 6585 | KZ03.04.0114 | 0114
971636 | 3.336 | 3.376 | 971636 | Fáze 2 | 16680 | KZ03.04.0115 | 0115
971647 | 1.392 | 1.432 | 971647 | Fáze 2 | 6960 | KZ03.04.0116 | 0116
971707 | 0.016 | 0.056 | 971707 | Fáze 2 | 80 | KZ03.04.0117 | 0117
971713 | 1.15432 | 1.19432 | 971713 | Fáze 2 | 5771.58 | KZ03.04.0118 | 0118
971718 | 3.38 | 3.42 | 971718 | Fáze 2 | 16900 | KZ03.04.0119 | 0119
971977 | 0.852406 | 0.892406 | 971977 | Fáze 2 | 4262.03 | KZ03.04.0120 | 0120
999814 | 0.58 | 0.62 | 999814 | Fáze 2 | 2900 | KZ03.04.0138 | 0138
999865 | 0.388353 | 0.428353 | 999865 | Fáze 2 | 1941.76 | KZ03.04.0139 | 0139
999913 | 0.128 | 0.168 | 999913 | Fáze 2 | 640 | KZ03.04.0140 | 0140

# IfcCableCarrierSegment: Kabelová lávka s tvarovkami:Parapetní žlab (29)
Type - PredefinedType: CABLETRAYSEGMENT
Type - Tvarovky - Horizontální ohyb: Parapetní žlab_Koleno: Standardní; Spojení: Žlab_Spojka: Standard; T-spoj: Parapetní žlab_Odbočka: Standardní
Type - Elektroinstalace - Násobitel poloměru ohybu: 1
Type - Identifikační data - Kód sestavy: KZ04; Model: PK; Název typu: Parapetní žlab; Označení typu: 02; Popis: Parapetní kanál; Popis sestavy: Parapetní kanály
Type - Jiné - Kategorie: Kabelové lávky; Název rodiny: Kabelová lávka s tvarovkami
Classification: KZ04 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Jiné - Páteřní trasa: yes; Rodina: Kabelová lávka s tvarovkami; Id typu: 16025; Rodina a typ: Kabelová lávka s tvarovkami: Parapetní žlab; Typ: Parapetní žlab; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
Name (Kabelová lávka s tvarovkami:Parapetní žlab:...) | In | Length (mm) = Výška (mm) | CrossSectionArea (m2) | OuterSurfaceArea (m2) | ID_import | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) = Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Délka (mm) | Šířka (mm) | Velikost | Kód prvku | Označení
932868 | 1.NP_SO-102 | 160 | 0.23244 | 1.16512 | 932868 | 1.NP_SO-102 | 1280 | 1200 | 1120 | Fáze 1 | 3576 | 65 | 65 mmx160 mmø | KZ04.02.0092 | 0092
932880 | 1.NP_SO-102 | 160 | 0.291587 | 1.4563 | 932880 | 1.NP_SO-102 | 1280 | 1200 | 1120 | Fáze 1 | 4485.95 | 65 | 65 mmx160 mmø | KZ04.02.0093 | 0093
933075 | 1.NP_SO-102 | 150 | 0.03844 | 0.2046 | 933075 | 1.NP_SO-102 | 1275 | 1200 | 1125 | Fáze 1 | 620 | 62 | 62 mmx150 mmø | KZ04.02.0094 | 0094
933426 | 1.NP_SO-102 | 150 | 0.03844 | 0.2046 | 933426 | 1.NP_SO-102 | 1275 | 1200 | 1125 | Fáze 1 | 620 | 62 | 62 mmx150 mmø | KZ04.02.0095 | 0095
933489 | 1.NP_SO-102 | 150 | 0.093 | 0.4686 | 933489 | 1.NP_SO-102 | 1275 | 1200 | 1125 | Fáze 2 | 1500 | 62 | 62 mmx150 mmø | KZ04.02.0096 | 0096
933504 | 1.NP_SO-102 | 150 | 0.186 | 0.9186 | 933504 | 1.NP_SO-102 | 1275 | 1200 | 1125 | Fáze 2 | 3000 | 62 | 62 mmx150 mmø | KZ04.02.0097 | 0097
970331 | 1.NP_SO-102 | 125 | 0.069688 | 0.2965 | 970331 | 1.NP_SO-102 | 1262.5 | 1200 | 1137.5 | Fáze 2 | 1124 | 62 | 62 mmx125 mmø | KZ04.02.0102 | 0102
970337 | 1.NP_SO-102 | 125 | 0.270661 | 1.10688 | 970337 | 1.NP_SO-102 | 1262.5 | 1200 | 1137.5 | Fáze 2 | 4365.5 | 62 | 62 mmx125 mmø | KZ04.02.0103 | 0103
970346 | 1.NP_SO-102 | 125 | 0.081406 | 0.34375 | 970346 | 1.NP_SO-102 | 1262.5 | 1200 | 1137.5 | Fáze 2 | 1313 | 62 | 62 mmx125 mmø | KZ04.02.0104 | 0104
970353 | 1.NP_SO-102 | 125 | 0.190898 | 0.78525 | 970353 | 1.NP_SO-102 | 1262.5 | 1200 | 1137.5 | Fáze 2 | 3079 | 62 | 62 mmx125 mmø | KZ04.02.0105 | 0105
970589 | 1.NP_SO-102 | 125 | 0.100533 | 0.420875 | 970589 | 1.NP_SO-102 | 1262.5 | 1200 | 1137.5 | Fáze 1 | 1621.5 | 62 | 62 mmx125 mmø | KZ04.02.0106 | 0106
970595 | 1.NP_SO-102 | 125 | 0.080383 | 0.339625 | 970595 | 1.NP_SO-102 | 1262.5 | 1200 | 1137.5 | Fáze 1 | 1296.5 | 62 | 62 mmx125 mmø | KZ04.02.0107 | 0107
970600 | 1.NP_SO-102 | 125 | 0.034813 | 0.155875 | 970600 | 1.NP_SO-102 | 1262.5 | 1200 | 1137.5 | Fáze 1 | 561.5 | 62 | 62 mmx125 mmø | KZ04.02.0108 | 0108
970814 | 1.NP_SO-102 | 125 | 0.186 | 0.7655 | 970814 | 1.NP_SO-102 | 1262.5 | 1200 | 1137.5 | Fáze 1 | 3000 | 62 | 62 mmx125 mmø | KZ04.02.0109 | 0109
970826 | 1.NP_SO-102 | 125 | 0.186 | 0.7655 | 970826 | 1.NP_SO-102 | 1262.5 | 1200 | 1137.5 | Fáze 1 | 3000 | 62 | 62 mmx125 mmø | KZ04.02.0110 | 0110
970848 | 1.NP_SO-102 | 125 | 0.0992 | 0.4155 | 970848 | 1.NP_SO-102 | 562.5 | 500 | 437.5 | Fáze 1 | 1600 | 62 | 62 mmx125 mmø | KZ04.02.0111 | 0111
1007617 | 4.NP_SO-102 | 125 | 0.053878 | 0.23275 | 1007617 | 4.NP_SO-102 | 1112.5 | 1050 | 987.5 | Fáze 2 | 869 | 62 | 62 mmx125 mmø | KZ04.02.0141 | 0141
1007621 | 4.NP_SO-102 | 125 | 0.102796 | 0.43 | 1007621 | 4.NP_SO-102 | 1112.5 | 1050 | 987.5 | Fáze 2 | 1658 | 62 | 62 mmx125 mmø | KZ04.02.0142 | 0142
1007631 | 4.NP_SO-102 | 125 | 0.114421 | 0.476875 | 1007631 | 4.NP_SO-102 | 1112.5 | 1050 | 987.5 | Fáze 2 | 1845.5 | 62 | 62 mmx125 mmø | KZ04.02.0143 | 0143
1007636 | 4.NP_SO-102 | 125 | 0.0403 | 0.178 | 1007636 | 4.NP_SO-102 | 1112.5 | 1050 | 987.5 | Fáze 2 | 650 | 62 | 62 mmx125 mmø | KZ04.02.0144 | 0144
1081399 | 1.NP_SO-102 | 150 | 0.496 | 2.4186 | 1081399 | 1.NP_SO-102 | 1275 | 1200 | 1125 | Fáze 1 | 8000 | 62 | 62 mmx150 mmø | KZ04.02.0151 | 0151
1081407 | 1.NP_SO-102 | 150 | 0.186 | 0.9186 | 1081407 | 1.NP_SO-102 | 1275 | 1200 | 1125 | Fáze 1 | 3000 | 62 | 62 mmx150 mmø | KZ04.02.0152 | 0152
1081415 | 1.NP_SO-102 | 150 | 0.186 | 0.9186 | 1081415 | 1.NP_SO-102 | 1275 | 1200 | 1125 | Fáze 1 | 3000 | 62 | 62 mmx150 mmø | KZ04.02.0153 | 0153
1081423 | 1.NP_SO-102 | 150 | 0.496 | 2.4186 | 1081423 | 1.NP_SO-102 | 1275 | 1200 | 1125 | Fáze 1 | 8000 | 62 | 62 mmx150 mmø | KZ04.02.0154 | 0154
1081885 | 1.NP_SO-102 | 160 | 0.2535 | 1.2688 | 1081885 | 1.NP_SO-102 | 1280 | 1200 | 1120 | Fáze 1 | 3900 | 65 | 65 mmx160 mmø | KZ04.02.0155 | 0155
1082060 | 1.NP_SO-102 | 160 | 0.111312 | 0.5688 | 1082060 | 1.NP_SO-102 | 1280 | 1200 | 1120 | Fáze 1 | 1712.5 | 65 | 65 mmx160 mmø | KZ04.02.0156 | 0156
1082193 | 1.NP_SO-102 | 160 | 0.255083 | 1.27659 | 1082193 | 1.NP_SO-102 | 1308.28 | 1228.28 | 1148.28 | Fáze 1 | 3924.35 | 65 | 65 mmx160 mmø | KZ04.02.0157 | 0157
1090568 | 1.NP_SO-102 | 160 | 0.256913 | 1.2856 | 1090568 | 1.NP_SO-102 | 1280 | 1200 | 1120 | Fáze 1 | 3952.5 | 65 | 65 mmx160 mmø | KZ04.02.0158 | 0158
1096352 | 1.NP_SO-102 | 160 | 0.0637 | 0.3344 | 1096352 | 1.NP_SO-102 | 1280 | 1200 | 1120 | Fáze 1 | 980 | 65 | 65 mmx160 mmø | KZ04.02.0159 | 0159

# IfcDistributionPort (2266)
Description: Flow; FlowDirection: SOURCEANDSINK
Name | PredefinedType | SystemType
Port_927807_1 | CABLECARRIER | CONVEYING
Port_1002242_3 | CABLECARRIER | CONVEYING
Port_929343_0 | CABLECARRIER | CONVEYING
Port_995145_3 | CABLECARRIER | CONVEYING
Port_929361_0 | CABLECARRIER | CONVEYING
Port_996950_2 | CABLECARRIER | CONVEYING
Port_929361_1 | CABLECARRIER | CONVEYING
Port_930306_3 | CABLECARRIER | CONVEYING
Port_929381_0 | CABLECARRIER | CONVEYING
Port_930477_1 | CABLECARRIER | CONVEYING
Port_929616_0 | CABLECARRIER | CONVEYING
Port_929819_2 | CABLECARRIER | CONVEYING
Port_929616_1 | CABLECARRIER | CONVEYING
Port_929800_1 | CABLECARRIER | CONVEYING
Port_929813_0 | CABLECARRIER | CONVEYING
Port_929819_3 | CABLECARRIER | CONVEYING
Port_929813_1 | CABLECARRIER | CONVEYING
Port_996207_3 | CABLECARRIER | CONVEYING
Port_929819_1 | CABLECARRIER | CONVEYING
Port_1063696_0 | CABLECARRIER | CONVEYING
Port_930057_1 | CABLECARRIER | CONVEYING
Port_930058_0 | CABLECARRIER | CONVEYING
Port_930343_1 | CABLECARRIER | CONVEYING
Port_930058_1 | CABLECARRIER | CONVEYING
Port_930173_2 | CABLECARRIER | CONVEYING
Port_1177648_1 | CABLECARRIER | CONVEYING
Port_930174_1 | CABLECARRIER | CONVEYING
Port_930253_0 | CABLECARRIER | CONVEYING
Port_930257_3 | CABLECARRIER | CONVEYING
Port_930253_1 | CABLECARRIER | CONVEYING
Port_930257_1 | CABLECARRIER | CONVEYING
Port_1179086_1 | CABLECARRIER | CONVEYING
Port_930257_2 | CABLECARRIER | CONVEYING
Port_930258_1 | CABLECARRIER | CONVEYING
Port_930258_0 | CABLECARRIER | CONVEYING
Port_930423_2 | CABLECARRIER | CONVEYING
Port_930267_0 | CABLECARRIER | CONVEYING
Port_930340_2 | CABLECARRIER | CONVEYING
Port_930267_1 | CABLECARRIER | CONVEYING
Port_930306_1 | CABLECARRIER | CONVEYING
Port_1179169_1 | CABLECARRIER | CONVEYING
Port_930334_1 | CABLECARRIER | CONVEYING
Port_930340_3 | CABLECARRIER | CONVEYING
Port_930340_1 | CABLECARRIER | CONVEYING
Port_1164441_0 | CABLECARRIER | CONVEYING
Port_930341_1 | CABLECARRIER | CONVEYING
Port_930343_2 | CABLECARRIER | CONVEYING
Port_1164103_0 | CABLECARRIER | CONVEYING
Port_930370_1 | CABLECARRIER | CONVEYING
Port_930423_1 | CABLECARRIER | CONVEYING
Port_930424_1 | CABLECARRIER | CONVEYING
Port_930469_0 | CABLECARRIER | CONVEYING
Port_931841_1 | CABLECARRIER | CONVEYING
Port_930477_2 | CABLECARRIER | CONVEYING
Port_930478_1 | CABLECARRIER | CONVEYING
Port_930510_0 | CABLECARRIER | CONVEYING
Port_932020_1 | CABLECARRIER | CONVEYING
Port_930537_0 | CABLECARRIER | CONVEYING
Port_932017_2 | CABLECARRIER | CONVEYING
Port_930774_0 | CABLECARRIER | CONVEYING
Port_930783_3 | CABLECARRIER | CONVEYING
Port_930774_1 | CABLECARRIER | CONVEYING
Port_930962_3 | CABLECARRIER | CONVEYING
Port_930777_0 | CABLECARRIER | CONVEYING
Port_930962_2 | CABLECARRIER | CONVEYING
Port_930777_1 | CABLECARRIER | CONVEYING
Port_930781_0 | CABLECARRIER | CONVEYING
Port_995880_1 | CABLECARRIER | CONVEYING
Port_930781_1 | CABLECARRIER | CONVEYING
Port_930782_0 | CABLECARRIER | CONVEYING
Port_930789_2 | CABLECARRIER | CONVEYING
Port_930782_1 | CABLECARRIER | CONVEYING
Port_930783_1 | CABLECARRIER | CONVEYING
Port_993844_0 | CABLECARRIER | CONVEYING
Port_930783_2 | CABLECARRIER | CONVEYING
Port_1166717_0 | CABLECARRIER | CONVEYING
Port_930788_0 | CABLECARRIER | CONVEYING
Port_930789_3 | CABLECARRIER | CONVEYING
Port_930788_1 | CABLECARRIER | CONVEYING
Port_995880_3 | CABLECARRIER | CONVEYING
Port_930789_1 | CABLECARRIER | CONVEYING
Port_1172895_0 | CABLECARRIER | CONVEYING
Port_930790_1 | CABLECARRIER | CONVEYING
Port_930796_0 | CABLECARRIER | CONVEYING
Port_993843_2 | CABLECARRIER | CONVEYING
Port_930796_1 | CABLECARRIER | CONVEYING
Port_930962_1 | CABLECARRIER | CONVEYING
Port_1166428_0 | CABLECARRIER | CONVEYING
Port_931081_0 | CABLECARRIER | CONVEYING
Port_1157577_3 | CABLECARRIER | CONVEYING
Port_931081_1 | CABLECARRIER | CONVEYING
Port_931114_0 | CABLECARRIER | CONVEYING
Port_1157577_1 | CABLECARRIER | CONVEYING
Port_931158_0 | CABLECARRIER | CONVEYING
Port_931158_1 | CABLECARRIER | CONVEYING
Port_931199_0 | CABLECARRIER | CONVEYING
Port_931555_2 | CABLECARRIER | CONVEYING
Port_931217_1 | CABLECARRIER | CONVEYING
Port_931225_1 | CABLECARRIER | CONVEYING
Port_1157578_0 | CABLECARRIER | CONVEYING
Port_931225_2 | CABLECARRIER | CONVEYING
Port_931226_1 | CABLECARRIER | CONVEYING
Port_931226_0 | CABLECARRIER | CONVEYING
Port_931247_0 | CABLECARRIER | CONVEYING
Port_931333_2 | CABLECARRIER | CONVEYING
Port_931247_1 | CABLECARRIER | CONVEYING
Port_931323_0 | CABLECARRIER | CONVEYING
Port_931333_3 | CABLECARRIER | CONVEYING
