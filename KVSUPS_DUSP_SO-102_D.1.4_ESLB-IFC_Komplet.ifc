Properties of the parts of a building model (IFC4), part 9 of 9

# IfcElectricAppliance: Datová zásuvka_vícerámečky.CC:Dvojzásuvka (218)
Name (Datová zásuvka_vícerámečky.CC:Dvojzásuvka:...) | In | ID_import | Podlaží = Vztažné podlaží | Hostitel | Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení | UPRAVIL
1007939 | 4.NP_SO-102 | 1007939 | 4.NP_SO-102 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | Fáze 2 | ZZ03.06.0902 | 0902 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1007971 | 4.NP_SO-102 | 1007971 | 4.NP_SO-102 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | Fáze 2 | ZZ03.06.0903 | 0903 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1008007 | 4.NP_SO-102 | 1008007 | 4.NP_SO-102 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | Fáze 2 | ZZ03.06.0904 | 0904 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1008082 | 4.NP_SO-102 | 1008082 | 4.NP_SO-102 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | Fáze 2 | ZZ03.06.0905 | 0905 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1008112 | 4.NP_SO-102 | 1008112 | 4.NP_SO-102 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | Fáze 2 | ZZ03.06.0906 | 0906 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1008134 | 4.NP_SO-102 | 1008134 | 4.NP_SO-102 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | Fáze 2 | ZZ03.06.0907 | 0907 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1008224 | 4.NP_SO-102 | 1008224 | 4.NP_SO-102 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | Fáze 2 | ZZ03.06.0908 | 0908 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1008231 | 4.NP_SO-102 | 1008231 | 4.NP_SO-102 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | Fáze 2 | ZZ03.06.0909 | 0909 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1008285 | 4.NP_SO-102 | 1008285 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 2x | 950 | Fáze 2 | ZZ03.06.0910 | 0910 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1008295 | 4.NP_SO-102 | 1008295 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 2x | 950 | Fáze 2 | ZZ03.06.0911 | 0911 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1008367 | 4.NP_SO-102 | 1008367 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 2x | 950 | Fáze 2 | ZZ03.06.0912 | 0912 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1008459 | 4.NP_SO-102 | 1008459 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 2x | 950 | Fáze 2 | ZZ03.06.0913 | 0913 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1008684 | 4.NP_SO-102 | 1008684 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 2x | 950 | Fáze 1 | ZZ03.06.0928 | 0928 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1008695 | 4.NP_SO-102 | 1008695 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 2x | 950 | Fáze 1 | ZZ03.06.0929 | 0929 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1008797 | 4.NP_SO-102 | 1008797 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 2x | 950 | Fáze 1 | ZZ03.06.0930 | 0930 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1008983 | 4.NP_SO-102 | 1008983 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 2x | 950 | Fáze 1 | ZZ03.06.0931 | 0931 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1070551 | 3.NP_SO-102 | 1070551 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 1 | ZZ03.06.1040 | 1040 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1091073 | 2.NP_SO-102 | 1091073 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 5x | 300 | Fáze 1 | ZZ03.06.1098 | 1098 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1091106 | 2.NP_SO-102 | 1091106 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 5x | 300 | Fáze 1 | ZZ03.06.1099 | 1099 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1091113 | 2.NP_SO-102 | 1091113 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 5x | 300 | Fáze 1 | ZZ03.06.1100 | 1100 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1091119 | 2.NP_SO-102 | 1091119 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 5x | 300 | Fáze 1 | ZZ03.06.1101 | 1101 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1091125 | 2.NP_SO-102 | 1091125 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 5x | 300 | Fáze 1 | ZZ03.06.1102 | 1102 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1091131 | 2.NP_SO-102 | 1091131 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 5x | 300 | Fáze 1 | ZZ03.06.1103 | 1103 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1091137 | 2.NP_SO-102 | 1091137 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 5x | 300 | Fáze 1 | ZZ03.06.1104 | 1104 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1091143 | 2.NP_SO-102 | 1091143 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 5x | 300 | Fáze 1 | ZZ03.06.1105 | 1105 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1091149 | 2.NP_SO-102 | 1091149 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 5x | 300 | Fáze 1 | ZZ03.06.1106 | 1106 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1091155 | 2.NP_SO-102 | 1091155 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 5x | 300 | Fáze 1 | ZZ03.06.1107 | 1107 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16

# IfcElectricAppliance: Digitální hodiny.CC:Digitální hodiny.CC (42)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - Počet fází: 1
Type - Grafika - Symbol: yes
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.50.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: PN00; Komentáře k typům: digitální; Model: Model; Nadpis OmniClass: Communication and Data Processing Equipment; Název typu: Digitální hodiny.CC; Označení typu: 11; Popis: Hodiny; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - Kategorie: Datová zařízení; Název rodiny: Digitální hodiny.CC
Classification: PN00 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: PGK; CCI Technický systém: JL
Vazby - Odsazení od hostitele: 2300 mm; Výška od podlaží: 2300 mm
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - HLOUBKA: 100 mm; Objem: 0.0149092 m3; Posun písma od středu: 170 mm; ŠÍŘKA: 400 mm; VÝŠKA: 400 mm
Jiné - a: 143.333 mm; Id typu: 1065663; Rodina: Digitální hodiny.CC; Rodina a typ: Digitální hodiny.CC: Digitální hodiny.CC; Typ: Digitální hodiny.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 11:21; Výška písma: 113.333 mm
Name (Digitální hodiny.CC:Digitální hodiny.CC:...) | In | ID_import | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
1065680 | 1.NP_SO-102 | 1065680 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | PN00.11.0946 | 0946
1065688 | 1.NP_SO-102 | 1065688 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | PN00.11.0947 | 0947
1065696 | 1.NP_SO-102 | 1065696 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | PN00.11.0948 | 0948
1065704 | 1.NP_SO-102 | 1065704 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | PN00.11.0949 | 0949
1065712 | 1.NP_SO-102 | 1065712 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | PN00.11.0950 | 0950
1065716 | 1.NP_SO-102 | 1065716 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | PN00.11.0951 | 0951
1065723 | 1.NP_SO-102 | 1065723 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | PN00.11.0952 | 0952
1065727 | 1.NP_SO-102 | 1065727 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | PN00.11.0953 | 0953
1065814 | -1.PP_SO-102 | 1065814 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | PN00.11.0954 | 0954
1065818 | -1.PP_SO-102 | 1065818 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | PN00.11.0955 | 0955
1065822 | -1.PP_SO-102 | 1065822 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | PN00.11.0956 | 0956
1065826 | -1.PP_SO-102 | 1065826 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | PN00.11.0957 | 0957
1065830 | -1.PP_SO-102 | 1065830 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | PN00.11.0958 | 0958
1065834 | -1.PP_SO-102 | 1065834 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | PN00.11.0959 | 0959
1065841 | 1.NP_SO-102 | 1065841 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | PN00.11.0960 | 0960
1065860 | 2.NP_SO-102 | 1065860 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PN00.11.0961 | 0961
1065868 | 2.NP_SO-102 | 1065868 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PN00.11.0962 | 0962
1065872 | 2.NP_SO-102 | 1065872 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PN00.11.0963 | 0963
1065876 | 2.NP_SO-102 | 1065876 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PN00.11.0964 | 0964
1065880 | 2.NP_SO-102 | 1065880 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PN00.11.0965 | 0965
1065887 | 2.NP_SO-102 | 1065887 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | PN00.11.0966 | 0966
1065891 | 2.NP_SO-102 | 1065891 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | PN00.11.0967 | 0967
1065902 | 2.NP_SO-102 | 1065902 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PN00.11.0968 | 0968
1065906 | 2.NP_SO-102 | 1065906 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PN00.11.0969 | 0969
1065918 | 2.NP_SO-102 | 1065918 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PN00.11.0970 | 0970
1065952 | 3.NP_SO-102 | 1065952 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PN00.11.0971 | 0971
1065960 | 3.NP_SO-102 | 1065960 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PN00.11.0972 | 0972
1065964 | 3.NP_SO-102 | 1065964 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PN00.11.0973 | 0973
1065968 | 3.NP_SO-102 | 1065968 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PN00.11.0974 | 0974
1065972 | 3.NP_SO-102 | 1065972 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PN00.11.0975 | 0975
1065994 | 3.NP_SO-102 | 1065994 | 3.NP_SO-102 | Kabelová lávka s tvarovkami : KOPOS JUPITER POZINKOVÁNO SENDZIMIR | Fáze 1 | PN00.11.0976 | 0976
1066015 | 3.NP_SO-102 | 1066015 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | PN00.11.0977 | 0977
1066019 | 3.NP_SO-102 | 1066019 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | PN00.11.0978 | 0978
1066030 | 4.NP_SO-102 | 1066030 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PN00.11.0979 | 0979
1066034 | 4.NP_SO-102 | 1066034 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PN00.11.0980 | 0980
1066042 | 4.NP_SO-102 | 1066042 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PN00.11.0981 | 0981
1066046 | 4.NP_SO-102 | 1066046 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PN00.11.0982 | 0982
1066050 | 4.NP_SO-102 | 1066050 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PN00.11.0983 | 0983
1066058 | 4.NP_SO-102 | 1066058 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PN00.11.0984 | 0984
1066062 | 4.NP_SO-102 | 1066062 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PN00.11.0985 | 0985
1066069 | 4.NP_SO-102 | 1066069 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | PN00.11.0986 | 0986
1066073 | 4.NP_SO-102 | 1066073 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | PN00.11.0987 | 0987

# IfcElectricAppliance: Dveřní interkom.CC:Dveřní interkom.CC (6)
Type - Material: <Unnamed>
Type - Elektroinstalace - PŘÍKON: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - Počet fází: 1; NAPĚTÍ: 230 V
Type - Grafika - Symbol: yes
Type - Kóty - Hloubka zapuštění: 0 mm; HLOUBKA: 30 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.10.17.11.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: OL02; Komentáře k typům: dveřní; Model: Model; Nadpis OmniClass: Broadcasting Receiving Equipment; Název typu: Dveřní interkom.CC; Označení typu: 10; Popis: Interkom; Popis sestavy: Dveřní interkom; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - FAKTOR ÚČINNOSTI: 1; Kategorie: Datová zařízení; Název rodiny: Dveřní interkom.CC
Classification: OL02 Uniformat (Uniformat)
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: M; CCI Komponenta: SZA; CCI Technický systém: JL
Vazby - Odsazení od hostitele: 1500 mm; Výška od podlaží: 1500 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.0005874 m3; ŠÍŘKA: 100 mm; VÝŠKA: 200 mm
Jiné - Id typu: 1027584; Rodina: Dveřní interkom.CC; Rodina a typ: Dveřní interkom.CC: Dveřní interkom.CC; Typ: Dveřní interkom.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:01
Name (Dveřní interkom.CC:Dveřní interkom.CC:...) | In | ID_import | Podlaží | Hostitel | Kód prvku | Označení
1027606 | -1.PP_SO-102 | 1027606 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | OL02.10.0938 | 0938
1027615 | -1.PP_SO-102 | 1027615 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | OL02.10.0939 | 0939
1028496 | 1.NP_SO-102 | 1028496 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | OL02.10.0941 | 0941
1089439 | -1.PP_SO-102 | 1089439 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | OL02.10.1093 | 1093
1089508 | -1.PP_SO-102 | 1089508 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | OL02.10.1094 | 1094
1089555 | -1.PP_SO-102 | 1089555 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | OL02.10.1095 | 1095

# IfcElectricAppliance: HDMI zásuvka do PK.CC:Jednozásuvka 1x modul (58)
Type - Material: Bílá
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Grafika - Dvojzásuvka: no; Jednozásuvka: yes; Typ symbolu: HDMI zásuvka.CC
Type - Kóty - HLOUBKA: 10 mm; ŠÍŘKA: 22.5 mm; VÝŠKA: 45 mm
Type - Identifikační data - Číslo OmniClass: 23.85.50.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZZ03; Komentáře k typům: Datová zásuvka; Model: Model; Nadpis OmniClass: Communication and Data Processing Equipment; Název typu: Jednozásuvka 1x modul; Označení typu: 07; Popis: Zásuvka; Popis sestavy: Datová; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Datová zařízení; Název rodiny: HDMI zásuvka do PK.CC
Classification: ZZ03 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Vazby - Výška od podlaží: 0 mm
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.000010125 m3
Jiné - Typ: Jednozásuvka 1x modul; Id typu: 980995; Rodina: HDMI zásuvka do PK.CC; Rodina a typ: HDMI zásuvka do PK.CC: Jednozásuvka 1x modul; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
Name (HDMI zásuvka do PK.CC:Jednozásuvka 1x modul:...) | In | ID_import | Podlaží = Vztažné podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
976799 | 2.NP_SO-102 | 976799 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.07.0211 | 0211
978768 | 2.NP_SO-102 | 978768 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.07.0213 | 0213
978870 | 2.NP_SO-102 | 978870 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.07.0215 | 0215
978876 | 2.NP_SO-102 | 978876 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.07.0216 | 0216
978882 | 2.NP_SO-102 | 978882 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.07.0217 | 0217
978888 | 2.NP_SO-102 | 978888 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.07.0218 | 0218
978894 | 2.NP_SO-102 | 978894 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.07.0219 | 0219
978906 | 2.NP_SO-102 | 978906 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.07.0220 | 0220
978912 | 2.NP_SO-102 | 978912 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.07.0221 | 0221
978918 | 2.NP_SO-102 | 978918 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.07.0222 | 0222
978924 | 2.NP_SO-102 | 978924 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.07.0223 | 0223
981030 | 2.NP_SO-102 | 981030 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.07.0224 | 0224
997296 | 2.NP_SO-102 | 997296 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.07.0396 | 0396
1000243 | 3.NP_SO-102 | 1000243 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.0415 | 0415
1000280 | 4.NP_SO-102 | 1000280 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.07.0418 | 0418
1000324 | 3.NP_SO-102 | 1000324 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.0421 | 0421
1000342 | 3.NP_SO-102 | 1000342 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.0424 | 0424
1000360 | 3.NP_SO-102 | 1000360 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.0427 | 0427
1000378 | 3.NP_SO-102 | 1000378 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.0430 | 0430
1000396 | 3.NP_SO-102 | 1000396 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.07.0433 | 0433
1000414 | 3.NP_SO-102 | 1000414 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.07.0436 | 0436
1000436 | 3.NP_SO-102 | 1000436 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.07.0439 | 0439
1000454 | 3.NP_SO-102 | 1000454 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.07.0442 | 0442
1000474 | 3.NP_SO-102 | 1000474 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZZ03.07.0445 | 0445
1000494 | 3.NP_SO-102 | 1000494 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.0448 | 0448
1000512 | 3.NP_SO-102 | 1000512 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.0451 | 0451
1001010 | 4.NP_SO-102 | 1001010 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.07.0478 | 0478
1001028 | 4.NP_SO-102 | 1001028 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.07.0481 | 0481
1001048 | 4.NP_SO-102 | 1001048 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.07.0484 | 0484
1001066 | 4.NP_SO-102 | 1001066 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.07.0487 | 0487
1001084 | 4.NP_SO-102 | 1001084 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.07.0490 | 0490
1002942 | 3.NP_SO-102 | 1002942 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.0693 | 0693
1002964 | 3.NP_SO-102 | 1002964 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.0696 | 0696
1003020 | 3.NP_SO-102 | 1003020 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.0697 | 0697
1003030 | 3.NP_SO-102 | 1003030 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.0698 | 0698
1003071 | 3.NP_SO-102 | 1003071 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.0699 | 0699
1003072 | 3.NP_SO-102 | 1003072 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.0700 | 0700
1066111 | 3.NP_SO-102 | 1066111 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.0990 | 0990
1066185 | 3.NP_SO-102 | 1066185 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.0993 | 0993 | Fázování - Fáze demolice: Fáze 1
1066199 | 3.NP_SO-102 | 1066199 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.0996 | 0996 | Fázování - Fáze demolice: Fáze 1
1066213 | 3.NP_SO-102 | 1066213 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.0999 | 0999 | Fázování - Fáze demolice: Fáze 1
1066241 | 3.NP_SO-102 | 1066241 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.1002 | 1002 | Fázování - Fáze demolice: Fáze 1
1066255 | 3.NP_SO-102 | 1066255 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.1005 | 1005 | Fázování - Fáze demolice: Fáze 1
1066269 | 3.NP_SO-102 | 1066269 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.1008 | 1008 | Fázování - Fáze demolice: Fáze 1
1066283 | 3.NP_SO-102 | 1066283 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.1011 | 1011 | Fázování - Fáze demolice: Fáze 1
1066297 | 3.NP_SO-102 | 1066297 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.1014 | 1014 | Fázování - Fáze demolice: Fáze 1
1066311 | 3.NP_SO-102 | 1066311 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.1017 | 1017 | Fázování - Fáze demolice: Fáze 1
1066339 | 3.NP_SO-102 | 1066339 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.1020 | 1020 | Fázování - Fáze demolice: Fáze 1
1066353 | 3.NP_SO-102 | 1066353 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.1023 | 1023 | Fázování - Fáze demolice: Fáze 1
1066367 | 3.NP_SO-102 | 1066367 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.1026 | 1026 | Fázování - Fáze demolice: Fáze 1
1070407 | 3.NP_SO-102 | 1070407 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.1035 | 1035
1070599 | 3.NP_SO-102 | 1070599 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.1044 | 1044
1080073 | 3.NP_SO-102 | 1080073 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.1056 | 1056
1080125 | 3.NP_SO-102 | 1080125 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.07.1058 | 1058
1080158 | 2.NP_SO-102 | 1080158 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.07.1060 | 1060
1080279 | 2.NP_SO-102 | 1080279 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.07.1062 | 1062
1080317 | 2.NP_SO-102 | 1080317 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.07.1064 | 1064
1080331 | 2.NP_SO-102 | 1080331 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.07.1066 | 1066

# IfcElectricAppliance: HDMI zásuvka_vícerámečky.CC:Dvojzásuvka (34)
Type - Material: Bílá
Type - Vazby - Výchozí výška: 2557 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Grafika - Dvojzásuvka: yes; Jednozásuvka: no; Šířka: 45 mm; Typ symbolu: HDMI zásuvka.CC
Type - Kóty - Hloubka: 10 mm
Type - Identifikační data - Číslo OmniClass: 23.85.50.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZZ03; Komentáře k typům: druhá klapka; Model: Model; Nadpis OmniClass: Communication and Data Processing Equipment; Název typu: Dvojzásuvka; Označení typu: 08; Popis: Vypínač; Popis sestavy: Datová; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Datová zařízení; Název rodiny: HDMI zásuvka_vícerámečky.CC
Classification: ZZ03 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Vazby - Hostitel: Vícerámečky, vodovné.CC : Vícerámečky - 4x
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.00002025 m3
Jiné - Typ: Dvojzásuvka; Id typu: 976766; Rodina: HDMI zásuvka_vícerámečky.CC; Rodina a typ: HDMI zásuvka_vícerámečky.CC: Dvojzásuvka
Name (HDMI zásuvka_vícerámečky.CC:Dvojzásuvka:...) | In | ID_import | Podlaží = Vztažné podlaží | Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení | UPRAVIL
978640 | 2.NP_SO-102 | 978640 | 2.NP_SO-102 | 2557.04 | Fáze 1 | ZZ03.08.0212 | 0212 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
978778 | 2.NP_SO-102 | 978778 | 2.NP_SO-102 | 25570 | Fáze 1 | ZZ03.08.0214 | 0214 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
985018 | 2.NP_SO-102 | 985018 | 2.NP_SO-102 | 2556.94 | Fáze 1 | ZZ03.08.0227 | 0227 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
989520 | 2.NP_SO-102 | 989520 | 2.NP_SO-102 | 2557 | Fáze 1 | ZZ03.08.0257 | 0257 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
989632 | 2.NP_SO-102 | 989632 | 2.NP_SO-102 | 2557 | Fáze 1 | ZZ03.08.0258 | 0258 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
989645 | 2.NP_SO-102 | 989645 | 2.NP_SO-102 | 2557 | Fáze 1 | ZZ03.08.0259 | 0259 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
989754 | 2.NP_SO-102 | 989754 | 2.NP_SO-102 | 2557 | Fáze 1 | ZZ03.08.0260 | 0260 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
989997 | 2.NP_SO-102 | 989997 | 2.NP_SO-102 | 2557 | Fáze 2 | ZZ03.08.0261 | 0261 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
990013 | 2.NP_SO-102 | 990013 | 2.NP_SO-102 | 2557 | Fáze 2 | ZZ03.08.0262 | 0262 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
990151 | 2.NP_SO-102 | 990151 | 2.NP_SO-102 | 2557 | Fáze 2 | ZZ03.08.0263 | 0263 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
990258 | 2.NP_SO-102 | 990258 | 2.NP_SO-102 | 2557 | Fáze 2 | ZZ03.08.0264 | 0264 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
990444 | 2.NP_SO-102 | 990444 | 2.NP_SO-102 | 2557 | Fáze 2 | ZZ03.08.0265 | 0265 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
990569 | 2.NP_SO-102 | 990569 | 2.NP_SO-102 | 2557 | Fáze 2 | ZZ03.08.0266 | 0266 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
990697 | 2.NP_SO-102 | 990697 | 2.NP_SO-102 | 2557 | Fáze 1 | ZZ03.08.0267 | 0267 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1003147 | 3.NP_SO-102 | 1003147 | 3.NP_SO-102 | 2557 | Fáze 1 | ZZ03.08.0702 | 0702 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
1003230 | 3.NP_SO-102 | 1003230 | 3.NP_SO-102 | 2557 | Fáze 1 | ZZ03.08.0704 | 0704 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
1003249 | 3.NP_SO-102 | 1003249 | 3.NP_SO-102 | 2557 | Fáze 2 | ZZ03.08.0706 | 0706 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
1003268 | 3.NP_SO-102 | 1003268 | 3.NP_SO-102 | 2557 | Fáze 2 | ZZ03.08.0708 | 0708 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
1003322 | 3.NP_SO-102 | 1003322 | 3.NP_SO-102 | 2557 | Fáze 1 | ZZ03.08.0710 | 0710 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
1003352 | 3.NP_SO-102 | 1003352 | 3.NP_SO-102 | 2557 | Fáze 1 | ZZ03.08.0712 | 0712 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
1003370 | 3.NP_SO-102 | 1003370 | 3.NP_SO-102 | 2557 | Fáze 1 | ZZ03.08.0714 | 0714 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
1003388 | 3.NP_SO-102 | 1003388 | 3.NP_SO-102 | 2557 | Fáze 1 | ZZ03.08.0716 | 0716 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1003402 | 3.NP_SO-102 | 1003402 | 3.NP_SO-102 | 2557 | Fáze 1 | ZZ03.08.0718 | 0718 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1003419 | 3.NP_SO-102 | 1003419 | 3.NP_SO-102 | 2557 | Fáze 1 | ZZ03.08.0720 | 0720 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
1003433 | 3.NP_SO-102 | 1003433 | 3.NP_SO-102 | 2557 | Fáze 2 | ZZ03.08.0722 | 0722 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
1003447 | 3.NP_SO-102 | 1003447 | 3.NP_SO-102 | 2557 | Fáze 2 | ZZ03.08.0724 | 0724 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
1003461 | 3.NP_SO-102 | 1003461 | 3.NP_SO-102 | 2557 | Fáze 2 | ZZ03.08.0726 | 0726 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
1003859 | 4.NP_SO-102 | 1003859 | 4.NP_SO-102 | 2557 | Fáze 1 | ZZ03.08.0731 | 0731 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
1003922 | 4.NP_SO-102 | 1003922 | 4.NP_SO-102 | 2557 | Fáze 1 | ZZ03.08.0733 | 0733 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
1003943 | 4.NP_SO-102 | 1003943 | 4.NP_SO-102 | 2557 | Fáze 1 | ZZ03.08.0735 | 0735 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
1003958 | 4.NP_SO-102 | 1003958 | 4.NP_SO-102 | 2557 | Fáze 1 | ZZ03.08.0737 | 0737 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
1003971 | 4.NP_SO-102 | 1003971 | 4.NP_SO-102 | 2557 | Fáze 2 | ZZ03.08.0739 | 0739 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
1003986 | 4.NP_SO-102 | 1003986 | 4.NP_SO-102 | 2557 | Fáze 2 | ZZ03.08.0741 | 0741 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:02
1070552 | 3.NP_SO-102 | 1070552 | 3.NP_SO-102 | 2557 | Fáze 1 | ZZ03.08.1041 | 1041 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16

# IfcElectricAppliance: Telefony.CC:Typ 1 - Horizontální (2)
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - Počet fází: 1
Type - Grafika - Symbol typ 1: yes; Symbol typ2: no; Typ 1 - Horizontální: yes; Typ 1 - Vertikální: no; Typ 2 - Horizontální: no; Typ 2 - Vertikální: no
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.10.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Komentáře k typům: typ 1, horizontální; Model: Model; Nadpis OmniClass: Audio Information, Sound Signals; Název typu: Typ 1 - Horizontální; Označení typu: 09; Popis: Telefon; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Datová zařízení; Název rodiny: Telefony.CC
Text - CCI Funkční systém: M; CCI Komponenta: TFE; CCI Technický systém: JL
Vazby - Podlaží: 1.NP_SO-102; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Hostitel: Podlaží : 1.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.00146351 m3; Šířka Typ 1: 150 mm; Šířka Typ 2: 60 mm; Výška: 150 mm
Jiné - Id typu: 1016858; Rodina: Telefony.CC; Rodina a typ: Telefony.CC: Typ 1 - Horizontální; Typ: Typ 1 - Horizontální; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:17
Name (Telefony.CC:Typ 1 - Horizontální:...) | ID_import | Kód prvku | Označení
1016884 | 1016884 | .09.0936 | 0936
1016892 | 1016892 | .09.0937 | 0937

# IfcElectricAppliance: WiFi.CC:WiFi Router Vertikální (100)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - Počet fází: 1
Type - Grafika - Symbol: yes; Horizontální: no; Vertikální: yes
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.50.17.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: SB00; Komentáře k typům: vertikální; Model: Model; Nadpis OmniClass: Network Routers; Název typu: WiFi Router Vertikální; Označení typu: 02; Popis: WiFi; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Datová zařízení; Název rodiny: WiFi.CC
Classification: SB00 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: KEC; CCI Technický systém: JL
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - DÉLKA: 220 mm; VÝŠKA: 60 mm
Jiné - Id typu: 966795; Rodina: WiFi.CC; Rodina a typ: WiFi.CC: WiFi Router Vertikální; Typ: WiFi Router Vertikální
Name (WiFi.CC:WiFi Router Vertikální:...) | In | ID_import | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Podlaží | Fáze vytvoření | Objem (m3) | ŠÍŘKA (mm) | Kód prvku | Označení | UPRAVIL
966811 | -1.PP_SO-102 | 966811 | Podlaží : -1.PP_SO-102 | 2500 | -1.PP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0010 | 0010 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
966851 | -1.PP_SO-102 | 966851 | Podlaží : -1.PP_SO-102 | 2500 | -1.PP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0012 | 0012 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
966862 | -1.PP_SO-102 | 966862 | Podlaží : -1.PP_SO-102 | 2500 | -1.PP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0014 | 0014 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
966871 | -1.PP_SO-102 | 966871 | Podlaží : -1.PP_SO-102 | 2500 | -1.PP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0016 | 0016 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
966882 | -1.PP_SO-102 | 966882 | Podlaží : -1.PP_SO-102 | 2500 | -1.PP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0018 | 0018 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
966901 | -1.PP_SO-102 | 966901 | Podlaží : -1.PP_SO-102 | 2500 | -1.PP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0020 | 0020 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
966922 | -1.PP_SO-102 | 966922 | Podlaží : -1.PP_SO-102 | 2500 | -1.PP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0022 | 0022 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
966952 | -1.PP_SO-102 | 966952 | Podlaží : -1.PP_SO-102 | 2500 | -1.PP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0024 | 0024 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
966961 | -1.PP_SO-102 | 966961 | Podlaží : -1.PP_SO-102 | 2500 | -1.PP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0026 | 0026 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
966981 | 1.NP_SO-102 | 966981 | Podlaží : 1.NP_SO-102 | 2500 | 1.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0028 | 0028 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
967006 | 1.NP_SO-102 | 967006 | Podlaží : 1.NP_SO-102 | 2500 | 1.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0030 | 0030 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
967015 | 1.NP_SO-102 | 967015 | Podlaží : 1.NP_SO-102 | 2500 | 1.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0032 | 0032 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
967028 | 1.NP_SO-102 | 967028 | Podlaží : 1.NP_SO-102 | 2500 | 1.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0034 | 0034 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
967037 | 1.NP_SO-102 | 967037 | Podlaží : 1.NP_SO-102 | 2500 | 1.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0036 | 0036 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
967048 | 1.NP_SO-102 | 967048 | Podlaží : 1.NP_SO-102 | 2500 | 1.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0038 | 0038 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
967059 | 1.NP_SO-102 | 967059 | Podlaží : 1.NP_SO-102 | 2500 | 1.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0040 | 0040 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
967070 | 1.NP_SO-102 | 967070 | Podlaží : 1.NP_SO-102 | 2500 | 1.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0042 | 0042 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
967081 | 1.NP_SO-102 | 967081 | Podlaží : 1.NP_SO-102 | 2500 | 1.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0044 | 0044 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
967092 | 1.NP_SO-102 | 967092 | Podlaží : 1.NP_SO-102 | 2500 | 1.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0046 | 0046 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
967101 | 1.NP_SO-102 | 967101 | Podlaží : 1.NP_SO-102 | 2500 | 1.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0048 | 0048 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
967114 | 1.NP_SO-102 | 967114 | Podlaží : 1.NP_SO-102 | 2500 | 1.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0050 | 0050 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
967123 | 1.NP_SO-102 | 967123 | Podlaží : 1.NP_SO-102 | 2500 | 1.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0052 | 0052 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
967132 | 1.NP_SO-102 | 967132 | Podlaží : 1.NP_SO-102 | 2500 | 1.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0054 | 0054 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
967141 | 1.NP_SO-102 | 967141 | Podlaží : 1.NP_SO-102 | 2500 | 1.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0056 | 0056 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
967150 | 1.NP_SO-102 | 967150 | Podlaží : 1.NP_SO-102 | 2500 | 1.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0058 | 0058 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
967159 | 1.NP_SO-102 | 967159 | Podlaží : 1.NP_SO-102 | 2500 | 1.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0060 | 0060 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
967170 | 1.NP_SO-102 | 967170 | Podlaží : 1.NP_SO-102 | 2500 | 1.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0062 | 0062 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
967934 | 1.NP_SO-102 | 967934 | Podlaží : 1.NP_SO-102 | 2500 | 1.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0126 | 0126 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
992618 | 2.NP_SO-102 | 992618 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0295 | 0295 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
992626 | 2.NP_SO-102 | 992626 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0297 | 0297 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
992666 | 2.NP_SO-102 | 992666 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0299 | 0299 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
992677 | 2.NP_SO-102 | 992677 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0301 | 0301 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
992688 | 2.NP_SO-102 | 992688 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0303 | 0303 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
992701 | 2.NP_SO-102 | 992701 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0305 | 0305 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
992739 | 2.NP_SO-102 | 992739 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0307 | 0307 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
992748 | 2.NP_SO-102 | 992748 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0309 | 0309 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
992759 | 2.NP_SO-102 | 992759 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0311 | 0311 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
992768 | 2.NP_SO-102 | 992768 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0313 | 0313 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
992777 | 2.NP_SO-102 | 992777 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 1 | 0.00120922 | 90.5079 | SB00.02.0315 | 0315 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
992786 | 2.NP_SO-102 | 992786 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0317 | 0317 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
992797 | 2.NP_SO-102 | 992797 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0319 | 0319 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:19
992813 | 2.NP_SO-102 | 992813 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0321 | 0321 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:19
992815 | 2.NP_SO-102 | 992815 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0323 | 0323 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:19
992817 | 2.NP_SO-102 | 992817 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0325 | 0325 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:19
992845 | 2.NP_SO-102 | 992845 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0327 | 0327 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:19
992854 | 2.NP_SO-102 | 992854 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0329 | 0329 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:19
992881 | 2.NP_SO-102 | 992881 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0331 | 0331 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:19
992903 | 2.NP_SO-102 | 992903 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0333 | 0333 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:19
993061 | 2.NP_SO-102 | 993061 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0336 | 0336 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:19
993076 | 2.NP_SO-102 | 993076 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0338 | 0338 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:19
993085 | 2.NP_SO-102 | 993085 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0340 | 0340 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:19
993094 | 2.NP_SO-102 | 993094 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0342 | 0342 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
993103 | 2.NP_SO-102 | 993103 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0344 | 0344 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
993116 | 2.NP_SO-102 | 993116 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0346 | 0346 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
993125 | 2.NP_SO-102 | 993125 | Podlaží : 2.NP_SO-102 | 3000 | 2.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0348 | 0348 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
997189 | 3.NP_SO-102 | 997189 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0390 | 0390 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
997197 | 4.NP_SO-102 | 997197 | Podlaží : 4.NP_SO-102 | 3000 | 4.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0392 | 0392 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
998166 | -1.PP_SO-102 | 998166 | Podlaží : -1.PP_SO-102 | 2500 | -1.PP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0397 | 0397 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
999344 | 1.NP_SO-102 | 999344 | Podlaží : 1.NP_SO-102 | 2500 | 1.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0411 | 0411 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006770 | 3.NP_SO-102 | 1006770 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0829 | 0829 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006778 | 4.NP_SO-102 | 1006778 | Podlaží : 4.NP_SO-102 | 3000 | 4.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0831 | 0831 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006797 | 3.NP_SO-102 | 1006797 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0833 | 0833 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006822 | 4.NP_SO-102 | 1006822 | Podlaží : 4.NP_SO-102 | 3000 | 4.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0835 | 0835 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006837 | 3.NP_SO-102 | 1006837 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0837 | 0837 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006839 | 3.NP_SO-102 | 1006839 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0839 | 0839 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006841 | 3.NP_SO-102 | 1006841 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0841 | 0841 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006843 | 3.NP_SO-102 | 1006843 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0843 | 0843 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006845 | 3.NP_SO-102 | 1006845 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0845 | 0845 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006847 | 3.NP_SO-102 | 1006847 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0847 | 0847 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006849 | 3.NP_SO-102 | 1006849 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0849 | 0849 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006857 | 4.NP_SO-102 | 1006857 | Podlaží : 4.NP_SO-102 | 3000 | 4.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0851 | 0851 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006859 | 4.NP_SO-102 | 1006859 | Podlaží : 4.NP_SO-102 | 3000 | 4.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0853 | 0853 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006861 | 4.NP_SO-102 | 1006861 | Podlaží : 4.NP_SO-102 | 3000 | 4.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0855 | 0855 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006863 | 4.NP_SO-102 | 1006863 | Podlaží : 4.NP_SO-102 | 3000 | 4.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0857 | 0857 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006865 | 4.NP_SO-102 | 1006865 | Podlaží : 4.NP_SO-102 | 3000 | 4.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0859 | 0859 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006867 | 4.NP_SO-102 | 1006867 | Podlaží : 4.NP_SO-102 | 3000 | 4.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0861 | 0861 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006869 | 4.NP_SO-102 | 1006869 | Podlaží : 4.NP_SO-102 | 3000 | 4.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0863 | 0863 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006883 | 3.NP_SO-102 | 1006883 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0865 | 0865 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006898 | 3.NP_SO-102 | 1006898 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0867 | 0867 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006909 | 3.NP_SO-102 | 1006909 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0869 | 0869 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006920 | 3.NP_SO-102 | 1006920 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0871 | 0871 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006931 | 3.NP_SO-102 | 1006931 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0873 | 0873 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006941 | 3.NP_SO-102 | 1006941 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0875 | 0875 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006978 | 3.NP_SO-102 | 1006978 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0877 | 0877 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1006991 | 3.NP_SO-102 | 1006991 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0879 | 0879 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1007002 | 3.NP_SO-102 | 1007002 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0881 | 0881 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1008541 | 4.NP_SO-102 | 1008541 | Podlaží : 4.NP_SO-102 | 3000 | 4.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0914 | 0914 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1008558 | 4.NP_SO-102 | 1008558 | Podlaží : 4.NP_SO-102 | 3000 | 4.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0916 | 0916 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1008567 | 4.NP_SO-102 | 1008567 | Podlaží : 4.NP_SO-102 | 3000 | 4.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0918 | 0918 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1008576 | 4.NP_SO-102 | 1008576 | Podlaží : 4.NP_SO-102 | 3000 | 4.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0920 | 0920 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1008595 | 4.NP_SO-102 | 1008595 | Podlaží : 4.NP_SO-102 | 3000 | 4.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0922 | 0922 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1008608 | 4.NP_SO-102 | 1008608 | Podlaží : 4.NP_SO-102 | 3000 | 4.NP_SO-102 | Fáze 2 | 0.00292104 | 220 | SB00.02.0924 | 0924 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1008617 | 4.NP_SO-102 | 1008617 | Podlaží : 4.NP_SO-102 | 3000 | 4.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0926 | 0926 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1009092 | 4.NP_SO-102 | 1009092 | Podlaží : 4.NP_SO-102 | 3000 | 4.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0932 | 0932 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1009105 | 4.NP_SO-102 | 1009105 | Podlaží : 4.NP_SO-102 | 3000 | 4.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.0934 | 0934 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1066437 | 3.NP_SO-102 | 1066437 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.1027 | 1027 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1066480 | 3.NP_SO-102 | 1066480 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 1 | 0.0105903 | 800.139 | SB00.02.1029 | 1029 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:08
1066541 | 3.NP_SO-102 | 1066541 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 1 | 0.000107855 | 7.13175 | SB00.02.1031 | 1031 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:08
1070524 | 3.NP_SO-102 | 1070524 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.1036 | 1036 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1070535 | 3.NP_SO-102 | 1070535 | Podlaží : 3.NP_SO-102 | 3000 | 3.NP_SO-102 | Fáze 1 | 0.00292104 | 220 | SB00.02.1038 | 1038 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
