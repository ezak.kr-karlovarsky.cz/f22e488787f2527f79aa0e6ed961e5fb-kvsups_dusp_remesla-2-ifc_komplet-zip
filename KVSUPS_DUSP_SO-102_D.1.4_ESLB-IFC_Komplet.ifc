Properties of the parts of a building model (IFC4), part 1 of 9

# File
Description: ViewDefinition [DesignTransferView_V1.0], RevitIdentifiers [VersionGUID: 8c4dcf1c-acb0-426d-a09d-6de980a38bea, NumberOfSaves: 271], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Vnitřní]
File name: 220055
Time: 2023-10-13T16:52:42
Written by: ODA IFC SDK 22.8
Made in: 22.1.30.34 - Exporter 22.6.0.0 - Alternate UI 22.6.0.0

# IfcProject, 220055
LongName: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; Phase: DUSP

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Text - EBC_Hlavní architekt: prof. Ing. Mgr. akad. arch. Petr Hájek; EBC_Hlavní projektant: Ing. Libor Truhelka; EBC_ID profese: D.1.4; EBC_ID projektu: KVSUPS; EBC_Nadmořská výška: 389,970; EBC_Název profese: ELEKTROINSTALACE SLABOPROUD; EBC_Zástupce hlavního projektanta: Ing. Miroslav Zyma; EBC_Zkratka profese: ESLB; EBC_Zodpovědný projektant: Martin Frühauf; EBC_Zpracovatel části: Projekce elektro s.r.o.; EBC_Zpracovatel části adresa: II. ulice 75, 273 07 Vinařice tel.: +420 603 897 422 e-mail: mf@martinfruhauf.cz
Identifikační data - Název budovy: Budova E; Název organizace: Energy Benefit Centre a.s.; Popis organizace: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz; Projektant: Martin Frühauf, Ing. Petra Frühaufová
Jiné - Adresa projektu: Nám. 17. listopadu 710/12, Karlovy Vary – Rybáře, č. p.: 394/1 až 394/3, 395/1 až 395/5, 396, 397; Číslo projektu: 220055; Datum vydání projektu: 30.05.2023; EBC_Stavebník adresa: Závodní 353/88, 360 06 Karlovy Vary, IČ: 70891168; Jméno klienta: Karlovarský kraj; Kategorie: Informace o projektu; Název projektu: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; OBJEKT: ETAPA; PROFESNÍ ČÁST: Elektroinstalace slaboproud; Stav projektu: DUSP; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 09:11

# IfcBuilding, Budova E
LongName: Budova E
Text - EBC_Hlavní architekt: prof. Ing. Mgr. akad. arch. Petr Hájek; EBC_Hlavní projektant: Ing. Libor Truhelka; EBC_ID profese: D.1.4; EBC_ID projektu: KVSUPS; EBC_Nadmořská výška: 389,970; EBC_Název profese: ELEKTROINSTALACE SLABOPROUD; EBC_Zástupce hlavního projektanta: Ing. Miroslav Zyma; EBC_Zkratka profese: ESLB; EBC_Zodpovědný projektant: Martin Frühauf; EBC_Zpracovatel části: Projekce elektro s.r.o.; EBC_Zpracovatel části adresa: II. ulice 75, 273 07 Vinařice tel.: +420 603 897 422 e-mail: mf@martinfruhauf.cz
Identifikační data - Název budovy: Budova E; Název organizace: Energy Benefit Centre a.s.; Popis organizace: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz; Projektant: Martin Frühauf, Ing. Petra Frühaufová
Jiné - Adresa projektu: Nám. 17. listopadu 710/12, Karlovy Vary – Rybáře, č. p.: 394/1 až 394/3, 395/1 až 395/5, 396, 397; Číslo projektu: 220055; Datum vydání projektu: 30.05.2023; EBC_Stavebník adresa: Závodní 353/88, 360 06 Karlovy Vary, IČ: 70891168; Jméno klienta: Karlovarský kraj; Kategorie: Informace o projektu; Název projektu: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; OBJEKT: ETAPA; PROFESNÍ ČÁST: Elektroinstalace slaboproud; Stav projektu: DUSP; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 09:11

# IfcBuildingStorey: Podlaží:Podlaží, 2.NP_SO-102
In: Budova E
LongName: 2.NP_SO-102; Elevation: 4000 mm
Vazby - Výška: 4000 mm
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes; Název: 2.NP_SO-102
Jiné - Kategorie: Podlaží; Rodina: Podlaží; Id typu: 11292; Rodina a typ: Podlaží: Podlaží; Typ: Podlaží; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.20 03:12
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Symbol: Výšková kačena.CC : Výšková kačena; Symbol na konci 1 – výchozí: no; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Barva: 16711680; Vzor čáry: Čerchovaná
Identifikační data(Type) - Název typu: Podlaží
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží

# IfcBuildingStorey: Podlaží:Pomocné (5)
In: Budova E
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes
Jiné - Id typu: 1520; Kategorie: Podlaží; Rodina: Podlaží; Rodina a typ: Podlaží: Pomocné; Typ: Pomocné
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Barva: 0; Symbol: Výšková kačena.CC : Výšková kačena; Symbol na konci 1 – výchozí: no; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Vzor čáry: Tečkovaná
Identifikační data(Type) - Název typu: Pomocné
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží
Name | LongName = Název | Elevation (mm) | Výška (mm) | UPRAVIL
-2.PP_SO-102 | -2.PP_SO-102 | -8000 | -8000 | Fruhauf.vinarice@seznam.cz 2023.06.20 03:13
-1.PP_SO-102 | -1.PP_SO-102 | -4000 | -4000 | Fruhauf.vinarice@seznam.cz 2023.06.20 03:13
1.NP_SO-102 | 1.NP_SO-102 | -7.27687e-10 | 0 | Fruhauf.vinarice@seznam.cz 2023.06.20 03:13
3.NP_SO-102 | 3.NP_SO-102 | 8000 | 8000 | Fruhauf.vinarice@seznam.cz 2023.06.20 03:12
4.NP_SO-102 | 4.NP_SO-102 | 12000 | 12000 | Fruhauf.vinarice@seznam.cz 2023.06.20 03:11

# IfcBuildingElementProxy: Datový rozvaděč rack.CC:Rack 15U 600x600 DR01.B1, Datový rozvaděč rack.CC:Rack 15U 600x600 DR01.B1:965408
In: -2.PP_SO-102
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace – zatížení - PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Nosnost: 300 kg
Type - Grafika - Vlastní rozměry: no
Type - Kóty - Délka: 600 mm; HLOUBKA: 600 mm; Počet U: 15; ŠÍŘKA: 600 mm; Vlastní výška: 1000 mm; VÝŠKA: 766.75 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV02; Komentáře k typům: datový Rack 15U 600x600; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rack 15U 600x600 DR01.B1; Označení typu: 05; Popis: Rozvaděč; Popis sestavy: Datový; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; FAKTOR ÚČINNOSTI: 1; HMOTNOST: 0 kg; Název rodiny: Datový rozvaděč rack.CC
Classification: RV02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.91377 m2; NetVolume: 0.0880568 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W
Text - CCI Funkční systém: M; CCI Komponenta: XDC; CCI Technický systém: JL; ID_import: 965408
Vazby - Hostitel: Podlaží : -2.PP_SO-102; Odsazení od hostitele: 2320 mm; Podlaží: -2.PP_SO-102; Výška od podlaží: 2320 mm
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Grafika - Viditelnost dveří: yes
Kóty - Objem: 0.0826725 m3; Plocha: 1.95682 m2
Identifikační data - Kód prvku: RV02.05.0005; Označení: 0005
Jiné - Páteřní trasa: yes; Rodina: Datový rozvaděč rack.CC; Id typu: 1037541; Rodina a typ: Datový rozvaděč rack.CC: Rack 15U 600x600 DR01.B1; Typ: Rack 15U 600x600 DR01.B1; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:24; vkl: 275 mm; vybr: 580 mm

# IfcBuildingElementProxy: Datový rozvaděč rack.CC:Rack 48U 600x800_1B.1, Datový rozvaděč rack.CC:Rack 48U 600x800_1B.1:933785
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace – zatížení - PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Nosnost: 500 kg
Type - Grafika - Vlastní rozměry: no
Type - Kóty - Délka: 600 mm; HLOUBKA: 800 mm; Počet U: 48; ŠÍŘKA: 600 mm; Vlastní výška: 1000 mm; VÝŠKA: 2233.6 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV02; Komentáře k typům: datový Rack 48U 600x800; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rack 48U 600x800_1B.1; Označení typu: 04; Popis: Rozvaděč; Popis sestavy: Datový; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; FAKTOR ÚČINNOSTI: 1; HMOTNOST: 0 kg; Název rodiny: Datový rozvaděč rack.CC
Classification: RV02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 14.4642 m2; NetVolume: 0.257143 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W
Text - CCI Funkční systém: M; CCI Komponenta: XDC; CCI Technický systém: JL; ID_import: 933785
Vazby - Podlaží: 1.NP_SO-102; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Hostitel: Podlaží : 1.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Grafika - Viditelnost dveří: yes
Kóty - Objem: 0.240024 m3; Plocha: 5.66125 m2
Identifikační data - Kód prvku: RV02.04.0004; Označení: 0004
Jiné - Páteřní trasa: yes; Rodina: Datový rozvaděč rack.CC; Id typu: 1007045; Rodina a typ: Datový rozvaděč rack.CC: Rack 48U 600x800_1B.1; Typ: Rack 48U 600x800_1B.1; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:23; vkl: 375 mm; vybr: 780 mm

# IfcBuildingElementProxy: Datový rozvaděč rack.CC:Rack 48U 600x800_1B.3, Datový rozvaděč rack.CC:Rack 48U 600x800_1B.3:933761
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace – zatížení - PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Nosnost: 500 kg
Type - Grafika - Vlastní rozměry: no
Type - Kóty - Délka: 600 mm; HLOUBKA: 800 mm; Počet U: 48; ŠÍŘKA: 600 mm; Vlastní výška: 1000 mm; VÝŠKA: 2233.6 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV02; Komentáře k typům: datový Rack 48U 600x800; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rack 48U 600x800_1B.3; Označení typu: 03; Popis: Rozvaděč; Popis sestavy: Datový; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; FAKTOR ÚČINNOSTI: 1; HMOTNOST: 0 kg; Název rodiny: Datový rozvaděč rack.CC
Classification: RV02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 14.4642 m2; NetVolume: 0.257143 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W
Text - CCI Funkční systém: M; CCI Komponenta: XDC; CCI Technický systém: JL; ID_import: 933761
Vazby - Podlaží: 1.NP_SO-102; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Hostitel: Podlaží : 1.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Grafika - Viditelnost dveří: yes
Kóty - Objem: 0.240024 m3; Plocha: 5.66125 m2
Identifikační data - Kód prvku: RV02.03.0003; Označení: 0003
Jiné - Páteřní trasa: yes; Rodina: Datový rozvaděč rack.CC; Id typu: 1007070; Rodina a typ: Datový rozvaděč rack.CC: Rack 48U 600x800_1B.3; Typ: Rack 48U 600x800_1B.3; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:23; vkl: 375 mm; vybr: 780 mm

# IfcBuildingElementProxy: Datový rozvaděč rack.CC:Rack 48U 600x800_1B.4, Datový rozvaděč rack.CC:Rack 48U 600x800_1B.4:933717
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace – zatížení - PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Nosnost: 500 kg
Type - Grafika - Vlastní rozměry: no
Type - Kóty - Délka: 600 mm; HLOUBKA: 800 mm; Počet U: 48; ŠÍŘKA: 600 mm; Vlastní výška: 1000 mm; VÝŠKA: 2233.6 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV02; Komentáře k typům: datový Rack 48U 600x800; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rack 48U 600x800_1B.4; Označení typu: 02; Popis: Rozvaděč; Popis sestavy: Datový; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; FAKTOR ÚČINNOSTI: 1; HMOTNOST: 0 kg; Název rodiny: Datový rozvaděč rack.CC
Classification: RV02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 14.4642 m2; NetVolume: 0.257143 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W
Text - CCI Funkční systém: M; CCI Komponenta: XDC; CCI Technický systém: JL; ID_import: 933717
Vazby - Podlaží: 1.NP_SO-102; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Hostitel: Podlaží : 1.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Grafika - Viditelnost dveří: yes
Kóty - Objem: 0.240024 m3; Plocha: 5.66125 m2
Identifikační data - Kód prvku: RV02.02.0002; Označení: 0002
Jiné - Páteřní trasa: yes; Rodina: Datový rozvaděč rack.CC; Id typu: 1007072; Rodina a typ: Datový rozvaděč rack.CC: Rack 48U 600x800_1B.4; Typ: Rack 48U 600x800_1B.4; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:23; vkl: 375 mm; vybr: 780 mm

# IfcBuildingElementProxy: Datový rozvaděč rack.CC:Rack 48U 600x800_1B.5, Datový rozvaděč rack.CC:Rack 48U 600x800_1B.5:933711
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace – zatížení - PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Nosnost: 500 kg
Type - Grafika - Vlastní rozměry: no
Type - Kóty - Délka: 600 mm; HLOUBKA: 800 mm; Počet U: 48; ŠÍŘKA: 600 mm; Vlastní výška: 1000 mm; VÝŠKA: 2233.6 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV02; Komentáře k typům: datový Rack 48U 600x800; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rack 48U 600x800_1B.5; Označení typu: 01; Popis: Rozvaděč; Popis sestavy: Datový; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; FAKTOR ÚČINNOSTI: 1; HMOTNOST: 0 kg; Název rodiny: Datový rozvaděč rack.CC
Classification: RV02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 14.4642 m2; NetVolume: 0.257143 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W
Text - CCI Funkční systém: M; CCI Komponenta: XDC; CCI Technický systém: JL; ID_import: 933711
Vazby - Podlaží: 1.NP_SO-102; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Hostitel: Podlaží : 1.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - NAPĚTÍ: 400 V; POČET FÁZÍ: 3
Grafika - Viditelnost dveří: yes
Kóty - Objem: 0.240024 m3; Plocha: 5.66125 m2
Identifikační data - Kód prvku: RV02.01.0001; Označení: 0001
Jiné - Páteřní trasa: yes; Id typu: 1007074; Rodina: Datový rozvaděč rack.CC; Rodina a typ: Datový rozvaděč rack.CC: Rack 48U 600x800_1B.5; Typ: Rack 48U 600x800_1B.5; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:23; vkl: 375 mm; vybr: 780 mm

# IfcBuildingElementProxy: Datový rozvaděč rack.CC:Rack 48U 600x800_3B.1, Datový rozvaděč rack.CC:Rack 48U 600x800_3B.1:973520
In: 3.NP_SO-102
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace – zatížení - PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Nosnost: 500 kg
Type - Grafika - Vlastní rozměry: no
Type - Kóty - Délka: 600 mm; HLOUBKA: 800 mm; Počet U: 48; ŠÍŘKA: 600 mm; Vlastní výška: 1000 mm; VÝŠKA: 2233.6 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV02; Komentáře k typům: datový Rack 48U 600x800; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rack 48U 600x800_3B.1; Označení typu: 07; Popis: Rozvaděč; Popis sestavy: Datový; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; FAKTOR ÚČINNOSTI: 1; HMOTNOST: 0 kg; Název rodiny: Datový rozvaděč rack.CC
Classification: RV02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 14.4642 m2; NetVolume: 0.257143 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W
Text - CCI Funkční systém: M; CCI Komponenta: XDC; CCI Technický systém: JL; ID_import: 973520
Vazby - Podlaží: 3.NP_SO-102; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Hostitel: Podlaží : 3.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Grafika - Viditelnost dveří: yes
Kóty - Objem: 0.240024 m3; Plocha: 5.66125 m2
Identifikační data - Kód prvku: RV02.07.0007; Označení: 0007
Jiné - Páteřní trasa: yes; Rodina: Datový rozvaděč rack.CC; Id typu: 1007076; Rodina a typ: Datový rozvaděč rack.CC: Rack 48U 600x800_3B.1; Typ: Rack 48U 600x800_3B.1; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:23; vkl: 375 mm; vybr: 780 mm

# IfcBuildingElementProxy: Datový rozvaděč rack.CC:Rack 48U 600x800_3B.2 (2)
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: ND
Type - Elektroinstalace – zatížení - PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Nosnost: 500 kg
Type - Grafika - Vlastní rozměry: no
Type - Kóty - Délka: 600 mm; HLOUBKA: 800 mm; Počet U: 48; ŠÍŘKA: 600 mm; Vlastní výška: 1000 mm; VÝŠKA: 2233.6 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: RV02; Komentáře k typům: datový Rack 48U 600x800; Model: Model; Nadpis OmniClass: Distribution Boards and Control Panels; Název typu: Rack 48U 600x800_3B.2; Označení typu: 06; Popis: Rozvaděč; Popis sestavy: Datový; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; FAKTOR ÚČINNOSTI: 1; HMOTNOST: 0 kg; Název rodiny: Datový rozvaděč rack.CC
Classification: RV02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 14.4642 m2; NetVolume: 0.257143 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 400 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W
Text - CCI Funkční systém: M; CCI Komponenta: XDC; CCI Technický systém: JL
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 400 V
Grafika - Viditelnost dveří: yes
Kóty - Objem: 0.240024 m3; Plocha: 5.66125 m2
Jiné - Páteřní trasa: yes; Rodina: Datový rozvaděč rack.CC; Id typu: 1007078; Rodina a typ: Datový rozvaděč rack.CC: Rack 48U 600x800_3B.2; Typ: Rack 48U 600x800_3B.2; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:23; vkl: 375 mm; vybr: 780 mm
Name (Datový rozvaděč rack.CC:Rack 48U 600x800_3B.2:...) | In | ID_import | Podlaží | Hostitel | Kód prvku | Označení
973514 | 3.NP_SO-102 | 973514 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | RV02.06.0006 | 0006
1144959 | 1.NP_SO-102 | 933785 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | RV02.06.0011 | 0011

# IfcBuildingElementProxy: Dveřní modul.CC:Dveřní modul Vertikální (52)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 2500 mm
Type - Elektrotechnika - Počet fází: 1
Type - Grafika - Symbol: yes; Horizontální: no; Vertikální: yes
Type - Kóty - Hloubka: 40 mm; Šířka: 200 mm; Výška: 140 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: OL00; Komentáře k typům: dveřní, vertikální; Model: Model; Nadpis OmniClass: Access Controls; Název typu: Dveřní modul Vertikální; Označení typu: 07; Popis: Modul; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Zabezpečovací zařízení; Název rodiny: Dveřní modul.CC
Classification: OL00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0938603 m2; NetVolume: 0.0011287 m3
Text - CCI Funkční systém: M; CCI Komponenta: KEC; CCI Technický systém: JL
Vazby - Odsazení od hostitele: 2500 mm; Výška od podlaží: 2500 mm
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.0011287 m3
Jiné - Id typu: 1026278; Rodina: Dveřní modul.CC; Rodina a typ: Dveřní modul.CC: Dveřní modul Vertikální; Typ: Dveřní modul Vertikální; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 03:59
Name (Dveřní modul.CC:Dveřní modul Vertikální:...) | In | ID_import | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
1026300 | 1.NP_SO-102 | 1026300 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | OL00.07.0018 | 0018
1027703 | -1.PP_SO-102 | 1027703 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OL00.07.0038 | 0038
1027707 | -1.PP_SO-102 | 1027707 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OL00.07.0039 | 0039
1027711 | -1.PP_SO-102 | 1027711 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OL00.07.0040 | 0040
1027931 | -1.PP_SO-102 | 1027931 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OL00.07.0046 | 0046
1027980 | -1.PP_SO-102 | 1027980 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OL00.07.0052 | 0052
1027993 | -1.PP_SO-102 | 1027993 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OL00.07.0056 | 0056
1028007 | -1.PP_SO-102 | 1028007 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OL00.07.0060 | 0060
1028374 | -1.PP_SO-102 | 1028374 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OL00.07.0066 | 0066
1028423 | -1.PP_SO-102 | 1028423 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OL00.07.0067 | 0067
1028848 | 1.NP_SO-102 | 1028848 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | OL00.07.0071 | 0071
1028863 | 1.NP_SO-102 | 1028863 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | OL00.07.0075 | 0075
1028965 | 1.NP_SO-102 | 1028965 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | OL00.07.0079 | 0079
1028989 | 3.NP_SO-102 | 1028989 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | OL00.07.0083 | 0083
1029028 | 4.NP_SO-102 | 1029028 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | OL00.07.0090 | 0090
1029066 | 4.NP_SO-102 | 1029066 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | OL00.07.0094 | 0094
1029094 | 3.NP_SO-102 | 1029094 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | OL00.07.0098 | 0098
1029108 | 3.NP_SO-102 | 1029108 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | OL00.07.0102 | 0102
1029122 | 3.NP_SO-102 | 1029122 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | OL00.07.0106 | 0106
1029136 | 3.NP_SO-102 | 1029136 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | OL00.07.0110 | 0110
1029200 | 3.NP_SO-102 | 1029200 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | OL00.07.0114 | 0114
1029318 | 1.NP_SO-102 | 1029318 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | OL00.07.0122 | 0122
1029338 | 3.NP_SO-102 | 1029338 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | OL00.07.0123 | 0123
1029345 | 4.NP_SO-102 | 1029345 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | OL00.07.0124 | 0124
1029523 | 4.NP_SO-102 | 1029523 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | OL00.07.0131 | 0131
1029593 | 4.NP_SO-102 | 1029593 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | OL00.07.0135 | 0135
1029737 | 3.NP_SO-102 | 1029737 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | OL00.07.0145 | 0145
1029759 | 2.NP_SO-102 | 1029759 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OL00.07.0149 | 0149
1029787 | 2.NP_SO-102 | 1029787 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OL00.07.0156 | 0156
1029815 | 2.NP_SO-102 | 1029815 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OL00.07.0163 | 0163
1029938 | 2.NP_SO-102 | 1029938 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OL00.07.0167 | 0167
1029989 | 2.NP_SO-102 | 1029989 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OL00.07.0171 | 0171
1030017 | 2.NP_SO-102 | 1030017 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OL00.07.0178 | 0178
1030045 | 2.NP_SO-102 | 1030045 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OL00.07.0185 | 0185
1030059 | 2.NP_SO-102 | 1030059 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OL00.07.0189 | 0189
1030073 | 2.NP_SO-102 | 1030073 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OL00.07.0193 | 0193
1030215 | 2.NP_SO-102 | 1030215 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OL00.07.0198 | 0198
1030231 | 2.NP_SO-102 | 1030231 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OL00.07.0202 | 0202
1032819 | -2.PP_SO-102 | 1032819 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | Fáze 1 | OL00.07.0299 | 0299
1032823 | -2.PP_SO-102 | 1032823 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | Fáze 1 | OL00.07.0300 | 0300
1032947 | -1.PP_SO-102 | 1032947 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OL00.07.0306 | 0306
1089472 | -1.PP_SO-102 | 1089472 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OL00.07.0321 | 0321
1090044 | 1.NP_SO-102 | 1090044 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | OL00.07.0333 | 0333
1090056 | 1.NP_SO-102 | 1090056 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | OL00.07.0337 | 0337
1090106 | 1.NP_SO-102 | 1090106 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | OL00.07.0342 | 0342
1090786 | 1.NP_SO-102 | 1090786 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | OL00.07.0346 | 0346
1090875 | 1.NP_SO-102 | 1090875 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | OL00.07.0356 | 0356
1090928 | 1.NP_SO-102 | 1090928 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | OL00.07.0360 | 0360
1091172 | 2.NP_SO-102 | 1091172 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OL00.07.0367 | 0367
1091423 | 2.NP_SO-102 | 1091423 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OL00.07.0373 | 0373
1091527 | 3.NP_SO-102 | 1091527 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | OL00.07.0379 | 0379
1091551 | 3.NP_SO-102 | 1091551 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | OL00.07.0386 | 0386

# IfcBuildingElementProxy: Elektromechanický zámek.CC:Elektromechanický zámek.CC (72)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 1070 mm
Type - Grafika - Symbol: yes
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: OL03; Komentáře k typům: elektromechanický; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Elektromechanický zámek.CC; Označení typu: 03; Popis: Zámek; Popis sestavy: Elektrický otevírač dveří; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Zabezpečovací zařízení; Název rodiny: Elektromechanický zámek.CC
Classification: OL03 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0504504 m2; NetVolume: 0.000356042 m3
Text - CCI Funkční systém: M; CCI Komponenta: QSA; CCI Technický systém: JL
Grafika - Posun horizontální: 0; Posun vertikální: 0; Viditelnost zámku: yes
Kóty - Objem: 0.000356042 m3
Jiné - Id typu: 1019149; Rodina: Elektromechanický zámek.CC; Rodina a typ: Elektromechanický zámek.CC: Elektromechanický zámek.CC; Typ: Elektromechanický zámek.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.25 10:11
Name (Elektromechanický zámek.CC:Elektromechanický zámek.CC:...) | In | ID_import | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení
1019173 | -1.PP_SO-102 | 1019173 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 875 | Fáze 1 | OL03.03.0003 | 0003
1019177 | 1.NP_SO-102 | 1019177 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 875 | Fáze 1 | OL03.03.0004 | 0004
1019181 | 1.NP_SO-102 | 1019181 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | -195 | Fáze 1 | OL03.03.0005 | 0005
1019185 | 1.NP_SO-102 | 1019185 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | -195 | Fáze 1 | OL03.03.0006 | 0006
1027630 | -1.PP_SO-102 | 1027630 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 875 | Fáze 1 | OL03.03.0029 | 0029
1027634 | -1.PP_SO-102 | 1027634 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 875 | Fáze 1 | OL03.03.0030 | 0030
1027638 | -1.PP_SO-102 | 1027638 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 875 | Fáze 1 | OL03.03.0031 | 0031
1027940 | -1.PP_SO-102 | 1027940 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 875 | Fáze 1 | OL03.03.0047 | 0047
1027949 | -1.PP_SO-102 | 1027949 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 875 | Fáze 1 | OL03.03.0048 | 0048
1027979 | -1.PP_SO-102 | 1027979 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 875 | Fáze 1 | OL03.03.0051 | 0051
1027992 | -1.PP_SO-102 | 1027992 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 875 | Fáze 1 | OL03.03.0055 | 0055
1028006 | -1.PP_SO-102 | 1028006 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 875 | Fáze 1 | OL03.03.0059 | 0059
1028187 | -1.PP_SO-102 | 1028187 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 875 | Fáze 1 | OL03.03.0063 | 0063
1028367 | -1.PP_SO-102 | 1028367 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 965 | Fáze 1 | OL03.03.0065 | 0065
1028458 | -1.PP_SO-102 | 1028458 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 875 | Fáze 1 | OL03.03.0068 | 0068
1028859 | 1.NP_SO-102 | 1028859 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 875 | Fáze 1 | OL03.03.0072 | 0072
1028953 | 1.NP_SO-102 | 1028953 | 1.NP_SO-102 | Kabelová lávka s tvarovkami : KOPOS JUPITER POZINKOVÁNO SENDZIMIR, NEDĚROVANÝ | 875 | Fáze 1 | OL03.03.0078 | 0078
1028988 | 3.NP_SO-102 | 1028988 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 875 | Fáze 1 | OL03.03.0082 | 0082
1029014 | 4.NP_SO-102 | 1029014 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 875 | Fáze 2 | OL03.03.0086 | 0086
1029027 | 4.NP_SO-102 | 1029027 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 875 | Fáze 2 | OL03.03.0089 | 0089
1029065 | 4.NP_SO-102 | 1029065 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 875 | Fáze 2 | OL03.03.0093 | 0093
1029093 | 3.NP_SO-102 | 1029093 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 875 | Fáze 2 | OL03.03.0097 | 0097
1029107 | 3.NP_SO-102 | 1029107 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 875 | Fáze 2 | OL03.03.0101 | 0101
1029121 | 3.NP_SO-102 | 1029121 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 875 | Fáze 1 | OL03.03.0105 | 0105
1029135 | 3.NP_SO-102 | 1029135 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 875 | Fáze 1 | OL03.03.0109 | 0109
1029199 | 3.NP_SO-102 | 1029199 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 875 | Fáze 1 | OL03.03.0113 | 0113
1029251 | 3.NP_SO-102 | 1029251 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | -195 | Fáze 1 | OL03.03.0116 | 0116
1029261 | 4.NP_SO-102 | 1029261 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | -195 | Fáze 1 | OL03.03.0119 | 0119
1029354 | 4.NP_SO-102 | 1029354 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | -195 | Fáze 1 | OL03.03.0125 | 0125
1029367 | 4.NP_SO-102 | 1029367 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | -195 | Fáze 1 | OL03.03.0128 | 0128
1029552 | 4.NP_SO-102 | 1029552 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | -195 | Fáze 1 | OL03.03.0132 | 0132
1029612 | 3.NP_SO-102 | 1029612 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | -195 | Fáze 1 | OL03.03.0136 | 0136
1029626 | 3.NP_SO-102 | 1029626 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | -195 | Fáze 1 | OL03.03.0139 | 0139
1029695 | 3.NP_SO-102 | 1029695 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | -195 | Fáze 1 | OL03.03.0142 | 0142
1029755 | 2.NP_SO-102 | 1029755 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 755 | Fáze 1 | OL03.03.0146 | 0146
1029769 | 2.NP_SO-102 | 1029769 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 755 | Fáze 1 | OL03.03.0150 | 0150
1029783 | 2.NP_SO-102 | 1029783 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 755 | Fáze 1 | OL03.03.0153 | 0153
1029797 | 2.NP_SO-102 | 1029797 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 755 | Fáze 1 | OL03.03.0157 | 0157
1029811 | 2.NP_SO-102 | 1029811 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | -195 | Fáze 1 | OL03.03.0160 | 0160
1029934 | 2.NP_SO-102 | 1029934 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | -195 | Fáze 1 | OL03.03.0164 | 0164
1029985 | 2.NP_SO-102 | 1029985 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | -195 | Fáze 1 | OL03.03.0169 | 0169
1029999 | 2.NP_SO-102 | 1029999 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | -195 | Fáze 1 | OL03.03.0172 | 0172
1030013 | 2.NP_SO-102 | 1030013 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | -195 | Fáze 1 | OL03.03.0175 | 0175
1030027 | 2.NP_SO-102 | 1030027 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | -195 | Fáze 1 | OL03.03.0179 | 0179
1030041 | 2.NP_SO-102 | 1030041 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | -195 | Fáze 1 | OL03.03.0182 | 0182
1030055 | 2.NP_SO-102 | 1030055 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | -195 | Fáze 1 | OL03.03.0186 | 0186
1030069 | 2.NP_SO-102 | 1030069 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | -195 | Fáze 1 | OL03.03.0190 | 0190
1030211 | 2.NP_SO-102 | 1030211 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | -195 | Fáze 1 | OL03.03.0195 | 0195
1030227 | 2.NP_SO-102 | 1030227 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | -195 | Fáze 1 | OL03.03.0199 | 0199
1032782 | -2.PP_SO-102 | 1032782 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 875 | Fáze 1 | OL03.03.0296 | 0296
1032786 | -2.PP_SO-102 | 1032786 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 875 | Fáze 1 | OL03.03.0297 | 0297
1032800 | -2.PP_SO-102 | 1032800 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 875 | Fáze 1 | OL03.03.0298 | 0298
1033089 | -1.PP_SO-102 | 1033089 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 875 | Fáze 1 | OL03.03.0307 | 0307
1033121 | -1.PP_SO-102 | 1033121 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 875 | Fáze 1 | OL03.03.0310 | 0310
1089182 | -1.PP_SO-102 | 1089182 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 875 | Fáze 1 | OL03.03.0312 | 0312
1089190 | -1.PP_SO-102 | 1089190 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 875 | Fáze 1 | OL03.03.0313 | 0313
1089534 | -1.PP_SO-102 | 1089534 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 875 | Fáze 1 | OL03.03.0322 | 0322
1090043 | 1.NP_SO-102 | 1090043 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 875 | Fáze 1 | OL03.03.0332 | 0332
1090055 | 1.NP_SO-102 | 1090055 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 875 | Fáze 1 | OL03.03.0336 | 0336
1090105 | 1.NP_SO-102 | 1090105 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 875 | Fáze 1 | OL03.03.0341 | 0341
1090785 | 1.NP_SO-102 | 1090785 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 875 | Fáze 1 | OL03.03.0345 | 0345
1090819 | 1.NP_SO-102 | 1090819 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 875 | Fáze 1 | OL03.03.0349 | 0349
1090843 | 1.NP_SO-102 | 1090843 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 875 | Fáze 1 | OL03.03.0352 | 0352
1090874 | 1.NP_SO-102 | 1090874 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 875 | Fáze 2 | OL03.03.0355 | 0355
1090910 | 1.NP_SO-102 | 1090910 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 875 | Fáze 2 | OL03.03.0359 | 0359
1090974 | 1.NP_SO-102 | 1090974 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 875 | Fáze 2 | OL03.03.0363 | 0363
1090985 | 1.NP_SO-102 | 1090985 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 875 | Fáze 2 | OL03.03.0366 | 0366
1091201 | 2.NP_SO-102 | 1091201 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | -195 | Fáze 1 | OL03.03.0368 | 0368
1091272 | 2.NP_SO-102 | 1091272 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | -195 | Fáze 1 | OL03.03.0371 | 0371
1091526 | 3.NP_SO-102 | 1091526 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 875 | Fáze 1 | OL03.03.0378 | 0378
1091538 | 3.NP_SO-102 | 1091538 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 875 | Fáze 1 | OL03.03.0382 | 0382
1091550 | 3.NP_SO-102 | 1091550 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 875 | Fáze 1 | OL03.03.0385 | 0385

# IfcBuildingElementProxy: Kamery.CC:Venkovní pevná DOME_nástěnná (27)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; PŘÍKON: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 0 V
Type - Grafika - Symbol: yes; Typ symbolu: Kamera venkovní pevná DOME.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.17.14; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: DV01; Komentáře k typům: venkovní, DOME; Model: Model; Nadpis OmniClass: Video Surveillance; Název typu: Venkovní pevná DOME_nástěnná; Označení typu: 09; Popis: Kamera; Popis sestavy: Kamera; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - FAKTOR ÚČINNOSTI: 1; Kategorie: Zabezpečovací zařízení; DOME: yes; Nástěnná: yes; Pevná: no; PTZ (otočná): no; Název rodiny: Kamery.CC
Classification: DV01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0329857 m2; NetVolume: 0.000480116 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 0 V/1-0.0 kW
Text - CCI Funkční systém: M; CCI Komponenta: BXC; CCI Technický systém: JL
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000480116 m3
Jiné - Rodina: Kamery.CC; úhel: 180 deg; Id typu: 1022249; Rodina a typ: Kamery.CC: Venkovní pevná DOME_nástěnná; Typ: Venkovní pevná DOME_nástěnná; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:06
Name (Kamery.CC:Venkovní pevná DOME_nástěnná:...) | In | ID_import | Podlaží | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Hostitel | Fáze vytvoření | Kód prvku | Označení
1030613 | 1.NP_SO-102 | 1030613 | 1.NP_SO-102 | 0 | Podlaží : 1.NP_SO-102 | Fáze 1 | DV01.09.0215 | 0215
1030635 | 1.NP_SO-102 | 1030635 | 1.NP_SO-102 | 0 | Podlaží : 1.NP_SO-102 | Fáze 1 | DV01.09.0216 | 0216
1030657 | 1.NP_SO-102 | 1030657 | 1.NP_SO-102 | 0 | Podlaží : 1.NP_SO-102 | Fáze 1 | DV01.09.0217 | 0217
1030680 | 1.NP_SO-102 | 1030680 | 1.NP_SO-102 | 0 | Podlaží : 1.NP_SO-102 | Fáze 1 | DV01.09.0218 | 0218
1030710 | 1.NP_SO-102 | 1030710 | 1.NP_SO-102 | 3200 | Podlaží : 1.NP_SO-102 | Fáze 1 | DV01.09.0219 | 0219
1030720 | 1.NP_SO-102 | 1030720 | 1.NP_SO-102 | 3200 | Podlaží : 1.NP_SO-102 | Fáze 1 | DV01.09.0220 | 0220
1030738 | 1.NP_SO-102 | 1030738 | 1.NP_SO-102 | 2500 | Podlaží : 1.NP_SO-102 | Fáze 1 | DV01.09.0221 | 0221
1030752 | 1.NP_SO-102 | 1030752 | 1.NP_SO-102 | 2441.18 | Podlaží : 1.NP_SO-102 | Fáze 1 | DV01.09.0222 | 0222
1031719 | -1.PP_SO-102 | 1031719 | -1.PP_SO-102 | 2500 | Podlaží : -1.PP_SO-102 | Fáze 1 | DV01.09.0254 | 0254
1031781 | -1.PP_SO-102 | 1031781 | -1.PP_SO-102 | 0 | Podlaží : -1.PP_SO-102 | Fáze 1 | DV01.09.0258 | 0258
1031787 | -1.PP_SO-102 | 1031787 | -1.PP_SO-102 | 0 | Podlaží : -1.PP_SO-102 | Fáze 1 | DV01.09.0259 | 0259
1031793 | -1.PP_SO-102 | 1031793 | -1.PP_SO-102 | 0 | Podlaží : -1.PP_SO-102 | Fáze 1 | DV01.09.0260 | 0260
1031799 | -1.PP_SO-102 | 1031799 | -1.PP_SO-102 | 0 | Podlaží : -1.PP_SO-102 | Fáze 1 | DV01.09.0261 | 0261
1031805 | -1.PP_SO-102 | 1031805 | -1.PP_SO-102 | 0 | Podlaží : -1.PP_SO-102 | Fáze 1 | DV01.09.0262 | 0262
1031944 | -1.PP_SO-102 | 1031944 | -1.PP_SO-102 | 0 | Podlaží : -1.PP_SO-102 | Fáze 1 | DV01.09.0263 | 0263
1032260 | 4.NP_SO-102 | 1032260 | 4.NP_SO-102 | 2500 | Podlaží : 4.NP_SO-102 | Fáze 1 | DV01.09.0271 | 0271
1032266 | 4.NP_SO-102 | 1032266 | 4.NP_SO-102 | 2500 | Podlaží : 4.NP_SO-102 | Fáze 1 | DV01.09.0272 | 0272
1032356 | -1.PP_SO-102 | 1032356 | -1.PP_SO-102 | 0 | Podlaží : -1.PP_SO-102 | Fáze 1 | DV01.09.0274 | 0274
1032362 | -1.PP_SO-102 | 1032362 | -1.PP_SO-102 | 0 | Podlaží : -1.PP_SO-102 | Fáze 2 | DV01.09.0275 | 0275
1032463 | 4.NP_SO-102 | 1032463 | 4.NP_SO-102 | 0 | Podlaží : 4.NP_SO-102 | Fáze 1 | DV01.09.0279 | 0279
1032469 | 4.NP_SO-102 | 1032469 | 4.NP_SO-102 | 0 | Podlaží : 4.NP_SO-102 | Fáze 1 | DV01.09.0280 | 0280
1032475 | 4.NP_SO-102 | 1032475 | 4.NP_SO-102 | 0 | Podlaží : 4.NP_SO-102 | Fáze 1 | DV01.09.0281 | 0281
1032503 | 4.NP_SO-102 | 1032503 | 4.NP_SO-102 | 0 | Podlaží : 4.NP_SO-102 | Fáze 1 | DV01.09.0282 | 0282
1032683 | 3.NP_SO-102 | 1032683 | 3.NP_SO-102 | 0 | Podlaží : 3.NP_SO-102 | Fáze 1 | DV01.09.0289 | 0289
1032689 | 3.NP_SO-102 | 1032689 | 3.NP_SO-102 | 0 | Podlaží : 3.NP_SO-102 | Fáze 1 | DV01.09.0290 | 0290
1089296 | -1.PP_SO-102 | 1089296 | -1.PP_SO-102 | 0 | Podlaží : -1.PP_SO-102 | Fáze 1 | DV01.09.0318 | 0318
1089405 | -1.PP_SO-102 | 1089405 | -1.PP_SO-102 | 0 | Podlaží : -1.PP_SO-102 | Fáze 1 | DV01.09.0319 | 0319

# IfcBuildingElementProxy: Kamery.CC:Vnitřní pevná DOME_nástěnná (67)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; PŘÍKON: 0 W
Type - Vazby - Výchozí výška: 2500 mm
Type - Elektrotechnika - NAPĚTÍ: 0 V
Type - Grafika - Symbol: yes; Typ symbolu: Kamera vnitřní pevná DOME.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.17.14; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: DV01; Komentáře k typům: venkovní, DOME; Model: Model; Nadpis OmniClass: Video Surveillance; Název typu: Vnitřní pevná DOME_nástěnná; Označení typu: 04; Popis: Kamera; Popis sestavy: Kamera; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - FAKTOR ÚČINNOSTI: 1; Kategorie: Zabezpečovací zařízení; DOME: yes; Nástěnná: yes; Název rodiny: Kamery.CC; Pevná: no; PTZ (otočná): no
Classification: DV01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0329857 m2; NetVolume: 0.000480116 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 0 V/1-0.0 kW
Text - CCI Funkční systém: M; CCI Komponenta: BXC; CCI Technický systém: JL
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000480116 m3
Jiné - Id typu: 1022251; Rodina: Kamery.CC; Rodina a typ: Kamery.CC: Vnitřní pevná DOME_nástěnná; Typ: Vnitřní pevná DOME_nástěnná; úhel: 180 deg; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:06
Name (Kamery.CC:Vnitřní pevná DOME_nástěnná:...) | In | ID_import | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení
1022267 | 1.NP_SO-102 | 1022267 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0007 | 0007
1030328 | 1.NP_SO-102 | 1030328 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3500 | Fáze 1 | DV01.04.0203 | 0203
1030334 | 1.NP_SO-102 | 1030334 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3500 | Fáze 1 | DV01.04.0204 | 0204
1030340 | 1.NP_SO-102 | 1030340 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3500 | Fáze 1 | DV01.04.0205 | 0205
1030396 | 1.NP_SO-102 | 1030396 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0206 | 0206
1030402 | 1.NP_SO-102 | 1030402 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0207 | 0207
1030408 | 1.NP_SO-102 | 1030408 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0208 | 0208
1030418 | 1.NP_SO-102 | 1030418 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2500 | Fáze 2 | DV01.04.0209 | 0209
1030430 | 1.NP_SO-102 | 1030430 | 1.NP_SO-102 | Kabelová lávka s tvarovkami : KOPOS JUPITER POZINKOVÁNO SENDZIMIR, NEDĚROVANÝ | 2500 | Fáze 2 | DV01.04.0210 | 0210
1030510 | 1.NP_SO-102 | 1030510 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0211 | 0211
1030520 | 1.NP_SO-102 | 1030520 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0212 | 0212
1030526 | 1.NP_SO-102 | 1030526 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3700 | Fáze 1 | DV01.04.0213 | 0213
1030532 | 1.NP_SO-102 | 1030532 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3700 | Fáze 1 | DV01.04.0214 | 0214
1030983 | 2.NP_SO-102 | 1030983 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0223 | 0223
1030989 | 2.NP_SO-102 | 1030989 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0224 | 0224
1030995 | 2.NP_SO-102 | 1030995 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0225 | 0225
1031005 | 2.NP_SO-102 | 1031005 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0226 | 0226
1031019 | 2.NP_SO-102 | 1031019 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2500 | Fáze 2 | DV01.04.0227 | 0227
1031033 | 2.NP_SO-102 | 1031033 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2500 | Fáze 2 | DV01.04.0228 | 0228
1031039 | 2.NP_SO-102 | 1031039 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0229 | 0229
1031048 | 1.NP_SO-102 | 1031048 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0230 | 0230
1031183 | 2.NP_SO-102 | 1031183 | 2.NP_SO-102 | Kabelová lávka s tvarovkami : KOPOS JUPITER POZINKOVÁNO SENDZIMIR | 2500 | Fáze 1 | DV01.04.0231 | 0231
1031191 | 2.NP_SO-102 | 1031191 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0232 | 0232
1031510 | 1.NP_SO-102 | 1031510 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0233 | 0233 | Fázování - Fáze demolice: Fáze 1
1031536 | 3.NP_SO-102 | 1031536 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0234 | 0234
1031542 | 3.NP_SO-102 | 1031542 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0235 | 0235
1031552 | 3.NP_SO-102 | 1031552 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0236 | 0236
1031562 | 3.NP_SO-102 | 1031562 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2500 | Fáze 2 | DV01.04.0237 | 0237
1031568 | 3.NP_SO-102 | 1031568 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2500 | Fáze 2 | DV01.04.0238 | 0238
1031578 | 3.NP_SO-102 | 1031578 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2500 | Fáze 2 | DV01.04.0239 | 0239
1031600 | 3.NP_SO-102 | 1031600 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0240 | 0240
1031618 | 3.NP_SO-102 | 1031618 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0241 | 0241
1031631 | 2.NP_SO-102 | 1031631 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0242 | 0242
1031644 | 1.NP_SO-102 | 1031644 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0243 | 0243
1031653 | -1.PP_SO-102 | 1031653 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 1 | DV01.04.0244 | 0244
1031659 | -1.PP_SO-102 | 1031659 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 1 | DV01.04.0245 | 0245
1031665 | -1.PP_SO-102 | 1031665 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 1 | DV01.04.0246 | 0246
1031671 | -1.PP_SO-102 | 1031671 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 1 | DV01.04.0247 | 0247
1031677 | -1.PP_SO-102 | 1031677 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 1 | DV01.04.0248 | 0248
1031683 | -1.PP_SO-102 | 1031683 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 1 | DV01.04.0249 | 0249
1031695 | -1.PP_SO-102 | 1031695 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 1 | DV01.04.0250 | 0250
1031701 | -1.PP_SO-102 | 1031701 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 2 | DV01.04.0251 | 0251
1031707 | -1.PP_SO-102 | 1031707 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 2 | DV01.04.0252 | 0252
1031713 | -1.PP_SO-102 | 1031713 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 2 | DV01.04.0253 | 0253
1031751 | -1.PP_SO-102 | 1031751 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 1 | DV01.04.0255 | 0255
1031757 | -1.PP_SO-102 | 1031757 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 1 | DV01.04.0256 | 0256
1031772 | -1.PP_SO-102 | 1031772 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 1 | DV01.04.0257 | 0257
1031986 | 3.NP_SO-102 | 1031986 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0264 | 0264
1032099 | 3.NP_SO-102 | 1032099 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2500 | Fáze 2 | DV01.04.0265 | 0265
1032121 | 3.NP_SO-102 | 1032121 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0266 | 0266
1032130 | 2.NP_SO-102 | 1032130 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0267 | 0267
1032163 | 4.NP_SO-102 | 1032163 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0268 | 0268
1032240 | 4.NP_SO-102 | 1032240 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0269 | 0269
1032250 | 4.NP_SO-102 | 1032250 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0270 | 0270
1032325 | -1.PP_SO-102 | 1032325 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 1 | DV01.04.0273 | 0273
1032383 | 4.NP_SO-102 | 1032383 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0276 | 0276
1032397 | 4.NP_SO-102 | 1032397 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0277 | 0277
1032415 | 4.NP_SO-102 | 1032415 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0278 | 0278
1032541 | 4.NP_SO-102 | 1032541 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0283 | 0283
1032547 | 4.NP_SO-102 | 1032547 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0284 | 0284
1032553 | 4.NP_SO-102 | 1032553 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0285 | 0285
1032571 | 4.NP_SO-102 | 1032571 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2500 | Fáze 2 | DV01.04.0286 | 0286
1032581 | 4.NP_SO-102 | 1032581 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2500 | Fáze 2 | DV01.04.0287 | 0287
1032595 | 4.NP_SO-102 | 1032595 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0288 | 0288
1032702 | 2.NP_SO-102 | 1032702 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2500 | Fáze 1 | DV01.04.0291 | 0291
1032717 | -2.PP_SO-102 | 1032717 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 2500 | Fáze 1 | DV01.04.0292 | 0292
1032851 | -1.PP_SO-102 | 1032851 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 1 | DV01.04.0304 | 0304

# IfcBuildingElementProxy: Klávesnice.CC:Klávesnice.CC (2)
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: PN02; Komentáře k typům: Komentáře k typům; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Klávesnice.CC; Označení typu: 02; Popis: Klávesnice; Popis sestavy: Klávesnice; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Zabezpečovací zařízení; Název rodiny: Klávesnice.CC
Classification: PN02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0596983 m2; NetVolume: 0.000717443 m3
Text - CCI Funkční systém: M; CCI Komponenta: SJB; CCI Technický systém: JL
Vazby - Podlaží: 1.NP_SO-102; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Hostitel: Podlaží : 1.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 7.06858e-08 m3; Plocha: 0.000106024 m2
Jiné - Id typu: 1011796; Rodina: Klávesnice.CC; Rodina a typ: Klávesnice.CC: Klávesnice.CC; Typ: Klávesnice.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:08
Name (Klávesnice.CC:Klávesnice.CC:...) | ID_import | Kód prvku | Označení
1011815 | 1011815 | PN02.02.0002 | 0002
1089800 | 1089800 | PN02.02.0323 | 0323

# IfcBuildingElementProxy: Napájecí zdroj s akumulátorem_Zabezpečovací.CC :Napájecí zdroj s akumulátorem_Zabezpečovací.CC, Napájecí zdroj s akumulátorem_Zabezpečovací.CC :Napájecí zdroj s akumulátorem_Zabezpečovací.CC:1010613
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes; Svislé umístění: yes; Vodorovné umístění: no
Type - Kóty - DÉLKA: 300 mm; HLOUBKA: 200 mm; ŠÍŘKA: 300 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: PN03; Komentáře k typům: s akumulátorem, zabezpečovací; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Napájecí zdroj s akumulátorem_Zabezpečovací.CC; Označení typu: 01; Popis: Napájecí zdroj; Popis sestavy: Zdroj napájení pro EPS; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Zabezpečovací zařízení; Název rodiny: Napájecí zdroj s akumulátorem_Zabezpečovací.CC
Classification: PN03 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.43826 m2; NetVolume: 0.0180161 m3
Text - CCI Funkční systém: M; CCI Komponenta: GBA; CCI Technický systém: JL; ID_import: 1010613
Vazby - Podlaží: 1.NP_SO-102; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Hostitel: Podlaží : 1.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.0180161 m3
Identifikační data - Kód prvku: PN03.01.0001; Označení: 0001
Jiné - a: 120 mm; b: 90 mm; Id typu: 1010597; Rodina: Napájecí zdroj s akumulátorem_Zabezpečovací.CC; Rodina a typ: Napájecí zdroj s akumulátorem_Zabezpečovací.CC : Napájecí zdroj s akumulátorem_Zabezpečovací.CC; Typ: Napájecí zdroj s akumulátorem_Zabezpečovací.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:15

# IfcBuildingElementProxy: Podlahová krabice.CC:Podlahová krabice - 12 modulů (43)
In: 3.NP_SO-102
Type - Material: Červená
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Počet modulů: 12
Type - Kóty - DÉLKA: 215 mm; HLOUBKA: 50 mm; ŠÍŘKA: 255 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: PQ00; Komentáře k typům: Podlahová krabice; Model: Model; Název typu: Podlahová krabice - 12 modulů; Označení typu: 09; Popis: Podlahová krabice; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrická tělesa; M: 90 mm; Název rodiny: Podlahová krabice.CC
Classification: PQ00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.26051 m2
Text - CCI Funkční systém: M; CCI Komponenta: XGB; CCI Technický systém: JL
Vazby - Podlaží: 3.NP_SO-102; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Hostitel: Podlaží : 3.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Materiály a povrchové úpravy - Materiál: Červená
Grafika - Úhel natočení: 0 deg; Víko: no; SESTAVA_POPIS: PPXX
Kóty - Objem: 0.00109618 m3
Jiné - Rodina: Podlahová krabice.CC; H: -55 mm; iD: 225 mm; Id typu: 318547; iH: 40 mm; iS: 265 mm; O: -40 mm; oD: 235 mm; oS: 275 mm; pm: 4; Rodina a typ: Podlahová krabice.CC: Podlahová krabice - 12 modulů; Typ: Podlahová krabice - 12 modulů; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:15
Name (Podlahová krabice.CC:Podlahová krabice - 12 modulů:...) | NetVolume (m3) | ID_import | Kód prvku | Označení
1002251 | 0.00109618 | 1002251 | PQ00.09.0214 | 0214
1002306 | 0.00109618 | 1002306 | PQ00.09.0215 | 0215
1002323 | 0.00109618 | 1002323 | PQ00.09.0216 | 0216
1002339 | 0.00109618 | 1002339 | PQ00.09.0217 | 0217
1002361 | 0.00109618 | 1002361 | PQ00.09.0218 | 0218
1002377 | 0.00109618 | 1002377 | PQ00.09.0219 | 0219
1002393 | 0.00109618 | 1002393 | PQ00.09.0220 | 0220
1002409 | 0.00109618 | 1002409 | PQ00.09.0221 | 0221
1002425 | 0.00109618 | 1002425 | PQ00.09.0222 | 0222
1002441 | 0.00109618 | 1002441 | PQ00.09.0223 | 0223
1002457 | 0.00109618 | 1002457 | PQ00.09.0224 | 0224
1002473 | 0.00109618 | 1002473 | PQ00.09.0225 | 0225
1002491 | 0.00109618 | 1002491 | PQ00.09.0226 | 0226
1002507 | 0.00109618 | 1002507 | PQ00.09.0227 | 0227
1002523 | 0.00109618 | 1002523 | PQ00.09.0228 | 0228
1002539 | 0.00109618 | 1002539 | PQ00.09.0229 | 0229
1002555 | 0.00109618 | 1002555 | PQ00.09.0230 | 0230
1002571 | 0.00109618 | 1002571 | PQ00.09.0231 | 0231
1002587 | 0.00109618 | 1002587 | PQ00.09.0232 | 0232
1002603 | 0.00109618 | 1002603 | PQ00.09.0233 | 0233
1002619 | 0.00109618 | 1002619 | PQ00.09.0234 | 0234
1002635 | 0.00109618 | 1002635 | PQ00.09.0235 | 0235
1002653 | 0.00109618 | 1002653 | PQ00.09.0236 | 0236
1002669 | 0.00109618 | 1002669 | PQ00.09.0237 | 0237
1002685 | 0.00109618 | 1002685 | PQ00.09.0238 | 0238
1002703 | 0.00109618 | 1002703 | PQ00.09.0239 | 0239
1002719 | 0.00109618 | 1002719 | PQ00.09.0240 | 0240
1002735 | 0.00109618 | 1002735 | PQ00.09.0241 | 0241
1002751 | 0.00109618 | 1002751 | PQ00.09.0242 | 0242
1002769 | 0.00109618 | 1002769 | PQ00.09.0243 | 0243
1002785 | 0.00109618 | 1002785 | PQ00.09.0244 | 0244
1002803 | 0.00109618 | 1002803 | PQ00.09.0245 | 0245
1002819 | 0.00109618 | 1002819 | PQ00.09.0246 | 0246
1002835 | 0.00109618 | 1002835 | PQ00.09.0247 | 0247
1002851 | 0.00109618 | 1002851 | PQ00.09.0248 | 0248
1002871 | 0.00109618 | 1002871 | PQ00.09.0249 | 0249
1002887 | 0.00109618 | 1002887 | PQ00.09.0250 | 0250
1002903 | 0.00109618 | 1002903 | PQ00.09.0251 | 0251
1079982 | 0.00109618 | 1079982 | PQ00.09.0392 | 0392
1080018 | 0.00109618 | 1080018 | PQ00.09.0393 | 0393
1080029 | 0.00109618 | 1080029 | PQ00.09.0394 | 0394
1080040 | 0.00109618 | 1080040 | PQ00.09.0395 | 0395
1080051 | 0.00109617 | 1080051 | PQ00.09.0396 | 0396

# IfcBuildingElementProxy: Podlahová krabice.CC:Podlahová krabice - 18 modulů (98)
Type - Material: Červená
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Počet modulů: 18
Type - Kóty - DÉLKA: 255 mm; HLOUBKA: 65 mm; ŠÍŘKA: 255 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: PQ00; Komentáře k typům: Podlahová krabice; Model: Model; Název typu: Podlahová krabice - 18 modulů; Označení typu: 02; Popis: Podlahová krabice; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrická tělesa; M: 135 mm; Název rodiny: Podlahová krabice.CC
Classification: PQ00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.32467 m2
Text - CCI Funkční systém: M; CCI Komponenta: XGB; CCI Technický systém: JL
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Materiály a povrchové úpravy - Materiál: Červená
Grafika - Úhel natočení: 0 deg; Víko: no; SESTAVA_POPIS: PPXX
Kóty - Objem: 0.00134997 m3
Jiné - Rodina: Podlahová krabice.CC; H: -70 mm; iD: 265 mm; Id typu: 330022; iH: 40 mm; iS: 265 mm; O: -55 mm; oD: 275 mm; oS: 275 mm; pm: 6; Rodina a typ: Podlahová krabice.CC: Podlahová krabice - 18 modulů; Typ: Podlahová krabice - 18 modulů; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:16
Name (Podlahová krabice.CC:Podlahová krabice - 18 modulů:...) | In | NetVolume (m3) | ID_import | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
933628 | 1.NP_SO-102 | 0.00134997 | 933628 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | PQ00.02.0005 | 0005
933644 | 1.NP_SO-102 | 0.00134997 | 933644 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | PQ00.02.0006 | 0006
933652 | 1.NP_SO-102 | 0.00134997 | 933652 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | PQ00.02.0007 | 0007
933660 | 1.NP_SO-102 | 0.00134997 | 933660 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | PQ00.02.0008 | 0008
933668 | 1.NP_SO-102 | 0.00134997 | 933668 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | PQ00.02.0009 | 0009
933676 | 1.NP_SO-102 | 0.00134997 | 933676 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | PQ00.02.0010 | 0010
933684 | 1.NP_SO-102 | 0.00134997 | 933684 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | PQ00.02.0011 | 0011
933692 | 1.NP_SO-102 | 0.00134997 | 933692 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | PQ00.02.0012 | 0012
933700 | 1.NP_SO-102 | 0.00134997 | 933700 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | PQ00.02.0013 | 0013
934194 | 2.NP_SO-102 | 0.00134998 | 934194 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PQ00.02.0014 | 0014
934202 | 2.NP_SO-102 | 0.00134997 | 934202 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PQ00.02.0015 | 0015
934210 | 2.NP_SO-102 | 0.00134997 | 934210 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PQ00.02.0016 | 0016
934218 | 2.NP_SO-102 | 0.00134997 | 934218 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PQ00.02.0017 | 0017
934226 | 2.NP_SO-102 | 0.00134997 | 934226 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PQ00.02.0018 | 0018
934234 | 2.NP_SO-102 | 0.00134997 | 934234 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PQ00.02.0019 | 0019
934242 | 2.NP_SO-102 | 0.00134997 | 934242 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | PQ00.02.0020 | 0020
934250 | 2.NP_SO-102 | 0.00134997 | 934250 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | PQ00.02.0021 | 0021
934266 | 2.NP_SO-102 | 0.00134997 | 934266 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PQ00.02.0022 | 0022
934274 | 2.NP_SO-102 | 0.00134997 | 934274 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | PQ00.02.0023 | 0023
934282 | 2.NP_SO-102 | 0.00134997 | 934282 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | PQ00.02.0024 | 0024
934290 | 2.NP_SO-102 | 0.00134997 | 934290 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | PQ00.02.0025 | 0025
934298 | 2.NP_SO-102 | 0.00134997 | 934298 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PQ00.02.0026 | 0026
934306 | 2.NP_SO-102 | 0.00134997 | 934306 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PQ00.02.0027 | 0027
934356 | 2.NP_SO-102 | 0.00134997 | 934356 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PQ00.02.0032 | 0032
934364 | 2.NP_SO-102 | 0.00134997 | 934364 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PQ00.02.0033 | 0033
934372 | 2.NP_SO-102 | 0.00134997 | 934372 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PQ00.02.0034 | 0034
