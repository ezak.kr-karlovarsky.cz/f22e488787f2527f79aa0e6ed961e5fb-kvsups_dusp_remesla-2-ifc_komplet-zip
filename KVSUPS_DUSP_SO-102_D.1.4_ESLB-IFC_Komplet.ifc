Properties of the parts of a building model (IFC4), part 2 of 9

# IfcBuildingElementProxy: Podlahová krabice.CC:Podlahová krabice - 18 modulů (98)
Name (Podlahová krabice.CC:Podlahová krabice - 18 modulů:...) | In | NetVolume (m3) | ID_import | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
934380 | 2.NP_SO-102 | 0.00134997 | 934380 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PQ00.02.0035 | 0035
934661 | 2.NP_SO-102 | 0.00134997 | 934661 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PQ00.02.0037 | 0037
934669 | 2.NP_SO-102 | 0.00134997 | 934669 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PQ00.02.0038 | 0038
934677 | 2.NP_SO-102 | 0.00134997 | 934677 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PQ00.02.0039 | 0039
934685 | 2.NP_SO-102 | 0.00134997 | 934685 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PQ00.02.0040 | 0040
997287 | 2.NP_SO-102 | 0.00134997 | 997287 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | PQ00.02.0160 | 0160
1000234 | 3.NP_SO-102 | 0.00134998 | 1000234 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0162 | 0162
1000271 | 4.NP_SO-102 | 0.00134997 | 1000271 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PQ00.02.0163 | 0163
1000315 | 3.NP_SO-102 | 0.00134997 | 1000315 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0164 | 0164
1000333 | 3.NP_SO-102 | 0.00134997 | 1000333 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0165 | 0165
1000351 | 3.NP_SO-102 | 0.00134997 | 1000351 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0166 | 0166
1000369 | 3.NP_SO-102 | 0.00134997 | 1000369 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0167 | 0167
1000387 | 3.NP_SO-102 | 0.00134997 | 1000387 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | PQ00.02.0168 | 0168
1000405 | 3.NP_SO-102 | 0.00134997 | 1000405 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | PQ00.02.0169 | 0169
1000427 | 3.NP_SO-102 | 0.00134997 | 1000427 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | PQ00.02.0170 | 0170
1000445 | 3.NP_SO-102 | 0.00134997 | 1000445 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | PQ00.02.0171 | 0171
1000465 | 3.NP_SO-102 | 0.00134997 | 1000465 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | PQ00.02.0172 | 0172
1000485 | 3.NP_SO-102 | 0.00134997 | 1000485 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0173 | 0173
1000503 | 3.NP_SO-102 | 0.00134997 | 1000503 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0174 | 0174
1001001 | 4.NP_SO-102 | 0.00134997 | 1001001 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PQ00.02.0178 | 0178
1001019 | 4.NP_SO-102 | 0.00134997 | 1001019 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PQ00.02.0179 | 0179
1001039 | 4.NP_SO-102 | 0.00134997 | 1001039 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PQ00.02.0180 | 0180
1001057 | 4.NP_SO-102 | 0.00134997 | 1001057 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | PQ00.02.0181 | 0181
1001075 | 4.NP_SO-102 | 0.00134997 | 1001075 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | PQ00.02.0182 | 0182
1001093 | 4.NP_SO-102 | 0.00134997 | 1001093 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PQ00.02.0183 | 0183
1001124 | 4.NP_SO-102 | 0.00134998 | 1001124 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PQ00.02.0184 | 0184
1001363 | 4.NP_SO-102 | 0.00134998 | 1001363 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PQ00.02.0185 | 0185
1001444 | 4.NP_SO-102 | 0.00134997 | 1001444 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PQ00.02.0186 | 0186
1001453 | 4.NP_SO-102 | 0.00134998 | 1001453 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PQ00.02.0187 | 0187
1001470 | 4.NP_SO-102 | 0.00134998 | 1001470 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PQ00.02.0188 | 0188
1001490 | 4.NP_SO-102 | 0.00134997 | 1001490 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PQ00.02.0189 | 0189
1001499 | 4.NP_SO-102 | 0.00134998 | 1001499 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PQ00.02.0190 | 0190
1001514 | 4.NP_SO-102 | 0.00134998 | 1001514 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PQ00.02.0191 | 0191
1001573 | 4.NP_SO-102 | 0.00134997 | 1001573 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PQ00.02.0192 | 0192
1001594 | 4.NP_SO-102 | 0.00134997 | 1001594 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PQ00.02.0193 | 0193
1001615 | 4.NP_SO-102 | 0.00134997 | 1001615 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PQ00.02.0194 | 0194
1001636 | 4.NP_SO-102 | 0.00134997 | 1001636 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | PQ00.02.0195 | 0195
1001657 | 4.NP_SO-102 | 0.00134997 | 1001657 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | PQ00.02.0196 | 0196
1001678 | 4.NP_SO-102 | 0.00134997 | 1001678 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | PQ00.02.0197 | 0197
1001699 | 4.NP_SO-102 | 0.00134997 | 1001699 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | PQ00.02.0198 | 0198
1001724 | 4.NP_SO-102 | 0.00134997 | 1001724 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | PQ00.02.0199 | 0199
1001745 | 4.NP_SO-102 | 0.00134997 | 1001745 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | PQ00.02.0200 | 0200
1001768 | 4.NP_SO-102 | 0.00134997 | 1001768 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | PQ00.02.0201 | 0201
1001789 | 4.NP_SO-102 | 0.00134997 | 1001789 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | PQ00.02.0202 | 0202
1001814 | 4.NP_SO-102 | 0.00134997 | 1001814 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | PQ00.02.0203 | 0203
1001839 | 4.NP_SO-102 | 0.00134997 | 1001839 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | PQ00.02.0204 | 0204
1001862 | 4.NP_SO-102 | 0.00134997 | 1001862 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | PQ00.02.0205 | 0205
1001885 | 4.NP_SO-102 | 0.00134997 | 1001885 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | PQ00.02.0206 | 0206
1001906 | 4.NP_SO-102 | 0.00134997 | 1001906 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | PQ00.02.0207 | 0207
1001941 | 4.NP_SO-102 | 0.00134997 | 1001941 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PQ00.02.0208 | 0208
1001975 | 4.NP_SO-102 | 0.00134997 | 1001975 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | PQ00.02.0209 | 0209
1001996 | 4.NP_SO-102 | 0.00134997 | 1001996 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | PQ00.02.0210 | 0210
1002017 | 4.NP_SO-102 | 0.00134997 | 1002017 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | PQ00.02.0211 | 0211
1002038 | 4.NP_SO-102 | 0.00134997 | 1002038 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | PQ00.02.0212 | 0212
1002059 | 4.NP_SO-102 | 0.00134997 | 1002059 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | PQ00.02.0213 | 0213
1002933 | 3.NP_SO-102 | 0.00134997 | 1002933 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0252 | 0252
1002955 | 3.NP_SO-102 | 0.00134997 | 1002955 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0253 | 0253
1066108 | 3.NP_SO-102 | 0.00134997 | 1066108 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0376 | 0376
1066182 | 3.NP_SO-102 | 0.00134997 | 1066182 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0377 | 0377 | Fázování - Fáze demolice: Fáze 1
1066196 | 3.NP_SO-102 | 0.00134997 | 1066196 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0378 | 0378 | Fázování - Fáze demolice: Fáze 1
1066210 | 3.NP_SO-102 | 0.00134997 | 1066210 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0379 | 0379 | Fázování - Fáze demolice: Fáze 1
1066238 | 3.NP_SO-102 | 0.00134997 | 1066238 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0380 | 0380 | Fázování - Fáze demolice: Fáze 1
1066252 | 3.NP_SO-102 | 0.00134997 | 1066252 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0381 | 0381 | Fázování - Fáze demolice: Fáze 1
1066266 | 3.NP_SO-102 | 0.00134997 | 1066266 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0382 | 0382 | Fázování - Fáze demolice: Fáze 1
1066280 | 3.NP_SO-102 | 0.00134997 | 1066280 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0383 | 0383 | Fázování - Fáze demolice: Fáze 1
1066294 | 3.NP_SO-102 | 0.00134997 | 1066294 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0384 | 0384 | Fázování - Fáze demolice: Fáze 1
1066308 | 3.NP_SO-102 | 0.00134997 | 1066308 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0385 | 0385 | Fázování - Fáze demolice: Fáze 1
1066336 | 3.NP_SO-102 | 0.00134997 | 1066336 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0386 | 0386 | Fázování - Fáze demolice: Fáze 1
1066350 | 3.NP_SO-102 | 0.00134997 | 1066350 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0387 | 0387 | Fázování - Fáze demolice: Fáze 1
1066364 | 3.NP_SO-102 | 0.00134997 | 1066364 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0388 | 0388 | Fázování - Fáze demolice: Fáze 1
1070404 | 3.NP_SO-102 | 0.00134997 | 1070404 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0389 | 0389
1070596 | 3.NP_SO-102 | 0.00134997 | 1070596 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.02.0391 | 0391

# IfcBuildingElementProxy: Podlahová krabice.CC:Podlahová krabice - 24 modulů (13)
Type - Material: Červená
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Počet modulů: 24
Type - Kóty - DÉLKA: 310 mm; HLOUBKA: 65 mm; ŠÍŘKA: 255 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: PQ00; Komentáře k typům: Podlahová krabice; Model: Model; Název typu: Podlahová krabice - 24 modulů; Označení typu: 01; Popis: Podlahová krabice; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrická tělesa; M: 180 mm; Název rodiny: Podlahová krabice.CC
Classification: PQ00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.37329 m2; NetVolume: 0.00159995 m3
Text - CCI Funkční systém: M; CCI Komponenta: XGB; CCI Technický systém: JL
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Materiály a povrchové úpravy - Materiál: Červená
Grafika - SESTAVA_POPIS: PPXX; Úhel natočení: 0 deg; Víko: no
Kóty - Objem: 0.00159995 m3
Jiné - H: -70 mm; iD: 320 mm; Id typu: 330345; iH: 40 mm; iS: 265 mm; O: -55 mm; oD: 330 mm; oS: 275 mm; pm: 8; Rodina: Podlahová krabice.CC; Rodina a typ: Podlahová krabice.CC: Podlahová krabice - 24 modulů; Typ: Podlahová krabice - 24 modulů; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:16
Name (Podlahová krabice.CC:Podlahová krabice - 24 modulů:...) | In | ID_import | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
932470 | 1.NP_SO-102 | 932470 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | PQ00.01.0001 | 0001
932478 | 1.NP_SO-102 | 932478 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | PQ00.01.0002 | 0002
932486 | 1.NP_SO-102 | 932486 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | PQ00.01.0003 | 0003
932498 | 1.NP_SO-102 | 932498 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | PQ00.01.0004 | 0004
934317 | 2.NP_SO-102 | 934317 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PQ00.01.0028 | 0028
934325 | 2.NP_SO-102 | 934325 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PQ00.01.0029 | 0029
934333 | 2.NP_SO-102 | 934333 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PQ00.01.0030 | 0030
934345 | 2.NP_SO-102 | 934345 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | PQ00.01.0031 | 0031
998483 | 1.NP_SO-102 | 998483 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | PQ00.01.0161 | 0161
1000545 | 3.NP_SO-102 | 1000545 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | PQ00.01.0175 | 0175
1000563 | 3.NP_SO-102 | 1000563 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | PQ00.01.0176 | 0176
1000581 | 3.NP_SO-102 | 1000581 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | PQ00.01.0177 | 0177
1004658 | 3.NP_SO-102 | 1004658 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | PQ00.01.0350 | 0350

# IfcBuildingElementProxy: Reproduktory.CC:Nástěnný reproduktor hranatý (44)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 2500 mm
Type - Elektrotechnika - Počet fází: 1
Type - Grafika - Symbol: yes; Typ symbolu: Reproduktor nástěnný.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.10.11.14.21; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: NZ04; Komentáře k typům: nástěnný, hranatý; Model: Model; Nadpis OmniClass: Audio Reproducing Units; Název typu: Nástěnný reproduktor hranatý; Označení typu: 01; Popis: Reproduktor; Popis sestavy: Reproduktory; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Komunikační zařízení; Název rodiny: Reproduktory.CC; Typ reproduktoru: Reproduktor_nástěnný_hranatý.CC : Nástěnný reproduktor
Classification: NZ04 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.1076 m2; NetVolume: 0.0021655 m3
Text - CCI Funkční systém: M; CCI Komponenta: PJA; CCI Technický systém: JL
Vazby - Odsazení od hostitele: 2500 mm; Výška od podlaží: 2500 mm
Grafika - Posun horizontální: 0; Posun vertikální: 0; Svislá poloha: no
Kóty - Hloubka reproduktoru: 100 mm; Objem: 0.0021655 m3; Průměr reproduktoru: 150 mm
Jiné - a: 75 mm; b: 18.75 mm; c: 10 mm; ch: 225 mm; d: 5 mm; e: 40 mm; f: 40 mm; g: 10 mm; h: 5 mm; Id typu: 1079095; JMENOVITÝ PŘÍKON REPRODUKTORU: 0 W; NASTAVENÝ PŘÍKON REPRODUKTORU: 0 W; Rodina: Reproduktory.CC; Rodina a typ: Reproduktory.CC: Nástěnný reproduktor hranatý; Typ: Nástěnný reproduktor hranatý; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:17
Name (Reproduktory.CC:Nástěnný reproduktor hranatý:...) | In | ID_import | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
1079112 | 3.NP_SO-102 | 1079112 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0001 | 0001
1079116 | 3.NP_SO-102 | 1079116 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0002 | 0002
1079143 | 3.NP_SO-102 | 1079143 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0003 | 0003
1079144 | 3.NP_SO-102 | 1079144 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0004 | 0004
1079152 | 3.NP_SO-102 | 1079152 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0005 | 0005
1079153 | 3.NP_SO-102 | 1079153 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0006 | 0006
1079163 | 3.NP_SO-102 | 1079163 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0007 | 0007
1079164 | 3.NP_SO-102 | 1079164 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0008 | 0008
1079172 | 3.NP_SO-102 | 1079172 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0009 | 0009
1079173 | 3.NP_SO-102 | 1079173 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0010 | 0010
1079181 | 3.NP_SO-102 | 1079181 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0011 | 0011
1079182 | 3.NP_SO-102 | 1079182 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0012 | 0012
1079192 | 3.NP_SO-102 | 1079192 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0013 | 0013
1079193 | 3.NP_SO-102 | 1079193 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0014 | 0014
1079819 | 3.NP_SO-102 | 1079819 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0015 | 0015
1079823 | 3.NP_SO-102 | 1079823 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0016 | 0016
1079827 | 3.NP_SO-102 | 1079827 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0017 | 0017
1079831 | 3.NP_SO-102 | 1079831 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0018 | 0018
1079835 | 3.NP_SO-102 | 1079835 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0019 | 0019
1079839 | 3.NP_SO-102 | 1079839 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0020 | 0020
1079843 | 3.NP_SO-102 | 1079843 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0021 | 0021
1079847 | 3.NP_SO-102 | 1079847 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0022 | 0022
1079851 | 3.NP_SO-102 | 1079851 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0023 | 0023
1079855 | 3.NP_SO-102 | 1079855 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0024 | 0024
1080548 | 2.NP_SO-102 | 1080548 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | NZ04.01.0025 | 0025
1080552 | 2.NP_SO-102 | 1080552 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | NZ04.01.0026 | 0026
1080556 | 2.NP_SO-102 | 1080556 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | NZ04.01.0027 | 0027
1080560 | 2.NP_SO-102 | 1080560 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | NZ04.01.0028 | 0028
1080564 | 2.NP_SO-102 | 1080564 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | NZ04.01.0029 | 0029
1080568 | 2.NP_SO-102 | 1080568 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | NZ04.01.0030 | 0030
1080578 | 2.NP_SO-102 | 1080578 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0031 | 0031
1080582 | 2.NP_SO-102 | 1080582 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0032 | 0032
1080725 | 2.NP_SO-102 | 1080725 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0033 | 0033
1080729 | 2.NP_SO-102 | 1080729 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0034 | 0034
1080733 | 2.NP_SO-102 | 1080733 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0035 | 0035
1080737 | 2.NP_SO-102 | 1080737 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0036 | 0036
1080741 | 2.NP_SO-102 | 1080741 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0037 | 0037
1080745 | 2.NP_SO-102 | 1080745 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0038 | 0038
1080749 | 2.NP_SO-102 | 1080749 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0039 | 0039
1080753 | 2.NP_SO-102 | 1080753 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0040 | 0040
1080757 | 2.NP_SO-102 | 1080757 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0041 | 0041
1080761 | 2.NP_SO-102 | 1080761 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0042 | 0042
1080765 | 2.NP_SO-102 | 1080765 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0043 | 0043
1080769 | 2.NP_SO-102 | 1080769 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0044 | 0044

# IfcBuildingElementProxy: Vícerámečky, vodovné.CC:Vícerámečky - 1x (39)
In: 2.NP_SO-102
Type - Material: Bílá
Type - Vazby - Výchozí výška: 900 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Kóty - Hloubka: 5 mm; Osová vzdálenost: 71 mm; ŠÍŘKA: 80 mm; Šířka_in: 45 mm; VÝŠKA: 80 mm; Výška_in: 45 mm
Type - Identifikační data - Číslo OmniClass: 23.80.70.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: MT00; Komentáře k typům: Rámečky vícenásobné; Nadpis OmniClass: Lighting; Název typu: Vícerámečky - 1x; Označení typu: 06; Popis: Rámeček; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Elektrická tělesa; P6: 0 mm; P4: 0 mm; P5: 0 mm; Název rodiny: Vícerámečky, vodovné.CC; P: 1; P2: 0 mm; P3: 0 mm; ST: 0 mm
Classification: MT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.01125 m2; NetVolume: 0.000021875 m3
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Vazby - Podlaží: 2.NP_SO-102; Vztažné podlaží: 2.NP_SO-102
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.000021875 m3
Jiné - Rodina: Vícerámečky, vodovné.CC; Id typu: 331379; Rodina a typ: Vícerámečky, vodovné.CC: Vícerámečky - 1x; S: 80 mm; Typ: Vícerámečky - 1x
Name (Vícerámečky, vodovné.CC:Vícerámečky - 1x:...) | ID_import | Hostitel | Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení | UPRAVIL
937614 | 937614 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.06.0048 | 0048 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
937697 | 937697 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.06.0049 | 0049 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
937743 | 937743 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 2 | MT00.06.0050 | 0050 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
937780 | 937780 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 2 | MT00.06.0051 | 0051 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
937801 | 937801 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 2 | MT00.06.0052 | 0052 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
937836 | 937836 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 356.935 | Fáze 2 | MT00.06.0053 | 0053 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
938002 | 938002 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 356.935 | Fáze 2 | MT00.06.0054 | 0054 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
938040 | 938040 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 356.935 | Fáze 1 | MT00.06.0055 | 0055 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
938137 | 938137 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 356.935 | Fáze 1 | MT00.06.0056 | 0056 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
938167 | 938167 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 356.935 | Fáze 1 | MT00.06.0057 | 0057 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
938210 | 938210 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 356.935 | Fáze 1 | MT00.06.0058 | 0058 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
938251 | 938251 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 356.935 | Fáze 1 | MT00.06.0059 | 0059 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
938291 | 938291 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 356.935 | Fáze 1 | MT00.06.0060 | 0060 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
943080 | 943080 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.06.0061 | 0061 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
956904 | 956904 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 900 | Fáze 1 | MT00.06.0112 | 0112 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
956910 | 956910 | Osamocené | 900 | Fáze 1 | MT00.06.0113 | 0113 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
956951 | 956951 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 900 | Fáze 1 | MT00.06.0114 | 0114 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
957060 | 957060 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 900 | Fáze 1 | MT00.06.0115 | 0115 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
957352 | 957352 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 900 | Fáze 1 | MT00.06.0116 | 0116 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
957394 | 957394 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 900 | Fáze 1 | MT00.06.0117 | 0117 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
957426 | 957426 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 900 | Fáze 1 | MT00.06.0118 | 0118 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
957527 | 957527 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 900 | Fáze 1 | MT00.06.0119 | 0119 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
957550 | 957550 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 900 | Fáze 2 | MT00.06.0120 | 0120 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
957612 | 957612 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 900 | Fáze 2 | MT00.06.0121 | 0121 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
957638 | 957638 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 900 | Fáze 2 | MT00.06.0122 | 0122 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
957717 | 957717 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 900 | Fáze 1 | MT00.06.0123 | 0123 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
957866 | 957866 | Osamocené | 900 | Fáze 1 | MT00.06.0124 | 0124 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
958029 | 958029 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 900 | Fáze 1 | MT00.06.0125 | 0125 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
962889 | 962889 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.06.0130 | 0130 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
962982 | 962982 | <nepřiřazeno> | 300 | Fáze 1 | MT00.06.0131 | 0131 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
962990 | 962990 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.06.0132 | 0132 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
963015 | 963015 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.06.0133 | 0133 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
963022 | 963022 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 900 | Fáze 1 | MT00.06.0134 | 0134 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
963076 | 963076 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 900 | Fáze 1 | MT00.06.0135 | 0135 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
963092 | 963092 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.06.0136 | 0136 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
963126 | 963126 | Osamocené | 300 | Fáze 1 | MT00.06.0137 | 0137 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
963190 | 963190 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.06.0138 | 0138 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
963286 | 963286 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.06.0139 | 0139 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
963440 | 963440 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.06.0140 | 0140 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16

# IfcBuildingElementProxy: Vícerámečky, vodovné.CC:Vícerámečky - 2x (13)
Type - Material: Bílá
Type - Vazby - Výchozí výška: 950 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Kóty - Hloubka: 5 mm; Osová vzdálenost: 71 mm; ŠÍŘKA: 80 mm; Šířka_in: 45 mm; VÝŠKA: 80 mm; Výška_in: 45 mm
Type - Identifikační data - Číslo OmniClass: 23.80.70.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: MT00; Komentáře k typům: Rámečky vícenásobné; Nadpis OmniClass: Lighting; Název typu: Vícerámečky - 2x; Označení typu: 08; Popis: Rámeček; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Elektrická tělesa; P6: 0 mm; P4: 0 mm; P5: 0 mm; P3: 0 mm; Název rodiny: Vícerámečky, vodovné.CC; P: 2; P2: 71 mm; ST: 35.5 mm
Classification: MT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.02017 m2; NetVolume: 0.00004015 m3
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.00004015 m3
Jiné - Rodina: Vícerámečky, vodovné.CC; Id typu: 358944; Rodina a typ: Vícerámečky, vodovné.CC: Vícerámečky - 2x; S: 151 mm; Typ: Vícerámečky - 2x; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
Name (Vícerámečky, vodovné.CC:Vícerámečky - 2x:...) | In | ID_import | Podlaží = Vztažné podlaží | Hostitel | Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení
973678 | 2.NP_SO-102 | 973678 | 2.NP_SO-102 | Osamocené | 1050 | Fáze 1 | MT00.08.0155 | 0155
991339 | 2.NP_SO-102 | 991339 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1107.5 | Fáze 1 | MT00.08.0156 | 0156
991576 | 2.NP_SO-102 | 991576 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 1 | MT00.08.0157 | 0157
991683 | 2.NP_SO-102 | 991683 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1050 | Fáze 1 | MT00.08.0158 | 0158
991721 | 2.NP_SO-102 | 991721 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1050 | Fáze 1 | MT00.08.0159 | 0159
1005355 | 3.NP_SO-102 | 1005355 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 950 | Fáze 1 | MT00.08.0351 | 0351
1005362 | 3.NP_SO-102 | 1005362 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 950 | Fáze 1 | MT00.08.0352 | 0352
1005396 | 3.NP_SO-102 | 1005396 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 950 | Fáze 2 | MT00.08.0353 | 0353
1005487 | 3.NP_SO-102 | 1005487 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 950 | Fáze 2 | MT00.08.0354 | 0354
1007535 | 4.NP_SO-102 | 1007535 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 950 | Fáze 2 | MT00.08.0372 | 0372
1007544 | 4.NP_SO-102 | 1007544 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 950 | Fáze 2 | MT00.08.0373 | 0373
1008632 | 4.NP_SO-102 | 1008632 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 950 | Fáze 1 | MT00.08.0374 | 0374
1008658 | 4.NP_SO-102 | 1008658 | 4.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 950 | Fáze 1 | MT00.08.0375 | 0375

# IfcBuildingElementProxy: Vícerámečky, vodovné.CC:Vícerámečky - 3x (125)
Type - Material: Bílá
Type - Vazby - Výchozí výška: 300 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Kóty - Hloubka: 5 mm; Osová vzdálenost: 71 mm; ŠÍŘKA: 80 mm; Šířka_in: 45 mm; VÝŠKA: 80 mm; Výška_in: 45 mm
Type - Identifikační data - Číslo OmniClass: 23.80.70.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: MT00; Komentáře k typům: Rámečky vícenásobné; Nadpis OmniClass: Lighting; Název typu: Vícerámečky - 3x; Označení typu: 05; Popis: Rámeček; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Elektrická tělesa; P6: 0 mm; Název rodiny: Vícerámečky, vodovné.CC; P: 3; P2: 71 mm; P3: 142 mm; P4: 0 mm; P5: 0 mm; ST: 71 mm
Classification: MT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.02909 m2; NetVolume: 0.000058425 m3
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.000058425 m3
Jiné - Rodina: Vícerámečky, vodovné.CC; Id typu: 360411; Rodina a typ: Vícerámečky, vodovné.CC: Vícerámečky - 3x; S: 222 mm; Typ: Vícerámečky - 3x
Name (Vícerámečky, vodovné.CC:Vícerámečky - 3x:...) | In | ID_import | Podlaží = Vztažné podlaží | Hostitel | Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení | UPRAVIL
934796 | 2.NP_SO-102 | 934796 | 2.NP_SO-102 | Osamocené | 1050 | Fáze 1 | MT00.05.0044 | 0044 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
934801 | 2.NP_SO-102 | 934801 | 2.NP_SO-102 | Osamocené | 1050 | Fáze 1 | MT00.05.0045 | 0045 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
934828 | 2.NP_SO-102 | 934828 | 2.NP_SO-102 | Osamocené | 1050 | Fáze 1 | MT00.05.0046 | 0046 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
934854 | 2.NP_SO-102 | 934854 | 2.NP_SO-102 | Osamocené | 1050 | Fáze 1 | MT00.05.0047 | 0047 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
954245 | 2.NP_SO-102 | 954245 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0099 | 0099 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
954251 | 2.NP_SO-102 | 954251 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0100 | 0100 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
954315 | 2.NP_SO-102 | 954315 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0101 | 0101 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
954375 | 2.NP_SO-102 | 954375 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0102 | 0102 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
954403 | 2.NP_SO-102 | 954403 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0103 | 0103 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
954435 | 2.NP_SO-102 | 954435 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0104 | 0104 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
954463 | 2.NP_SO-102 | 954463 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 2 | MT00.05.0105 | 0105 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
954500 | 2.NP_SO-102 | 954500 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 2 | MT00.05.0106 | 0106 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
954551 | 2.NP_SO-102 | 954551 | 2.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 2 | MT00.05.0107 | 0107 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
955945 | 2.NP_SO-102 | 955945 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0108 | 0108 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
955955 | 2.NP_SO-102 | 955955 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 2 | MT00.05.0109 | 0109 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
956009 | 2.NP_SO-102 | 956009 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 2 | MT00.05.0110 | 0110 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
956118 | 2.NP_SO-102 | 956118 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0111 | 0111 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
964444 | 2.NP_SO-102 | 964444 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 2 | MT00.05.0141 | 0141 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
964455 | 2.NP_SO-102 | 964455 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 2 | MT00.05.0142 | 0142 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
964461 | 2.NP_SO-102 | 964461 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0143 | 0143 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
964505 | 2.NP_SO-102 | 964505 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0144 | 0144 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
964539 | 2.NP_SO-102 | 964539 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0145 | 0145 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
964556 | 2.NP_SO-102 | 964556 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0146 | 0146 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
964599 | 2.NP_SO-102 | 964599 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0147 | 0147 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
964626 | 2.NP_SO-102 | 964626 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0148 | 0148 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
964660 | 2.NP_SO-102 | 964660 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0149 | 0149 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
964683 | 2.NP_SO-102 | 964683 | 2.NP_SO-102 | Osamocené | 300 | Fáze 1 | MT00.05.0150 | 0150 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
964710 | 2.NP_SO-102 | 964710 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0151 | 0151 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
964764 | 2.NP_SO-102 | 964764 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0152 | 0152 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
965385 | 2.NP_SO-102 | 965385 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0153 | 0153 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
965395 | 2.NP_SO-102 | 965395 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0154 | 0154 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1003469 | 3.NP_SO-102 | 1003469 | 3.NP_SO-102 | Osamocené | 300 | Fáze 1 | MT00.05.0267 | 0267 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1003480 | 3.NP_SO-102 | 1003480 | 3.NP_SO-102 | Osamocené | 300 | Fáze 1 | MT00.05.0268 | 0268 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1003598 | 4.NP_SO-102 | 1003598 | 4.NP_SO-102 | Osamocené | 300 | Fáze 1 | MT00.05.0269 | 0269 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1003999 | 4.NP_SO-102 | 1003999 | 4.NP_SO-102 | Osamocené | 300 | Fáze 1 | MT00.05.0276 | 0276 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004013 | 4.NP_SO-102 | 1004013 | 4.NP_SO-102 | Osamocené | 300 | Fáze 1 | MT00.05.0277 | 0277 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004027 | 4.NP_SO-102 | 1004027 | 4.NP_SO-102 | Osamocené | 300 | Fáze 1 | MT00.05.0278 | 0278 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004039 | 4.NP_SO-102 | 1004039 | 4.NP_SO-102 | Osamocené | 300 | Fáze 2 | MT00.05.0279 | 0279 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004051 | 4.NP_SO-102 | 1004051 | 4.NP_SO-102 | Osamocené | 300 | Fáze 2 | MT00.05.0280 | 0280 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004065 | 3.NP_SO-102 | 1004065 | 3.NP_SO-102 | Osamocené | 300 | Fáze 1 | MT00.05.0281 | 0281 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004084 | 3.NP_SO-102 | 1004084 | 3.NP_SO-102 | Osamocené | 300 | Fáze 1 | MT00.05.0282 | 0282 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004098 | 3.NP_SO-102 | 1004098 | 3.NP_SO-102 | Osamocené | 300 | Fáze 1 | MT00.05.0283 | 0283 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004110 | 3.NP_SO-102 | 1004110 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0284 | 0284 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004122 | 3.NP_SO-102 | 1004122 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0285 | 0285 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004134 | 3.NP_SO-102 | 1004134 | 3.NP_SO-102 | Osamocené | 300 | Fáze 1 | MT00.05.0286 | 0286 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004146 | 3.NP_SO-102 | 1004146 | 3.NP_SO-102 | Osamocené | 300 | Fáze 2 | MT00.05.0287 | 0287 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004158 | 3.NP_SO-102 | 1004158 | 3.NP_SO-102 | Osamocené | 300 | Fáze 2 | MT00.05.0288 | 0288 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004184 | 3.NP_SO-102 | 1004184 | 3.NP_SO-102 | Osamocené | 300 | Fáze 1 | MT00.05.0289 | 0289 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004198 | 3.NP_SO-102 | 1004198 | 3.NP_SO-102 | Osamocené | 300 | Fáze 2 | MT00.05.0290 | 0290 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004208 | 3.NP_SO-102 | 1004208 | 3.NP_SO-102 | Osamocené | 300 | Fáze 2 | MT00.05.0291 | 0291 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004227 | 2.NP_SO-102 | 1004227 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 2 | MT00.05.0292 | 0292 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004229 | 2.NP_SO-102 | 1004229 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 2 | MT00.05.0293 | 0293 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004231 | 2.NP_SO-102 | 1004231 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0294 | 0294 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004233 | 2.NP_SO-102 | 1004233 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0295 | 0295 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004235 | 2.NP_SO-102 | 1004235 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0296 | 0296 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004237 | 2.NP_SO-102 | 1004237 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0297 | 0297 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004239 | 2.NP_SO-102 | 1004239 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0298 | 0298 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004241 | 2.NP_SO-102 | 1004241 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0299 | 0299 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004269 | 2.NP_SO-102 | 1004269 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 2 | MT00.05.0300 | 0300 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004271 | 2.NP_SO-102 | 1004271 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0301 | 0301 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004272 | 2.NP_SO-102 | 1004272 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0302 | 0302 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004273 | 2.NP_SO-102 | 1004273 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0303 | 0303 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004274 | 2.NP_SO-102 | 1004274 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0304 | 0304 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004275 | 2.NP_SO-102 | 1004275 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0305 | 0305 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004276 | 2.NP_SO-102 | 1004276 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0306 | 0306 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004302 | 2.NP_SO-102 | 1004302 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 2 | MT00.05.0307 | 0307 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004324 | 3.NP_SO-102 | 1004324 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0308 | 0308 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004333 | 3.NP_SO-102 | 1004333 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0309 | 0309 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004340 | 3.NP_SO-102 | 1004340 | 3.NP_SO-102 | Osamocené | 300 | Fáze 1 | MT00.05.0310 | 0310 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004344 | 3.NP_SO-102 | 1004344 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0311 | 0311 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004347 | 3.NP_SO-102 | 1004347 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0312 | 0312 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004360 | 3.NP_SO-102 | 1004360 | 3.NP_SO-102 | Osamocené | 300 | Fáze 1 | MT00.05.0313 | 0313 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004364 | 3.NP_SO-102 | 1004364 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0314 | 0314 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004367 | 3.NP_SO-102 | 1004367 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0315 | 0315 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004380 | 3.NP_SO-102 | 1004380 | 3.NP_SO-102 | Osamocené | 300 | Fáze 1 | MT00.05.0316 | 0316 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004384 | 3.NP_SO-102 | 1004384 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0317 | 0317 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004387 | 3.NP_SO-102 | 1004387 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0318 | 0318 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004398 | 3.NP_SO-102 | 1004398 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0319 | 0319 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004402 | 3.NP_SO-102 | 1004402 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0320 | 0320 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004405 | 3.NP_SO-102 | 1004405 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0321 | 0321 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004414 | 3.NP_SO-102 | 1004414 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0322 | 0322 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004418 | 3.NP_SO-102 | 1004418 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0323 | 0323 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004421 | 3.NP_SO-102 | 1004421 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | MT00.05.0324 | 0324 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004430 | 3.NP_SO-102 | 1004430 | 3.NP_SO-102 | Osamocené | 300 | Fáze 2 | MT00.05.0325 | 0325 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004434 | 3.NP_SO-102 | 1004434 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 2 | MT00.05.0326 | 0326 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004437 | 3.NP_SO-102 | 1004437 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 2 | MT00.05.0327 | 0327 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004446 | 3.NP_SO-102 | 1004446 | 3.NP_SO-102 | Osamocené | 300 | Fáze 2 | MT00.05.0328 | 0328 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004450 | 3.NP_SO-102 | 1004450 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 2 | MT00.05.0329 | 0329 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004453 | 3.NP_SO-102 | 1004453 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 2 | MT00.05.0330 | 0330 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004462 | 3.NP_SO-102 | 1004462 | 3.NP_SO-102 | Osamocené | 300 | Fáze 2 | MT00.05.0331 | 0331 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004466 | 3.NP_SO-102 | 1004466 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 2 | MT00.05.0332 | 0332 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004469 | 3.NP_SO-102 | 1004469 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 2 | MT00.05.0333 | 0333 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004479 | 3.NP_SO-102 | 1004479 | 3.NP_SO-102 | Osamocené | 300 | Fáze 1 | MT00.05.0334 | 0334 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004506 | 3.NP_SO-102 | 1004506 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0335 | 0335 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004518 | 3.NP_SO-102 | 1004518 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0336 | 0336 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004530 | 3.NP_SO-102 | 1004530 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0337 | 0337 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004548 | 3.NP_SO-102 | 1004548 | 3.NP_SO-102 | Osamocené | 300 | Fáze 1 | MT00.05.0338 | 0338 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004552 | 3.NP_SO-102 | 1004552 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0339 | 0339 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004555 | 3.NP_SO-102 | 1004555 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0340 | 0340 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004558 | 3.NP_SO-102 | 1004558 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0341 | 0341 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004571 | 3.NP_SO-102 | 1004571 | 3.NP_SO-102 | Osamocené | 300 | Fáze 2 | MT00.05.0342 | 0342 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004575 | 3.NP_SO-102 | 1004575 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 2 | MT00.05.0343 | 0343 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004578 | 3.NP_SO-102 | 1004578 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 2 | MT00.05.0344 | 0344 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004581 | 3.NP_SO-102 | 1004581 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 2 | MT00.05.0345 | 0345 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004596 | 3.NP_SO-102 | 1004596 | 3.NP_SO-102 | Osamocené | 300 | Fáze 2 | MT00.05.0346 | 0346 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004600 | 3.NP_SO-102 | 1004600 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 2 | MT00.05.0347 | 0347 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004603 | 3.NP_SO-102 | 1004603 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 2 | MT00.05.0348 | 0348 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1004606 | 3.NP_SO-102 | 1004606 | 3.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 2 | MT00.05.0349 | 0349 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1007344 | 4.NP_SO-102 | 1007344 | 4.NP_SO-102 | Osamocené | 300 | Fáze 1 | MT00.05.0355 | 0355 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1007376 | 4.NP_SO-102 | 1007376 | 4.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0356 | 0356 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1007385 | 4.NP_SO-102 | 1007385 | 4.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0357 | 0357 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1007393 | 4.NP_SO-102 | 1007393 | 4.NP_SO-102 | Osamocené | 300 | Fáze 1 | MT00.05.0358 | 0358 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1007397 | 4.NP_SO-102 | 1007397 | 4.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0359 | 0359 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1007400 | 4.NP_SO-102 | 1007400 | 4.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0360 | 0360 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1007415 | 4.NP_SO-102 | 1007415 | 4.NP_SO-102 | Osamocené | 300 | Fáze 1 | MT00.05.0361 | 0361 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1007419 | 4.NP_SO-102 | 1007419 | 4.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0362 | 0362 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1007422 | 4.NP_SO-102 | 1007422 | 4.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0363 | 0363 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1007433 | 4.NP_SO-102 | 1007433 | 4.NP_SO-102 | Osamocené | 300 | Fáze 1 | MT00.05.0364 | 0364 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1007437 | 4.NP_SO-102 | 1007437 | 4.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0365 | 0365 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1007440 | 4.NP_SO-102 | 1007440 | 4.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 1 | MT00.05.0366 | 0366 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1007449 | 4.NP_SO-102 | 1007449 | 4.NP_SO-102 | Osamocené | 300 | Fáze 2 | MT00.05.0367 | 0367 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1007453 | 4.NP_SO-102 | 1007453 | 4.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 2 | MT00.05.0368 | 0368 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1007456 | 4.NP_SO-102 | 1007456 | 4.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 2 | MT00.05.0369 | 0369 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18
1007465 | 4.NP_SO-102 | 1007465 | 4.NP_SO-102 | Osamocené | 300 | Fáze 2 | MT00.05.0370 | 0370 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1007487 | 4.NP_SO-102 | 1007487 | 4.NP_SO-102 | <nepřiřazeno> | 300 | Fáze 2 | MT00.05.0371 | 0371 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:18

# IfcBuildingElementProxy: Vícerámečky, vodovné.CC:Vícerámečky - 4x (53)
Type - Material: Bílá
Type - Vazby - Výchozí výška: 1050 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Kóty - Hloubka: 5 mm; Osová vzdálenost: 71 mm; ŠÍŘKA: 80 mm; Šířka_in: 45 mm; VÝŠKA: 80 mm; Výška_in: 45 mm
Type - Identifikační data - Číslo OmniClass: 23.80.70.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: MT00; Komentáře k typům: Rámečky vícenásobné; Nadpis OmniClass: Lighting; Název typu: Vícerámečky - 4x; Označení typu: 07; Popis: Rámeček; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Elektrická tělesa; P6: 0 mm; P5: 0 mm; Název rodiny: Vícerámečky, vodovné.CC; P: 4; P2: 71 mm; P3: 142 mm; P4: 213 mm; ST: 106.5 mm
Classification: MT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.03801 m2; NetVolume: 0.0000767 m3
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.0000767 m3
Jiné - Rodina: Vícerámečky, vodovné.CC; Id typu: 361876; Rodina a typ: Vícerámečky, vodovné.CC: Vícerámečky - 4x; S: 293 mm; Typ: Vícerámečky - 4x; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
Name (Vícerámečky, vodovné.CC:Vícerámečky - 4x:...) | In | ID_import | Podlaží = Vztažné podlaží | Hostitel | Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení
946938 | 2.NP_SO-102 | 946938 | 2.NP_SO-102 | Osamocené | 2556.94 | Fáze 2 | MT00.07.0064 | 0064
946972 | 2.NP_SO-102 | 946972 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2556.94 | Fáze 2 | MT00.07.0065 | 0065
946989 | 2.NP_SO-102 | 946989 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2556.94 | Fáze 2 | MT00.07.0066 | 0066
947034 | 2.NP_SO-102 | 947034 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2556.94 | Fáze 1 | MT00.07.0067 | 0067
947087 | 2.NP_SO-102 | 947087 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2556.94 | Fáze 1 | MT00.07.0068 | 0068
947146 | 2.NP_SO-102 | 947146 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2556.94 | Fáze 1 | MT00.07.0069 | 0069
947238 | 2.NP_SO-102 | 947238 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2556.94 | Fáze 1 | MT00.07.0070 | 0070
947293 | 2.NP_SO-102 | 947293 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2556.94 | Fáze 1 | MT00.07.0071 | 0071
947371 | 2.NP_SO-102 | 947371 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2556.94 | Fáze 1 | MT00.07.0072 | 0072
947473 | 2.NP_SO-102 | 947473 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2556.94 | Fáze 1 | MT00.07.0073 | 0073
947681 | 2.NP_SO-102 | 947681 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2556.94 | Fáze 2 | MT00.07.0074 | 0074
947895 | 2.NP_SO-102 | 947895 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2556.94 | Fáze 2 | MT00.07.0075 | 0075
947966 | 2.NP_SO-102 | 947966 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2556.94 | Fáze 2 | MT00.07.0076 | 0076
952579 | 2.NP_SO-102 | 952579 | 2.NP_SO-102 | Osamocené | 1106.94 | Fáze 2 | MT00.07.0077 | 0077
952689 | 2.NP_SO-102 | 952689 | 2.NP_SO-102 | Osamocené | 1106.94 | Fáze 2 | MT00.07.0078 | 0078
952702 | 2.NP_SO-102 | 952702 | 2.NP_SO-102 | Osamocené | 1106.94 | Fáze 2 | MT00.07.0079 | 0079
952712 | 2.NP_SO-102 | 952712 | 2.NP_SO-102 | Osamocené | 1106.94 | Fáze 2 | MT00.07.0080 | 0080
952724 | 2.NP_SO-102 | 952724 | 2.NP_SO-102 | Osamocené | 1106.94 | Fáze 2 | MT00.07.0081 | 0081
952736 | 2.NP_SO-102 | 952736 | 2.NP_SO-102 | Osamocené | 1106.94 | Fáze 2 | MT00.07.0082 | 0082
952752 | 2.NP_SO-102 | 952752 | 2.NP_SO-102 | Osamocené | 1106.94 | Fáze 2 | MT00.07.0083 | 0083
952810 | 2.NP_SO-102 | 952810 | 2.NP_SO-102 | Osamocené | 1106.94 | Fáze 1 | MT00.07.0084 | 0084
953155 | 2.NP_SO-102 | 953155 | 2.NP_SO-102 | Osamocené | 1106.94 | Fáze 2 | MT00.07.0087 | 0087
953172 | 2.NP_SO-102 | 953172 | 2.NP_SO-102 | Osamocené | 1106.94 | Fáze 2 | MT00.07.0088 | 0088
953183 | 2.NP_SO-102 | 953183 | 2.NP_SO-102 | Osamocené | 1106.94 | Fáze 2 | MT00.07.0089 | 0089
953194 | 2.NP_SO-102 | 953194 | 2.NP_SO-102 | Osamocené | 1106.94 | Fáze 2 | MT00.07.0090 | 0090
953395 | 2.NP_SO-102 | 953395 | 2.NP_SO-102 | Osamocené | 1106.94 | Fáze 2 | MT00.07.0091 | 0091
953408 | 2.NP_SO-102 | 953408 | 2.NP_SO-102 | Osamocené | 1106.94 | Fáze 2 | MT00.07.0092 | 0092
953419 | 2.NP_SO-102 | 953419 | 2.NP_SO-102 | Osamocené | 1106.94 | Fáze 2 | MT00.07.0093 | 0093
953430 | 2.NP_SO-102 | 953430 | 2.NP_SO-102 | Osamocené | 1106.94 | Fáze 2 | MT00.07.0094 | 0094
953690 | 2.NP_SO-102 | 953690 | 2.NP_SO-102 | Osamocené | 1106.94 | Fáze 1 | MT00.07.0095 | 0095
953705 | 2.NP_SO-102 | 953705 | 2.NP_SO-102 | Osamocené | 1106.94 | Fáze 1 | MT00.07.0096 | 0096
953716 | 2.NP_SO-102 | 953716 | 2.NP_SO-102 | Osamocené | 1106.94 | Fáze 1 | MT00.07.0097 | 0097
953727 | 2.NP_SO-102 | 953727 | 2.NP_SO-102 | Osamocené | 1106.94 | Fáze 1 | MT00.07.0098 | 0098
1003141 | 3.NP_SO-102 | 1003141 | 3.NP_SO-102 | Osamocené | 2556.94 | Fáze 1 | MT00.07.0254 | 0254
1003224 | 3.NP_SO-102 | 1003224 | 3.NP_SO-102 | Osamocené | 2556.94 | Fáze 1 | MT00.07.0255 | 0255
1003243 | 3.NP_SO-102 | 1003243 | 3.NP_SO-102 | Osamocené | 2556.94 | Fáze 2 | MT00.07.0256 | 0256
1003262 | 3.NP_SO-102 | 1003262 | 3.NP_SO-102 | Osamocené | 2556.94 | Fáze 2 | MT00.07.0257 | 0257
1003316 | 3.NP_SO-102 | 1003316 | 3.NP_SO-102 | Osamocené | 2556.94 | Fáze 1 | MT00.07.0258 | 0258
1003346 | 3.NP_SO-102 | 1003346 | 3.NP_SO-102 | Osamocené | 2556.94 | Fáze 1 | MT00.07.0259 | 0259
1003364 | 3.NP_SO-102 | 1003364 | 3.NP_SO-102 | Osamocené | 2556.94 | Fáze 1 | MT00.07.0260 | 0260
1003382 | 3.NP_SO-102 | 1003382 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2556.94 | Fáze 1 | MT00.07.0261 | 0261
1003396 | 3.NP_SO-102 | 1003396 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2556.94 | Fáze 1 | MT00.07.0262 | 0262
1003413 | 3.NP_SO-102 | 1003413 | 3.NP_SO-102 | Osamocené | 2556.94 | Fáze 1 | MT00.07.0263 | 0263
1003427 | 3.NP_SO-102 | 1003427 | 3.NP_SO-102 | Osamocené | 2556.94 | Fáze 2 | MT00.07.0264 | 0264
1003441 | 3.NP_SO-102 | 1003441 | 3.NP_SO-102 | Osamocené | 2556.94 | Fáze 2 | MT00.07.0265 | 0265
1003455 | 3.NP_SO-102 | 1003455 | 3.NP_SO-102 | Osamocené | 2556.94 | Fáze 2 | MT00.07.0266 | 0266
1003853 | 4.NP_SO-102 | 1003853 | 4.NP_SO-102 | Osamocené | 2556.94 | Fáze 1 | MT00.07.0270 | 0270
1003916 | 4.NP_SO-102 | 1003916 | 4.NP_SO-102 | Osamocené | 2556.94 | Fáze 1 | MT00.07.0271 | 0271
1003937 | 4.NP_SO-102 | 1003937 | 4.NP_SO-102 | Osamocené | 2556.94 | Fáze 1 | MT00.07.0272 | 0272
1003952 | 4.NP_SO-102 | 1003952 | 4.NP_SO-102 | Osamocené | 2556.94 | Fáze 1 | MT00.07.0273 | 0273
1003965 | 4.NP_SO-102 | 1003965 | 4.NP_SO-102 | Osamocené | 2556.94 | Fáze 2 | MT00.07.0274 | 0274
1003980 | 4.NP_SO-102 | 1003980 | 4.NP_SO-102 | Osamocené | 2556.94 | Fáze 2 | MT00.07.0275 | 0275
1070550 | 3.NP_SO-102 | 1070550 | 3.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2556.94 | Fáze 1 | MT00.07.0390 | 0390

# IfcBuildingElementProxy: Vícerámečky, vodovné.CC:Vícerámečky - 5x (9)
In: 2.NP_SO-102
Type - Material: Bílá
Type - Vazby - Výchozí výška: 1050 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Kóty - Hloubka: 5 mm; Osová vzdálenost: 71 mm; ŠÍŘKA: 80 mm; Šířka_in: 45 mm; VÝŠKA: 80 mm; Výška_in: 45 mm
Type - Identifikační data - Číslo OmniClass: 23.80.70.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: MT00; Komentáře k typům: Rámečky vícenásobné; Nadpis OmniClass: Lighting; Název typu: Vícerámečky - 5x; Označení typu: 03; Popis: Rámeček; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Elektrická tělesa; Název rodiny: Vícerámečky, vodovné.CC; P: 5; P2: 71 mm; P3: 142 mm; P4: 213 mm; P5: 284 mm; P6: 0 mm; ST: 142 mm
Classification: MT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.04693 m2; NetVolume: 0.000094975 m3
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Vazby - Podlaží: 2.NP_SO-102; Vztažné podlaží: 2.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
