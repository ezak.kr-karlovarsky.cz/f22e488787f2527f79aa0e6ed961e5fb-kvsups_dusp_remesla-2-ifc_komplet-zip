Properties of the parts of a building model (IFC4), part 8 of 9

# IfcElectricAppliance: Datová zásuvka do PK.CC:Jednozásuvka 1x modul (469)
Name (Datová zásuvka do PK.CC:Jednozásuvka 1x modul:...) | In | ID_import | Podlaží = Vztažné podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
1001497 | 4.NP_SO-102 | 1001497 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0515 | 0515
1001498 | 4.NP_SO-102 | 1001498 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0516 | 0516
1001506 | 4.NP_SO-102 | 1001506 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0517 | 0517
1001507 | 4.NP_SO-102 | 1001507 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0518 | 0518
1001508 | 4.NP_SO-102 | 1001508 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0519 | 0519
1001509 | 4.NP_SO-102 | 1001509 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0520 | 0520
1001512 | 4.NP_SO-102 | 1001512 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0521 | 0521
1001513 | 4.NP_SO-102 | 1001513 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0522 | 0522
1001521 | 4.NP_SO-102 | 1001521 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0523 | 0523
1001522 | 4.NP_SO-102 | 1001522 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0524 | 0524
1001523 | 4.NP_SO-102 | 1001523 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0525 | 0525
1001524 | 4.NP_SO-102 | 1001524 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0526 | 0526
1001580 | 4.NP_SO-102 | 1001580 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0527 | 0527
1001581 | 4.NP_SO-102 | 1001581 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0528 | 0528
1001583 | 4.NP_SO-102 | 1001583 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0529 | 0529
1001584 | 4.NP_SO-102 | 1001584 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0530 | 0530
1001601 | 4.NP_SO-102 | 1001601 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0531 | 0531
1001602 | 4.NP_SO-102 | 1001602 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0532 | 0532
1001604 | 4.NP_SO-102 | 1001604 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0533 | 0533
1001605 | 4.NP_SO-102 | 1001605 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0534 | 0534
1001622 | 4.NP_SO-102 | 1001622 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0535 | 0535
1001623 | 4.NP_SO-102 | 1001623 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0536 | 0536
1001625 | 4.NP_SO-102 | 1001625 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0537 | 0537
1001626 | 4.NP_SO-102 | 1001626 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0538 | 0538
1001643 | 4.NP_SO-102 | 1001643 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0539 | 0539
1001644 | 4.NP_SO-102 | 1001644 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0540 | 0540
1001646 | 4.NP_SO-102 | 1001646 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0541 | 0541
1001647 | 4.NP_SO-102 | 1001647 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0542 | 0542
1001664 | 4.NP_SO-102 | 1001664 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0543 | 0543
1001665 | 4.NP_SO-102 | 1001665 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0544 | 0544
1001667 | 4.NP_SO-102 | 1001667 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0545 | 0545
1001668 | 4.NP_SO-102 | 1001668 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0546 | 0546
1001685 | 4.NP_SO-102 | 1001685 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0547 | 0547
1001686 | 4.NP_SO-102 | 1001686 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0548 | 0548
1001688 | 4.NP_SO-102 | 1001688 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0549 | 0549
1001689 | 4.NP_SO-102 | 1001689 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0550 | 0550
1001706 | 4.NP_SO-102 | 1001706 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0551 | 0551
1001707 | 4.NP_SO-102 | 1001707 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0552 | 0552
1001709 | 4.NP_SO-102 | 1001709 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0553 | 0553
1001710 | 4.NP_SO-102 | 1001710 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0554 | 0554
1001731 | 4.NP_SO-102 | 1001731 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0555 | 0555
1001732 | 4.NP_SO-102 | 1001732 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0556 | 0556
1001734 | 4.NP_SO-102 | 1001734 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0557 | 0557
1001735 | 4.NP_SO-102 | 1001735 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0558 | 0558
1001752 | 4.NP_SO-102 | 1001752 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0559 | 0559
1001753 | 4.NP_SO-102 | 1001753 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0560 | 0560
1001755 | 4.NP_SO-102 | 1001755 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0561 | 0561
1001756 | 4.NP_SO-102 | 1001756 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0562 | 0562
1001775 | 4.NP_SO-102 | 1001775 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0563 | 0563
1001776 | 4.NP_SO-102 | 1001776 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0564 | 0564
1001778 | 4.NP_SO-102 | 1001778 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0565 | 0565
1001779 | 4.NP_SO-102 | 1001779 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0566 | 0566
1001796 | 4.NP_SO-102 | 1001796 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0567 | 0567
1001797 | 4.NP_SO-102 | 1001797 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0568 | 0568
1001799 | 4.NP_SO-102 | 1001799 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0569 | 0569
1001800 | 4.NP_SO-102 | 1001800 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0570 | 0570
1001821 | 4.NP_SO-102 | 1001821 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0571 | 0571
1001822 | 4.NP_SO-102 | 1001822 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0572 | 0572
1001824 | 4.NP_SO-102 | 1001824 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0573 | 0573
1001825 | 4.NP_SO-102 | 1001825 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0574 | 0574
1001846 | 4.NP_SO-102 | 1001846 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0575 | 0575
1001847 | 4.NP_SO-102 | 1001847 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0576 | 0576
1001849 | 4.NP_SO-102 | 1001849 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0577 | 0577
1001850 | 4.NP_SO-102 | 1001850 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0578 | 0578
1001869 | 4.NP_SO-102 | 1001869 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0579 | 0579
1001870 | 4.NP_SO-102 | 1001870 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0580 | 0580
1001872 | 4.NP_SO-102 | 1001872 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0581 | 0581
1001873 | 4.NP_SO-102 | 1001873 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0582 | 0582
1001892 | 4.NP_SO-102 | 1001892 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0583 | 0583
1001893 | 4.NP_SO-102 | 1001893 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0584 | 0584
1001895 | 4.NP_SO-102 | 1001895 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0585 | 0585
1001896 | 4.NP_SO-102 | 1001896 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0586 | 0586
1001913 | 4.NP_SO-102 | 1001913 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0587 | 0587
1001914 | 4.NP_SO-102 | 1001914 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0588 | 0588
1001916 | 4.NP_SO-102 | 1001916 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0589 | 0589
1001917 | 4.NP_SO-102 | 1001917 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0590 | 0590
1001948 | 4.NP_SO-102 | 1001948 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0591 | 0591
1001949 | 4.NP_SO-102 | 1001949 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0592 | 0592
1001951 | 4.NP_SO-102 | 1001951 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0593 | 0593
1001952 | 4.NP_SO-102 | 1001952 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0594 | 0594
1001982 | 4.NP_SO-102 | 1001982 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0595 | 0595
1001983 | 4.NP_SO-102 | 1001983 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0596 | 0596
1001985 | 4.NP_SO-102 | 1001985 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0597 | 0597
1001986 | 4.NP_SO-102 | 1001986 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZZ03.03.0598 | 0598
1002003 | 4.NP_SO-102 | 1002003 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0599 | 0599
1002004 | 4.NP_SO-102 | 1002004 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0600 | 0600
1002006 | 4.NP_SO-102 | 1002006 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0601 | 0601
1002007 | 4.NP_SO-102 | 1002007 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0602 | 0602
1002024 | 4.NP_SO-102 | 1002024 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0603 | 0603
1002025 | 4.NP_SO-102 | 1002025 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0604 | 0604
1002027 | 4.NP_SO-102 | 1002027 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0605 | 0605
1002028 | 4.NP_SO-102 | 1002028 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0606 | 0606
1002045 | 4.NP_SO-102 | 1002045 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0607 | 0607
1002046 | 4.NP_SO-102 | 1002046 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0608 | 0608
1002048 | 4.NP_SO-102 | 1002048 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0609 | 0609
1002049 | 4.NP_SO-102 | 1002049 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0610 | 0610
1002066 | 4.NP_SO-102 | 1002066 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0611 | 0611
1002067 | 4.NP_SO-102 | 1002067 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0612 | 0612
1002069 | 4.NP_SO-102 | 1002069 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0613 | 0613
1002070 | 4.NP_SO-102 | 1002070 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZZ03.03.0614 | 0614
1002278 | 3.NP_SO-102 | 1002278 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0615 | 0615
1002279 | 3.NP_SO-102 | 1002279 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0616 | 0616
1002311 | 3.NP_SO-102 | 1002311 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0617 | 0617
1002312 | 3.NP_SO-102 | 1002312 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0618 | 0618
1002328 | 3.NP_SO-102 | 1002328 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0619 | 0619
1002329 | 3.NP_SO-102 | 1002329 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0620 | 0620
1002344 | 3.NP_SO-102 | 1002344 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0621 | 0621
1002345 | 3.NP_SO-102 | 1002345 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0622 | 0622
1002366 | 3.NP_SO-102 | 1002366 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0623 | 0623
1002367 | 3.NP_SO-102 | 1002367 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0624 | 0624
1002382 | 3.NP_SO-102 | 1002382 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0625 | 0625
1002383 | 3.NP_SO-102 | 1002383 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0626 | 0626
1002398 | 3.NP_SO-102 | 1002398 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0627 | 0627
1002399 | 3.NP_SO-102 | 1002399 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0628 | 0628
1002414 | 3.NP_SO-102 | 1002414 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0629 | 0629
1002415 | 3.NP_SO-102 | 1002415 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0630 | 0630
1002430 | 3.NP_SO-102 | 1002430 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0631 | 0631
1002431 | 3.NP_SO-102 | 1002431 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0632 | 0632
1002446 | 3.NP_SO-102 | 1002446 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0633 | 0633
1002447 | 3.NP_SO-102 | 1002447 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0634 | 0634
1002462 | 3.NP_SO-102 | 1002462 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0635 | 0635
1002463 | 3.NP_SO-102 | 1002463 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0636 | 0636
1002478 | 3.NP_SO-102 | 1002478 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0637 | 0637
1002479 | 3.NP_SO-102 | 1002479 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0638 | 0638
1002496 | 3.NP_SO-102 | 1002496 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0639 | 0639
1002497 | 3.NP_SO-102 | 1002497 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0640 | 0640
1002512 | 3.NP_SO-102 | 1002512 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0641 | 0641
1002513 | 3.NP_SO-102 | 1002513 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0642 | 0642
1002528 | 3.NP_SO-102 | 1002528 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0643 | 0643
1002529 | 3.NP_SO-102 | 1002529 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0644 | 0644
1002544 | 3.NP_SO-102 | 1002544 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0645 | 0645
1002545 | 3.NP_SO-102 | 1002545 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0646 | 0646
1002560 | 3.NP_SO-102 | 1002560 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0647 | 0647
1002561 | 3.NP_SO-102 | 1002561 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0648 | 0648
1002576 | 3.NP_SO-102 | 1002576 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0649 | 0649
1002577 | 3.NP_SO-102 | 1002577 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0650 | 0650
1002592 | 3.NP_SO-102 | 1002592 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0651 | 0651
1002593 | 3.NP_SO-102 | 1002593 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0652 | 0652
1002608 | 3.NP_SO-102 | 1002608 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0653 | 0653
1002609 | 3.NP_SO-102 | 1002609 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0654 | 0654
1002624 | 3.NP_SO-102 | 1002624 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0655 | 0655
1002625 | 3.NP_SO-102 | 1002625 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0656 | 0656
1002640 | 3.NP_SO-102 | 1002640 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0657 | 0657
1002641 | 3.NP_SO-102 | 1002641 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0658 | 0658
1002658 | 3.NP_SO-102 | 1002658 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0659 | 0659
1002659 | 3.NP_SO-102 | 1002659 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0660 | 0660
1002674 | 3.NP_SO-102 | 1002674 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0661 | 0661
1002675 | 3.NP_SO-102 | 1002675 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0662 | 0662
1002690 | 3.NP_SO-102 | 1002690 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0663 | 0663
1002691 | 3.NP_SO-102 | 1002691 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0664 | 0664
1002708 | 3.NP_SO-102 | 1002708 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0665 | 0665
1002709 | 3.NP_SO-102 | 1002709 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0666 | 0666
1002724 | 3.NP_SO-102 | 1002724 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0667 | 0667
1002725 | 3.NP_SO-102 | 1002725 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0668 | 0668
1002740 | 3.NP_SO-102 | 1002740 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0669 | 0669
1002741 | 3.NP_SO-102 | 1002741 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0670 | 0670
1002756 | 3.NP_SO-102 | 1002756 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0671 | 0671
1002757 | 3.NP_SO-102 | 1002757 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0672 | 0672
1002774 | 3.NP_SO-102 | 1002774 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0673 | 0673
1002775 | 3.NP_SO-102 | 1002775 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0674 | 0674
1002790 | 3.NP_SO-102 | 1002790 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0675 | 0675
1002791 | 3.NP_SO-102 | 1002791 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0676 | 0676
1002808 | 3.NP_SO-102 | 1002808 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0677 | 0677
1002809 | 3.NP_SO-102 | 1002809 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0678 | 0678
1002824 | 3.NP_SO-102 | 1002824 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0679 | 0679
1002825 | 3.NP_SO-102 | 1002825 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0680 | 0680
1002840 | 3.NP_SO-102 | 1002840 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0681 | 0681
1002841 | 3.NP_SO-102 | 1002841 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0682 | 0682
1002856 | 3.NP_SO-102 | 1002856 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0683 | 0683
1002857 | 3.NP_SO-102 | 1002857 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0684 | 0684
1002876 | 3.NP_SO-102 | 1002876 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0685 | 0685
1002877 | 3.NP_SO-102 | 1002877 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0686 | 0686
1002892 | 3.NP_SO-102 | 1002892 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0687 | 0687
1002893 | 3.NP_SO-102 | 1002893 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0688 | 0688
1002908 | 3.NP_SO-102 | 1002908 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0689 | 0689
1002909 | 3.NP_SO-102 | 1002909 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0690 | 0690
1002940 | 3.NP_SO-102 | 1002940 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0691 | 0691
1002941 | 3.NP_SO-102 | 1002941 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0692 | 0692
1002962 | 3.NP_SO-102 | 1002962 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0694 | 0694
1002963 | 3.NP_SO-102 | 1002963 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0695 | 0695
1004665 | 3.NP_SO-102 | 1004665 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0815 | 0815
1004666 | 3.NP_SO-102 | 1004666 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0816 | 0816
1004837 | 3.NP_SO-102 | 1004837 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0817 | 0817
1004838 | 3.NP_SO-102 | 1004838 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0818 | 0818
1004848 | 3.NP_SO-102 | 1004848 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0819 | 0819
1004849 | 3.NP_SO-102 | 1004849 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0820 | 0820
1066109 | 3.NP_SO-102 | 1066109 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0988 | 0988
1066110 | 3.NP_SO-102 | 1066110 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0989 | 0989
1066183 | 3.NP_SO-102 | 1066183 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0991 | 0991 | Fázování - Fáze demolice: Fáze 1
1066184 | 3.NP_SO-102 | 1066184 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0992 | 0992 | Fázování - Fáze demolice: Fáze 1
1066197 | 3.NP_SO-102 | 1066197 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0994 | 0994 | Fázování - Fáze demolice: Fáze 1
1066198 | 3.NP_SO-102 | 1066198 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0995 | 0995 | Fázování - Fáze demolice: Fáze 1
1066211 | 3.NP_SO-102 | 1066211 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0997 | 0997 | Fázování - Fáze demolice: Fáze 1
1066212 | 3.NP_SO-102 | 1066212 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.0998 | 0998 | Fázování - Fáze demolice: Fáze 1
1066239 | 3.NP_SO-102 | 1066239 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1000 | 1000 | Fázování - Fáze demolice: Fáze 1
1066240 | 3.NP_SO-102 | 1066240 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1001 | 1001 | Fázování - Fáze demolice: Fáze 1
1066253 | 3.NP_SO-102 | 1066253 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1003 | 1003 | Fázování - Fáze demolice: Fáze 1
1066254 | 3.NP_SO-102 | 1066254 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1004 | 1004 | Fázování - Fáze demolice: Fáze 1
1066267 | 3.NP_SO-102 | 1066267 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1006 | 1006 | Fázování - Fáze demolice: Fáze 1
1066268 | 3.NP_SO-102 | 1066268 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1007 | 1007 | Fázování - Fáze demolice: Fáze 1
1066281 | 3.NP_SO-102 | 1066281 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1009 | 1009 | Fázování - Fáze demolice: Fáze 1
1066282 | 3.NP_SO-102 | 1066282 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1010 | 1010 | Fázování - Fáze demolice: Fáze 1
1066295 | 3.NP_SO-102 | 1066295 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1012 | 1012 | Fázování - Fáze demolice: Fáze 1
1066296 | 3.NP_SO-102 | 1066296 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1013 | 1013 | Fázování - Fáze demolice: Fáze 1
1066309 | 3.NP_SO-102 | 1066309 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1015 | 1015 | Fázování - Fáze demolice: Fáze 1
1066310 | 3.NP_SO-102 | 1066310 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1016 | 1016 | Fázování - Fáze demolice: Fáze 1
1066337 | 3.NP_SO-102 | 1066337 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1018 | 1018 | Fázování - Fáze demolice: Fáze 1
1066338 | 3.NP_SO-102 | 1066338 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1019 | 1019 | Fázování - Fáze demolice: Fáze 1
1066351 | 3.NP_SO-102 | 1066351 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1021 | 1021 | Fázování - Fáze demolice: Fáze 1
1066352 | 3.NP_SO-102 | 1066352 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1022 | 1022 | Fázování - Fáze demolice: Fáze 1
1066365 | 3.NP_SO-102 | 1066365 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1024 | 1024 | Fázování - Fáze demolice: Fáze 1
1066366 | 3.NP_SO-102 | 1066366 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1025 | 1025 | Fázování - Fáze demolice: Fáze 1
1070405 | 3.NP_SO-102 | 1070405 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1033 | 1033
1070406 | 3.NP_SO-102 | 1070406 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1034 | 1034
1070597 | 3.NP_SO-102 | 1070597 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1042 | 1042
1070598 | 3.NP_SO-102 | 1070598 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1043 | 1043
1079983 | 3.NP_SO-102 | 1079983 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1045 | 1045
1079984 | 3.NP_SO-102 | 1079984 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1046 | 1046
1080019 | 3.NP_SO-102 | 1080019 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1047 | 1047
1080020 | 3.NP_SO-102 | 1080020 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1048 | 1048
1080030 | 3.NP_SO-102 | 1080030 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1049 | 1049
1080031 | 3.NP_SO-102 | 1080031 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1050 | 1050
1080041 | 3.NP_SO-102 | 1080041 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1051 | 1051
1080042 | 3.NP_SO-102 | 1080042 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1052 | 1052
1080052 | 3.NP_SO-102 | 1080052 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1053 | 1053
1080053 | 3.NP_SO-102 | 1080053 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1054 | 1054
1080072 | 3.NP_SO-102 | 1080072 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1055 | 1055
1080124 | 3.NP_SO-102 | 1080124 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZZ03.03.1057 | 1057
1080157 | 2.NP_SO-102 | 1080157 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZZ03.03.1059 | 1059
1080278 | 2.NP_SO-102 | 1080278 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.03.1061 | 1061
1080316 | 2.NP_SO-102 | 1080316 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.03.1063 | 1063
1080330 | 2.NP_SO-102 | 1080330 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZZ03.03.1065 | 1065

# IfcElectricAppliance: Datová zásuvka_vícerámečky.CC:Dvojzásuvka (218)
Type - Material: Bílá
Type - Vazby - Výchozí výška: 1050 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Grafika - Dvojzásuvka: yes; Jednozásuvka: no; Šířka: 45 mm; Typ symbolu: Datová dvojzásuvka 2x RJ45.CC
Type - Kóty - Hloubka: 10 mm
Type - Identifikační data - Číslo OmniClass: 23.85.50.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZZ03; Komentáře k typům: druhá klapka; Model: Model; Nadpis OmniClass: Communication and Data Processing Equipment; Název typu: Dvojzásuvka; Označení typu: 06; Popis: Zásuvka; Popis sestavy: Datová; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Datová zařízení; Název rodiny: Datová zásuvka_vícerámečky.CC
Classification: ZZ03 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.00002025 m3
Jiné - Typ: Dvojzásuvka; Id typu: 364876; Rodina: Datová zásuvka_vícerámečky.CC; Rodina a typ: Datová zásuvka_vícerámečky.CC: Dvojzásuvka
Name (Datová zásuvka_vícerámečky.CC:Dvojzásuvka:...) | In | ID_import | Podlaží = Vztažné podlaží | Hostitel | Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení | UPRAVIL
973599 | 2.NP_SO-102 | 973599 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | ZZ03.06.0158 | 0158 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
973944 | 2.NP_SO-102 | 973944 | 2.NP_SO-102 | Osamocené | 1050 | Fáze 1 | ZZ03.06.0159 | 0159 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
973992 | 2.NP_SO-102 | 973992 | 2.NP_SO-102 | Osamocené | 1050 | Fáze 1 | ZZ03.06.0160 | 0160 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
974294 | 2.NP_SO-102 | 974294 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 299.385 | Fáze 1 | ZZ03.06.0204 | 0204 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
974302 | 2.NP_SO-102 | 974302 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0205 | 0205 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
974391 | 2.NP_SO-102 | 974391 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0206 | 0206 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
974433 | 2.NP_SO-102 | 974433 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0207 | 0207 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
974576 | 2.NP_SO-102 | 974576 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0208 | 0208 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
974851 | 2.NP_SO-102 | 974851 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0209 | 0209 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
974928 | 2.NP_SO-102 | 974928 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2556.94 | Fáze 1 | ZZ03.06.0210 | 0210 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
984831 | 2.NP_SO-102 | 984831 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2556.94 | Fáze 1 | ZZ03.06.0225 | 0225 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
984972 | 2.NP_SO-102 | 984972 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 1 | ZZ03.06.0226 | 0226 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
985101 | 2.NP_SO-102 | 985101 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0228 | 0228 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
985109 | 2.NP_SO-102 | 985109 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0229 | 0229 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
985168 | 2.NP_SO-102 | 985168 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0230 | 0230 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
985474 | 2.NP_SO-102 | 985474 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 1 | ZZ03.06.0231 | 0231 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
985483 | 2.NP_SO-102 | 985483 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 1 | ZZ03.06.0232 | 0232 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
985609 | 2.NP_SO-102 | 985609 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 1 | ZZ03.06.0233 | 0233 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
985691 | 2.NP_SO-102 | 985691 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557.01 | Fáze 1 | ZZ03.06.0234 | 0234 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
985886 | 2.NP_SO-102 | 985886 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 2 | ZZ03.06.0235 | 0235 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
985897 | 2.NP_SO-102 | 985897 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 2 | ZZ03.06.0236 | 0236 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
986002 | 2.NP_SO-102 | 986002 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 2 | ZZ03.06.0237 | 0237 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
986190 | 2.NP_SO-102 | 986190 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 2 | ZZ03.06.0238 | 0238 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
986434 | 2.NP_SO-102 | 986434 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 2 | ZZ03.06.0239 | 0239 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
986533 | 2.NP_SO-102 | 986533 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 2 | ZZ03.06.0240 | 0240 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
986638 | 2.NP_SO-102 | 986638 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 1 | ZZ03.06.0241 | 0241 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
986942 | 2.NP_SO-102 | 986942 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0242 | 0242 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
987217 | 2.NP_SO-102 | 987217 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 300 | Fáze 2 | ZZ03.06.0243 | 0243 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
987282 | 2.NP_SO-102 | 987282 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0244 | 0244 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
987405 | 2.NP_SO-102 | 987405 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0245 | 0245 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
987545 | 2.NP_SO-102 | 987545 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 1106.94 | Fáze 2 | ZZ03.06.0246 | 0246 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
987939 | 2.NP_SO-102 | 987939 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0247 | 0247 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
987998 | 2.NP_SO-102 | 987998 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0248 | 0248 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
988183 | 2.NP_SO-102 | 988183 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0249 | 0249 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
988206 | 2.NP_SO-102 | 988206 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0250 | 0250 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
988373 | 2.NP_SO-102 | 988373 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0251 | 0251 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
988393 | 2.NP_SO-102 | 988393 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0252 | 0252 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
988592 | 2.NP_SO-102 | 988592 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0253 | 0253 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
988626 | 2.NP_SO-102 | 988626 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0254 | 0254 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
988824 | 2.NP_SO-102 | 988824 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0255 | 0255 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
988911 | 2.NP_SO-102 | 988911 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0256 | 0256 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
991622 | 2.NP_SO-102 | 991622 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1107.5 | Fáze 1 | ZZ03.06.0268 | 0268 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
991632 | 2.NP_SO-102 | 991632 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1107.5 | Fáze 1 | ZZ03.06.0269 | 0269 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
991648 | 2.NP_SO-102 | 991648 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 1 | ZZ03.06.0270 | 0270 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
991661 | 2.NP_SO-102 | 991661 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 1 | ZZ03.06.0271 | 0271 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
991850 | 2.NP_SO-102 | 991850 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1050 | Fáze 1 | ZZ03.06.0272 | 0272 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
991863 | 2.NP_SO-102 | 991863 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1050 | Fáze 1 | ZZ03.06.0273 | 0273 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
991879 | 2.NP_SO-102 | 991879 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1050 | Fáze 1 | ZZ03.06.0274 | 0274 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
991889 | 2.NP_SO-102 | 991889 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1050 | Fáze 1 | ZZ03.06.0275 | 0275 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
991917 | 2.NP_SO-102 | 991917 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 1 | ZZ03.06.0276 | 0276 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
991929 | 2.NP_SO-102 | 991929 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 1 | ZZ03.06.0277 | 0277 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
991981 | 2.NP_SO-102 | 991981 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 1 | ZZ03.06.0278 | 0278 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
991991 | 2.NP_SO-102 | 991991 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 1 | ZZ03.06.0279 | 0279 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
992001 | 2.NP_SO-102 | 992001 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 1 | ZZ03.06.0280 | 0280 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
992088 | 2.NP_SO-102 | 992088 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 2 | ZZ03.06.0281 | 0281 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
992161 | 2.NP_SO-102 | 992161 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 2 | ZZ03.06.0282 | 0282 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
992171 | 2.NP_SO-102 | 992171 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 2 | ZZ03.06.0283 | 0283 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
992181 | 2.NP_SO-102 | 992181 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 2 | ZZ03.06.0284 | 0284 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
992191 | 2.NP_SO-102 | 992191 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 2 | ZZ03.06.0285 | 0285 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
992227 | 2.NP_SO-102 | 992227 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 2 | ZZ03.06.0286 | 0286 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
992247 | 2.NP_SO-102 | 992247 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 2 | ZZ03.06.0287 | 0287 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
992257 | 2.NP_SO-102 | 992257 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 2 | ZZ03.06.0288 | 0288 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
992267 | 2.NP_SO-102 | 992267 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 2 | ZZ03.06.0289 | 0289 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
992364 | 2.NP_SO-102 | 992364 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 2 | ZZ03.06.0290 | 0290 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
992390 | 2.NP_SO-102 | 992390 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 2 | ZZ03.06.0291 | 0291 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
992406 | 2.NP_SO-102 | 992406 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 2 | ZZ03.06.0292 | 0292 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
992422 | 2.NP_SO-102 | 992422 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 2 | ZZ03.06.0293 | 0293 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
992438 | 2.NP_SO-102 | 992438 | 2.NP_SO-102 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | Fáze 2 | ZZ03.06.0294 | 0294 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
992972 | 2.NP_SO-102 | 992972 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0335 | 0335 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1003146 | 3.NP_SO-102 | 1003146 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 1 | ZZ03.06.0701 | 0701 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1003229 | 3.NP_SO-102 | 1003229 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 1 | ZZ03.06.0703 | 0703 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1003248 | 3.NP_SO-102 | 1003248 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 2 | ZZ03.06.0705 | 0705 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1003267 | 3.NP_SO-102 | 1003267 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 2 | ZZ03.06.0707 | 0707 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1003321 | 3.NP_SO-102 | 1003321 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 1 | ZZ03.06.0709 | 0709 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1003351 | 3.NP_SO-102 | 1003351 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 1 | ZZ03.06.0711 | 0711 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1003369 | 3.NP_SO-102 | 1003369 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 1 | ZZ03.06.0713 | 0713 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1003387 | 3.NP_SO-102 | 1003387 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 1 | ZZ03.06.0715 | 0715 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1003401 | 3.NP_SO-102 | 1003401 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 1 | ZZ03.06.0717 | 0717 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1003418 | 3.NP_SO-102 | 1003418 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 1 | ZZ03.06.0719 | 0719 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1003432 | 3.NP_SO-102 | 1003432 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 2 | ZZ03.06.0721 | 0721 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1003446 | 3.NP_SO-102 | 1003446 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 2 | ZZ03.06.0723 | 0723 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1003460 | 3.NP_SO-102 | 1003460 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 2 | ZZ03.06.0725 | 0725 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1003473 | 3.NP_SO-102 | 1003473 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0727 | 0727 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1003484 | 3.NP_SO-102 | 1003484 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0728 | 0728 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1003602 | 4.NP_SO-102 | 1003602 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0729 | 0729 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1003858 | 4.NP_SO-102 | 1003858 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 1 | ZZ03.06.0730 | 0730 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1003921 | 4.NP_SO-102 | 1003921 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 1 | ZZ03.06.0732 | 0732 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1003942 | 4.NP_SO-102 | 1003942 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 1 | ZZ03.06.0734 | 0734 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1003957 | 4.NP_SO-102 | 1003957 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 1 | ZZ03.06.0736 | 0736 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1003970 | 4.NP_SO-102 | 1003970 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 2 | ZZ03.06.0738 | 0738 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1003985 | 4.NP_SO-102 | 1003985 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 4x | 2557 | Fáze 2 | ZZ03.06.0740 | 0740 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004003 | 4.NP_SO-102 | 1004003 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0742 | 0742 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004017 | 4.NP_SO-102 | 1004017 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0743 | 0743 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004031 | 4.NP_SO-102 | 1004031 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0744 | 0744 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004043 | 4.NP_SO-102 | 1004043 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0745 | 0745 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004055 | 4.NP_SO-102 | 1004055 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0746 | 0746 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004067 | 3.NP_SO-102 | 1004067 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0747 | 0747 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004088 | 3.NP_SO-102 | 1004088 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0748 | 0748 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004102 | 3.NP_SO-102 | 1004102 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0749 | 0749 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004114 | 3.NP_SO-102 | 1004114 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0750 | 0750 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004126 | 3.NP_SO-102 | 1004126 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0751 | 0751 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004138 | 3.NP_SO-102 | 1004138 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0752 | 0752 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004150 | 3.NP_SO-102 | 1004150 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0753 | 0753 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004162 | 3.NP_SO-102 | 1004162 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0754 | 0754 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004186 | 3.NP_SO-102 | 1004186 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0755 | 0755 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004200 | 3.NP_SO-102 | 1004200 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0756 | 0756 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004210 | 3.NP_SO-102 | 1004210 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0757 | 0757 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004243 | 2.NP_SO-102 | 1004243 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0758 | 0758 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004247 | 2.NP_SO-102 | 1004247 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0759 | 0759 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004249 | 2.NP_SO-102 | 1004249 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0760 | 0760 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004251 | 2.NP_SO-102 | 1004251 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0761 | 0761 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004253 | 2.NP_SO-102 | 1004253 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0762 | 0762 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004255 | 2.NP_SO-102 | 1004255 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0763 | 0763 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004277 | 2.NP_SO-102 | 1004277 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0764 | 0764 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004281 | 2.NP_SO-102 | 1004281 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0765 | 0765 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004283 | 2.NP_SO-102 | 1004283 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0766 | 0766 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004285 | 2.NP_SO-102 | 1004285 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0767 | 0767 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004287 | 2.NP_SO-102 | 1004287 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0768 | 0768 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004289 | 2.NP_SO-102 | 1004289 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0769 | 0769 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004297 | 2.NP_SO-102 | 1004297 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0770 | 0770 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004300 | 2.NP_SO-102 | 1004300 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0771 | 0771 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004303 | 2.NP_SO-102 | 1004303 | 2.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0772 | 0772 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004326 | 3.NP_SO-102 | 1004326 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0773 | 0773 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004334 | 3.NP_SO-102 | 1004334 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0774 | 0774 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004342 | 3.NP_SO-102 | 1004342 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0775 | 0775 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004345 | 3.NP_SO-102 | 1004345 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0776 | 0776 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004348 | 3.NP_SO-102 | 1004348 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0777 | 0777 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004362 | 3.NP_SO-102 | 1004362 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0778 | 0778 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004365 | 3.NP_SO-102 | 1004365 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0779 | 0779 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004368 | 3.NP_SO-102 | 1004368 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0780 | 0780 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004382 | 3.NP_SO-102 | 1004382 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0781 | 0781 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004385 | 3.NP_SO-102 | 1004385 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0782 | 0782 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004388 | 3.NP_SO-102 | 1004388 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0783 | 0783 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004400 | 3.NP_SO-102 | 1004400 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0784 | 0784 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004403 | 3.NP_SO-102 | 1004403 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0785 | 0785 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004406 | 3.NP_SO-102 | 1004406 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0786 | 0786 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004416 | 3.NP_SO-102 | 1004416 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0787 | 0787 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004419 | 3.NP_SO-102 | 1004419 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0788 | 0788 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004422 | 3.NP_SO-102 | 1004422 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0789 | 0789 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1004432 | 3.NP_SO-102 | 1004432 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0790 | 0790 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004435 | 3.NP_SO-102 | 1004435 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0791 | 0791 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004438 | 3.NP_SO-102 | 1004438 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0792 | 0792 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004448 | 3.NP_SO-102 | 1004448 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0793 | 0793 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004451 | 3.NP_SO-102 | 1004451 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0794 | 0794 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004454 | 3.NP_SO-102 | 1004454 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0795 | 0795 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004464 | 3.NP_SO-102 | 1004464 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0796 | 0796 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004467 | 3.NP_SO-102 | 1004467 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0797 | 0797 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004470 | 3.NP_SO-102 | 1004470 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0798 | 0798 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004481 | 3.NP_SO-102 | 1004481 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0799 | 0799 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004508 | 3.NP_SO-102 | 1004508 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0800 | 0800 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004520 | 3.NP_SO-102 | 1004520 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0801 | 0801 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004532 | 3.NP_SO-102 | 1004532 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0802 | 0802 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004550 | 3.NP_SO-102 | 1004550 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0803 | 0803 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004553 | 3.NP_SO-102 | 1004553 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0804 | 0804 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004556 | 3.NP_SO-102 | 1004556 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0805 | 0805 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004559 | 3.NP_SO-102 | 1004559 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0806 | 0806 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004573 | 3.NP_SO-102 | 1004573 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0807 | 0807 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004576 | 3.NP_SO-102 | 1004576 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0808 | 0808 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004579 | 3.NP_SO-102 | 1004579 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0809 | 0809 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004582 | 3.NP_SO-102 | 1004582 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0810 | 0810 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004598 | 3.NP_SO-102 | 1004598 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0811 | 0811 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004601 | 3.NP_SO-102 | 1004601 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0812 | 0812 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004604 | 3.NP_SO-102 | 1004604 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0813 | 0813 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1004607 | 3.NP_SO-102 | 1004607 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0814 | 0814 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1005881 | 3.NP_SO-102 | 1005881 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 2x | 950 | Fáze 1 | ZZ03.06.0821 | 0821 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1005887 | 3.NP_SO-102 | 1005887 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 2x | 950 | Fáze 1 | ZZ03.06.0822 | 0822 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1006021 | 3.NP_SO-102 | 1006021 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 2x | 950 | Fáze 1 | ZZ03.06.0823 | 0823 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1006086 | 3.NP_SO-102 | 1006086 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 2x | 950 | Fáze 1 | ZZ03.06.0824 | 0824 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1006149 | 3.NP_SO-102 | 1006149 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 2x | 950 | Fáze 2 | ZZ03.06.0825 | 0825 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1006169 | 3.NP_SO-102 | 1006169 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 2x | 950 | Fáze 2 | ZZ03.06.0826 | 0826 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1006294 | 3.NP_SO-102 | 1006294 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 2x | 950 | Fáze 2 | ZZ03.06.0827 | 0827 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1006419 | 3.NP_SO-102 | 1006419 | 3.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 2x | 950 | Fáze 2 | ZZ03.06.0828 | 0828 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1007346 | 4.NP_SO-102 | 1007346 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0883 | 0883 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1007378 | 4.NP_SO-102 | 1007378 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0884 | 0884 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1007386 | 4.NP_SO-102 | 1007386 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0885 | 0885 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1007395 | 4.NP_SO-102 | 1007395 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0886 | 0886 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1007398 | 4.NP_SO-102 | 1007398 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0887 | 0887 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1007401 | 4.NP_SO-102 | 1007401 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0888 | 0888 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1007417 | 4.NP_SO-102 | 1007417 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0889 | 0889 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1007420 | 4.NP_SO-102 | 1007420 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0890 | 0890 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1007423 | 4.NP_SO-102 | 1007423 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0891 | 0891 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1007435 | 4.NP_SO-102 | 1007435 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0892 | 0892 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1007438 | 4.NP_SO-102 | 1007438 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0893 | 0893 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1007441 | 4.NP_SO-102 | 1007441 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 1 | ZZ03.06.0894 | 0894 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1007451 | 4.NP_SO-102 | 1007451 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0895 | 0895 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1007454 | 4.NP_SO-102 | 1007454 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0896 | 0896 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1007457 | 4.NP_SO-102 | 1007457 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0897 | 0897 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1007467 | 4.NP_SO-102 | 1007467 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0898 | 0898 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1007489 | 4.NP_SO-102 | 1007489 | 4.NP_SO-102 | Vícerámečky, vodovné.CC : Vícerámečky - 3x | 300 | Fáze 2 | ZZ03.06.0899 | 0899 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1007906 | 4.NP_SO-102 | 1007906 | 4.NP_SO-102 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | Fáze 2 | ZZ03.06.0900 | 0900 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
1007923 | 4.NP_SO-102 | 1007923 | 4.NP_SO-102 | Kabelová lávka s tvarovkami : Parapetní žlab | 1050 | Fáze 2 | ZZ03.06.0901 | 0901 | Fruhauf.vinarice@seznam.cz 2023.06.26 04:27
