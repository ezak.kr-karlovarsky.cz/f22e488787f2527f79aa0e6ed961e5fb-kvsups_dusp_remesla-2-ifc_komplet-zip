Properties of the parts of a building model (IFC4), part 4 of 9

# IfcCableCarrierFitting: KOPOS JUPITER spojka kloubová:neelektrolytické pokovení (45)
Name (KOPOS JUPITER spojka kloubová:neelektrolytické pokovení:...) | In | Material | Poznámka | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | TLOUŠŤKA PLECHU (mm) | DÉLKA (mm) | H (mm) | Hspojky (mm) | Od středu ke konci (mm) | Úhel (deg) | Kód prvku | Označení | POLOŽKA | W | csv_H (mm)
1158173 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 10940 | Fáze 1 | 0 | 0 | 50 | 43 | 20.7107 | 45 | KT07.14.0195 | 0195 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:48
1158689 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 11090 | Fáze 1 | 0 | 0 | 50 | 43 | 11.8034 | 26.5651 | KT07.14.0201 | 0201 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:51
1158736 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 11090 | Fáze 1 | 0 | 0 | 50 | 43 | 15.1388 | 33.6901 | KT07.14.0210 | 0210 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:51
1159382 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 9329.68 | Fáze 1 | 0 | 0 | 50 | 43 | 12.9309 | 29 | KT07.14.0213 | 0213 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:56
1159447 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 11300 | Fáze 1 | 0 | 0 | 50 | 43 | 14.8491 | 33.0809 | KT07.14.0219 | 0219 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:56
1161382 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3085 | Fáze 1 | 0 | 0 | 50 | 43 | 25.0672 | 53.2533 | KT07.14.0227 | 0227 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.25 07:44
1161433 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3085 | Fáze 1 | 0 | 0 | 50 | 43 | 28.5087 | 59.3814 | KT07.14.0230 | 0230 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.25 10:18
1164244 | 3.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 3.NP_SO-102 | 19240 | Fáze 2 | 0 | 0 | 50 | 43 | 9.04908 | 20.5169 | KT07.14.0252 | 0252 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:43
1164273 | 3.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 3.NP_SO-102 | 19240 | Fáze 2 | 0 | 0 | 50 | 43 | 8.39382 | 19.0595 | KT07.14.0255 | 0255 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:43
1164705 | 3.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 3.NP_SO-102 | 19120 | Fáze 2 | 0 | 0 | 50 | 43 | 8.12459 | 18.4589 | KT07.14.0261 | 0261 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:47
1165790 | 3.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 3.NP_SO-102 | 8664.33 | Fáze 1 | 0 | 0 | 50 | 43 | 24.8003 | 52.7633 | KT07.14.0270 | 0270 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:51
1165912 | 3.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 3.NP_SO-102 | 18805.8 | Fáze 1 | 0 | 0 | 50 | 43 | 13.198 | 29.5731 | KT07.14.0276 | 0276 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:51
1165962 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 11236.3 | Fáze 2 | 0 | 0 | 50 | 43 | 2.23485 | 5.11849 | KT07.14.0279 | 0279 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:54
1167172 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 10980 | Fáze 1 | 0 | 0 | 50 | 43 | 16.8614 | 37.2711 | KT07.14.0285 | 0285 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 09:11
1167211 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 10980 | Fáze 1 | 0 | 0 | 50 | 43 | 16.2741 | 36.0584 | KT07.14.0291 | 0291 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 09:11
1168232 | 4.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 4.NP_SO-102 | 20558.7 | Fáze 1 | 0 | 0 | 50 | 43 | 14.2642 | 31.8452 | KT07.14.0300 | 0300 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 01:02
1168789 | 4.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 4.NP_SO-102 | 20528.6 | Fáze 1 | 0 | 0 | 50 | 43 | 14.3019 | 31.9251 | KT07.14.0307 | 0307 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 01:07
1172564 | 3.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 3.NP_SO-102 | 19121.3 | Fáze 2 | 0 | 0 | 50 | 43 | 5.35749 | 12.2318 | KT07.14.0325 | 0325 | NEDEF | yes | 0
1172932 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 11225 | Fáze 2 | 0 | 0 | 50 | 43 | 13.3975 | 30 | KT07.14.0331 | 0331 | NEDEF | yes | 0
1173723 | 1.NP_SO-102 |  |  | 1.NP_SO-102 | 3220 | Fáze 2 | 1 | 47.1239 | 60 | 53 | 24.8528 | 45 | KT07.14.0336 | 0336 | SK 60_GMT | no | 53
1173724 | 1.NP_SO-102 |  |  | 1.NP_SO-102 | 3220 | Fáze 2 | 1 | 0 | 60 | 53 | 24.8528 | 45 | KT07.14.0337 | 0337 | SK 60_GMT | no | 53
1173857 | 1.NP_SO-102 |  |  | 1.NP_SO-102 | 3220 | Fáze 2 | 1 | 47.1239 | 60 | 53 | 24.8528 | 45 | KT07.14.0342 | 0342 | SK 60_GMT | no | 53
1173858 | 1.NP_SO-102 |  |  | 1.NP_SO-102 | 3220 | Fáze 2 | 1 | 0 | 60 | 53 | 24.8528 | 45 | KT07.14.0343 | 0343 | SK 60_GMT | no | 53
1174086 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3150 | Fáze 2 | 0 | 0 | 100 | 93 | 41.4214 | 45 | KT07.14.0349 | 0349 | NEDEF | yes | 0
1174275 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 11225 | Fáze 2 | 0 | 0 | 50 | 43 | 13.3975 | 30 | KT07.14.0355 | 0355 | NEDEF | yes | 0
1174617 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3175 | Fáze 2 | 0 | 0 | 50 | 43 | 13.3975 | 30 | KT07.14.0366 | 0366 | NEDEF | yes | 0
1174637 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3175 | Fáze 2 | 0 | 0 | 50 | 43 | 13.3975 | 30 | KT07.14.0369 | 0369 | NEDEF | yes | 0
1174923 | 4.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 4.NP_SO-102 | 27301.3 | Fáze 1 | 0 | 0 | 50 | 43 | 13.3975 | 30.0001 | KT07.14.0377 | 0377 | NEDEF | yes | 0
1175467 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3225 | Fáze 1 | 0 | 0 | 50 | 43 | 13.3975 | 30 | KT07.14.0385 | 0385 | NEDEF | yes | 0
1175491 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3225 | Fáze 1 | 0 | 0 | 50 | 43 | 13.3975 | 30 | KT07.14.0391 | 0391 | NEDEF | yes | 0
1175617 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3140 | Fáze 1 | 0 | 0 | 50 | 43 | 20.7107 | 45 | KT07.14.0400 | 0400 | NEDEF | yes | 0
1175621 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3325 | Fáze 1 | 0 | 0 | 50 | 43 | 20.7107 | 45 | KT07.14.0403 | 0403 | NEDEF | yes | 0
1177360 | 4.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 4.NP_SO-102 | 27240 | Fáze 1 | 0 | 0 | 50 | 43 | 20.7107 | 45 | KT07.14.0410 | 0410 | NEDEF | yes | 0
1177386 | 4.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 4.NP_SO-102 | 27240 | Fáze 1 | 0 | 0 | 50 | 43 | 20.7107 | 45 | KT07.14.0416 | 0416 | NEDEF | yes | 0
1177410 | 4.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 4.NP_SO-102 | 27240 | Fáze 1 | 0 | 0 | 50 | 43 | 20.7107 | 45 | KT07.14.0422 | 0422 | NEDEF | yes | 0
1177440 | 4.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 4.NP_SO-102 | 27240 | Fáze 1 | 0 | 0 | 50 | 43 | 13.3975 | 30 | KT07.14.0428 | 0428 | NEDEF | yes | 0
1177464 | 4.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 4.NP_SO-102 | 27240 | Fáze 1 | 0 | 0 | 50 | 43 | 13.3975 | 30 | KT07.14.0431 | 0431 | NEDEF | yes | 0
1178087 | 4.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 4.NP_SO-102 | 27240 | Fáze 1 | 0 | 0 | 50 | 43 | 20.7107 | 45 | KT07.14.0444 | 0444 | NEDEF | yes | 0
1178442 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 11286.6 | Fáze 2 | 0 | 0 | 50 | 43 | 13.3975 | 30 | KT07.14.0450 | 0450 | NEDEF | yes | 0
1178541 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 11266.6 | Fáze 2 | 0 | 0 | 50 | 43 | 13.3975 | 30.0002 | KT07.14.0459 | 0459 | NEDEF | yes | 0
1179113 | 3.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 3.NP_SO-102 | 18800 | Fáze 1 | 0 | 0 | 50 | 43 | 20.7107 | 45 | KT07.14.0473 | 0473 | NEDEF | yes | 0
1179177 | 3.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 3.NP_SO-102 | 18800 | Fáze 1 | 0 | 0 | 50 | 43 | 20.7107 | 45 | KT07.14.0485 | 0485 | NEDEF | yes | 0
1179257 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3225 | Fáze 1 | 0 | 0 | 50 | 43 | 20.7107 | 45 | KT07.14.0491 | 0491 | NEDEF | yes | 0
1180999 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3130 | Fáze 1 | 0 | 0 | 50 | 43 | 0.662373 | 1.51796 | KT07.14.0506 | 0506 | NEDEF | yes | 0

# IfcCableCarrierFitting: KOPOS JUPITER spojka kloubová:neelektrolytické pokovení (41)
Type - Material: Warnings, <Unnamed>
Type - Nastavit - Family collapse: no
Type - Text - Lookup Table Name: kontrola JUPITER - spojka kloubová_GMT
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - tl stěny žlabu: 2.5 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.17.17; Copyright: © cadconsulting, spol. s r.o.; Kód sestavy: KT07; Komentáře k typům: JUPITER spojka kloubová; Model: Kabelové žlaby JUPITER; Nadpis OmniClass: Cable Trays and Horizontal Racks; Název typu: neelektrolytické pokovení; Označení typu: 14; Popis: spojka kloubová; Popis sestavy: Spojka; URL: https://www.kopos.cz/cs; Výrobce: KOPOS KOLÍN a.s.
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: KOPOS JUPITER spojka kloubová
Classification: KT07 Uniformat (Uniformat)
Nastavit - Warnings: yes
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL; Poznámka: spojka této velikosti se nedodává
Vazby - Přesunout s blízkými prvky: no
Kóty - TLOUŠŤKA PLECHU: 0 mm; Objem: 0.00014095 m3; Plocha: 0.0101962 m2; T: 1 mm; Tloušťka: 0 mm
Identifikační data - POLOŽKA: NEDEF
Jiné - Collapser: no; W: yes; Ohyb nebo tvarovka: Tvarovka; csv_H: 0 mm; Id typu: 562813; Rodina: KOPOS JUPITER spojka kloubová; Rodina a typ: KOPOS JUPITER spojka kloubová: neelektrolytické pokovení; Typ: neelektrolytické pokovení
Name (KOPOS JUPITER spojka kloubová:neelektrolytické pokovení:...) | In | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | DÉLKA (mm) | H (mm) | Hspojky (mm) | Od středu ke konci (mm) | Úhel (deg) | Kód prvku | Označení
1158145 | 2.NP_SO-102 | 2.NP_SO-102 | 2940 | Fáze 1 | 27.5193 | 50 | 43 | 14.1178 | 31.5348 | KT07.14.0188 | 0188 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:48
1158172 | 2.NP_SO-102 | 2.NP_SO-102 | 2940 | Fáze 1 | 39.2699 | 50 | 43 | 20.7107 | 45 | KT07.14.0194 | 0194 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:48
1158688 | 2.NP_SO-102 | 2.NP_SO-102 | 3090 | Fáze 1 | 23.1824 | 50 | 43 | 11.8034 | 26.5651 | KT07.14.0200 | 0200 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:51
1158735 | 2.NP_SO-102 | 2.NP_SO-102 | 3090 | Fáze 1 | 29.4001 | 50 | 43 | 15.1388 | 33.6901 | KT07.14.0209 | 0209 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:51
1159381 | 2.NP_SO-102 | 2.NP_SO-102 | 3210 | Fáze 1 | 25.3073 | 50 | 43 | 12.9309 | 29 | KT07.14.0212 | 0212 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:56
1159446 | 2.NP_SO-102 | 2.NP_SO-102 | 3300 | Fáze 1 | 28.8685 | 50 | 43 | 14.8491 | 33.0809 | KT07.14.0218 | 0218 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:56
1161381 | 1.NP_SO-102 | 1.NP_SO-102 | 3085 | Fáze 1 | 46.4723 | 50 | 43 | 25.0672 | 53.2533 | KT07.14.0226 | 0226 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.25 07:44
1161432 | 1.NP_SO-102 | 1.NP_SO-102 | 3085 | Fáze 1 | 51.82 | 50 | 43 | 28.5087 | 59.3814 | KT07.14.0229 | 0229 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.25 10:18
1164243 | 3.NP_SO-102 | 3.NP_SO-102 | 3240 | Fáze 2 | 17.9043 | 50 | 43 | 9.04908 | 20.5169 | KT07.14.0251 | 0251 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:43
1164272 | 3.NP_SO-102 | 3.NP_SO-102 | 3240 | Fáze 2 | 16.6325 | 50 | 43 | 8.39382 | 19.0595 | KT07.14.0254 | 0254 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:43
1164704 | 3.NP_SO-102 | 3.NP_SO-102 | 3120 | Fáze 2 | 16.1084 | 50 | 43 | 8.12459 | 18.4589 | KT07.14.0260 | 0260 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:47
1165789 | 3.NP_SO-102 | 3.NP_SO-102 | 2805.82 | Fáze 1 | 46.0447 | 50 | 43 | 24.8003 | 52.7633 | KT07.14.0269 | 0269 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:51
1165911 | 3.NP_SO-102 | 3.NP_SO-102 | 2805.82 | Fáze 1 | 25.8074 | 50 | 43 | 13.198 | 29.5731 | KT07.14.0275 | 0275 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:51
1165961 | 2.NP_SO-102 | 2.NP_SO-102 | 3300 | Fáze 2 | 4.46672 | 50 | 43 | 2.23485 | 5.11849 | KT07.14.0278 | 0278 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:54
1167171 | 2.NP_SO-102 | 2.NP_SO-102 | 2980 | Fáze 1 | 32.5252 | 50 | 43 | 16.8614 | 37.2711 | KT07.14.0284 | 0284 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 09:11
1167210 | 2.NP_SO-102 | 2.NP_SO-102 | 2980 | Fáze 1 | 31.4669 | 50 | 43 | 16.2741 | 36.0584 | KT07.14.0290 | 0290 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 09:11
1168231 | 4.NP_SO-102 | 4.NP_SO-102 | 3240 | Fáze 1 | 27.7901 | 50 | 43 | 14.2642 | 31.8452 | KT07.14.0299 | 0299 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 01:02
1168788 | 4.NP_SO-102 | 4.NP_SO-102 | 3240 | Fáze 1 | 27.8599 | 50 | 43 | 14.3019 | 31.9251 | KT07.14.0306 | 0306 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 01:07
1172563 | 3.NP_SO-102 | 3.NP_SO-102 | 3118.66 | Fáze 2 | 10.6743 | 50 | 43 | 5.35749 | 12.2318 | KT07.14.0324 | 0324
1172931 | 2.NP_SO-102 | 2.NP_SO-102 | 3225 | Fáze 2 | 26.1799 | 50 | 43 | 13.3975 | 30 | KT07.14.0330 | 0330
1174085 | 1.NP_SO-102 | 1.NP_SO-102 | 3150 | Fáze 2 | 78.5398 | 100 | 93 | 41.4214 | 45 | KT07.14.0348 | 0348
1174274 | 2.NP_SO-102 | 2.NP_SO-102 | 3225 | Fáze 2 | 26.1799 | 50 | 43 | 13.3975 | 30 | KT07.14.0354 | 0354
1174616 | 1.NP_SO-102 | 1.NP_SO-102 | 3175 | Fáze 2 | 26.1799 | 50 | 43 | 13.3975 | 30 | KT07.14.0365 | 0365
1174636 | 1.NP_SO-102 | 1.NP_SO-102 | 3175 | Fáze 2 | 26.1799 | 50 | 43 | 13.3975 | 30 | KT07.14.0368 | 0368
1174922 | 4.NP_SO-102 | 4.NP_SO-102 | 3301.31 | Fáze 1 | 26.1801 | 50 | 43 | 13.3975 | 30.0001 | KT07.14.0376 | 0376
1175466 | 1.NP_SO-102 | 1.NP_SO-102 | 3225 | Fáze 1 | 26.1799 | 50 | 43 | 13.3975 | 30 | KT07.14.0384 | 0384
1175490 | 1.NP_SO-102 | 1.NP_SO-102 | 3225 | Fáze 1 | 26.1799 | 50 | 43 | 13.3975 | 30 | KT07.14.0390 | 0390
1175616 | 1.NP_SO-102 | 1.NP_SO-102 | 3140 | Fáze 1 | 39.2699 | 50 | 43 | 20.7107 | 45 | KT07.14.0399 | 0399
1175620 | 1.NP_SO-102 | 1.NP_SO-102 | 3325 | Fáze 1 | 39.2699 | 50 | 43 | 20.7107 | 45 | KT07.14.0402 | 0402
1177359 | 4.NP_SO-102 | 4.NP_SO-102 | 3240 | Fáze 1 | 39.2699 | 50 | 43 | 20.7107 | 45 | KT07.14.0409 | 0409
1177385 | 4.NP_SO-102 | 4.NP_SO-102 | 3240 | Fáze 1 | 39.2699 | 50 | 43 | 20.7107 | 45 | KT07.14.0415 | 0415
1177409 | 4.NP_SO-102 | 4.NP_SO-102 | 3240 | Fáze 1 | 39.2699 | 50 | 43 | 20.7107 | 45 | KT07.14.0421 | 0421
1177439 | 4.NP_SO-102 | 4.NP_SO-102 | 3240 | Fáze 1 | 26.1799 | 50 | 43 | 13.3975 | 30 | KT07.14.0427 | 0427
1177463 | 4.NP_SO-102 | 4.NP_SO-102 | 3240 | Fáze 1 | 26.1799 | 50 | 43 | 13.3975 | 30 | KT07.14.0430 | 0430
1178086 | 4.NP_SO-102 | 4.NP_SO-102 | 3240 | Fáze 1 | 39.2699 | 50 | 43 | 20.7107 | 45 | KT07.14.0443 | 0443
1178441 | 2.NP_SO-102 | 2.NP_SO-102 | 3286.59 | Fáze 2 | 26.1799 | 50 | 43 | 13.3975 | 30 | KT07.14.0449 | 0449
1178540 | 2.NP_SO-102 | 2.NP_SO-102 | 3266.59 | Fáze 2 | 26.1801 | 50 | 43 | 13.3975 | 30.0002 | KT07.14.0458 | 0458
1179112 | 3.NP_SO-102 | 3.NP_SO-102 | 2800 | Fáze 1 | 39.2699 | 50 | 43 | 20.7107 | 45 | KT07.14.0472 | 0472
1179176 | 3.NP_SO-102 | 3.NP_SO-102 | 2800 | Fáze 1 | 39.2699 | 50 | 43 | 20.7107 | 45 | KT07.14.0484 | 0484
1179256 | 1.NP_SO-102 | 1.NP_SO-102 | 3225 | Fáze 1 | 39.2699 | 50 | 43 | 20.7107 | 45 | KT07.14.0490 | 0490
1180998 | 1.NP_SO-102 | 1.NP_SO-102 | 3130 | Fáze 1 | 1.32467 | 50 | 43 | 0.662373 | 1.51796 | KT07.14.0505 | 0505

# IfcCableCarrierFitting: KOPOS JUPITER spojka kloubová:zinkování Sendzimir (46)
Type - Material: <Unnamed>
Type - Nastavit - Family collapse: no
Type - Text - Lookup Table Name: kontrola JUPITER - spojka kloubová_S
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - tl stěny žlabu: 2.5 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.17.17; Copyright: © cadconsulting, spol. s r.o.; Kód sestavy: KT07; Komentáře k typům: JUPITER spojka kloubová; Model: Kabelové žlaby JUPITER; Nadpis OmniClass: Cable Trays and Horizontal Racks; Název typu: zinkování Sendzimir; Označení typu: 16; Popis: spojka kloubová; Popis sestavy: Spojka; URL: https://www.kopos.cz/cs; Výrobce: KOPOS KOLÍN a.s.
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: KOPOS JUPITER spojka kloubová
Classification: KT07 Uniformat (Uniformat)
Nastavit - Warnings: yes
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL
Vazby - Přesunout s blízkými prvky: no
Kóty - Tloušťka: 0 mm; Objem: 0.00014095 m3; Plocha: 0.0101962 m2
Jiné - Collapser: no; Typ: zinkování Sendzimir; Ohyb nebo tvarovka: Tvarovka; Rodina: KOPOS JUPITER spojka kloubová; Id typu: 562814; Rodina a typ: KOPOS JUPITER spojka kloubová: zinkování Sendzimir
Name (KOPOS JUPITER spojka kloubová:zinkování Sendzimir:...) | In | Material | Poznámka | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | TLOUŠŤKA PLECHU (mm) | DÉLKA (mm) | H (mm) | Hspojky (mm) | Od středu ke konci (mm) | T (mm) | Úhel (deg) | Kód prvku | Označení | POLOŽKA | W | csv_H (mm)
1158154 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 11210 | Fáze 1 | 0 | 27.5193 | 50 | 43 | 14.1178 | 1 | 31.5348 | KT07.16.0192 | 0192 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:48
1158631 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 7210 | Fáze 1 | 0 | 39.2699 | 50 | 43 | 20.7107 | 1 | 45 | KT07.16.0198 | 0198 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:51
1158697 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 11210 | Fáze 1 | 0 | 23.1824 | 50 | 43 | 11.8034 | 1 | 26.5651 | KT07.16.0204 | 0204 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.25 07:53
1158731 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 11210 | Fáze 1 | 0 | 29.4001 | 50 | 43 | 15.1388 | 1 | 33.6901 | KT07.16.0207 | 0207 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:51
1159403 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 9469.68 | Fáze 1 | 0 | 25.3073 | 50 | 43 | 12.9309 | 1 | 29 | KT07.16.0216 | 0216 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:56
1159463 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 11350 | Fáze 1 | 0 | 28.8685 | 50 | 43 | 14.8491 | 1 | 33.0809 | KT07.16.0222 | 0222 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:56
1161441 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3330 | Fáze 1 | 0 | 51.82 | 50 | 43 | 28.5087 | 1 | 59.3814 | KT07.16.0233 | 0233 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.25 10:18
1162395 | 4.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 4.NP_SO-102 | 27340 | Fáze 1 | 0 | 27.7901 | 50 | 43 | 14.2642 | 1 | 31.8452 | KT07.16.0240 | 0240 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 01:02
1162761 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3342.57 | Fáze 1 | 0 | 30.5433 | 50 | 43 | 15.7649 | 1 | 35 | KT07.16.0243 | 0243 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.25 09:56
1164237 | 3.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 3.NP_SO-102 | 19330 | Fáze 2 | 0 | 17.9043 | 50 | 43 | 9.04908 | 1 | 20.5169 | KT07.16.0249 | 0249 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:43
1164280 | 3.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 3.NP_SO-102 | 19330 | Fáze 2 | 0 | 16.6325 | 50 | 43 | 8.39382 | 1 | 19.0595 | KT07.16.0258 | 0258 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:43
1164713 | 3.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 3.NP_SO-102 | 19240 | Fáze 2 | 0 | 16.1084 | 50 | 43 | 8.12459 | 1 | 18.4589 | KT07.16.0264 | 0264 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:47
1165740 | 3.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 3.NP_SO-102 | 19240 | Fáze 1 | 0 | 46.0447 | 50 | 43 | 24.8003 | 1 | 52.7633 | KT07.16.0267 | 0267 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:50
1165907 | 3.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 3.NP_SO-102 | 19240 | Fáze 1 | 0 | 25.8074 | 50 | 43 | 13.198 | 1 | 29.5731 | KT07.16.0273 | 0273 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:51
1167165 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 11300 | Fáze 1 | 0 | 32.5252 | 50 | 43 | 16.8614 | 1 | 37.2711 | KT07.16.0282 | 0282 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 09:11
1167203 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 11300 | Fáze 1 | 0 | 31.4669 | 50 | 43 | 16.2741 | 1 | 36.0584 | KT07.16.0288 | 0288 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 09:11
1168037 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3540 | Fáze 2 | 0 | 20.5188 | 50 | 43 | 10.4059 | 1 | 23.5128 | KT07.16.0297 | 0297 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 10:02
1168959 | 4.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 4.NP_SO-102 | 20628.6 | Fáze 1 | 0 | 27.8599 | 50 | 43 | 14.3019 | 1 | 31.9251 | KT07.16.0310 | 0310 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 01:08
1172594 | 3.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 3.NP_SO-102 | 18482 | Fáze 2 | 0 | 10.6743 | 50 | 43 | 5.35749 | 1 | 12.2318 | KT07.16.0328 | 0328 | NEDEF | yes | 0
1173674 | 1.NP_SO-102 |  |  | 1.NP_SO-102 | 3340 | Fáze 2 | 0.8 | 0 | 60 | 53 | 24.8528 | 0.8 | 45 | KT07.16.0333 | 0333 | SK 60_S | no | 53
1173675 | 1.NP_SO-102 |  |  | 1.NP_SO-102 | 3340 | Fáze 2 | 0.8 | 47.1239 | 60 | 53 | 24.8528 | 0.8 | 45 | KT07.16.0334 | 0334 | SK 60_S | no | 53
1173854 | 1.NP_SO-102 |  |  | 1.NP_SO-102 | 3340 | Fáze 2 | 0.8 | 0 | 60 | 53 | 24.8528 | 0.8 | 45 | KT07.16.0339 | 0339 | SK 60_S | no | 53
1173855 | 1.NP_SO-102 |  |  | 1.NP_SO-102 | 3340 | Fáze 2 | 0.8 | 47.1239 | 60 | 53 | 24.8528 | 0.8 | 45 | KT07.16.0340 | 0340 | SK 60_S | no | 53
1174091 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3340 | Fáze 2 | 0 | 78.5398 | 100 | 93 | 41.4214 | 1 | 45 | KT07.16.0352 | 0352 | NEDEF | yes | 0
1174280 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 9300 | Fáze 2 | 0 | 26.1799 | 50 | 43 | 13.3975 | 1 | 30 | KT07.16.0358 | 0358 | NEDEF | yes | 0
1174490 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3340 | Fáze 2 | 0 | 26.1799 | 50 | 43 | 13.3975 | 1 | 30 | KT07.16.0361 | 0361 | NEDEF | yes | 0
1174642 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3340 | Fáze 2 | 0 | 26.1799 | 50 | 43 | 13.3975 | 1 | 30 | KT07.16.0372 | 0372 | NEDEF | yes | 0
1174934 | 4.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 4.NP_SO-102 | 21340 | Fáze 1 | 0 | 26.1801 | 50 | 43 | 13.3975 | 1 | 30.0001 | KT07.16.0380 | 0380 | NEDEF | yes | 0
1175472 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3325 | Fáze 1 | 0 | 26.1799 | 50 | 43 | 13.3975 | 1 | 30 | KT07.16.0388 | 0388 | NEDEF | yes | 0
1175496 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3325 | Fáze 1 | 0 | 26.1799 | 50 | 43 | 13.3975 | 1 | 30 | KT07.16.0394 | 0394 | NEDEF | yes | 0
1175572 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3325 | Fáze 1 | 0 | 39.2699 | 50 | 43 | 20.7107 | 1 | 45 | KT07.16.0397 | 0397 | NEDEF | yes | 0
1177365 | 4.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 4.NP_SO-102 | 15370 | Fáze 1 | 0 | 39.2699 | 50 | 43 | 20.7107 | 1 | 45 | KT07.16.0413 | 0413 | NEDEF | yes | 0
1177391 | 4.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 4.NP_SO-102 | 15370 | Fáze 1 | 0 | 39.2699 | 50 | 43 | 20.7107 | 1 | 45 | KT07.16.0419 | 0419 | NEDEF | yes | 0
1177415 | 4.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 4.NP_SO-102 | 15370 | Fáze 1 | 0 | 39.2699 | 50 | 43 | 20.7107 | 1 | 45 | KT07.16.0425 | 0425 | NEDEF | yes | 0
1177469 | 4.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 4.NP_SO-102 | 21346.6 | Fáze 1 | 0 | 26.1799 | 50 | 43 | 13.3975 | 1 | 30 | KT07.16.0434 | 0434 | NEDEF | yes | 0
1177477 | 4.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 4.NP_SO-102 | 21346.6 | Fáze 1 | 0 | 26.1799 | 50 | 43 | 13.3975 | 1 | 30 | KT07.16.0437 | 0437 | NEDEF | yes | 0
1178092 | 4.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 4.NP_SO-102 | 15397 | Fáze 1 | 0 | 39.2699 | 50 | 43 | 20.7107 | 1 | 45 | KT07.16.0447 | 0447 | NEDEF | yes | 0
1178447 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 9352.3 | Fáze 2 | 0 | 26.1799 | 50 | 43 | 13.3975 | 1 | 30 | KT07.16.0453 | 0453 | NEDEF | yes | 0
1178455 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 11288.6 | Fáze 2 | 0 | 4.46672 | 50 | 43 | 2.23485 | 1 | 5.11849 | KT07.16.0456 | 0456 | NEDEF | yes | 0
1178552 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 9299.98 | Fáze 2 | 0 | 26.1801 | 50 | 43 | 13.3975 | 1 | 30.0002 | KT07.16.0462 | 0462 | NEDEF | yes | 0
1178559 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 9300 | Fáze 2 | 0 | 26.1799 | 50 | 43 | 13.3975 | 1 | 30 | KT07.16.0465 | 0465 | NEDEF | yes | 0
1179118 | 3.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 3.NP_SO-102 | 11240 | Fáze 1 | 0 | 39.2699 | 50 | 43 | 20.7107 | 1 | 45 | KT07.16.0476 | 0476 | NEDEF | yes | 0
1179182 | 3.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 3.NP_SO-102 | 11240 | Fáze 1 | 0 | 39.2699 | 50 | 43 | 20.7107 | 1 | 45 | KT07.16.0488 | 0488 | NEDEF | yes | 0
1179264 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3335 | Fáze 1 | 0 | 39.2699 | 50 | 43 | 20.7107 | 1 | 45 | KT07.16.0494 | 0494 | NEDEF | yes | 0
1179272 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3335 | Fáze 1 | 0 | 46.4723 | 50 | 43 | 25.0672 | 1 | 53.2533 | KT07.16.0497 | 0497 | NEDEF | yes | 0
1181005 | 1.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 1.NP_SO-102 | 3330 | Fáze 2 | 0 | 1.32467 | 50 | 43 | 0.662373 | 1 | 1.51796 | KT07.16.0509 | 0509 | NEDEF | yes | 0

# IfcCableCarrierFitting: KOPOS JUPITER spojka kloubová:zinkování Sendzimir (42)
Type - Material: Warnings, <Unnamed>
Type - Nastavit - Family collapse: no
Type - Text - Lookup Table Name: kontrola JUPITER - spojka kloubová_S
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - tl stěny žlabu: 2.5 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.17.17; Copyright: © cadconsulting, spol. s r.o.; Kód sestavy: KT07; Komentáře k typům: JUPITER spojka kloubová; Model: Kabelové žlaby JUPITER; Nadpis OmniClass: Cable Trays and Horizontal Racks; Název typu: zinkování Sendzimir; Označení typu: 16; Popis: spojka kloubová; Popis sestavy: Spojka; URL: https://www.kopos.cz/cs; Výrobce: KOPOS KOLÍN a.s.
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: KOPOS JUPITER spojka kloubová
Classification: KT07 Uniformat (Uniformat)
Nastavit - Warnings: yes
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL; Poznámka: spojka této velikosti se nedodává
Vazby - Přesunout s blízkými prvky: no
Kóty - TLOUŠŤKA PLECHU: 0 mm; Tloušťka: 0 mm; DÉLKA: 0 mm; Objem: 0.00014095 m3; Plocha: 0.0101962 m2; T: 1 mm
Identifikační data - POLOŽKA: NEDEF
Jiné - Collapser: no; Typ: zinkování Sendzimir; W: yes; Ohyb nebo tvarovka: Tvarovka; csv_H: 0 mm; Rodina: KOPOS JUPITER spojka kloubová; Id typu: 562814; Rodina a typ: KOPOS JUPITER spojka kloubová: zinkování Sendzimir
Name (KOPOS JUPITER spojka kloubová:zinkování Sendzimir:...) | In | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | H (mm) | Hspojky (mm) | Od středu ke konci (mm) | Úhel (deg) | Kód prvku | Označení
1158153 | 2.NP_SO-102 | 2.NP_SO-102 | 3210 | Fáze 1 | 50 | 43 | 14.1178 | 31.5348 | KT07.16.0191 | 0191 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:48
1158630 | 2.NP_SO-102 | 2.NP_SO-102 | 3210 | Fáze 1 | 50 | 43 | 20.7107 | 45 | KT07.16.0197 | 0197 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:51
1158696 | 2.NP_SO-102 | 2.NP_SO-102 | 3210 | Fáze 1 | 50 | 43 | 11.8034 | 26.5651 | KT07.16.0203 | 0203 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.25 07:53
1158730 | 2.NP_SO-102 | 2.NP_SO-102 | 3210 | Fáze 1 | 50 | 43 | 15.1388 | 33.6901 | KT07.16.0206 | 0206 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:51
1159402 | 2.NP_SO-102 | 2.NP_SO-102 | 3350 | Fáze 1 | 50 | 43 | 12.9309 | 29 | KT07.16.0215 | 0215 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:56
1159462 | 2.NP_SO-102 | 2.NP_SO-102 | 3350 | Fáze 1 | 50 | 43 | 14.8491 | 33.0809 | KT07.16.0221 | 0221 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:56
1161440 | 1.NP_SO-102 | 1.NP_SO-102 | 3330 | Fáze 1 | 50 | 43 | 28.5087 | 59.3814 | KT07.16.0232 | 0232 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.25 10:18
1162394 | 4.NP_SO-102 | 4.NP_SO-102 | 3340 | Fáze 1 | 50 | 43 | 14.2642 | 31.8452 | KT07.16.0239 | 0239 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 01:02
1162760 | 1.NP_SO-102 | 1.NP_SO-102 | 3342.57 | Fáze 1 | 50 | 43 | 15.7649 | 35 | KT07.16.0242 | 0242 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.25 09:56
1164236 | 3.NP_SO-102 | 3.NP_SO-102 | 3330 | Fáze 2 | 50 | 43 | 9.04908 | 20.5169 | KT07.16.0248 | 0248 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:43
1164279 | 3.NP_SO-102 | 3.NP_SO-102 | 3330 | Fáze 2 | 50 | 43 | 8.39382 | 19.0595 | KT07.16.0257 | 0257 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:43
1164712 | 3.NP_SO-102 | 3.NP_SO-102 | 3240 | Fáze 2 | 50 | 43 | 8.12459 | 18.4589 | KT07.16.0263 | 0263 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:47
1165739 | 3.NP_SO-102 | 3.NP_SO-102 | 3240 | Fáze 1 | 50 | 43 | 24.8003 | 52.7633 | KT07.16.0266 | 0266 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:50
1165906 | 3.NP_SO-102 | 3.NP_SO-102 | 3240 | Fáze 1 | 50 | 43 | 13.198 | 29.5731 | KT07.16.0272 | 0272 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:51
1167164 | 2.NP_SO-102 | 2.NP_SO-102 | 3300 | Fáze 1 | 50 | 43 | 16.8614 | 37.2711 | KT07.16.0281 | 0281 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 09:11
1167202 | 2.NP_SO-102 | 2.NP_SO-102 | 3300 | Fáze 1 | 50 | 43 | 16.2741 | 36.0584 | KT07.16.0287 | 0287 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 09:11
1168036 | 1.NP_SO-102 | 1.NP_SO-102 | 3540 | Fáze 2 | 50 | 43 | 10.4059 | 23.5128 | KT07.16.0296 | 0296 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 10:02
1168958 | 4.NP_SO-102 | 4.NP_SO-102 | 3340 | Fáze 1 | 50 | 43 | 14.3019 | 31.9251 | KT07.16.0309 | 0309 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 01:08
1172593 | 3.NP_SO-102 | 3.NP_SO-102 | 3202.75 | Fáze 2 | 50 | 43 | 5.35749 | 12.2318 | KT07.16.0327 | 0327
1174090 | 1.NP_SO-102 | 1.NP_SO-102 | 3340 | Fáze 2 | 100 | 93 | 41.4214 | 45 | KT07.16.0351 | 0351
1174279 | 2.NP_SO-102 | 2.NP_SO-102 | 3300 | Fáze 2 | 50 | 43 | 13.3975 | 30 | KT07.16.0357 | 0357
1174489 | 1.NP_SO-102 | 1.NP_SO-102 | 3340 | Fáze 2 | 50 | 43 | 13.3975 | 30 | KT07.16.0360 | 0360
1174641 | 1.NP_SO-102 | 1.NP_SO-102 | 3340 | Fáze 2 | 50 | 43 | 13.3975 | 30 | KT07.16.0371 | 0371
1174933 | 4.NP_SO-102 | 4.NP_SO-102 | 3340 | Fáze 1 | 50 | 43 | 13.3975 | 30.0001 | KT07.16.0379 | 0379
1175471 | 1.NP_SO-102 | 1.NP_SO-102 | 3325 | Fáze 1 | 50 | 43 | 13.3975 | 30 | KT07.16.0387 | 0387
1175495 | 1.NP_SO-102 | 1.NP_SO-102 | 3325 | Fáze 1 | 50 | 43 | 13.3975 | 30 | KT07.16.0393 | 0393
1175571 | 1.NP_SO-102 | 1.NP_SO-102 | 3325 | Fáze 1 | 50 | 43 | 20.7107 | 45 | KT07.16.0396 | 0396
1177364 | 4.NP_SO-102 | 4.NP_SO-102 | 3370 | Fáze 1 | 50 | 43 | 20.7107 | 45 | KT07.16.0412 | 0412
1177390 | 4.NP_SO-102 | 4.NP_SO-102 | 3370 | Fáze 1 | 50 | 43 | 20.7107 | 45 | KT07.16.0418 | 0418
1177414 | 4.NP_SO-102 | 4.NP_SO-102 | 3370 | Fáze 1 | 50 | 43 | 20.7107 | 45 | KT07.16.0424 | 0424
1177468 | 4.NP_SO-102 | 4.NP_SO-102 | 3346.61 | Fáze 1 | 50 | 43 | 13.3975 | 30 | KT07.16.0433 | 0433
1177476 | 4.NP_SO-102 | 4.NP_SO-102 | 3346.61 | Fáze 1 | 50 | 43 | 13.3975 | 30 | KT07.16.0436 | 0436
1178091 | 4.NP_SO-102 | 4.NP_SO-102 | 3397.02 | Fáze 1 | 50 | 43 | 20.7107 | 45 | KT07.16.0446 | 0446
1178446 | 2.NP_SO-102 | 2.NP_SO-102 | 3352.3 | Fáze 2 | 50 | 43 | 13.3975 | 30 | KT07.16.0452 | 0452
1178454 | 2.NP_SO-102 | 2.NP_SO-102 | 3352.3 | Fáze 2 | 50 | 43 | 2.23485 | 5.11849 | KT07.16.0455 | 0455
1178551 | 2.NP_SO-102 | 2.NP_SO-102 | 3300 | Fáze 2 | 50 | 43 | 13.3975 | 30.0002 | KT07.16.0461 | 0461
1178558 | 2.NP_SO-102 | 2.NP_SO-102 | 3300 | Fáze 2 | 50 | 43 | 13.3975 | 30 | KT07.16.0464 | 0464
1179117 | 3.NP_SO-102 | 3.NP_SO-102 | 3240 | Fáze 1 | 50 | 43 | 20.7107 | 45 | KT07.16.0475 | 0475
1179181 | 3.NP_SO-102 | 3.NP_SO-102 | 3240 | Fáze 1 | 50 | 43 | 20.7107 | 45 | KT07.16.0487 | 0487
1179263 | 1.NP_SO-102 | 1.NP_SO-102 | 3335 | Fáze 1 | 50 | 43 | 20.7107 | 45 | KT07.16.0493 | 0493
1179271 | 1.NP_SO-102 | 1.NP_SO-102 | 3335 | Fáze 1 | 50 | 43 | 25.0672 | 53.2533 | KT07.16.0496 | 0496
1181004 | 1.NP_SO-102 | 1.NP_SO-102 | 3330 | Fáze 2 | 50 | 43 | 0.662373 | 1.51796 | KT07.16.0508 | 0508

# IfcCableCarrierFitting: KOPOS JUPITER spojka:zinkování Sendzimir (5)
Type - Material: <Unnamed>
Type - Nastavit - Family collapse: no
Type - Text - Lookup Table Name: kontrola JUPITER - spojka_S
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.17.17; Copyright: © cadconsulting, spol. s r.o.; Kód sestavy: KT07; Komentáře k typům: JUPITER spojka; Model: Kabelové žlaby JUPITER; Nadpis OmniClass: Cable Trays and Horizontal Racks; Název typu: zinkování Sendzimir; Označení typu: 05; Popis: spojka; Popis sestavy: Spojka; URL: https://www.kopos.cz/cs; Výrobce: KOPOS KOLÍN a.s.
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: KOPOS JUPITER spojka
Classification: KT07 Uniformat (Uniformat)
Nastavit - Warnings: yes
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL; Poznámka: spojka této velikosti se nedodává
Vazby - Přesunout s blízkými prvky: no
Kóty - Aspojky: 200 mm; H: 50 mm; H spojky: 40 mm; Objem: 0.0002819 m3; odsazení: 0 mm; Plocha: 0.0203924 m2; TLOUŠŤKA PLECHU: 1.2 mm; tl plechu: 1.2 mm; Úhel: 0 deg; Úhel/2: 0 deg
Identifikační data - POLOŽKA: NEDEF
Jiné - Collapser: no; Typ: zinkování Sendzimir; W: yes; !1: yes; !2: no; A: 200 mm; Aspojky/2: 100 mm; csv_H: 0 mm; Id typu: 562820; Rodina: KOPOS JUPITER spojka; Rodina a typ: KOPOS JUPITER spojka: zinkování Sendzimir; W2: no
Name (KOPOS JUPITER spojka:zinkování Sendzimir:...) | In | ID_import | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení | UPRAVIL | Material
929453 | 4.NP_SO-102 | 929453 | 4.NP_SO-102 | 3650 | Fáze 1 | KT07.05.0009 | 0009 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
994764 | 3.NP_SO-102 | 994764 | 3.NP_SO-102 | 3240 | Fáze 2 | KT07.05.0133 | 0133 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:42 | Warnings, <Unnamed>
997352 | 1.NP_SO-102 | 997352 | 1.NP_SO-102 | 3140 | Fáze 2 | KT07.05.0154 | 0154 | Fruhauf.vinarice@seznam.cz 2023.07.19 11:50 | Warnings, <Unnamed>
1063679 | 4.NP_SO-102 | 1063679 | 4.NP_SO-102 | 3240 | Fáze 1 | KT07.05.0173 | 0173 | Fruhauf.vinarice@seznam.cz 2023.08.10 01:02 | Warnings, <Unnamed>
1063698 | 4.NP_SO-102 | 1063698 | 4.NP_SO-102 | 3240 | Fáze 1 | KT07.05.0176 | 0176 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47 | Warnings, <Unnamed>

# IfcCableCarrierFitting: KOPOS JUPITER spojka:zinkování Sendzimir (5)
Type - Material: Warnings, <Unnamed>
Type - Nastavit - Family collapse: no
Type - Text - Lookup Table Name: kontrola JUPITER - spojka_S
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.17.17; Copyright: © cadconsulting, spol. s r.o.; Kód sestavy: KT07; Komentáře k typům: JUPITER spojka; Model: Kabelové žlaby JUPITER; Nadpis OmniClass: Cable Trays and Horizontal Racks; Název typu: zinkování Sendzimir; Označení typu: 05; Popis: spojka; Popis sestavy: Spojka; URL: https://www.kopos.cz/cs; Výrobce: KOPOS KOLÍN a.s.
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: KOPOS JUPITER spojka
Classification: KT07 Uniformat (Uniformat)
Nastavit - Warnings: yes
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL; Poznámka: spojka této velikosti se nedodává
Vazby - Přesunout s blízkými prvky: no
Kóty - odsazení: 0 mm; Úhel: 0 deg; Úhel/2: 0 deg; Aspojky: 200 mm; H: 50 mm; H spojky: 40 mm; Objem: 0.0002819 m3; Plocha: 0.0203924 m2; TLOUŠŤKA PLECHU: 1.2 mm; tl plechu: 1.2 mm
Identifikační data - POLOŽKA: NEDEF
Jiné - Collapser: no; Typ: zinkování Sendzimir; csv_H: 0 mm; Id typu: 562820; Rodina: KOPOS JUPITER spojka; Rodina a typ: KOPOS JUPITER spojka: zinkování Sendzimir; !1: no; !2: yes; A: 200 mm; Aspojky/2: 100 mm; W: no; W2: yes
Name (KOPOS JUPITER spojka:zinkování Sendzimir:...) | In | ID_import | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení | UPRAVIL
929454 | 4.NP_SO-102 | 929454 | 4.NP_SO-102 | 3650 | Fáze 1 | KT07.05.0010 | 0010 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
994765 | 3.NP_SO-102 | 994765 | 3.NP_SO-102 | 3240 | Fáze 2 | KT07.05.0134 | 0134 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:42
997353 | 1.NP_SO-102 | 997353 | 1.NP_SO-102 | 3140 | Fáze 2 | KT07.05.0155 | 0155 | Fruhauf.vinarice@seznam.cz 2023.07.19 11:50
1063680 | 4.NP_SO-102 | 1063680 | 4.NP_SO-102 | 3240 | Fáze 1 | KT07.05.0174 | 0174 | Fruhauf.vinarice@seznam.cz 2023.08.10 01:02
1063699 | 4.NP_SO-102 | 1063699 | 4.NP_SO-102 | 3240 | Fáze 1 | KT07.05.0177 | 0177 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47

# IfcCableCarrierFitting: KOPOS JUPITER_T-kus.CC:žárové zinkování Sendzimir (2)
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Nastavit - Warnings: yes; Family collapse: no
Type - Text - Lookup Table Name: kontrola JUPITER - T-kus_S
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.17.17; Copyright: © cadconsulting, spol. s r.o.; Kód sestavy: KT02; Komentáře k typům: JUPITER T-kus; Model: Kabelové žlaby JUPITER; Nadpis OmniClass: Cable Trays and Horizontal Racks; Název typu: žárové zinkování Sendzimir; Označení typu: 06; Popis: T-kus; Popis sestavy: Odbočení žlabů; URL: https://www.kopos.cz/cs; Výrobce: KOPOS KOLÍN a.s.
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: KOPOS JUPITER_T-kus.CC; poloměr oblouku: 100 mm
Classification: KT02 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL
Vazby - Podlaží: 1.NP_SO-102; Výška od podlaží: 3340 mm
Fázování - Fáze vytvoření: Fáze 2
Grafika - Použít měřítko poznámky: yes
Kóty - A: 100 mm; DÉLKA: 452.4 mm; H: 60 mm; Objem: 0.00014095 m3; Plocha: 0.0101962 m2; TLOUŠŤKA PLECHU: 0.8 mm; Velikost: 100 mmx60 mmø-100 mmx60 mmø-100 mmx60 mmø
Identifikační data - POLOŽKA: T 60X100_S
Jiné - Páteřní trasa: yes; Collapser: no; W: no; Id typu: 562883; Rodina: KOPOS JUPITER_T-kus.CC; Rodina a typ: KOPOS JUPITER_T-kus.CC: žárové zinkování Sendzimir; Typ: žárové zinkování Sendzimir; csv_AH: 303 mm; D: 10 mm; poloměr oblouku_vnitřní: 100.8 mm; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 11:50
Name (KOPOS JUPITER_T-kus.CC:žárové zinkování Sendzimir:...) | ID_import | Kód prvku | Označení
972612 | 972612 | KT02.06.0118 | 0118
999797 | 999797 | KT02.06.0162 | 0162

# IfcCableCarrierFitting: KOPOS JUPITER_T-kus.CC:žárové zinkování Sendzimir (42)
Type - Material: Warnings, <Unnamed>
Type - Nastavit - Warnings: yes; Family collapse: no
Type - Text - Lookup Table Name: kontrola JUPITER - T-kus_S
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.17.17; Copyright: © cadconsulting, spol. s r.o.; Kód sestavy: KT02; Komentáře k typům: JUPITER T-kus; Model: Kabelové žlaby JUPITER; Nadpis OmniClass: Cable Trays and Horizontal Racks; Název typu: žárové zinkování Sendzimir; Označení typu: 06; Popis: T-kus; Popis sestavy: Odbočení žlabů; URL: https://www.kopos.cz/cs; Výrobce: KOPOS KOLÍN a.s.
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: KOPOS JUPITER_T-kus.CC; poloměr oblouku: 100 mm
Classification: KT02 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL; Poznámka: T-kus této velikosti se nedodává
Grafika - Použít měřítko poznámky: yes
Kóty - Objem: 0.00014095 m3; Plocha: 0.0101962 m2; TLOUŠŤKA PLECHU: 1 mm
Identifikační data - POLOŽKA: NEDEF
Jiné - Páteřní trasa: yes; Collapser: no; W: yes; csv_AH: 0 mm; D: 10 mm; Id typu: 562883; poloměr oblouku_vnitřní: 101 mm; Rodina: KOPOS JUPITER_T-kus.CC; Rodina a typ: KOPOS JUPITER_T-kus.CC: žárové zinkování Sendzimir; Typ: žárové zinkování Sendzimir
Name (KOPOS JUPITER_T-kus.CC:žárové zinkování Sendzimir:...) | In | ID_import | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | A (mm) | DÉLKA (mm) | H (mm) | Velikost | Kód prvku | Označení | UPRAVIL
929819 | 4.NP_SO-102 | 929819 | 4.NP_SO-102 | 3240 | Fáze 2 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0011 | 0011 | Fruhauf.vinarice@seznam.cz 2023.07.21 10:22
930173 | 3.NP_SO-102 | 930173 | 3.NP_SO-102 | 3240 | Fáze 1 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0012 | 0012 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:25
930257 | 3.NP_SO-102 | 930257 | 3.NP_SO-102 | 3240 | Fáze 1 | 300 | 753 | 50 | 300 mmx50 mmø-300 mmx50 mmø-300 mmx50 mmø | KT02.06.0013 | 0013 | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
930306 | 3.NP_SO-102 | 930306 | 3.NP_SO-102 | 3240 | Fáze 1 | 300 | 753 | 50 | 300 mmx50 mmø-300 mmx50 mmø-300 mmx50 mmø | KT02.06.0014 | 0014 | Fruhauf.vinarice@seznam.cz 2023.08.10 09:12
930340 | 3.NP_SO-102 | 930340 | 3.NP_SO-102 | 3240 | Fáze 2 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0015 | 0015 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:47
930343 | 3.NP_SO-102 | 930343 | 3.NP_SO-102 | 3240 | Fáze 2 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0016 | 0016 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:43
930423 | 3.NP_SO-102 | 930423 | 3.NP_SO-102 | 3240 | Fáze 1 | 300 | 753 | 50 | 300 mmx50 mmø-300 mmx50 mmø-300 mmx50 mmø | KT02.06.0017 | 0017 | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
930477 | 3.NP_SO-102 | 930477 | 3.NP_SO-102 | 3240 | Fáze 1 | 300 | 753 | 50 | 300 mmx50 mmø-300 mmx50 mmø-300 mmx50 mmø | KT02.06.0018 | 0018 | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
930783 | 2.NP_SO-102 | 930783 | 2.NP_SO-102 | 3300 | Fáze 1 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0027 | 0027 | Fruhauf.vinarice@seznam.cz 2023.08.10 09:10
930789 | 2.NP_SO-102 | 930789 | 2.NP_SO-102 | 3266.59 | Fáze 2 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0028 | 0028 | Fruhauf.vinarice@seznam.cz 2023.08.10 09:03
930962 | 2.NP_SO-102 | 930962 | 2.NP_SO-102 | 3300 | Fáze 1 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0029 | 0029 | Fruhauf.vinarice@seznam.cz 2023.08.10 09:05
931225 | 2.NP_SO-102 | 931225 | 2.NP_SO-102 | 3250 | Fáze 1 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0036 | 0036 | Fruhauf.vinarice@seznam.cz 2023.07.25 07:53
931333 | 2.NP_SO-102 | 931333 | 2.NP_SO-102 | 3270 | Fáze 1 | 100 | 453 | 50 | 100 mmx50 mmø-100 mmx50 mmø-100 mmx50 mmø | KT02.06.0046 | 0046 | Fruhauf.vinarice@seznam.cz 2023.08.10 01:16
931488 | 1.NP_SO-102 | 931488 | 1.NP_SO-102 | 3320 | Fáze 1 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0057 | 0057 | Fruhauf.vinarice@seznam.cz 2023.07.21 10:22
931528 | 1.NP_SO-102 | 931528 | 1.NP_SO-102 | 3122.51 | Fáze 1 | 100 | 453 | 50 | 100 mmx50 mmø-100 mmx50 mmø-100 mmx50 mmø | KT02.06.0058 | 0058 | Fruhauf.vinarice@seznam.cz 2023.07.25 08:10
931555 | 2.NP_SO-102 | 931555 | 2.NP_SO-102 | 3280 | Fáze 1 | 100 | 453 | 50 | 100 mmx50 mmø-100 mmx50 mmø-100 mmx50 mmø | KT02.06.0059 | 0059 | Fruhauf.vinarice@seznam.cz 2023.08.10 12:49
931571 | 2.NP_SO-102 | 931571 | 2.NP_SO-102 | 3280 | Fáze 1 | 100 | 453 | 50 | 100 mmx50 mmø-100 mmx50 mmø-100 mmx50 mmø | KT02.06.0060 | 0060 | Fruhauf.vinarice@seznam.cz 2023.08.10 12:45
931587 | 2.NP_SO-102 | 931587 | 2.NP_SO-102 | 3280 | Fáze 1 | 100 | 453 | 50 | 100 mmx50 mmø-100 mmx50 mmø-100 mmx50 mmø | KT02.06.0061 | 0061 | Fruhauf.vinarice@seznam.cz 2023.08.10 12:45
931589 | 2.NP_SO-102 | 931589 | 2.NP_SO-102 | 3280 | Fáze 1 | 100 | 453 | 50 | 100 mmx50 mmø-100 mmx50 mmø-100 mmx50 mmø | KT02.06.0062 | 0062 | Fruhauf.vinarice@seznam.cz 2023.08.10 12:49
931697 | 3.NP_SO-102 | 931697 | 3.NP_SO-102 | 3240 | Fáze 1 | 100 | 453 | 50 | 100 mmx50 mmø-100 mmx50 mmø-100 mmx50 mmø | KT02.06.0065 | 0065 | Fruhauf.vinarice@seznam.cz 2023.07.25 08:10
931841 | 3.NP_SO-102 | 931841 | 3.NP_SO-102 | 3240 | Fáze 1 | 100 | 453 | 50 | 100 mmx50 mmø-100 mmx50 mmø-100 mmx50 mmø | KT02.06.0066 | 0066 | Fruhauf.vinarice@seznam.cz 2023.07.25 08:10
931957 | 4.NP_SO-102 | 931957 | 4.NP_SO-102 | 3650 | Fáze 1 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0071 | 0071 | Fruhauf.vinarice@seznam.cz 2023.07.21 10:22
931980 | 4.NP_SO-102 | 931980 | 4.NP_SO-102 | 3650 | Fáze 1 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0074 | 0074 | Fruhauf.vinarice@seznam.cz 2023.07.21 10:22
932017 | 4.NP_SO-102 | 932017 | 4.NP_SO-102 | 3650 | Fáze 1 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0077 | 0077 | Fruhauf.vinarice@seznam.cz 2023.07.21 10:22
932020 | 4.NP_SO-102 | 932020 | 4.NP_SO-102 | 3650 | Fáze 1 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0078 | 0078 | Fruhauf.vinarice@seznam.cz 2023.07.21 10:22
932248 | 3.NP_SO-102 | 932248 | 3.NP_SO-102 | 3240 | Fáze 1 | 100 | 453 | 50 | 100 mmx50 mmø-100 mmx50 mmø-100 mmx50 mmø | KT02.06.0093 | 0093 | Fruhauf.vinarice@seznam.cz 2023.07.25 08:10
932276 | 1.NP_SO-102 | 932276 | 1.NP_SO-102 | 3320 | Fáze 1 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0096 | 0096 | Fruhauf.vinarice@seznam.cz 2023.07.21 10:22
969672 | 1.NP_SO-102 | 969672 | 1.NP_SO-102 | 3300 | Fáze 1 | 300 | 753 | 50 | 300 mmx50 mmø-300 mmx50 mmø-300 mmx50 mmø | KT02.06.0102 | 0102 | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
969675 | 1.NP_SO-102 | 969675 | 1.NP_SO-102 | 3225 | Fáze 1 | 400 | 903 | 50 | 400 mmx50 mmø-400 mmx50 mmø-400 mmx50 mmø | KT02.06.0103 | 0103 | Fruhauf.vinarice@seznam.cz 2023.07.19 11:53
972482 | 1.NP_SO-102 | 972482 | 1.NP_SO-102 | 3340 | Fáze 2 | 300 | 753 | 100 | 300 mmx100 mmø-300 mmx100 mmø-300 mmx100 mmø | KT02.06.0115 | 0115 | Fruhauf.vinarice@seznam.cz 2023.07.19 11:50
993843 | 2.NP_SO-102 | 993843 | 2.NP_SO-102 | 3300 | Fáze 1 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0123 | 0123 | Fruhauf.vinarice@seznam.cz 2023.07.21 10:22
995145 | 3.NP_SO-102 | 995145 | 3.NP_SO-102 | 2800 | Fáze 1 | 300 | 753 | 50 | 300 mmx50 mmø-300 mmx50 mmø-300 mmx50 mmø | KT02.06.0139 | 0139 | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
995880 | 2.NP_SO-102 | 995880 | 2.NP_SO-102 | 3266.59 | Fáze 2 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0140 | 0140 | Fruhauf.vinarice@seznam.cz 2023.07.21 10:22
996207 | 4.NP_SO-102 | 996207 | 4.NP_SO-102 | 3240 | Fáze 2 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0141 | 0141 | Fruhauf.vinarice@seznam.cz 2023.07.21 10:22
996705 | 4.NP_SO-102 | 996705 | 4.NP_SO-102 | 3370 | Fáze 1 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0142 | 0142 | Fruhauf.vinarice@seznam.cz 2023.07.21 10:22
996950 | 3.NP_SO-102 | 996950 | 3.NP_SO-102 | 3240 | Fáze 1 | 300 | 753 | 50 | 300 mmx50 mmø-300 mmx50 mmø-300 mmx50 mmø | KT02.06.0149 | 0149 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:21
998666 | 1.NP_SO-102 | 998666 | 1.NP_SO-102 | 3225 | Fáze 1 | 400 | 903 | 50 | 400 mmx50 mmø-400 mmx50 mmø-400 mmx50 mmø | KT02.06.0156 | 0156 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:15
1002242 | 4.NP_SO-102 | 1002242 | 4.NP_SO-102 | 3240 | Fáze 1 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0165 | 0165 | Fruhauf.vinarice@seznam.cz 2023.08.10 01:07
1090906 | 1.NP_SO-102 | 1090906 | 1.NP_SO-102 | 3140 | Fáze 2 | 300 | 753 | 100 | 300 mmx100 mmø-300 mmx100 mmø-300 mmx100 mmø | KT02.06.0180 | 0180 | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
1157577 | 2.NP_SO-102 |  | 2.NP_SO-102 | 3250 | Fáze 1 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0182 | 0182 | Fruhauf.vinarice@seznam.cz 2023.07.25 08:09
1160226 | 1.NP_SO-102 |  | 1.NP_SO-102 | 3322.5 | Fáze 1 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0223 | 0223 | Fruhauf.vinarice@seznam.cz 2023.07.21 10:22
1160237 | 1.NP_SO-102 |  | 1.NP_SO-102 | 3322.5 | Fáze 1 | 200 | 603 | 50 | 200 mmx50 mmø-200 mmx50 mmø-200 mmx50 mmø | KT02.06.0224 | 0224 | Fruhauf.vinarice@seznam.cz 2023.07.21 10:22

# IfcCableCarrierFitting: Parapetní žlab_Koleno:Standardní (13)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Kód sestavy: KT01; Název typu: Standardní; Označení typu: 07; Popis sestavy: Oblouk žlabů
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: Parapetní žlab_Koleno
Classification: KT01 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL
Grafika - Použít měřítko poznámky: yes
Kóty - Délka lávky: 100 mm; Tloušťka: 2.54 mm; Úhel: 90 deg
Jiné - Ohyb nebo tvarovka: Tvarovka; Délka 2: 102.54 mm; Id typu: 15977; Max. úhel segmentace: 90 deg; Rodina: Parapetní žlab_Koleno; Rodina a typ: Parapetní žlab_Koleno: Standardní; Typ: Standardní
Name (Parapetní žlab_Koleno:Standardní:...) | In | ID_import | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Objem (m3) | Poloměr ohybu (mm) = Délka 1 (mm) = Štítek poloměru ohybu (mm) | Šířka lávky (mm) | Velikost | Výška lávky (mm) | Kód prvku | Označení | Páteřní trasa | Délka 3 (mm) | Odsazení (mm) | UPRAVIL
933211 | 1.NP_SO-102 | 933211 | 1.NP_SO-102 | 1200 | Fáze 1 | 0.002756 | 132.5 | 65 | 65 mmx160 mmø-65 mmx160 mmø | 160 | KT01.07.0097 | 0097 | yes | 59.92 | 80 | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
933219 | 1.NP_SO-102 | 933219 | 1.NP_SO-102 | 1200 | Fáze 1 | 0.002756 | 132.5 | 65 | 65 mmx160 mmø-65 mmx160 mmø | 160 | KT01.07.0098 | 0098 | yes | 59.92 | 80 | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
933329 | 1.NP_SO-102 | 933329 | 1.NP_SO-102 | 1200 | Fáze 1 | 0.002756 | 132.5 | 65 | 65 mmx160 mmø-65 mmx160 mmø | 160 | KT01.07.0099 | 0099 | yes | 59.92 | 80 | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
970344 | 1.NP_SO-102 | 970344 | 1.NP_SO-102 | 1200 | Fáze 2 | 0.0020305 | 131 | 62 | 62 mmx125 mmø-62 mmx125 mmø | 125 | KT01.07.0104 | 0104 | yes | 56.92 | 62.5 | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
970352 | 1.NP_SO-102 | 970352 | 1.NP_SO-102 | 1200 | Fáze 2 | 0.0020305 | 131 | 62 | 62 mmx125 mmø-62 mmx125 mmø | 125 | KT01.07.0105 | 0105 | yes | 56.92 | 62.5 | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
970357 | 1.NP_SO-102 | 970357 | 1.NP_SO-102 | 1200 | Fáze 2 | 0.0020305 | 131 | 62 | 62 mmx125 mmø-62 mmx125 mmø | 125 | KT01.07.0106 | 0106 | yes | 56.92 | 62.5 | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
1007630 | 4.NP_SO-102 | 1007630 | 4.NP_SO-102 | 1050 | Fáze 2 | 0.0020305 | 131 | 62 | 62 mmx125 mmø-62 mmx125 mmø | 125 | KT01.07.0169 | 0169 | yes | 56.92 | 62.5 | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
1007635 | 4.NP_SO-102 | 1007635 | 4.NP_SO-102 | 1050 | Fáze 2 | 0.0020305 | 131 | 62 | 62 mmx125 mmø-62 mmx125 mmø | 125 | KT01.07.0170 | 0170 | yes | 56.92 | 62.5 | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
1007642 | 4.NP_SO-102 | 1007642 | 4.NP_SO-102 | 1050 | Fáze 2 | 0.0020305 | 131 | 62 | 62 mmx125 mmø-62 mmx125 mmø | 125 | KT01.07.0171 | 0171 | yes | 56.92 | 62.5 | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
1090454 | 1.NP_SO-102 | 1090454 | 1.NP_SO-102 | 1228.28 | Fáze 1 | 0.002756 | 132.5 | 65 | 65 mmx160 mmø-65 mmx160 mmø | 160 | KT01.07.0178 | 0178 | yes | 59.92 | 80 | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
1090682 | 1.NP_SO-102 | 1090682 | 1.NP_SO-102 | 1200 | Fáze 1 | 0.002756 | 132.5 | 65 | 65 mmx160 mmø-65 mmx160 mmø | 160 | KT01.07.0179 | 0179 | yes | 59.92 | 80 | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
1174762 | 1.NP_SO-102 |  | 1.NP_SO-102 | 1200 | Fáze 1 | 0.0020305 | 131 | 62 | 62 mmx125 mmø-62 mmx125 mmø | 125 | KT01.07.0373 | 0373 |  | 56.92 | 62.5
1174763 | 1.NP_SO-102 |  | 1.NP_SO-102 | 1200 | Fáze 1 | 0.0020305 | 131 | 62 | 62 mmx125 mmø-62 mmx125 mmø | 125 | KT01.07.0374 | 0374 |  | 56.92 | 62.5

# IfcCableCarrierFitting: Žlab_Spojka:Standard, Žlab_Spojka:Standard:1096353
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.80.30.17.17; Kód sestavy: KT07; Nadpis OmniClass: Cable Trays and Horizontal Racks; Název typu: Standard; Označení typu: 12; Popis sestavy: Spojka; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: Žlab_Spojka
Classification: KT07 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL; ID_import: 1096353
Vazby - Podlaží: 1.NP_SO-102; Výška od podlaží: 1200 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - Lávka_Délka: 75 mm; Lávka_Šířka: 65 mm; Lávka_Výška: 160 mm; Objem: 0.00078 m3; Tloušťka: 2.54 mm; Velikost: 65 mmx160 mmø-65 mmx160 mmø
Identifikační data - Kód prvku: KT07.12.0181; Označení: 0181
Jiné - Páteřní trasa: yes; Id typu: 15967; Rodina: Žlab_Spojka; Rodina a typ: Žlab_Spojka: Standard; Typ: Standard; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 01:02

# IfcCableCarrierSegment: Kabelová lávka s tvarovkami:KOPOS JUPITER POZINKOVÁNO SENDZIMIR (201)
Type - PredefinedType: CABLETRAYSEGMENT
Type - Tvarovky - Horizontální ohyb: KOPOS JUPITER_oblouk 90°.CC: zinkování Sendzimir; Kříž: KOPOS JUPITER_kříž.CC: zinkování Sendzimir; Přechod: KOPOS JUPITER_redukce.CC: zinkování Sendzimir; Spojení: KOPOS JUPITER_spojka.CC: zinkování Sendzimir; T-spoj: KOPOS JUPITER_T-kus.CC: žárové zinkování Sendzimir; Vertikální vnější ohyb: KOPOS JUPITER_oblouk klesající 90°.CC: zinkování Sendzimir; Vertikální vnitřní ohyb: KOPOS JUPITER_oblouk stoupající 90°.CC: zinkování Sendzimir
Type - Elektroinstalace - Násobitel poloměru ohybu: 1
Type - Identifikační data - Kód sestavy: KZ03; Komentáře k typům: 3 m;-1PP; Model: KZI_S; Název typu: KOPOS JUPITER POZINKOVÁNO SENDZIMIR; Označení typu: 01; Popis: Kabelové žlaby JUPITER; Popis sestavy: Kabelová lávka a žebřík; URL: https://www.kopos.cz/cs; Výrobce: KOPOS KOLÍN a.s.
Type - Jiné - Kategorie: Kabelové lávky; Název rodiny: Kabelová lávka s tvarovkami
Classification: KZ03 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Kóty - Výška: 50 mm
Jiné - Id typu: 560968; Rodina: Kabelová lávka s tvarovkami; Rodina a typ: Kabelová lávka s tvarovkami: KOPOS JUPITER POZINKOVÁNO SENDZIMIR; Typ: KOPOS JUPITER POZINKOVÁNO SENDZIMIR
Name (Kabelová lávka s tvarovkami:KOPOS JUPITER POZINKOVÁNO SENDZIMIR:...) | In | Length (mm) | CrossSectionArea (m2) | OuterSurfaceArea (m2) | ID_import | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Spodní výška (mm) | Fáze vytvoření | Délka (mm) | Šířka (mm) | Velikost | Kód prvku | Označení | Páteřní trasa | UPRAVIL
927807 | 4.NP_SO-102 | 50 | 0.993731 | 0.516865 | 927807 | 3265 | 3240 | 3240 | 4.NP_SO-102 | 3215 | Fáze 1 | 4968.65 | 200 | 200 mmx50 mmø | KZ03.01.0001 | 0001 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
929337 | 3.NP_SO-102 | 50 | 0.675865 | 0.255288 | 929337 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 2252.88 | 300 | 300 mmx50 mmø | KZ03.01.0002 | 0002 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
929343 | 3.NP_SO-102 | 50 | 0.209787 | 0.0999289 | 929343 | 2825 | 2800 | 2800 | 3.NP_SO-102 | 2775 | Fáze 1 | 699.289 | 300 | 300 mmx50 mmø | KZ03.01.0003 | 0003 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
929361 | 3.NP_SO-102 | 50 | 1.19151 | 0.427171 | 929361 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 3971.71 | 300 | 300 mmx50 mmø | KZ03.01.0004 | 0004 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:21
929381 | 3.NP_SO-102 | 50 | 2.29812 | 0.79604 | 929381 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 1 | 7660.4 | 300 | 300 mmx50 mmø | KZ03.01.0005 | 0005 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
929616 | 4.NP_SO-102 | 50 | 1.21847 | 0.629236 | 929616 | 3265 | 3240 | 3240 | 4.NP_SO-102 | 3215 | Fáze 2 | 6092.36 | 200 | 200 mmx50 mmø | KZ03.01.0006 | 0006 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
929800 | 4.NP_SO-102 | 50 | 0.6369 | 0.33845 | 929800 | 2775 | 2750 | 2750 | 4.NP_SO-102 | 2725 | Fáze 1 | 3184.5 | 200 | 200 mmx50 mmø | KZ03.01.0007 | 0007 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
929813 | 4.NP_SO-102 | 50 | 1.28174 | 0.660868 | 929813 | 3265 | 3240 | 3240 | 4.NP_SO-102 | 3215 | Fáze 2 | 6408.68 | 200 | 200 mmx50 mmø | KZ03.01.0008 | 0008 | yes | Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
930057 | 3.NP_SO-102 | 50 | 0.8449 | 0.44245 | 930057 | 2645 | 2620 | 2620 | 3.NP_SO-102 | 2595 | Fáze 1 | 4224.5 | 200 | 200 mmx50 mmø | KZ03.01.0009 | 0009 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:24
930058 | 3.NP_SO-102 | 50 | 0.933584 | 0.486792 | 930058 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 2 | 4667.92 | 200 | 200 mmx50 mmø | KZ03.01.0010 | 0010 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:42
930174 | 3.NP_SO-102 | 50 | 3.1958 | 1.6179 | 930174 | 3265 | 3240 | 3240 | 3.NP_SO-102 | 3215 | Fáze 2 | 15979 | 200 | 200 mmx50 mmø | KZ03.01.0011 | 0011 | yes | Fruhauf.vinarice@seznam.cz 2023.08.10 08:43
