Properties of the parts of a building model (IFC4), part 3 of 9

# IfcBuildingElementProxy: Vícerámečky, vodovné.CC:Vícerámečky - 5x (9)
Grafika - Posun horizontální: 0; Posun vertikální: 0; Symbol: yes
Kóty - Objem: 0.000094975 m3
Jiné - Id typu: 362928; Rodina: Vícerámečky, vodovné.CC; Rodina a typ: Vícerámečky, vodovné.CC: Vícerámečky - 5x; S: 364 mm; Typ: Vícerámečky - 5x; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
Name (Vícerámečky, vodovné.CC:Vícerámečky - 5x:...) | ID_import | Hostitel | Výška od podlaží (mm) | Kód prvku | Označení
934392 | 934392 | Osamocené | 1050 | MT00.03.0036 | 0036
943974 | 943974 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1050 | MT00.03.0062 | 0062
943981 | 943981 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1050 | MT00.03.0063 | 0063
952969 | 952969 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | MT00.03.0085 | 0085
952975 | 952975 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1106.94 | MT00.03.0086 | 0086
962313 | 962313 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1050 | MT00.03.0126 | 0126
962319 | 962319 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1050 | MT00.03.0127 | 0127
962858 | 962858 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1050 | MT00.03.0128 | 0128
962878 | 962878 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1050 | MT00.03.0129 | 0129

# IfcBuildingElementProxy: Vícerámečky, vodovné.CC:Vícerámečky - 6x (3)
In: 2.NP_SO-102
Type - Material: Bílá
Type - Vazby - Výchozí výška: 1050 mm
Type - Materiály a povrchové úpravy - Materiál: Bílá
Type - Kóty - Hloubka: 5 mm; Osová vzdálenost: 71 mm; ŠÍŘKA: 80 mm; Šířka_in: 45 mm; VÝŠKA: 80 mm; Výška_in: 45 mm
Type - Identifikační data - Číslo OmniClass: 23.80.70.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: MT00; Komentáře k typům: Rámečky vícenásobné; Nadpis OmniClass: Lighting; Název typu: Vícerámečky - 6x; Označení typu: 04; Popis: Rámeček; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Elektrická tělesa; Název rodiny: Vícerámečky, vodovné.CC; P: 6; P2: 71 mm; P3: 142 mm; P4: 213 mm; P5: 284 mm; P6: 355 mm; ST: 177.5 mm
Classification: MT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.05585 m2; NetVolume: 0.00011325 m3
Text - CCI Funkční systém: M; CCI Komponenta: XGA; CCI Technický systém: JL
Vazby - Podlaží: 2.NP_SO-102; Vztažné podlaží: 2.NP_SO-102; Hostitel: Osamocené; Výška od podlaží: 1050 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Symbol: yes; Posun vertikální: 2
Kóty - Objem: 0.00011325 m3
Jiné - Rodina: Vícerámečky, vodovné.CC; Id typu: 363560; Rodina a typ: Vícerámečky, vodovné.CC: Vícerámečky - 6x; S: 435 mm; Typ: Vícerámečky - 6x; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
Name (Vícerámečky, vodovné.CC:Vícerámečky - 6x:...) | ID_import | Kód prvku | Označení
934705 | 934705 | MT00.04.0041 | 0041
934713 | 934713 | MT00.04.0042 | 0042
934751 | 934751 | MT00.04.0043 | 0043

# IfcBuildingElementProxy: Závrtný kontakt do oken.CC:Závrtný kontakt do oken.CC (74)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 1970 mm
Type - Grafika - Posun horizontální: 0
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.14; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: PN07; Komentáře k typům: závrtný; Model: Model; Nadpis OmniClass: Presence Detection/Registration; Název typu: Závrtný kontakt do oken.CC; Označení typu: 05; Popis: Magnetický kontakt; Popis sestavy: Magnetický kontakt; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Zabezpečovací zařízení; Název rodiny: Závrtný kontakt do oken.CC
Classification: PN07 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0319957 m2; NetVolume: 0.000169111 m3
Text - CCI Funkční systém: M; CCI Komponenta: BED; CCI Technický systém: JL
Grafika - Posun vertikální: 0
Kóty - Objem: 0.000169111 m3
Jiné - Id typu: 1023391; Rodina: Závrtný kontakt do oken.CC; Rodina a typ: Závrtný kontakt do oken.CC: Závrtný kontakt do oken.CC; Typ: Závrtný kontakt do oken.CC
Name (Závrtný kontakt do oken.CC:Závrtný kontakt do oken.CC:...) | In | ID_import | Podlaží = Vztažné podlaží | Odsazení od hostitele (mm) | Pracovní rovina | Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení | UPRAVIL
1023424 | -1.PP_SO-102 | 1023424 | -1.PP_SO-102 | -2711.67 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2158.33 | Fáze 1 | PN07.05.0008 | 0008 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1023496 | 1.NP_SO-102 | 1023496 | 1.NP_SO-102 | 1288.33 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2158.33 | Fáze 1 | PN07.05.0009 | 0009 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1023508 | 1.NP_SO-102 | 1023508 | 1.NP_SO-102 | 1288.33 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2158.33 | Fáze 1 | PN07.05.0010 | 0010 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1023617 | 1.NP_SO-102 | 1023617 | 1.NP_SO-102 | 180 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1390 | Fáze 1 | PN07.05.0011 | 0011 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1023648 | 1.NP_SO-102 | 1023648 | 1.NP_SO-102 | 180 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1390 | Fáze 1 | PN07.05.0012 | 0012 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1027744 | -1.PP_SO-102 | 1027744 | -1.PP_SO-102 | 180 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 1820 | Fáze 1 | PN07.05.0041 | 0041 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1027778 | -1.PP_SO-102 | 1027778 | -1.PP_SO-102 | 640 | <nepřiřazeno> | 1250 | Fáze 1 | PN07.05.0042 | 0042 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1027791 | -1.PP_SO-102 | 1027791 | -1.PP_SO-102 | 440 | <nepřiřazeno> | 1050 | Fáze 1 | PN07.05.0043 | 0043 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1027834 | -1.PP_SO-102 | 1027834 | -1.PP_SO-102 | 640 | <nepřiřazeno> | 1250 | Fáze 1 | PN07.05.0044 | 0044 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1027873 | -1.PP_SO-102 | 1027873 | -1.PP_SO-102 | 640 | <nepřiřazeno> | 1250 | Fáze 1 | PN07.05.0045 | 0045 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1027978 | -1.PP_SO-102 | 1027978 | -1.PP_SO-102 | 440 | <nepřiřazeno> | 1250 | Fáze 1 | PN07.05.0050 | 0050 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1027991 | -1.PP_SO-102 | 1027991 | -1.PP_SO-102 | 440 | <nepřiřazeno> | 1250 | Fáze 1 | PN07.05.0054 | 0054 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1028005 | -1.PP_SO-102 | 1028005 | -1.PP_SO-102 | 440 | <nepřiřazeno> | 1250 | Fáze 1 | PN07.05.0058 | 0058 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1028186 | -1.PP_SO-102 | 1028186 | -1.PP_SO-102 | 440 | <nepřiřazeno> | 1250 | Fáze 1 | PN07.05.0062 | 0062 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1028354 | -1.PP_SO-102 | 1028354 | -1.PP_SO-102 | 1590 | <nepřiřazeno> | 2400 | Fáze 1 | PN07.05.0064 | 0064 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1028470 | -1.PP_SO-102 | 1028470 | -1.PP_SO-102 | 180 | <nepřiřazeno> | 790 | Fáze 1 | PN07.05.0069 | 0069 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1028860 | 1.NP_SO-102 | 1028860 | 1.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0073 | 0073 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1028933 | 1.NP_SO-102 | 1028933 | 1.NP_SO-102 | 1590 | <nepřiřazeno> | 2200 | Fáze 1 | PN07.05.0077 | 0077 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:11
1028986 | 3.NP_SO-102 | 1028986 | 3.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0081 | 0081 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029012 | 4.NP_SO-102 | 1029012 | 4.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 2 | PN07.05.0085 | 0085 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029025 | 4.NP_SO-102 | 1029025 | 4.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 2 | PN07.05.0088 | 0088 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029063 | 4.NP_SO-102 | 1029063 | 4.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 2 | PN07.05.0092 | 0092 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029091 | 3.NP_SO-102 | 1029091 | 3.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 2 | PN07.05.0096 | 0096 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029105 | 3.NP_SO-102 | 1029105 | 3.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 2 | PN07.05.0100 | 0100 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029119 | 3.NP_SO-102 | 1029119 | 3.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0104 | 0104 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029133 | 3.NP_SO-102 | 1029133 | 3.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0108 | 0108 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029197 | 3.NP_SO-102 | 1029197 | 3.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0112 | 0112 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029221 | 3.NP_SO-102 | 1029221 | 3.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0115 | 0115 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029252 | 3.NP_SO-102 | 1029252 |  | 180 | <nepřiřazeno> | 0 | Fáze 1 | PN07.05.0117 | 0117 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029262 | 4.NP_SO-102 | 1029262 | 4.NP_SO-102 | 180 | <nepřiřazeno> | 790 | Fáze 1 | PN07.05.0120 | 0120 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029355 | 4.NP_SO-102 | 1029355 | 4.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0126 | 0126 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029368 | 4.NP_SO-102 | 1029368 | 4.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0129 | 0129 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029553 | 4.NP_SO-102 | 1029553 | 4.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0133 | 0133 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029613 | 3.NP_SO-102 | 1029613 | 3.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0137 | 0137 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029627 | 3.NP_SO-102 | 1029627 | 3.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0140 | 0140 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029696 | 3.NP_SO-102 | 1029696 | 3.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0143 | 0143 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029756 | 2.NP_SO-102 | 1029756 | 2.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0147 | 0147 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029770 | 2.NP_SO-102 | 1029770 | 2.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0151 | 0151 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029784 | 2.NP_SO-102 | 1029784 | 2.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0154 | 0154 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029798 | 2.NP_SO-102 | 1029798 | 2.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0158 | 0158 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029812 | 2.NP_SO-102 | 1029812 | 2.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0161 | 0161 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029935 | 2.NP_SO-102 | 1029935 | 2.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0165 | 0165 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1029965 | 2.NP_SO-102 | 1029965 | 2.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0168 | 0168 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1030000 | 2.NP_SO-102 | 1030000 | 2.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0173 | 0173 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1030014 | 2.NP_SO-102 | 1030014 | 2.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0176 | 0176 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1030028 | 2.NP_SO-102 | 1030028 | 2.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0180 | 0180 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1030042 | 2.NP_SO-102 | 1030042 | 2.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0183 | 0183 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1030056 | 2.NP_SO-102 | 1030056 | 2.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0187 | 0187 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1030070 | 2.NP_SO-102 | 1030070 | 2.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0191 | 0191 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1030188 | 2.NP_SO-102 | 1030188 | 2.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0194 | 0194 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1030212 | 2.NP_SO-102 | 1030212 | 2.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0196 | 0196 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1030228 | 2.NP_SO-102 | 1030228 | 2.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0200 | 0200 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1032734 | -2.PP_SO-102 | 1032734 | -2.PP_SO-102 | 180 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2430 | Fáze 1 | PN07.05.0293 | 0293 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1032753 | -2.PP_SO-102 | 1032753 | -2.PP_SO-102 | 180 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2430 | Fáze 1 | PN07.05.0294 | 0294 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1032769 | -2.PP_SO-102 | 1032769 | -2.PP_SO-102 | 180 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 2430 | Fáze 1 | PN07.05.0295 | 0295 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:16
1033091 | -1.PP_SO-102 | 1033091 | -1.PP_SO-102 | 180 | <nepřiřazeno> | 1820 | Fáze 1 | PN07.05.0309 | 0309 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1089264 | -1.PP_SO-102 | 1089264 | -1.PP_SO-102 | 440 | <nepřiřazeno> | 1050 | Fáze 1 | PN07.05.0316 | 0316 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1089273 | -1.PP_SO-102 | 1089273 | -1.PP_SO-102 | 440 | <nepřiřazeno> | 1050 | Fáze 1 | PN07.05.0317 | 0317 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1090041 | 1.NP_SO-102 | 1090041 | 1.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0331 | 0331 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1090054 | 1.NP_SO-102 | 1090054 | 1.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0335 | 0335 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1090104 | 1.NP_SO-102 | 1090104 | 1.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0340 | 0340 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1090784 | 1.NP_SO-102 | 1090784 | 1.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0344 | 0344 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1090818 | 1.NP_SO-102 | 1090818 | 1.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0348 | 0348 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1090842 | 1.NP_SO-102 | 1090842 | 1.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0351 | 0351 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1090873 | 1.NP_SO-102 | 1090873 | 1.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 2 | PN07.05.0354 | 0354 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1090909 | 1.NP_SO-102 | 1090909 | 1.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 2 | PN07.05.0358 | 0358 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1090973 | 1.NP_SO-102 | 1090973 | 1.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 2 | PN07.05.0362 | 0362 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1090984 | 1.NP_SO-102 | 1090984 | 1.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 2 | PN07.05.0365 | 0365 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1091226 | 2.NP_SO-102 | 1091226 | 2.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0369 | 0369 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1091292 | 2.NP_SO-102 | 1091292 | 2.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0372 | 0372 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1091445 | 2.NP_SO-102 | 1091445 | 2.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0374 | 0374 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1091524 | 3.NP_SO-102 | 1091524 | 3.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0377 | 0377 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1091537 | 3.NP_SO-102 | 1091537 | 3.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0381 | 0381 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10
1091549 | 3.NP_SO-102 | 1091549 | 3.NP_SO-102 | 1540 | <nepřiřazeno> | 2150 | Fáze 1 | PN07.05.0384 | 0384 | Fruhauf.vinarice@seznam.cz 2023.07.25 10:10

# IfcBuildingElementProxy: Ústředna_Požární.CC:Napájecí zdroj_Požární.CC 2, Ústředna_Požární.CC:Napájecí zdroj_Požární.CC 2:999244
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes
Type - Kóty - HLOUBKA: 180 mm; ŠÍŘKA: 416 mm; VÝŠKA: 618 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP01; Komentáře k typům: požární; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Napájecí zdroj_Požární.CC 2; Označení typu: 09; Popis: Transformer; Popis sestavy: Ústředna EPS; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Ústředna_Požární.CC
Classification: EP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.926395 m2; NetVolume: 0.0459208 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 0 V/1-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: M; CCI Komponenta: XDC; CCI Technický systém: JL; ID_import: 999244
Vazby - Podlaží: -1.PP_SO-102; Hostitel: Podlaží : -1.PP_SO-102; Odsazení od hostitele: 200 mm; Výška od podlaží: 200 mm
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - POČET FÁZÍ: 1; NAPĚTÍ: 0 V
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.0459208 m3
Identifikační data - Kód prvku: EP01.09.0009; Označení: 0009
Jiné - Páteřní trasa: yes; Rodina: Ústředna_Požární.CC; Id typu: 913900; Rodina a typ: Ústředna_Požární.CC: Napájecí zdroj_Požární.CC 2; Typ: Napájecí zdroj_Požární.CC 2; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:19

# IfcBuildingElementProxy: Ústředna_Požární.CC:Ústředna_Požární.CC, Ústředna_Požární.CC:Ústředna_Požární.CC:999219
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes
Type - Kóty - HLOUBKA: 300 mm; ŠÍŘKA: 500 mm; VÝŠKA: 600 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP01; Komentáře k typům: požární; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Ústředna_Požární.CC; Označení typu: 08; Popis: Ústředna; Popis sestavy: Ústředna EPS; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Ústředna_Požární.CC
Classification: EP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.29998 m2; NetVolume: 0.089645 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 0 V/1-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: M; CCI Komponenta: XDC; CCI Technický systém: JL; ID_import: 999219
Vazby - Podlaží: -1.PP_SO-102; Hostitel: Podlaží : -1.PP_SO-102; Odsazení od hostitele: 900 mm; Výška od podlaží: 900 mm
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - NAPĚTÍ: 0 V; POČET FÁZÍ: 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.089645 m3
Identifikační data - Kód prvku: EP01.08.0008; Označení: 0008
Jiné - Páteřní trasa: yes; Id typu: 256501; Rodina: Ústředna_Požární.CC; Rodina a typ: Ústředna_Požární.CC: Ústředna_Požární.CC; Typ: Ústředna_Požární.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:20

# IfcBuildingElementProxy: Ústředna_Zabezpečení.CC:Ústředna_Zabezpečení.CC, Ústředna_Zabezpečení.CC:Ústředna_Zabezpečení.CC:1009169
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes
Type - Kóty - HLOUBKA: 300 mm; ŠÍŘKA: 500 mm; VÝŠKA: 600 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: PN01; Komentáře k typům: zabezpečovací zařízení; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Ústředna_Zabezpečení.CC; Označení typu: 10; Popis: Ústředna; Popis sestavy: Ústředna PZTS; URL: www.cadconsulting.cz; Version: 1.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Ústředna_Zabezpečení.CC
Classification: PN01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.29998 m2; NetVolume: 0.089645 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 0 V/3-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: M; CCI Komponenta: XDC; CCI Technický systém: JL; ID_import: 1009169
Vazby - Podlaží: 1.NP_SO-102; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Hostitel: Podlaží : 1.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - POČET FÁZÍ: 3; NAPĚTÍ: 0 V
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.089645 m3
Identifikační data - Kód prvku: PN01.10.0010; Označení: 0010
Jiné - Páteřní trasa: yes; Id typu: 258049; Rodina: Ústředna_Zabezpečení.CC; Rodina a typ: Ústředna_Zabezpečení.CC: Ústředna_Zabezpečení.CC; Typ: Ústředna_Zabezpečení.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:20

# IfcBuildingElementProxy: Čtečka karet.CC:Typ 1 (71)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; PŘÍKON: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Grafika - Symbol: yes
Type - Kóty - HLOUBKA: 30 mm; Hloubka zapuštění: 0 mm; ŠÍŘKA: 50 mm; VÝŠKA: 100 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: OL01; Komentáře k typům: Komentáře k typům; Model: Model; Nadpis OmniClass: Access Controls; Název typu: Typ 1; Označení typu: 06; Popis: Čtečka karet; Popis sestavy: Čtečka karet; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - FAKTOR ÚČINNOSTI: 1; Kategorie: Zabezpečovací zařízení; Název rodiny: Čtečka karet.CC
Classification: OL01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.01937 m2; NetVolume: 0.000150218 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: M; CCI Komponenta: BYA; CCI Technický systém: JL
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000150218 m3
Jiné - Id typu: 1025094; Rodina: Čtečka karet.CC; Rodina a typ: Čtečka karet.CC: Typ 1; Typ: Typ 1; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.25 10:12
Name (Čtečka karet.CC:Typ 1:...) | In | ID_import | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení
1025112 | 1.NP_SO-102 | 1025112 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0013 | 0013
1025116 | 1.NP_SO-102 | 1025116 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0014 | 0014
1025120 | 1.NP_SO-102 | 1025120 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0015 | 0015
1025124 | 1.NP_SO-102 | 1025124 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0016 | 0016
1025132 | 1.NP_SO-102 | 1025132 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2608.04 | Fáze 1 | OL01.06.0017 | 0017
1026337 | 1.NP_SO-102 | 1026337 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0019 | 0019
1026338 | 1.NP_SO-102 | 1026338 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0020 | 0020
1026348 | 1.NP_SO-102 | 1026348 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0021 | 0021
1026349 | 1.NP_SO-102 | 1026349 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0022 | 0022
1026357 | 1.NP_SO-102 | 1026357 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0023 | 0023
1026358 | 1.NP_SO-102 | 1026358 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0024 | 0024
1026368 | 1.NP_SO-102 | 1026368 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0025 | 0025
1026369 | 1.NP_SO-102 | 1026369 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0026 | 0026
1026377 | 1.NP_SO-102 | 1026377 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0027 | 0027
1026378 | 1.NP_SO-102 | 1026378 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0028 | 0028
1028862 | 1.NP_SO-102 | 1028862 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2608.04 | Fáze 1 | OL01.06.0074 | 0074
1028914 | 1.NP_SO-102 | 1028914 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0076 | 0076
1028985 | 3.NP_SO-102 | 1028985 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0080 | 0080
1029011 | 4.NP_SO-102 | 1029011 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 1108.04 | Fáze 2 | OL01.06.0084 | 0084
1029024 | 4.NP_SO-102 | 1029024 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 1108.04 | Fáze 2 | OL01.06.0087 | 0087
1029062 | 4.NP_SO-102 | 1029062 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 1108.04 | Fáze 2 | OL01.06.0091 | 0091
1029090 | 3.NP_SO-102 | 1029090 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1108.04 | Fáze 2 | OL01.06.0095 | 0095
1029104 | 3.NP_SO-102 | 1029104 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1108.04 | Fáze 2 | OL01.06.0099 | 0099
1029118 | 3.NP_SO-102 | 1029118 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0103 | 0103
1029132 | 3.NP_SO-102 | 1029132 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0107 | 0107
1029196 | 3.NP_SO-102 | 1029196 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0111 | 0111
1029254 | 3.NP_SO-102 | 1029254 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0118 | 0118
1029264 | 4.NP_SO-102 | 1029264 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0121 | 0121
1029357 | 4.NP_SO-102 | 1029357 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0127 | 0127
1029370 | 4.NP_SO-102 | 1029370 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0130 | 0130
1029555 | 4.NP_SO-102 | 1029555 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0134 | 0134
1029615 | 3.NP_SO-102 | 1029615 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0138 | 0138
1029629 | 3.NP_SO-102 | 1029629 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0141 | 0141
1029697 | 3.NP_SO-102 | 1029697 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0144 | 0144
1029758 | 2.NP_SO-102 | 1029758 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2608.04 | Fáze 1 | OL01.06.0148 | 0148
1029772 | 2.NP_SO-102 | 1029772 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2608.04 | Fáze 1 | OL01.06.0152 | 0152
1029786 | 2.NP_SO-102 | 1029786 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2608.04 | Fáze 1 | OL01.06.0155 | 0155
1029800 | 2.NP_SO-102 | 1029800 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2608.04 | Fáze 1 | OL01.06.0159 | 0159
1029814 | 2.NP_SO-102 | 1029814 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0162 | 0162
1029937 | 2.NP_SO-102 | 1029937 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0166 | 0166
1029988 | 2.NP_SO-102 | 1029988 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0170 | 0170
1030002 | 2.NP_SO-102 | 1030002 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0174 | 0174
1030016 | 2.NP_SO-102 | 1030016 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0177 | 0177
1030030 | 2.NP_SO-102 | 1030030 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0181 | 0181
1030044 | 2.NP_SO-102 | 1030044 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0184 | 0184
1030058 | 2.NP_SO-102 | 1030058 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0188 | 0188
1030072 | 2.NP_SO-102 | 1030072 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0192 | 0192
1030214 | 2.NP_SO-102 | 1030214 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0197 | 0197
1030230 | 2.NP_SO-102 | 1030230 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0201 | 0201
1089926 | 1.NP_SO-102 | 1089926 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0324 | 0324
1089927 | 1.NP_SO-102 | 1089927 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0325 | 0325
1089928 | 1.NP_SO-102 | 1089928 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0326 | 0326
1089929 | 1.NP_SO-102 | 1089929 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0327 | 0327
1089930 | 1.NP_SO-102 | 1089930 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0328 | 0328
1089931 | 1.NP_SO-102 | 1089931 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0329 | 0329
1090040 | 1.NP_SO-102 | 1090040 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0330 | 0330
1090053 | 1.NP_SO-102 | 1090053 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0334 | 0334
1090102 | 1.NP_SO-102 | 1090102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0338 | 0338
1090103 | 1.NP_SO-102 | 1090103 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0339 | 0339
1090783 | 1.NP_SO-102 | 1090783 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0343 | 0343
1090817 | 1.NP_SO-102 | 1090817 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0347 | 0347
1090841 | 1.NP_SO-102 | 1090841 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1180.13 | Fáze 1 | OL01.06.0350 | 0350
1090872 | 1.NP_SO-102 | 1090872 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 2 | OL01.06.0353 | 0353
1090908 | 1.NP_SO-102 | 1090908 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 2 | OL01.06.0357 | 0357
1090972 | 1.NP_SO-102 | 1090972 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 2 | OL01.06.0361 | 0361
1090983 | 1.NP_SO-102 | 1090983 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1108.04 | Fáze 2 | OL01.06.0364 | 0364
1091241 | 2.NP_SO-102 | 1091241 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0370 | 0370
1091490 | 2.NP_SO-102 | 1091490 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2608.04 | Fáze 1 | OL01.06.0375 | 0375
1091523 | 3.NP_SO-102 | 1091523 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0376 | 0376
1091536 | 3.NP_SO-102 | 1091536 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0380 | 0380
1091548 | 3.NP_SO-102 | 1091548 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1108.04 | Fáze 1 | OL01.06.0383 | 0383

# IfcBuildingElementProxy: Čtečka karet.CC:Typ 2 (20)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; PŘÍKON: 0 W
Type - Vazby - Výchozí výška: 1500 mm
Type - Elektrotechnika - NAPĚTÍ: 0 V
Type - Grafika - Symbol: yes
Type - Kóty - HLOUBKA: 50 mm; Hloubka zapuštění: 35.4392 mm; ŠÍŘKA: 100 mm; VÝŠKA: 200 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: OL01; Komentáře k typům: Komentáře k typům; Model: Model; Nadpis OmniClass: Access Controls; Název typu: Typ 2; Označení typu: 08; Popis: Popis; Popis sestavy: Čtečka karet; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - FAKTOR ÚČINNOSTI: 1; Kategorie: Zabezpečovací zařízení; Název rodiny: Čtečka karet.CC
Classification: OL01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.070267 m2; NetVolume: 0.00100006 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 0 V/1-0.0 kW
Text - CCI Funkční systém: M; CCI Komponenta: BYA; CCI Technický systém: JL
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.00100006 m3
Jiné - Rodina: Čtečka karet.CC; Id typu: 1025096; Rodina a typ: Čtečka karet.CC: Typ 2; Typ: Typ 2; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 04:20
Name (Čtečka karet.CC:Typ 2:...) | In | ID_import | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
1027645 | -1.PP_SO-102 | 1027645 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1500 | OL01.08.0032 | 0032
1027651 | -1.PP_SO-102 | 1027651 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1500 | OL01.08.0033 | 0033
1027657 | -1.PP_SO-102 | 1027657 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1500 | OL01.08.0034 | 0034
1027663 | -1.PP_SO-102 | 1027663 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1500 | OL01.08.0035 | 0035
1027669 | -1.PP_SO-102 | 1027669 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1500 | OL01.08.0036 | 0036
1027681 | -1.PP_SO-102 | 1027681 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1500 | OL01.08.0037 | 0037
1027977 | -1.PP_SO-102 | 1027977 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | OL01.08.0049 | 0049
1027990 | -1.PP_SO-102 | 1027990 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | OL01.08.0053 | 0053
1028004 | -1.PP_SO-102 | 1028004 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | OL01.08.0057 | 0057
1028185 | -1.PP_SO-102 | 1028185 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | OL01.08.0061 | 0061
1028482 | -1.PP_SO-102 | 1028482 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1500 | OL01.08.0070 | 0070
1032830 | -2.PP_SO-102 | 1032830 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 1500 | OL01.08.0301 | 0301
1032836 | -2.PP_SO-102 | 1032836 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 1500 | OL01.08.0302 | 0302
1032842 | -2.PP_SO-102 | 1032842 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 1500 | OL01.08.0303 | 0303
1032927 | -1.PP_SO-102 | 1032927 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | OL01.08.0305 | 0305
1033090 | -1.PP_SO-102 | 1033090 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1500 | OL01.08.0308 | 0308
1033122 | -1.PP_SO-102 | 1033122 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1500 | OL01.08.0311 | 0311
1089212 | -1.PP_SO-102 | 1089212 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1500 | OL01.08.0314 | 0314
1089220 | -1.PP_SO-102 | 1089220 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1500 | OL01.08.0315 | 0315
1089471 | -1.PP_SO-102 | 1089471 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | OL01.08.0320 | 0320

# IfcCableCarrierFitting: Hranaté_žlab_horizontální koleno.CC:Standardní (5)
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Kód sestavy: KT01; Název typu: Standardní; Označení typu: 09; Popis sestavy: Oblouk žlabů
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: Hranaté_žlab_horizontální koleno.CC
Classification: KT01 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL
Vazby - Podlaží: 1.NP_SO-102; Výška od podlaží: -60 mm
Fázování - Fáze vytvoření: Fáze 2
Grafika - Použít měřítko poznámky: yes
Kóty - Úhel: 90 deg; Objem: 0.004 m3; Poloměr ohybu: 100 mm; Šířka lávky: 200 mm; Tloušťka: 2.54 mm; Velikost: 200 mmx100 mmø-200 mmx100 mmø; Výška lávky: 100 mm
Jiné - Páteřní trasa: yes; Ohyb nebo tvarovka: Tvarovka; Max. úhel segmentace: 90 deg; Typ: Standardní; Id typu: 17658; Od středu ke konci: 100 mm; Rodina: Hranaté_žlab_horizontální koleno.CC; Rodina a typ: Hranaté_žlab_horizontální koleno.CC: Standardní; Štítek poloměru ohybu: 100 mm; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.14 01:02
Name (Hranaté_žlab_horizontální koleno.CC:Standardní:...) | ID_import | Kód prvku | Označení
971613 | 971613 | KT01.09.0109 | 0109
971717 | 971717 | KT01.09.0111 | 0111
971724 | 971724 | KT01.09.0112 | 0112
999824 | 999824 | KT01.09.0163 | 0163
999919 | 999919 | KT01.09.0164 | 0164

# IfcCableCarrierFitting: Hranaté_žlab_horizontální spoj T.CC:Standardní, Hranaté_žlab_horizontální spoj T.CC:Standardní:971646
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Kód sestavy: KT07; Název typu: Standardní; Označení typu: 10; Popis sestavy: Spojka
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: Hranaté_žlab_horizontální spoj T.CC
Classification: KT07 Uniformat (Uniformat)
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL; ID_import: 971646
Vazby - Podlaží: 1.NP_SO-102; Výška od podlaží: -60 mm
Fázování - Fáze vytvoření: Fáze 2
Grafika - Použít měřítko poznámky: yes
Kóty - Objem: 0.004 m3; Šířka lávky 1: 200 mm; Šířka lávky 3: 200 mm; Tloušťka: 2.54 mm; Velikost: 200 mmx100 mmø-200 mmx100 mmø-200 mmx100 mmø; Výška lávky: 100 mm
Identifikační data - Kód prvku: KT07.10.0110; Označení: 0110
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 17660; Rodina: Hranaté_žlab_horizontální spoj T.CC; Rodina a typ: Hranaté_žlab_horizontální spoj T.CC: Standardní; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 03:47

# IfcCableCarrierFitting: KOPOS JUPITER oblouk 90°:zinkování Sendzimir (3)
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Nastavit - Family collapse: no
Type - Text - Lookup Table Name: kontrola JUPITER - oblouk 90°_S
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: KT01; Komentáře k typům: JUPITER oblouk 90°; Model: Kabelové žlaby JUPITER; Název typu: zinkování Sendzimir; Označení typu: 04; Popis: oblouk 90°; Popis sestavy: Oblouk žlabů; URL: https://www.kopos.cz/cs; Výrobce: KOPOS KOLÍN a.s.
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: KOPOS JUPITER oblouk 90°
Classification: KT01 Uniformat (Uniformat)
Nastavit - Warnings: yes
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL
Vazby - Přesunout s blízkými prvky: no; Podlaží: 1.NP_SO-102; Výška od podlaží: 3140 mm
Fázování - Fáze vytvoření: Fáze 2
Kóty - A: 100 mm; DÉLKA: 300 mm; H: 60 mm; Objem: 0.00014095 m3; Plocha: 0.0101962 m2; Poloměr ohybu_x: 100 mm; Poloměr ohybu - vnitřní: 99 mm; TLOUŠŤKA PLECHU: 0.8 mm
Identifikační data - POLOŽKA: O 90X60X100_S
Jiné - Collapser: no; Typ: zinkování Sendzimir; Id typu: 562863; Ohyb nebo tvarovka: Tvarovka; Rodina: KOPOS JUPITER oblouk 90°; Rodina a typ: KOPOS JUPITER oblouk 90°: zinkování Sendzimir; W: no; csv_AH: 100 mm; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 11:50
Name (KOPOS JUPITER oblouk 90°:zinkování Sendzimir:...) | ID_import | Kód prvku | Označení
972584 | 972584 | KT01.04.0117 | 0117
972622 | 972622 | KT01.04.0120 | 0120
972628 | 972628 | KT01.04.0122 | 0122

# IfcCableCarrierFitting: KOPOS JUPITER oblouk 90°:zinkování Sendzimir (46)
Type - Material: Warnings, <Unnamed>
Type - Nastavit - Family collapse: no
Type - Text - Lookup Table Name: kontrola JUPITER - oblouk 90°_S
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: KT01; Komentáře k typům: JUPITER oblouk 90°; Model: Kabelové žlaby JUPITER; Název typu: zinkování Sendzimir; Označení typu: 04; Popis: oblouk 90°; Popis sestavy: Oblouk žlabů; URL: https://www.kopos.cz/cs; Výrobce: KOPOS KOLÍN a.s.
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: KOPOS JUPITER oblouk 90°
Classification: KT01 Uniformat (Uniformat)
Nastavit - Warnings: yes
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL; Poznámka: Koleno se v této velikosti nevyrábí
Vazby - Přesunout s blízkými prvky: no
Kóty - TLOUŠŤKA PLECHU: 0 mm; H: 50 mm; Objem: 0.00014095 m3; Plocha: 0.0101962 m2; Poloměr ohybu_x: 100 mm; Poloměr ohybu - vnitřní: 99 mm
Identifikační data - POLOŽKA: NEDEF
Jiné - Collapser: no; Typ: zinkování Sendzimir; W: yes; csv_AH: 0 mm; Id typu: 562863; Ohyb nebo tvarovka: Tvarovka; Rodina: KOPOS JUPITER oblouk 90°; Rodina a typ: KOPOS JUPITER oblouk 90°: zinkování Sendzimir
Name (KOPOS JUPITER oblouk 90°:zinkování Sendzimir:...) | In | ID_import | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | A (mm) | DÉLKA (mm) | Kód prvku | Označení | UPRAVIL
929353 | 3.NP_SO-102 | 929353 | 3.NP_SO-102 | 2650 | Fáze 1 | 300 | 500 | KT01.04.0005 | 0005 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
929396 | 3.NP_SO-102 | 929396 | 3.NP_SO-102 | 2650 | Fáze 1 | 300 | 500 | KT01.04.0007 | 0007 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
930517 | 4.NP_SO-102 | 930517 | 4.NP_SO-102 | 3650 | Fáze 1 | 200 | 400 | KT01.04.0020 | 0020 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
930528 | 4.NP_SO-102 | 930528 | 4.NP_SO-102 | 3650 | Fáze 1 | 200 | 400 | KT01.04.0022 | 0022 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
930536 | 4.NP_SO-102 | 930536 | 4.NP_SO-102 | 3650 | Fáze 1 | 200 | 400 | KT01.04.0024 | 0024 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
930542 | 4.NP_SO-102 | 930542 | 4.NP_SO-102 | 3650 | Fáze 1 | 200 | 400 | KT01.04.0026 | 0026 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
931157 | 2.NP_SO-102 | 931157 | 2.NP_SO-102 | 3650 | Fáze 1 | 100 | 300 | KT01.04.0031 | 0031 | Fruhauf.vinarice@seznam.cz 2023.07.25 08:27
931210 | 2.NP_SO-102 | 931210 | 2.NP_SO-102 | 3650 | Fáze 1 | 100 | 300 | KT01.04.0033 | 0033 | Fruhauf.vinarice@seznam.cz 2023.07.25 07:55
931216 | 2.NP_SO-102 | 931216 | 2.NP_SO-102 | 3650 | Fáze 1 | 100 | 300 | KT01.04.0035 | 0035 | Fruhauf.vinarice@seznam.cz 2023.07.25 07:55
931233 | 2.NP_SO-102 | 931233 | 2.NP_SO-102 | 3650 | Fáze 1 | 100 | 300 | KT01.04.0041 | 0041 | Fruhauf.vinarice@seznam.cz 2023.07.25 07:55
931254 | 2.NP_SO-102 | 931254 | 2.NP_SO-102 | 3650 | Fáze 1 | 100 | 300 | KT01.04.0043 | 0043 | Fruhauf.vinarice@seznam.cz 2023.07.25 08:27
931322 | 2.NP_SO-102 | 931322 | 2.NP_SO-102 | 3650 | Fáze 1 | 100 | 300 | KT01.04.0045 | 0045 | Fruhauf.vinarice@seznam.cz 2023.07.25 08:27
931337 | 2.NP_SO-102 | 931337 | 2.NP_SO-102 | 3650 | Fáze 1 | 100 | 300 | KT01.04.0048 | 0048 | Fruhauf.vinarice@seznam.cz 2023.07.25 08:27
931453 | 1.NP_SO-102 | 931453 | 1.NP_SO-102 | 3650 | Fáze 1 | 200 | 400 | KT01.04.0050 | 0050 | Fruhauf.vinarice@seznam.cz 2023.07.21 10:20
931461 | 1.NP_SO-102 | 931461 | 1.NP_SO-102 | 3650 | Fáze 1 | 200 | 400 | KT01.04.0052 | 0052 | Fruhauf.vinarice@seznam.cz 2023.07.21 10:20
931467 | 1.NP_SO-102 | 931467 | 1.NP_SO-102 | 3650 | Fáze 1 | 200 | 400 | KT01.04.0054 | 0054 | Fruhauf.vinarice@seznam.cz 2023.07.21 10:20
931475 | 1.NP_SO-102 | 931475 | 1.NP_SO-102 | 3650 | Fáze 1 | 200 | 400 | KT01.04.0056 | 0056 | Fruhauf.vinarice@seznam.cz 2023.07.21 10:20
931646 | 3.NP_SO-102 | 931646 | 3.NP_SO-102 | 3650 | Fáze 1 | 100 | 300 | KT01.04.0064 | 0064 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
931867 | 3.NP_SO-102 | 931867 | 3.NP_SO-102 | 3650 | Fáze 1 | 100 | 300 | KT01.04.0068 | 0068 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
931941 | 4.NP_SO-102 | 931941 | 4.NP_SO-102 | 3650 | Fáze 1 | 200 | 400 | KT01.04.0070 | 0070 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
931960 | 4.NP_SO-102 | 931960 | 4.NP_SO-102 | 3650 | Fáze 1 | 200 | 400 | KT01.04.0073 | 0073 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
931983 | 4.NP_SO-102 | 931983 | 4.NP_SO-102 | 3650 | Fáze 1 | 200 | 400 | KT01.04.0076 | 0076 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
932039 | 4.NP_SO-102 | 932039 | 4.NP_SO-102 | 3650 | Fáze 1 | 100 | 300 | KT01.04.0080 | 0080 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
932054 | 4.NP_SO-102 | 932054 | 4.NP_SO-102 | 3650 | Fáze 1 | 100 | 300 | KT01.04.0082 | 0082 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
932069 | 4.NP_SO-102 | 932069 | 4.NP_SO-102 | 3650 | Fáze 1 | 100 | 300 | KT01.04.0084 | 0084 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
932091 | 4.NP_SO-102 | 932091 | 4.NP_SO-102 | 3650 | Fáze 1 | 100 | 300 | KT01.04.0089 | 0089 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
932256 | 3.NP_SO-102 | 932256 | 3.NP_SO-102 | 3650 | Fáze 1 | 100 | 300 | KT01.04.0095 | 0095 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
934091 | 1.NP_SO-102 | 934091 | 1.NP_SO-102 | 3140 | Fáze 1 | 400 | 600 | KT01.04.0101 | 0101 | Fruhauf.vinarice@seznam.cz 2023.07.25 09:56
971915 | 1.NP_SO-102 | 971915 | 1.NP_SO-102 | 3140 | Fáze 2 | 300 | 500 | KT01.04.0114 | 0114 | Fruhauf.vinarice@seznam.cz 2023.07.19 11:50
993847 | 2.NP_SO-102 | 993847 | 2.NP_SO-102 | 3650 | Fáze 1 | 200 | 400 | KT01.04.0125 | 0125 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
993945 | 2.NP_SO-102 | 993945 | 2.NP_SO-102 | 3650 | Fáze 1 | 100 | 300 | KT01.04.0127 | 0127 | Fruhauf.vinarice@seznam.cz 2023.07.25 08:27
994664 | 3.NP_SO-102 | 994664 | 3.NP_SO-102 | 3240 | Fáze 1 | 100 | 300 | KT01.04.0129 | 0129 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
994666 | 3.NP_SO-102 | 994666 | 3.NP_SO-102 | 3240 | Fáze 1 | 100 | 300 | KT01.04.0131 | 0131 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
995010 | 3.NP_SO-102 | 995010 | 3.NP_SO-102 | 3240 | Fáze 1 | 100 | 300 | KT01.04.0136 | 0136 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
995012 | 3.NP_SO-102 | 995012 | 3.NP_SO-102 | 3240 | Fáze 1 | 100 | 300 | KT01.04.0138 | 0138 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
998923 | 1.NP_SO-102 | 998923 | 1.NP_SO-102 | 3240 | Fáze 1 | 200 | 400 | KT01.04.0161 | 0161 | Fruhauf.vinarice@seznam.cz 2023.07.21 10:20
1157626 | 2.NP_SO-102 |  | 2.NP_SO-102 | 3210 | Fáze 1 | 200 | 400 | KT01.04.0184 | 0184 | Fruhauf.vinarice@seznam.cz 2023.07.19 12:45
1157628 | 2.NP_SO-102 |  | 2.NP_SO-102 | 3210 | Fáze 1 | 200 | 400 | KT01.04.0186 | 0186 | Fruhauf.vinarice@seznam.cz 2023.07.25 07:53
1161726 | 2.NP_SO-102 |  | 2.NP_SO-102 | 3280 | Fáze 1 | 100 | 300 | KT01.04.0235 | 0235 | Fruhauf.vinarice@seznam.cz 2023.07.25 08:00
1161728 | 2.NP_SO-102 |  | 2.NP_SO-102 | 3280 | Fáze 1 | 100 | 300 | KT01.04.0237 | 0237 | Fruhauf.vinarice@seznam.cz 2023.07.25 08:27
1168677 | 4.NP_SO-102 |  | 4.NP_SO-102 | 3240 | Fáze 1 | 200 | 400 | KT01.04.0302 | 0302 | Fruhauf.vinarice@seznam.cz 2023.08.10 01:08
1168709 | 4.NP_SO-102 |  | 4.NP_SO-102 | 3240 | Fáze 1 | 200 | 400 | KT01.04.0304 | 0304 | Fruhauf.vinarice@seznam.cz 2023.08.10 01:08
1168977 | 4.NP_SO-102 |  | 4.NP_SO-102 | 3340 | Fáze 1 | 200 | 400 | KT01.04.0312 | 0312 | Fruhauf.vinarice@seznam.cz 2023.08.10 01:08
1172301 | 3.NP_SO-102 |  | 3.NP_SO-102 | 3240 | Fáze 1 | 100 | 300 | KT01.04.0316 | 0316
1174494 | 1.NP_SO-102 |  | 1.NP_SO-102 | 3340 | Fáze 2 | 300 | 500 | KT01.04.0363 | 0363
1174940 | 4.NP_SO-102 |  | 4.NP_SO-102 | 3340 | Fáze 1 | 200 | 400 | KT01.04.0382 | 0382

# IfcCableCarrierFitting: KOPOS JUPITER oblouk klesající 90°:zinkování Sendzimir (6)
Type - Material: Warnings, <Unnamed>
Type - Nastavit - Family collapse: no
Type - Text - Lookup Table Name: kontrola JUPITER - oblouk klesající 90°_S
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.17.17; Copyright: © cadconsulting, spol. s r.o.; Komentáře k typům: JUPITER oblouk klesající 90°; Model: Kabelové žlaby JUPITER; Nadpis OmniClass: Cable Trays and Horizontal Racks; Název typu: zinkování Sendzimir; Označení typu: 17; Popis: oblouk klesající 90°; URL: https://www.kopos.cz/cs; Výrobce: KOPOS KOLÍN a.s.
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: KOPOS JUPITER oblouk klesající 90°
Nastavit - Warnings: yes
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL
Vazby - Přesunout s blízkými prvky: no; Výška od podlaží: 3240 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - B: 241 mm; DÉLKA: 212.058 mm; H: 50 mm; Objem: 0.00014095 m3; Plocha: 0.0101962 m2; TLOUŠŤKA PLECHU: 1 mm
Identifikační data - POLOŽKA: NEDEF
Jiné - Collapser: no; Typ: zinkování Sendzimir; W: yes; csv_AH: 0 mm; Ohyb nebo tvarovka: Tvarovka; Id typu: 562817; Rodina: KOPOS JUPITER oblouk klesající 90°; Rodina a typ: KOPOS JUPITER oblouk klesající 90°: zinkování Sendzimir
Name (KOPOS JUPITER oblouk klesající 90°:zinkování Sendzimir:...) | In | Podlaží | A (mm) | Kód prvku | Označení
1172296 | 3.NP_SO-102 | 3.NP_SO-102 | 100 | .17.0314 | 0314
1172327 | 3.NP_SO-102 | 3.NP_SO-102 | 100 | .17.0318 | 0318
1176515 | 4.NP_SO-102 | 4.NP_SO-102 | 200 | .17.0405 | 0405
1177659 | 3.NP_SO-102 | 3.NP_SO-102 | 200 | .17.0441 | 0441
1179152 | 3.NP_SO-102 | 3.NP_SO-102 | 200 | .17.0480 | 0480
1179158 | 3.NP_SO-102 | 3.NP_SO-102 | 200 | .17.0482 | 0482

# IfcCableCarrierFitting: KOPOS JUPITER oblouk stoupající 90°:zinkování Sendzimir (6)
Type - Material: Warnings, <Unnamed>
Type - Nastavit - Family collapse: no
Type - Text - Lookup Table Name: kontrola JUPITER - oblouk stoupající 90°_S
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.17.17; Copyright: © cadconsulting, spol. s r.o.; Komentáře k typům: Komentáře k typům; Model: Kabelové žlaby JUPITER; Nadpis OmniClass: Cable Trays and Horizontal Racks; Název typu: zinkování Sendzimir; Označení typu: 18; Popis: oblouk stoupající 90°; URL: https://www.kopos.cz/cs; Výrobce: KOPOS KOLÍN a.s.
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: KOPOS JUPITER oblouk stoupající 90°
Nastavit - Warnings: yes
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL; Poznámka: oblouk této velikosti se nedodává
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - B: 241 mm; DÉLKA: 274.889 mm; H: 50 mm; Objem: 0.00014095 m3; Plocha: 0.0101962 m2; TLOUŠŤKA PLECHU: 1 mm; tl plechu: 1 mm
Identifikační data - POLOŽKA: NEDEF
Jiné - Collapser: no; Typ: zinkování Sendzimir; W: yes; csv_AH: 0 mm; Ohyb nebo tvarovka: Tvarovka; Id typu: 562816; Rodina: KOPOS JUPITER oblouk stoupající 90°; Rodina a typ: KOPOS JUPITER oblouk stoupající 90°: zinkování Sendzimir
Name (KOPOS JUPITER oblouk stoupající 90°:zinkování Sendzimir:...) | In | Podlaží | Výška od podlaží (mm) | A (mm) | Kód prvku | Označení
1172337 | 3.NP_SO-102 | 3.NP_SO-102 | 2749.82 | 100 | .18.0320 | 0320
1172385 | 3.NP_SO-102 | 3.NP_SO-102 | 2749.82 | 100 | .18.0322 | 0322
1176545 | 4.NP_SO-102 | 4.NP_SO-102 | 2825 | 200 | .18.0407 | 0407
1177655 | 3.NP_SO-102 | 3.NP_SO-102 | 2620 | 200 | .18.0439 | 0439
1178788 | 3.NP_SO-102 | 3.NP_SO-102 | 2740 | 200 | .18.0467 | 0467
1179148 | 3.NP_SO-102 | 3.NP_SO-102 | 2800 | 200 | .18.0478 | 0478

# IfcCableCarrierFitting: KOPOS JUPITER redukce:zinkování Sendzimir (16)
Type - Material: <Unnamed>
Type - Nastavit - Family collapse: no
Type - Text - Lookup Table Name: kontrola JUPITER - redukce_S
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - tl stěny lávky: 2.5 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.17.17; Copyright: © cadconsulting, spol. s r.o.; Kód sestavy: KT07; Komentáře k typům: JUPITER redukce; Model: Kabelové žlaby JUPITER; Nadpis OmniClass: Cable Trays and Horizontal Racks; Název typu: zinkování Sendzimir; Označení typu: 02; Popis: redukce; Popis sestavy: Spojka; URL: https://www.kopos.cz/cs; Výrobce: KOPOS KOLÍN a.s.
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: KOPOS JUPITER redukce
Classification: KT07 Uniformat (Uniformat)
Nastavit - Warnings: yes
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL
Vazby - Přesunout s blízkými prvky: no
Kóty - Objem: 0.00014095 m3; Plocha: 0.0101962 m2
Jiné - Collapser: no; Id typu: 562823; Rodina: KOPOS JUPITER redukce; Rodina a typ: KOPOS JUPITER redukce: zinkování Sendzimir; Typ: zinkování Sendzimir
Name (KOPOS JUPITER redukce:zinkování Sendzimir:...) | In | ID_import | Poznámka | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | A (mm) | A1 (mm) | A2 (mm) | H (mm) | Hspojky (mm) | TLOUŠŤKA PLECHU (mm) | Kód prvku | Označení | POLOŽKA | csv_HA (mm) | UPRAVIL | W | Material
927850 | 4.NP_SO-102 | 927850 | redukce se v této velikosti nedodává | 4.NP_SO-102 | 3650 | Fáze 1 | -100 | 0 | 101 | 50 | 40 | 0 | KT07.02.0002 | 0002 | NEDEF | 0 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47 | yes
931230 | 2.NP_SO-102 | 931230 | redukce se v této velikosti nedodává | 2.NP_SO-102 | 3650 | Fáze 1 | -50 | 0 | 51 | 50 | 40 | 0 | KT07.02.0038 | 0038 | NEDEF | 0 | Fruhauf.vinarice@seznam.cz 2023.07.25 07:53 | yes
932071 | 4.NP_SO-102 | 932071 | redukce se v této velikosti nedodává | 4.NP_SO-102 | 3650 | Fáze 1 | 50 | 50 | 1 | 50 | 40 | 0 | KT07.02.0086 | 0086 | NEDEF | 0 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47 | yes
932093 | 4.NP_SO-102 | 932093 | redukce se v této velikosti nedodává | 4.NP_SO-102 | 3650 | Fáze 1 | 50 | 50 | 1 | 50 | 40 | 0 | KT07.02.0091 | 0091 | NEDEF | 0 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47 | yes | Warnings, <Unnamed>
996801 | 3.NP_SO-102 | 996801 | redukce se v této velikosti nedodává | 3.NP_SO-102 | 3240 | Fáze 1 | -100 | 0 | 101 | 50 | 40 | 0 | KT07.02.0145 | 0145 | NEDEF | 0 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47 | yes | Warnings, <Unnamed>
996803 | 3.NP_SO-102 | 996803 | redukce se v této velikosti nedodává | 3.NP_SO-102 | 3240 | Fáze 1 | 100 | 100 | 1 | 50 | 40 | 0 | KT07.02.0147 | 0147 | NEDEF | 0 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47 | yes
997349 | 3.NP_SO-102 | 997349 | redukce se v této velikosti nedodává | 3.NP_SO-102 | 3240 | Fáze 1 | -50 | 0 | 51 | 50 | 40 | 0 | KT07.02.0151 | 0151 | NEDEF | 0 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:21 | yes | Warnings, <Unnamed>
998742 | 1.NP_SO-102 | 998742 | redukce se v této velikosti nedodává | 1.NP_SO-102 | 3140 | Fáze 1 | -50 | 0 | 51 | 50 | 40 | 0 | KT07.02.0158 | 0158 | NEDEF | 0 | Fruhauf.vinarice@seznam.cz 2023.07.19 11:53 | yes | Warnings, <Unnamed>
1002993 | 3.NP_SO-102 | 1002993 | redukce se v této velikosti nedodává | 3.NP_SO-102 | 3240 | Fáze 1 | -100 | 0 | 101 | 50 | 40 | 0 | KT07.02.0167 | 0167 | NEDEF | 0 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47 | yes | Warnings, <Unnamed>
1163421 | 3.NP_SO-102 |  | redukce se v této velikosti nedodává | 3.NP_SO-102 | 3240 | Fáze 1 | 50 | 50 | 1 | 50 | 40 | 0 | KT07.02.0245 | 0245 | NEDEF | 0 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:21 | yes | Warnings, <Unnamed>
1167266 | 3.NP_SO-102 |  | redukce se v této velikosti nedodává | 3.NP_SO-102 | 3240 | Fáze 1 | -50 | 0 | 51 | 50 | 40 | 0 | KT07.02.0293 | 0293 | NEDEF | 0 | Fruhauf.vinarice@seznam.cz 2023.08.10 09:12 | yes | Warnings, <Unnamed>
1173886 | 1.NP_SO-102 |  |  | 1.NP_SO-102 | 3340 | Fáze 2 | -100 | 0 | 101 | 60 | 50 | 1 | KT07.02.0345 | 0345 | SR 60X100_S | 100 |  | no
1173887 | 1.NP_SO-102 |  |  | 1.NP_SO-102 | 3340 | Fáze 2 | -100 | 0 | 101 | 60 | 50 | 1 | KT07.02.0346 | 0346 | SR 60X100_S | 100 |  | no
1178796 | 3.NP_SO-102 |  | redukce se v této velikosti nedodává | 3.NP_SO-102 | 3240 | Fáze 1 | 50 | 50 | 1 | 50 | 40 | 0 | KT07.02.0469 | 0469 | NEDEF | 0 |  | yes | Warnings, <Unnamed>
1179309 | 1.NP_SO-102 |  | redukce se v této velikosti nedodává | 1.NP_SO-102 | 3225 | Fáze 1 | -100 | 0 | 101 | 50 | 40 | 0 | KT07.02.0499 | 0499 | NEDEF | 0 |  | yes | Warnings, <Unnamed>
1180930 | 1.NP_SO-102 |  | redukce se v této velikosti nedodává | 1.NP_SO-102 | 3330 | Fáze 2 | -50 | 0 | 51 | 50 | 40 | 0 | KT07.02.0502 | 0502 | NEDEF | 0 |  | yes | Warnings, <Unnamed>

# IfcCableCarrierFitting: KOPOS JUPITER redukce:zinkování Sendzimir (14)
Type - Material: Warnings, <Unnamed>
Type - Nastavit - Family collapse: no
Type - Text - Lookup Table Name: kontrola JUPITER - redukce_S
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - tl stěny lávky: 2.5 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.17.17; Copyright: © cadconsulting, spol. s r.o.; Kód sestavy: KT07; Komentáře k typům: JUPITER redukce; Model: Kabelové žlaby JUPITER; Nadpis OmniClass: Cable Trays and Horizontal Racks; Název typu: zinkování Sendzimir; Označení typu: 02; Popis: redukce; Popis sestavy: Spojka; URL: https://www.kopos.cz/cs; Výrobce: KOPOS KOLÍN a.s.
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: KOPOS JUPITER redukce
Classification: KT07 Uniformat (Uniformat)
Nastavit - Warnings: yes
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL; Poznámka: redukce se v této velikosti nedodává
Vazby - Přesunout s blízkými prvky: no
Kóty - TLOUŠŤKA PLECHU: 0 mm; H: 50 mm; Hspojky: 40 mm; Objem: 0.00014095 m3; Plocha: 0.0101962 m2
Identifikační data - POLOŽKA: NEDEF
Jiné - Collapser: no; csv_HA: 0 mm; Id typu: 562823; Rodina: KOPOS JUPITER redukce; Rodina a typ: KOPOS JUPITER redukce: zinkování Sendzimir; Typ: zinkování Sendzimir; W: yes
Name (KOPOS JUPITER redukce:zinkování Sendzimir:...) | In | ID_import | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | A1 (mm) | A (mm) | A2 (mm) | Kód prvku | Označení | UPRAVIL
927851 | 4.NP_SO-102 | 927851 | 4.NP_SO-102 | 3650 | Fáze 1 | 0 | -100 | 101 | KT07.02.0003 | 0003 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
931231 | 2.NP_SO-102 | 931231 | 2.NP_SO-102 | 3650 | Fáze 1 | 0 | -50 | 51 | KT07.02.0039 | 0039 | Fruhauf.vinarice@seznam.cz 2023.07.25 07:53
932072 | 4.NP_SO-102 | 932072 | 4.NP_SO-102 | 3650 | Fáze 1 | 50 | 50 | 1 | KT07.02.0087 | 0087 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
932094 | 4.NP_SO-102 | 932094 | 4.NP_SO-102 | 3650 | Fáze 1 | 50 | 50 | 1 | KT07.02.0092 | 0092 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
996802 | 3.NP_SO-102 | 996802 | 3.NP_SO-102 | 3240 | Fáze 1 | 0 | -100 | 101 | KT07.02.0146 | 0146 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
996804 | 3.NP_SO-102 | 996804 | 3.NP_SO-102 | 3240 | Fáze 1 | 100 | 100 | 1 | KT07.02.0148 | 0148 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
997350 | 3.NP_SO-102 | 997350 | 3.NP_SO-102 | 3240 | Fáze 1 | 0 | -50 | 51 | KT07.02.0152 | 0152 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:21
998743 | 1.NP_SO-102 | 998743 | 1.NP_SO-102 | 3140 | Fáze 1 | 0 | -50 | 51 | KT07.02.0159 | 0159 | Fruhauf.vinarice@seznam.cz 2023.07.19 11:53
1002994 | 3.NP_SO-102 | 1002994 | 3.NP_SO-102 | 3240 | Fáze 1 | 0 | -100 | 101 | KT07.02.0168 | 0168 | Fruhauf.vinarice@seznam.cz 2023.06.26 03:47
1163422 | 3.NP_SO-102 |  | 3.NP_SO-102 | 3240 | Fáze 1 | 50 | 50 | 1 | KT07.02.0246 | 0246 | Fruhauf.vinarice@seznam.cz 2023.08.10 08:21
1167267 | 3.NP_SO-102 |  | 3.NP_SO-102 | 3240 | Fáze 1 | 0 | -50 | 51 | KT07.02.0294 | 0294 | Fruhauf.vinarice@seznam.cz 2023.08.10 09:12
1178797 | 3.NP_SO-102 |  | 3.NP_SO-102 | 3240 | Fáze 1 | 50 | 50 | 1 | KT07.02.0470 | 0470
1179310 | 1.NP_SO-102 |  | 1.NP_SO-102 | 3225 | Fáze 1 | 0 | -100 | 101 | KT07.02.0500 | 0500
1180931 | 1.NP_SO-102 |  | 1.NP_SO-102 | 3330 | Fáze 2 | 0 | -50 | 51 | KT07.02.0503 | 0503

# IfcCableCarrierFitting: KOPOS JUPITER spojka kloubová:neelektrolytické pokovení (45)
Type - Material: <Unnamed>
Type - Nastavit - Family collapse: no
Type - Text - Lookup Table Name: kontrola JUPITER - spojka kloubová_GMT
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - tl stěny žlabu: 2.5 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.80.30.17.17; Copyright: © cadconsulting, spol. s r.o.; Kód sestavy: KT07; Komentáře k typům: JUPITER spojka kloubová; Model: Kabelové žlaby JUPITER; Nadpis OmniClass: Cable Trays and Horizontal Racks; Název typu: neelektrolytické pokovení; Označení typu: 14; Popis: spojka kloubová; Popis sestavy: Spojka; URL: https://www.kopos.cz/cs; Výrobce: KOPOS KOLÍN a.s.
Type - Jiné - Kategorie: Tvarovky kabelové lávky; Název rodiny: KOPOS JUPITER spojka kloubová
Classification: KT07 Uniformat (Uniformat)
Nastavit - Warnings: yes
Text - CCI Funkční systém: M; CCI Komponenta: UBA; CCI Technický systém: JL
Vazby - Přesunout s blízkými prvky: no
Kóty - Tloušťka: 0 mm; Objem: 0.00014095 m3; Plocha: 0.0101962 m2; T: 1 mm
Jiné - Collapser: no; Ohyb nebo tvarovka: Tvarovka; Id typu: 562813; Rodina: KOPOS JUPITER spojka kloubová; Rodina a typ: KOPOS JUPITER spojka kloubová: neelektrolytické pokovení; Typ: neelektrolytické pokovení
Name (KOPOS JUPITER spojka kloubová:neelektrolytické pokovení:...) | In | Material | Poznámka | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | TLOUŠŤKA PLECHU (mm) | DÉLKA (mm) | H (mm) | Hspojky (mm) | Od středu ke konci (mm) | Úhel (deg) | Kód prvku | Označení | POLOŽKA | W | csv_H (mm)
1158146 | 2.NP_SO-102 | Warnings, <Unnamed> | spojka této velikosti se nedodává | 2.NP_SO-102 | 10940 | Fáze 1 | 0 | 0 | 50 | 43 | 14.1178 | 31.5348 | KT07.14.0189 | 0189 | NEDEF | yes | 0 | Jiné - UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.07.19 12:48
