Properties of the parts of a building model (IFC4), part 27 of 60

# IfcFlowTerminal: Baterie umyvadlová stojánková:Baterie umyvadlová stojánková (112)
Name (Baterie umyvadlová stojánková:Baterie umyvadlová stojánková:...) | In | Podlaží = Vztažné podlaží | Výška od podlaží (mm) | Fáze vytvoření | Název systému | Kód prvku | Název sestavy | Označení | Group
12892905 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 89,WS_Studená vnitřní 88 | ZT09.08.0382 | Umyvadlo + modul | 0382 | WS_Teplá vnitřní 89; WS_Studená vnitřní 88
12893036 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 91,WS_Studená vnitřní 90 | ZT09.08.0386 | Umyvadlo + modul | 0386 | WS_Teplá vnitřní 91; WS_Studená vnitřní 90
12893161 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 93,WS_Studená vnitřní 92 | ZT09.08.0390 | Umyvadlo + modul | 0390 | WS_Teplá vnitřní 93; WS_Studená vnitřní 92
12894062 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 98,WS_Studená vnitřní 94 | ZT09.08.0409 | Umyvadlo + modul | 0409 | WS_Teplá vnitřní 98; WS_Studená vnitřní 94
12894128 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 99,WS_Studená vnitřní 95 | ZT09.08.0413 | Umyvadlo + modul | 0413 | WS_Teplá vnitřní 99; WS_Studená vnitřní 95
12894207 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 100,WS_Studená vnitřní 96 | ZT09.08.0417 | Umyvadlo + modul | 0417 | WS_Teplá vnitřní 100; WS_Studená vnitřní 96
12894271 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 101,WS_Studená vnitřní 97 | ZT09.08.0421 | Umyvadlo + modul | 0421 | WS_Teplá vnitřní 101; WS_Studená vnitřní 97
12894332 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 102,WS_Studená vnitřní 98 | ZT09.08.0425 | Umyvadlo + modul | 0425 | WS_Teplá vnitřní 102; WS_Studená vnitřní 98
12894677 | -2.PP_SO-102 | -1.PP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 103,WS_Studená vnitřní 99 | ZT09.08.0432 | Umyvadlo + modul | 0432 | WS_Teplá vnitřní 103; WS_Studená vnitřní 99
12894791 | -1.PP_SO-102 | 1.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 104,WS_Studená vnitřní 100 | ZT09.08.0436 | Umyvadlo + modul | 0436 | WS_Teplá vnitřní 104; WS_Studená vnitřní 100
12895101 | -1.PP_SO-102 | 1.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 105,WS_Studená vnitřní 101 | ZT09.08.0452 | Umyvadlo + modul | 0452 | WS_Teplá vnitřní 105; WS_Studená vnitřní 101
12895284 | -1.PP_SO-102 | 1.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 106,WS_Studená vnitřní 102 | ZT09.08.0459 | Umyvadlo + modul | 0459 | WS_Teplá vnitřní 106; WS_Studená vnitřní 102
12895308 | -1.PP_SO-102 | 1.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 107,WS_Studená vnitřní 103 | ZT09.08.0463 | Umyvadlo + modul | 0463 | WS_Teplá vnitřní 107; WS_Studená vnitřní 103
12895439 | -1.PP_SO-102 | 1.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 110,WS_Studená vnitřní 106 | ZT09.08.0467 | Umyvadlo + modul | 0467 | WS_Teplá vnitřní 110; WS_Studená vnitřní 106
12895785 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 113,WS_Studená vnitřní 109 | ZT09.08.0471 | Umyvadlo + modul | 0471 | WS_Teplá vnitřní 113; WS_Studená vnitřní 109
12896139 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 114,WS_Studená vnitřní 110 | ZT09.08.0487 | Umyvadlo + modul | 0487 | WS_Teplá vnitřní 114; WS_Studená vnitřní 110
12896339 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 115,WS_Studená vnitřní 111 | ZT09.08.0494 | Umyvadlo + modul | 0494 | WS_Teplá vnitřní 115; WS_Studená vnitřní 111
12896407 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 116,WS_Studená vnitřní 112 | ZT09.08.0498 | Umyvadlo + modul | 0498 | WS_Teplá vnitřní 116; WS_Studená vnitřní 112
12896720 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 120,WS_Studená vnitřní 116 | ZT09.08.0502 | Umyvadlo + modul | 0502 | WS_Teplá vnitřní 120; WS_Studená vnitřní 116
12896780 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 121,WS_Studená vnitřní 117 | ZT09.08.0506 | Umyvadlo + modul | 0506 | WS_Teplá vnitřní 121; WS_Studená vnitřní 117
12896896 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 122,WS_Studená vnitřní 118 | ZT09.08.0510 | Umyvadlo + modul | 0510 | WS_Teplá vnitřní 122; WS_Studená vnitřní 118
12896920 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 123,WS_Studená vnitřní 119 | ZT09.08.0514 | Umyvadlo + modul | 0514 | WS_Teplá vnitřní 123; WS_Studená vnitřní 119
12897293 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 124,WS_Studená vnitřní 120 | ZT09.08.0533 | Umyvadlo + modul | 0533 | WS_Teplá vnitřní 124; WS_Studená vnitřní 120
12897366 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 125,WS_Studená vnitřní 121 | ZT09.08.0537 | Umyvadlo + modul | 0537 | WS_Teplá vnitřní 125; WS_Studená vnitřní 121
12897417 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 127,WS_Studená vnitřní 123 | ZT09.08.0541 | Umyvadlo + modul | 0541 | WS_Teplá vnitřní 127; WS_Studená vnitřní 123
12897448 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 128,WS_Studená vnitřní 124 | ZT09.08.0545 | Umyvadlo + modul | 0545 | WS_Teplá vnitřní 128; WS_Studená vnitřní 124
12897755 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 130,WS_Studená vnitřní 126 | ZT09.08.0549 | Umyvadlo + modul | 0549 | WS_Teplá vnitřní 130; WS_Studená vnitřní 126
12897779 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 131,WS_Studená vnitřní 127 | ZT09.08.0553 | Umyvadlo + modul | 0553 | WS_Teplá vnitřní 131; WS_Studená vnitřní 127
12898203 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 132,WS_Studená vnitřní 128 | ZT09.08.0572 | Umyvadlo + modul | 0572 | WS_Teplá vnitřní 132; WS_Studená vnitřní 128
12898227 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 133,WS_Studená vnitřní 129 | ZT09.08.0576 | Umyvadlo + modul | 0576 | WS_Teplá vnitřní 133; WS_Studená vnitřní 129
12898549 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 135,WS_Studená vnitřní 131 | ZT09.08.0580 | Umyvadlo + modul | 0580 | WS_Teplá vnitřní 135; WS_Studená vnitřní 131
12898600 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 137,WS_Studená vnitřní 133 | ZT09.08.0584 | Umyvadlo + modul | 0584 | WS_Teplá vnitřní 137; WS_Studená vnitřní 133
12899105 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 79,WS_Studená vnitřní 50 | ZT09.08.0588 | Umyvadlo + modul | 0588 | WS_Teplá vnitřní 79; WS_Studená vnitřní 50
12899476 | -1.PP_SO-102 | 1.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 57,WS_Studená vnitřní 56 | ZT09.08.0598 | Umyvadlo + modul | 0598 | WS_Teplá vnitřní 57; WS_Studená vnitřní 56
12899626 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 139,WS_Studená vnitřní 135 | ZT09.08.0608 | Umyvadlo + modul | 0608 | WS_Teplá vnitřní 139; WS_Studená vnitřní 135
12992018 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 183,WS_Studená vnitřní 76 | ZT09.08.0624 | Umyvadlo + modul | 0624 | WS_Teplá vnitřní 183; WS_Studená vnitřní 76
12992036 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 78,WS_Studená vnitřní 77 | ZT09.08.0628 | Umyvadlo + modul | 0628 | WS_Teplá vnitřní 78; WS_Studená vnitřní 77
13068782 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 199,WS_Studená vnitřní 200 | ZT09.08.0645 | Umyvadlo + modul | 0645 | WS_Teplá vnitřní 199; WS_Studená vnitřní 200
13068920 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 200,WS_Studená vnitřní 201 | ZT09.08.0649 | Umyvadlo + modul | 0649 | WS_Teplá vnitřní 200; WS_Studená vnitřní 201
13071951 | -1.PP_SO-102 | 1.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 37,WS_Studená vnitřní 36 | ZT09.08.0653 | Umyvadlo + modul | 0653 | WS_Teplá vnitřní 37; WS_Studená vnitřní 36
13102571 | -1.PP_SO-102 | 1.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 12,WS_Studená vnitřní 4 | ZT09.08.0657 | Umyvadlo + modul | 0657 | WS_Teplá vnitřní 12; WS_Studená vnitřní 4
13102686 | -1.PP_SO-102 | 1.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 14,WS_Studená vnitřní 9 | ZT09.08.0661 | Umyvadlo + modul | 0661 | WS_Teplá vnitřní 14; WS_Studená vnitřní 9
13105041 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 15,WS_Studená vnitřní 10 | ZT09.08.0665 | Umyvadlo + modul | 0665 | WS_Teplá vnitřní 15; WS_Studená vnitřní 10
13154257 | -1.PP_SO-102 | 1.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 13,WS_Studená vnitřní 8 | ZT09.08.0686 | Umyvadlo + modul | 0686 | WS_Teplá vnitřní 13; WS_Studená vnitřní 8
13401878 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 36,WS_Studená vnitřní 91 | ZT09.08.0737 | Umyvadlo | 0737 | WS_Teplá vnitřní 36; WS_Studená vnitřní 91
13505818 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 90,WS_Studená vnitřní 138 | ZT09.08.0746 | Umyvadlo + modul | 0746 | WS_Teplá vnitřní 90; WS_Studená vnitřní 138
13505926 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 117,WS_Studená vnitřní 114 | ZT09.08.0750 | Umyvadlo + modul | 0750 | WS_Teplá vnitřní 117; WS_Studená vnitřní 114
13506568 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 92,WS_Studená vnitřní 122 | ZT09.08.0754 | Umyvadlo + modul | 0754 | WS_Teplá vnitřní 92; WS_Studená vnitřní 122
13506641 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 94,WS_Studená vnitřní 113 | ZT09.08.0758 | Umyvadlo + modul | 0758 | WS_Teplá vnitřní 94; WS_Studená vnitřní 113
13506751 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 97,WS_Studená vnitřní 93 | ZT09.08.0762 | Umyvadlo + modul | 0762 | WS_Teplá vnitřní 97; WS_Studená vnitřní 93
13506819 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 96,WS_Studená vnitřní 78 | ZT09.08.0766 | Umyvadlo + modul | 0766 | WS_Teplá vnitřní 96; WS_Studená vnitřní 78
13525890 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 118,WS_Studená vnitřní 130 | ZT09.08.0771 | Umyvadlo + modul | 0771 | WS_Teplá vnitřní 118; WS_Studená vnitřní 130
13526123 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 126,WS_Studená vnitřní 140 | ZT09.08.0775 | Umyvadlo + modul | 0775 | WS_Teplá vnitřní 126; WS_Studená vnitřní 140
13526374 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 119,WS_Studená vnitřní 125 | ZT09.08.0779 | Umyvadlo + modul | 0779 | WS_Teplá vnitřní 119; WS_Studená vnitřní 125
13526791 | -2.PP_SO-102 | -1.PP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 88,WS_Studená vnitřní 115 | ZT09.08.0783 | Umyvadlo + modul | 0783 | WS_Teplá vnitřní 88; WS_Studená vnitřní 115
13544051 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 2 | WS_Teplá vnitřní 80,WS_Studená vnitřní 73 | ZT09.08.0787 | Umyvadlo + modul | 0787 | WS_Teplá vnitřní 80; WS_Studená vnitřní 73
13544820 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 134,WS_Studená vnitřní 141 | ZT09.08.0790 | Umyvadlo | 0790 | WS_Teplá vnitřní 134; WS_Studená vnitřní 141
13545427 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 138,WS_Studená vnitřní 144 | ZT09.08.0800 | Umyvadlo + modul | 0800 | WS_Teplá vnitřní 138; WS_Studená vnitřní 144
13546124 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 140,WS_Studená vnitřní 145 | ZT09.08.0803 | Umyvadlo | 0803 | WS_Teplá vnitřní 140; WS_Studená vnitřní 145
14030751 | -2.PP_SO-102 |  | 0 | Fáze 2 | WS_Teplá vnitřní 109,WS_Studená vnitřní 39 | ZT09.08.0902 | Umyvadlo | 0902 | WS_Teplá vnitřní 109; WS_Studená vnitřní 39

# IfcFlowTerminal: Baterie umyvadlová stojánková_invalida:Baterie umyvadlová stojánková_invalida (10)
Type - Classification: ZT09 SNIM (SNIM); Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_TEPLÁ_VODA: 0 m3/s; PRŮTOK_VODA: 0 m3/s
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: BSi; Kód sestavy: ZT09; Komentáře k typům: Baterie stojánková, invalida; Název typu: Baterie umyvadlová stojánková_invalida; Označení typu: 44; Popis: Baterie stojánková invalida; Popis sestavy: Baterie; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Baterie umyvadlová stojánková_invalida
Classification: ZT09 SNIM (SNIM); ZT09 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Odsazení od hostitele: -45.8135 mm; Pracovní rovina: <nepřiřazeno>
Mechanické - Klasifikace systému: Teplá voda v domácnosti,Studená voda v domácnosti
Kóty - JMENOVITÝ PRŮMĚR: 15 mm; Objem: 0.000582104 m3
Jiné - Id typu: 13720224; JM: 12.5 mm; Rodina: Baterie umyvadlová stojánková_invalida; Rodina a typ: Baterie umyvadlová stojánková_invalida: Baterie umyvadlová stojánková_invalida; Typ: Baterie umyvadlová stojánková_invalida
Name (Baterie umyvadlová stojánková_invalida:Baterie umyvadlová stojánková_invalida:...) | In | Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Název sestavy | Označení
13725014 | -1.PP_SO-102 | 800 | Fáze 1 | ZT09.44.0818 | Výlevka nástěnnî | 0818 | Vazby - Podlaží: 1.NP_SO-102; Vztažné podlaží: 1.NP_SO-102
13728602 | 1.NP_SO-102 | 800 | Fáze 1 | ZT09.44.0830 | Výlevka nástěnnñ | 0830 | Vazby - Podlaží: 2.NP_SO-102; Vztažné podlaží: 2.NP_SO-102
13728677 | 1.NP_SO-102 | 800 | Fáze 1 | ZT09.44.0834 | Výlevka nástěnnñ | 0834 | Vazby - Podlaží: 2.NP_SO-102; Vztažné podlaží: 2.NP_SO-102
13733491 | 2.NP_SO-102 | 800 | Fáze 1 | ZT09.44.0839 | Výlevka nástěnnî | 0839 | Vazby - Podlaží: 3.NP_SO-102; Vztažné podlaží: 3.NP_SO-102
14005561 | -2.PP_SO-102 | 0 | Fáze 1 | ZT09.44.0857 | Výlevka nástěnnò | 0857
14005941 | -2.PP_SO-102 | 0 | Fáze 1 | ZT09.44.0864 | Výlevka nástěnnô | 0864
14007202 | 3.NP_SO-102 | 0 | Fáze 2 | ZT09.44.0875 | Výlevka nástěnnö | 0875
14007282 | 2.NP_SO-102 | 0 | Fáze 2 | ZT09.44.0882 | Výlevka nástěnnö | 0882
14007313 | 1.NP_SO-102 | 0 | Fáze 2 | ZT09.44.0889 | Výlevka nástěnnö | 0889
14007342 | -1.PP_SO-102 | 0 | Fáze 2 | ZT09.44.0896 | Výlevka nástěnnö | 0896

# IfcFlowTerminal: Baterie vanová nástěnná:Baterie vanová nástěnná, Baterie vanová nástěnná:Baterie vanová nástěnná:12864817
In: 1.NP_SO-102
Type - Classification: ZT09 SNIM (SNIM); Material: CHROM
Type - Vazby - Výchozí výška: 750 mm
Type - Materiály a povrchové úpravy - Hadice: Plast; Materiál: CHROM
Type - Identifikační data - Kód sestavy: ZT09; Komentáře k typům: nástěnná, bez příslušenství; Model: HansaPico; Název typu: Baterie vanová nástěnná; Označení typu: 18; Popis: vodovodní baterie vanová; Popis sestavy: Baterie; Výrobce: HANSA
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Baterie vanová nástěnná
Classification: ZT09 SNIM (SNIM); ZT09 Uniformat (Uniformat); Group: WS_Studená vnitřní 24
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Podlaží: 1.NP_SO-102; Odsazení od hostitele: 20 mm; Pracovní rovina: <nepřiřazeno>; Výška od podlaží: 735.032 mm; Vztažné podlaží: 1.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_Studená vnitřní; Klasifikace systému: Teplá voda v domácnosti,Studená voda v domácnosti; Název systému: WS_Studená vnitřní 24
Kóty - Objem: 0.000675853 m3; Rozteč: 150 mm
Identifikační data - Kód prvku: ZT09.18.0039; Název sestavy: Vana (nástěnná baterie); Označení: 0039
Jiné - Id typu: 12859111; Rodina: Baterie vanová nástěnná; Rodina a typ: Baterie vanová nástěnná: Baterie vanová nástěnná; Typ: Baterie vanová nástěnná

# IfcFlowTerminal: Baterie výlevková nástěnná:Baterie výlevková nástěnná (10)
Type - Classification: ZT09 SNIM (SNIM); Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 1150 mm
Type - Mechanické - PRŮTOK_TEPLÁ_VODA: 0 m3/s; PRŮTOK_VODA: 0 m3/s
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: BNi; Kód sestavy: ZT09; Komentáře k typům: dřezová, nástěnná páková, rozteč 150 mm, invalida; Název typu: Baterie výlevková nástěnná; Označení typu: 22; Popis: Baterie nástěnná invalida; Popis sestavy: Baterie; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Baterie výlevková nástěnná
Classification: ZT09 SNIM (SNIM); ZT09 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Mechanické - Klasifikace systému: Teplá voda v domácnosti,Studená voda v domácnosti
Kóty - JMENOVITÝ PRŮMĚR: 15 mm; Objem: 0.000614887 m3; Rozteč: 150 mm
Jiné - Id typu: 12825708; Rodina: Baterie výlevková nástěnná; Rodina a typ: Baterie výlevková nástěnná: Baterie výlevková nástěnná; Typ: Baterie výlevková nástěnná
Name (Baterie výlevková nástěnná:Baterie výlevková nástěnná:...) | In | Podlaží = Vztažné podlaží | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Pracovní rovina | Fáze vytvoření | Kód prvku | Název sestavy | Označení
12874867 | -2.PP_SO-102 | -1.PP_SO-102 | 1100 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZT09.22.0061 | Výlevka + modul | 0061
12895162 | -1.PP_SO-102 | 1.NP_SO-102 | 1100 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZT09.22.0456 | Výlevka + modul | 0456
12896223 | 1.NP_SO-102 | 2.NP_SO-102 | 1100 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZT09.22.0491 | Výlevka + modul | 0491
12897200 | 2.NP_SO-102 | 3.NP_SO-102 | 1100 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZT09.22.0530 | Výlevka + modul | 0530
12898143 | 3.NP_SO-102 | 4.NP_SO-102 | 1100 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZT09.22.0569 | Výlevka + modul | 0569
12932544 | 3.NP_SO-102 | 4.NP_SO-102 | 1200 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT09.22.0612 | Výlevka DN50_modul+nástěnná baterie | 0612
12937671 | 3.NP_SO-102 | 4.NP_SO-102 | 1200 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT09.22.0616 | Výlevka DN50_modul+nástěnná baterie | 0616
12937714 | 3.NP_SO-102 | 4.NP_SO-102 | 1200 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT09.22.0620 | Výlevka DN50_modul+nástěnná baterie | 0620
12992062 | 1.NP_SO-102 | 2.NP_SO-102 | 1100 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT09.22.0638 | Výlevka + modul | 0638
13691387 | 1.NP_SO-102 | 2.NP_SO-102 | 1100 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT09.22.0810 | Výlevka + modul | 0810

# IfcFlowTerminal: Bidet nástěnný:Bidet nástěnný (4)
Type - Classification: ZT03 SNIM (SNIM); Material: ZDRAVOTNÍ KERAMIKA
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s
Type - Materiály a povrchové úpravy - Chrom: CHROM; Materiál: ZDRAVOTNÍ KERAMIKA
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: B; Kód sestavy: ZT03; Komentáře k typům: Bidet pro předstěnu; Název typu: Bidet nástěnný; Označení typu: 25; Popis: Bidet pro předstěnu; Popis sestavy: Bidet; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Bidet nástěnný
Classification: ZT03 SNIM (SNIM); ZT03 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Mechanické - Klasifikace systému: Sanitární
Kóty - JMENOVITÝ PRŮMĚR: 50 mm; Objem: 0.016503 m3; Tloušťka obkladu: 20 mm
Identifikační data - Název sestavy: Bidet + modul
Jiné - Id typu: 12882062; Rodina: Bidet nástěnný; Rodina a typ: Bidet nástěnný: Bidet nástěnný; t: -20 mm; Typ: Bidet nástěnný
Name (Bidet nástěnný:Bidet nástěnný:...) | In | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
12881994 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT03.25.0252 | 0252
12899363 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZT03.25.0590 | 0590
12899554 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZT03.25.0600 | 0600
13067065 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT03.25.0640 | 0640

# IfcFlowTerminal: Dřez_centrovaný.CC:Dřez_centrovaný.CC (6)
Type - Classification: ZT06 SNIM (SNIM); Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Kóty - Délka: 500 mm; JMENOVITÝ PRŮMĚR: 50 mm; Šířka: 400 mm; Výška: 200 mm; Výška od podlahy: 850 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: D; Kód sestavy: ZT06; Komentáře k typům: Dřez bez odkapávače; Název typu: Dřez_centrovaný.CC; Označení typu: 38; Popis: Dřez; Popis sestavy: Dřez; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Dřez_centrovaný.CC
Classification: ZT06 SNIM (SNIM); ZT06 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: XKA; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 14.5719 mm; Výška od podlaží: 14.5719 mm
Mechanické - Klasifikace systému: Sanitární
Kóty - Objem: 0.017099 m3
Jiné - Id typu: 13399826; Rodina: Dřez_centrovaný.CC; Rodina a typ: Dřez_centrovaný.CC: Dřez_centrovaný.CC; Typ: Dřez_centrovaný.CC
Name (Dřez_centrovaný.CC:Dřez_centrovaný.CC:...) | In | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Název sestavy | Označení
13401573 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | ZT06.38.0727 | Výlevka nástěnné | 0727
13401600 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT06.38.0730 | Výlevka nástěnné | 0730
13401721 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT06.38.0733 | Výlevka nástěnnê | 0733
13545098 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZT06.38.0792 | Výlevka nástěnnë | 0792
13545320 | -2.PP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT06.38.0795 | Výlevka nástěnnë | 0795
13550208 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT06.38.0805 | Výlevka nástěnnê | 0805

# IfcFlowTerminal: Hydrant D25 s tvarově stálou hadicí_nástěnný.LH:800×800, RAL3000 (17)
Type - Classification: PZ00 SNIM (SNIM); Material: pictogram_color_red, pictogram_color_white, 032-175-175, Wartość domyślna Nowy materiał, Szkło, DC01, RAL3000
Type - Požární ochrana - Požární odolnost: –
Type - Mechanické – tok - K Factor: 42
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Materiál: DC01, RAL3000
Type - Kóty - D1: 90 mm; D2: 90 mm; Délka: 710 mm; H1: 90 mm; Jmenovitá velikost vstupu: 25 mm; Šířka: 245 mm; Výška: 710 mm; W1: 90 mm; W2: 90 mm
Type - Identifikační data - Kód sestavy: PZ00; Komentáře k typům: HYDRANT; Model: HW-25NW-20/30 HS (N), RAL3000; Název typu: 800×800, RAL3000; Označení typu: 30; Popis: http://gras.pl/en/hw-25-n-20-30-hs/; Popis sestavy: Obecný prvek; URL: http://www.gras.pl/; Výrobce: GRAS PPPH
Type - Jiné - Kategorie: Instalační zařizovací předměty; Délka hadice: 30000 mm; Název rodiny: Hydrant D25 s tvarově stálou hadicí_nástěnný.LH; Průtok hasiva: 0.0003 m3/s
Classification: PZ00 SNIM (SNIM); PZ00 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: FMD; CCI Technický systém: JB
Vazby - Hostitel: <nepřiřazeno>
Mechanické - Klasifikace systému: Požární ochrana – vodní prostředky
Stavba - Door_Right - Door_Left: no
Kóty - Objem: 0.123504 m3; Plocha: 1.21447 m2
Jiné - Páteřní trasa: yes; Id typu: 13117635; Rodina: Hydrant D25 s tvarově stálou hadicí_nástěnný.LH; Rodina a typ: Hydrant D25 s tvarově stálou hadicí_nástěnný.LH: 800×800, RAL3000; Typ: 800×800, RAL3000
Name (Hydrant D25 s tvarově stálou hadicí_nástěnný.LH:800×800, RAL3000:...) | In | Třída reakce na oheň | Podlaží = Vztažné podlaží | Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Typ systému | Kód prvku | Označení | ID pozice
13124349 | 1.NP_SO-102 | A1 | 1.NP_SO-102 | 1150 | Fáze 1 | WS_Požární zavodněný 2 | WS_Požární zavodněný | PZ00.30.0667 | 0667
13124773 | 2.NP_SO-102 | A1 | 2.NP_SO-102 | 1150 | Fáze 1 |  |  | PZ00.30.0668 | 0668 | Hydrant
13124775 | 3.NP_SO-102 | A1 | 3.NP_SO-102 | 1150 | Fáze 1 |  |  | PZ00.30.0669 | 0669
13124777 | 4.NP_SO-102 | A1 | 4.NP_SO-102 | 1150 | Fáze 1 | WS_Požární zavodněný 1 | WS_Požární zavodněný | PZ00.30.0670 | 0670
13142251 | -1.PP_SO-102 | A1 | -1.PP_SO-102 | 1150 | Fáze 1 | WS_Požární zavodněný 1 | WS_Požární zavodněný | PZ00.30.0671 | 0671 | Hydrant
13142254 | -1.PP_SO-102 | A1 | -1.PP_SO-102 | 1150 | Fáze 1 | WS_Požární zavodněný 1 | WS_Požární zavodněný | PZ00.30.0672 | 0672 | Hydrant
13142257 | -1.PP_SO-102 |  | -1.PP_SO-102 | 1150 | Fáze 2 | WS_Požární zavodněný 3 | WS_Požární zavodněný | PZ00.30.0673 | 0673 | Hydrant
13142401 | 4.NP_SO-102 |  | 4.NP_SO-102 | 0 | Fáze 2 | WS_Požární zavodněný 3 | WS_Požární zavodněný | PZ00.30.0674 | 0674
13143120 | 3.NP_SO-102 | A1 | 3.NP_SO-102 | 800 | Fáze 1 | WS_Požární zavodněný 1 | WS_Požární zavodněný | PZ00.30.0675 | 0675
13143321 | 3.NP_SO-102 | A1 | 3.NP_SO-102 | 1150 | Fáze 1 |  |  | PZ00.30.0676 | 0676 | Hydrant
13143670 | 3.NP_SO-102 |  | 3.NP_SO-102 | 0 | Fáze 2 | WS_Požární zavodněný 3 | WS_Požární zavodněný | PZ00.30.0677 | 0677 | Hydrant
13143847 | 2.NP_SO-102 |  | 2.NP_SO-102 | 1150 | Fáze 2 | WS_Požární zavodněný 3 | WS_Požární zavodněný | PZ00.30.0678 | 0678 | Hydrant
13143854 | 1.NP_SO-102 |  | 1.NP_SO-102 | 1150 | Fáze 2 | WS_Požární zavodněný 3 | WS_Požární zavodněný | PZ00.30.0679 | 0679 | Hydrant
13144336 | 4.NP_SO-102 | A1 | 4.NP_SO-102 | 800 | Fáze 1 | WS_Požární zavodněný 1 | WS_Požární zavodněný | PZ00.30.0680 | 0680
13151320 | 2.NP_SO-102 | A1 | 2.NP_SO-102 | 800 | Fáze 1 | WS_Požární zavodněný 1 | WS_Požární zavodněný | PZ00.30.0681 | 0681
13151325 | 1.NP_SO-102 | A1 | 1.NP_SO-102 | 1150 | Fáze 1 | WS_Požární zavodněný 1 | WS_Požární zavodněný | PZ00.30.0682 | 0682
13154247 | 1.NP_SO-102 |  | 1.NP_SO-102 | 1150 | Fáze 2 | WS_Požární zavodněný 3 | WS_Požární zavodněný | PZ00.30.0683 | 0683 | Hydrant

# IfcFlowTerminal: Modul pro WC 112cm, s nádrží Sigma 12cm - lehká kce.CC:Modul pro WC 112cm, s nádrží Sigma 12cm (50)
Type - Classification: MT04 SNIM (SNIM); Material: PLAST_BÍLÝ, <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Tlačítko: PLAST_BÍLÝ
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: ZR; Kód sestavy: MT04; Komentáře k typům: Duofix pro WC 112cm, s nádrží Sigma 12cm; Model: 111.300.00.5; Název typu: Modul pro WC 112cm, s nádrží Sigma 12cm; Označení typu: 14; Popis: Závěsný rám pro WC; Popis sestavy: Závěs; URL: www.cadconsulting.cz; Výrobce: Geberit
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Modul pro WC 112cm, s nádrží Sigma 12cm - lehká kce.CC
Classification: MT04 SNIM (SNIM); MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABB; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Kóty - Objem: 0.0356336 m3; Vysunutí nožiček: 100 mm; Vysunutí tlačítka: 60 mm
Identifikační data - Název sestavy: Toaleta + modul
Jiné - Id typu: 12818279; Rodina: Modul pro WC 112cm, s nádrží Sigma 12cm - lehká kce.CC; Rodina a typ: Modul pro WC 112cm, s nádrží Sigma 12cm - lehká kce.CC: Modul pro WC 112cm, s nádrží Sigma 12cm; Typ: Modul pro WC 112cm, s nádrží Sigma 12cm; VN: 100 mm
Name (Modul pro WC 112cm, s nádrží Sigma 12cm - lehká kce.CC:Modul pro WC 112cm, s nádrží Sigma 12cm:...) | In | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
12833555 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | MT04.14.0022 | 0022
12833580 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | MT04.14.0025 | 0025
12866034 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.14.0045 | 0045
12879217 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.14.0063 | 0063
12879266 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.14.0066 | 0066
12879277 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.14.0069 | 0069
12879292 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.14.0072 | 0072
12879305 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.14.0075 | 0075
12880185 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.14.0111 | 0111
12880671 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.14.0114 | 0114
12880675 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.14.0117 | 0117
12880679 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.14.0120 | 0120
12880683 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.14.0123 | 0123
12880687 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.14.0126 | 0126
12880841 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.14.0158 | 0158
12880845 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.14.0161 | 0161
12880849 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.14.0164 | 0164
12880853 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.14.0167 | 0167
12880857 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.14.0170 | 0170
12881011 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.14.0202 | 0202
12881015 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.14.0205 | 0205
12881019 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.14.0208 | 0208
12881023 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.14.0211 | 0211
12881027 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.14.0214 | 0214
12881912 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.14.0246 | 0246
12889906 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.14.0285 | 0285
12889914 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.14.0288 | 0288
12889925 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.14.0291 | 0291
12889947 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.14.0294 | 0294
12892699 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.14.0374 | 0374
12894599 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | MT04.14.0428 | 0428
12894889 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | MT04.14.0439 | 0439
12894982 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | MT04.14.0445 | 0445
12894990 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | MT04.14.0448 | 0448
12895977 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | MT04.14.0477 | 0477
12896032 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | MT04.14.0480 | 0480
12896040 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | MT04.14.0483 | 0483
12897074 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | MT04.14.0520 | 0520
12897082 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | MT04.14.0523 | 0523
12897093 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | MT04.14.0526 | 0526
12897989 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | MT04.14.0559 | 0559
12897997 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | MT04.14.0562 | 0562
12898008 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | MT04.14.0565 | 0565
12899418 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | MT04.14.0594 | 0594
12899600 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | MT04.14.0604 | 0604
12992047 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.14.0631 | 0631
12992051 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.14.0634 | 0634
13154282 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | MT04.14.0692 | 0692
13691413 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.14.0812 | 0812
14005367 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | MT04.14.0844 | 0844

# IfcFlowTerminal: Modul pro WC a madla, pro lehké kce_invalida:Modul pro WC a madla, pro lehké kce_invalida (10)
Type - Classification: MT04 SNIM (SNIM); Material: <Unnamed>, PLAST_BÍLÝ
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Tlačítko: PLAST_BÍLÝ
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: ZR; Kód sestavy: MT04; Komentáře k typům: Předstěnové systémy modul pro WC Geberit Duofix Special pro závěs. WC s nádrž. UP320 bezbariérový; Model: 111.375.00.5 218058128000000065; Název typu: Modul pro WC a madla, pro lehké kce_invalida; Označení typu: 45; Popis: Závěsný rám pro WC; Popis sestavy: Závěs; URL: www.cadconsulting.cz; Výrobce: Geberit
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Modul pro WC a madla, pro lehké kce_invalida
Classification: MT04 SNIM (SNIM); MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABB; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Kóty - Objem: 0.0496315 m3; Vysunuté tlačítka: 60 mm; Vysunutí nožiček: 50 mm
Jiné - Id typu: 13717414; Rodina: Modul pro WC a madla, pro lehké kce_invalida; Rodina a typ: Modul pro WC a madla, pro lehké kce_invalida: Modul pro WC a madla, pro lehké kce_invalida; Typ: Modul pro WC a madla, pro lehké kce_invalida
Name (Modul pro WC a madla, pro lehké kce_invalida:Modul pro WC a madla, pro lehké kce_invalida:...) | In | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Název sestavy | Označení
13725112 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.45.0819 | Toaleta + modul (madla, lehká kce)_invalida | 0819
13728391 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.45.0822 | Výlevka nástěnnï | 0822
13728473 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.45.0825 | Výlevka nástěnnð | 0825
13733493 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.45.0840 | Toaleta + modul (madla, lehká kce)_invalida | 0840
14005658 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | MT04.45.0859 | Výlevka nástěnnó | 0859
14006028 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | MT04.45.0866 | Výlevka nástěnnõ | 0866
14007100 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | MT04.45.0870 | Toaleta + modul (madla, lehká kce)_invalida | 0870
14007265 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | MT04.45.0877 | Toaleta + modul (madla, lehká kce)_invalida | 0877
14007296 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | MT04.45.0884 | Toaleta + modul (madla, lehká kce)_invalida | 0884
14007325 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | MT04.45.0891 | Toaleta + modul (madla, lehká kce)_invalida | 0891

# IfcFlowTerminal: Modul pro bidet 82cm - lehká kce.CC:Modul pro bidet 82cm - lehká kce.CC (4)
Type - Classification: MT04 SNIM (SNIM); Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: ZR; Kód sestavy: MT04; Komentáře k typům: pro bidet, h 82 cm; Model: Duofix 111.515.00.1; Název typu: Modul pro bidet 82cm - lehká kce.CC; Označení typu: 26; Popis: Závěsný rám pro bidet; Popis sestavy: Závěs; URL: www.cadconsulting.cz; Výrobce: Geberit
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Modul pro bidet 82cm - lehká kce.CC
Classification: MT04 SNIM (SNIM); MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Kóty - Objem: 0.004576 m3; Vysunutí nožiček: 100 mm
Identifikační data - Název sestavy: Bidet + modul
Jiné - Id typu: 12882065; Rodina: Modul pro bidet 82cm - lehká kce.CC; Rodina a typ: Modul pro bidet 82cm - lehká kce.CC: Modul pro bidet 82cm - lehká kce.CC; Typ: Modul pro bidet 82cm - lehká kce.CC; VN: 100 mm
Name (Modul pro bidet 82cm - lehká kce.CC:Modul pro bidet 82cm - lehká kce.CC:...) | In | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
12881995 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.26.0253 | 0253
12899364 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | MT04.26.0591 | 0591
12899555 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | MT04.26.0601 | 0601
13067066 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.26.0641 | 0641

# IfcFlowTerminal: Modul pro pisoár 112-130 cm Universal - lehká kce.CC:Modul pro pisoár 112-130 cm Universal - lehká kce.CC (20)
Type - Classification: MT04 SNIM (SNIM); Material: <Unnamed>, PLAST_BÍLÝ
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Tlačítko: PLAST_BÍLÝ
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: ZR; Kód sestavy: MT04; Komentáře k typům: Duofix pro pisoár 112-130 cm Universal; Model: 111.616.00.1; Název typu: Modul pro pisoár 112-130 cm Universal - lehká kce.CC; Označení typu: 23; Popis: Závěcný rám pro pisoár; Popis sestavy: Závěs; URL: www.cadconsulting.cz; Výrobce: Geberit
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Modul pro pisoár 112-130 cm Universal - lehká kce.CC
Classification: MT04 SNIM (SNIM); MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABB; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Kóty - Objem: 0.0163786 m3; Výška čidla: 1170 mm; Vysunutí nožiček: 100 mm; Vysunutí tlačítka: 90 mm
Identifikační data - Název sestavy: Pisoár + modul
Jiné - Id typu: 12834492; Rodina: Modul pro pisoár 112-130 cm Universal - lehká kce.CC; Rodina a typ: Modul pro pisoár 112-130 cm Universal - lehká kce.CC: Modul pro pisoár 112-130 cm Universal - lehká kce.CC; Typ: Modul pro pisoár 112-130 cm Universal - lehká kce.CC; VC: 1170 mm; VN: 100 mm
Name (Modul pro pisoár 112-130 cm Universal - lehká kce.CC:Modul pro pisoár 112-130 cm Universal - lehká kce.CC:...) | In | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
12879583 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.23.0101 | 0101
12879625 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.23.0104 | 0104
12879637 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.23.0107 | 0107
12880774 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.23.0148 | 0148
12880779 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.23.0151 | 0151
12880784 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.23.0154 | 0154
12880944 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.23.0192 | 0192
12880949 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.23.0195 | 0195
12880954 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.23.0198 | 0198
12881114 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.23.0236 | 0236
12881119 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.23.0239 | 0239
12881124 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.23.0242 | 0242
12890548 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.23.0308 | 0308
12890557 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.23.0311 | 0311
12890569 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.23.0314 | 0314
12894932 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | MT04.23.0441 | 0441
12895862 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | MT04.23.0473 | 0473
12897018 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | MT04.23.0516 | 0516
12897901 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | MT04.23.0555 | 0555
13154272 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | MT04.23.0688 | 0688

# IfcFlowTerminal: Modul pro sprchu 130 cm odpadní koleno 50.CC:Modul pro sprchu 130 cm odpadní koleno 50.CC (6)
In: -2.PP_SO-102
Type - Classification: MT04 SNIM (SNIM); Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: ZR; Kód sestavy: MT04; Komentáře k typům: Duofix pro sprchu 130 cm odpadní koleno 50; Model: 111.580.00.1; Název typu: Modul pro sprchu 130 cm odpadní koleno 50.CC; Označení typu: 06; Popis: Závěsný rám pro sprchu; Popis sestavy: Závěs; URL: www.cadconsulting.cz; Výrobce: Geberit
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Modul pro sprchu 130 cm odpadní koleno 50.CC
Classification: MT04 SNIM (SNIM); MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABE; CCI Technický systém: JB
Vazby - Přesunout s blízkými prvky: no; Podlaží: -1.PP_SO-102; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Hostitel: Podlaží : -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0190393 m3; Tloušťka podlahy: 90 mm; Úhel napojení: 180 deg
Identifikační data - Název sestavy: Sprchový kout + modul (podomítková baterie)
Jiné - Id typu: 12805724; Rodina: Modul pro sprchu 130 cm odpadní koleno 50.CC; Rodina a typ: Modul pro sprchu 130 cm odpadní koleno 50.CC: Modul pro sprchu 130 cm odpadní koleno 50.CC; Typ: Modul pro sprchu 130 cm odpadní koleno 50.CC
Name (Modul pro sprchu 130 cm odpadní koleno 50.CC:Modul pro sprchu 130 cm odpadní koleno 50.CC:...) | Kód prvku | Označení
12825570 | MT04.06.0011 | 0011
12833328 | MT04.06.0018 | 0018
12886120 | MT04.06.0261 | 0261
14005433 | MT04.06.0846 | 0846
14005463 | MT04.06.0849 | 0849
14005515 | MT04.06.0852 | 0852

# IfcFlowTerminal: Modul pro umyvadlo 82_98 cm.CC:Modul pro umyvadlo 82_98 cm.CC (105)
Type - Classification: MT04 SNIM (SNIM); Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: ZR; Kód sestavy: MT04; Komentáře k typům: Duofix pro umyvadlo 82/98 cm; Model: 111.485.00.1; Název typu: Modul pro umyvadlo 82_98 cm.CC; Označení typu: 20; Popis: Závěsný rám pro umyvadlo; Popis sestavy: Závěs; URL: www.cadconsulting.cz; Výrobce: Geberit
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Modul pro umyvadlo 82_98 cm.CC
Classification: MT04 SNIM (SNIM); MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Přesunout s blízkými prvky: no; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Kóty - Objem: 0.0040844 m3; Tloušťka podlahy: 90 mm
Identifikační data - Název sestavy: Umyvadlo + modul
Jiné - Id typu: 12812721; Rodina: Modul pro umyvadlo 82_98 cm.CC; Rodina a typ: Modul pro umyvadlo 82_98 cm.CC: Modul pro umyvadlo 82_98 cm.CC; Typ: Modul pro umyvadlo 82_98 cm.CC
Name (Modul pro umyvadlo 82_98 cm.CC:Modul pro umyvadlo 82_98 cm.CC:...) | In | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
12865977 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.20.0041 | 0041
12871081 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | MT04.20.0049 | 0049
12871109 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | MT04.20.0053 | 0053
12871170 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | MT04.20.0057 | 0057
12879371 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.20.0077 | 0077
12879412 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.20.0081 | 0081
12879441 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.20.0085 | 0085
12879472 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.20.0089 | 0089
12879499 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.20.0093 | 0093
12879528 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.20.0097 | 0097
12880690 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0128 | 0128
12880704 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0132 | 0132
12880732 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0136 | 0136
12880746 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0140 | 0140
12880760 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0144 | 0144
12880860 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.20.0172 | 0172
12880874 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.20.0176 | 0176
12880902 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.20.0180 | 0180
12880916 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.20.0184 | 0184
12880930 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.20.0188 | 0188
12881030 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.20.0216 | 0216
12881044 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.20.0220 | 0220
12881072 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.20.0224 | 0224
12881086 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.20.0228 | 0228
12881100 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.20.0232 | 0232
12881931 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0248 | 0248
12886216 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | MT04.20.0264 | 0264
12888131 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.20.0268 | 0268
12888838 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0272 | 0272
12888862 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0276 | 0276
12889672 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0280 | 0280
12890304 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0296 | 0296
12890331 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0300 | 0300
12890442 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0304 | 0304
12890827 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0317 | 0317
12890851 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0321 | 0321
12891272 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.20.0325 | 0325
12891683 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0329 | 0329
12891774 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0333 | 0333
12891847 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0337 | 0337
12891919 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0341 | 0341
12891994 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0345 | 0345
12892060 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0349 | 0349
12892277 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.20.0353 | 0353
12892344 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.20.0357 | 0357
12892410 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.20.0361 | 0361
12892476 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.20.0365 | 0365
12892541 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.20.0369 | 0369
12892794 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.20.0376 | 0376
12892897 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.20.0380 | 0380
12893028 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.20.0384 | 0384
12893153 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.20.0388 | 0388
12894054 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.20.0407 | 0407
12894120 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.20.0411 | 0411
12894199 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.20.0415 | 0415
12894263 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.20.0419 | 0419
12894324 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.20.0423 | 0423
12894669 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | MT04.20.0430 | 0430
12894783 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | MT04.20.0434 | 0434
12895093 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | MT04.20.0450 | 0450
12895276 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | MT04.20.0457 | 0457
12895300 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | MT04.20.0461 | 0461
12895431 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | MT04.20.0465 | 0465
12895777 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | MT04.20.0469 | 0469
12896131 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | MT04.20.0485 | 0485
12896331 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | MT04.20.0492 | 0492
12896399 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | MT04.20.0496 | 0496
12896712 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | MT04.20.0500 | 0500
12896772 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | MT04.20.0504 | 0504
12896888 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | MT04.20.0508 | 0508
12896912 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | MT04.20.0512 | 0512
12897285 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | MT04.20.0531 | 0531
12897358 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | MT04.20.0535 | 0535
12897409 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | MT04.20.0539 | 0539
12897440 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | MT04.20.0543 | 0543
12897747 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | MT04.20.0547 | 0547
12897771 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | MT04.20.0551 | 0551
12898195 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | MT04.20.0570 | 0570
12898219 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | MT04.20.0574 | 0574
12898541 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | MT04.20.0578 | 0578
12898592 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | MT04.20.0582 | 0582
12899097 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.20.0586 | 0586
12899468 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | MT04.20.0596 | 0596
12899618 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | MT04.20.0606 | 0606
12992010 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0622 | 0622
12992028 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0626 | 0626
13068774 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.20.0643 | 0643
13068912 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.20.0647 | 0647
13071943 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.20.0651 | 0651
13102563 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.20.0655 | 0655
13102678 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.20.0659 | 0659
13105033 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0663 | 0663
13154249 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | MT04.20.0684 | 0684
13505810 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | MT04.20.0744 | 0744
13505918 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | MT04.20.0748 | 0748
13506560 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | MT04.20.0752 | 0752
13506633 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.20.0756 | 0756
13506743 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.20.0760 | 0760
13506811 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.20.0764 | 0764
13525882 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | MT04.20.0769 | 0769
13526115 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | MT04.20.0773 | 0773
13526366 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | MT04.20.0777 | 0777
13526783 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | MT04.20.0781 | 0781
13544043 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | MT04.20.0785 | 0785
13545419 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.20.0798 | 0798

# IfcFlowTerminal: Modul pro umyvadlo, pro lehké kce_invalida:Modul pro umyvadlo, pro lehké kce_invalida (10)
Type - Classification: MT04 SNIM (SNIM); Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: ZR; Kód sestavy: MT04; Komentáře k typům: Duofix pro umyvadlo 112cm též pro TP; Model: 111.430.00.1; Název typu: Modul pro umyvadlo, pro lehké kce_invalida; Označení typu: 42; Popis: Závěsný rám pro umyvadlo; Popis sestavy: Závěs; URL: www.cadconsulting.cz; Výrobce: Geberit
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Modul pro umyvadlo, pro lehké kce_invalida
Classification: MT04 SNIM (SNIM); MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Přesunout s blízkými prvky: no; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Kóty - Objem: 0.00448845 m3; Tloušťka podlahy: 90 mm
Jiné - Id typu: 13720227; Rodina: Modul pro umyvadlo, pro lehké kce_invalida; Rodina a typ: Modul pro umyvadlo, pro lehké kce_invalida: Modul pro umyvadlo, pro lehké kce_invalida; Typ: Modul pro umyvadlo, pro lehké kce_invalida
Name (Modul pro umyvadlo, pro lehké kce_invalida:Modul pro umyvadlo, pro lehké kce_invalida:...) | In | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Název sestavy | Označení
13725010 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | MT04.42.0815 | Výlevka nástěnnî | 0815
13728598 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.42.0828 | Výlevka nástěnnñ | 0828
13728674 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.42.0832 | Výlevka nástěnnñ | 0832
13733487 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | MT04.42.0836 | Výlevka nástěnnî | 0836
14005557 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | MT04.42.0855 | Výlevka nástěnnò | 0855
14005938 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | MT04.42.0862 | Výlevka nástěnnô | 0862
14007199 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | MT04.42.0873 | Výlevka nástěnnö | 0873
14007279 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | MT04.42.0880 | Výlevka nástěnnö | 0880
14007310 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | MT04.42.0887 | Výlevka nástěnnö | 0887
14007339 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | MT04.42.0894 | Výlevka nástěnnö | 0894

# IfcFlowTerminal: Modul výlevka.CC:Modul výlevka.CC (10)
Type - Classification: MT04 SNIM (SNIM); Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: ZR; Kód sestavy: MT04; Komentáře k typům: pro výlevku 130 cm; Model: Duofix 111.450.00.1; Název typu: Modul výlevka.CC; Označení typu: 09; Popis: Závěsný rám pro výlevku; Popis sestavy: Závěs; URL: www.cadconsulting.cz; Výrobce: Geberit
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Modul výlevka.CC
Classification: MT04 SNIM (SNIM); MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Přesunout s blízkými prvky: no; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Kóty - Objem: 0.00932 m3; Tloušťka podlahy: 0 mm
Jiné - Id typu: 12825710; Rodina: Modul výlevka.CC; Rodina a typ: Modul výlevka.CC: Modul výlevka.CC; Typ: Modul výlevka.CC
Name (Modul výlevka.CC:Modul výlevka.CC:...) | In | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Název sestavy | Označení
12828507 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | MT04.09.0014 | Výlevka + modul | 0014
12895159 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | MT04.09.0454 | Výlevka + modul | 0454
12896220 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | MT04.09.0489 | Výlevka + modul | 0489
12897197 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | MT04.09.0528 | Výlevka + modul | 0528
12898140 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | MT04.09.0567 | Výlevka + modul | 0567
12932543 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.09.0611 | Výlevka DN50_modul+nástěnná baterie | 0611
12937670 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.09.0615 | Výlevka DN50_modul+nástěnná baterie | 0615
12937713 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | MT04.09.0619 | Výlevka DN50_modul+nástěnná baterie | 0619
12992059 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.09.0636 | Výlevka + modul | 0636
13691384 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT04.09.0808 | Výlevka + modul | 0808

# IfcFlowTerminal: Nerezový dvoudřez:Nerezový dvoudřez š.1400 (3)
In: 1.NP_SO-102
Type - Classification: ZT06 SNIM (SNIM); Material: Ocel, leštěná
Type - Vazby - Výchozí výška: 850 mm
Type - Materiály a povrchové úpravy - Materiál dřezu: Ocel, leštěná; Materiál příslušenství: Ocel, leštěná
Type - Stavba - Baterie vestavěná: no
Type - Kóty - Hloubka: 730 mm; Hloubka rovné plochy: 100 mm; Odsazení od stěny: 0 mm; Šířka: 1400 mm; Šířka lemu: 35 mm
Type - Identifikační data - Číslo OmniClass: 23.45.05.14.14; Kód sestavy: ZT06; Komentáře k typům: NEREZOVÝ DVOJDŘEZ; Nadpis OmniClass: Sinks/Lavatories; Název typu: Nerezový dvoudřez š.1400; Označení typu: 47; Popis sestavy: Dřez
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Nerezový dvoudřez
Classification: ZT06 SNIM (SNIM); ZT06 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JD
Vazby - Podlaží: 1.NP_SO-102; Hostitel: Podlaží : 1.NP_SO-102; Odsazení od hostitele: 850 mm; Výška od podlaží: 850 mm
Mechanické - Klasifikace systému: Sanitární
Kóty - Objem: 0.0249918 m3; Plocha: 2.0696 m2; Poloha připojení odpadního potrubí: 320 mm; Průměr odpadního potrubí: 40 mm
Jiné - Id typu: 14006164; Rodina: Nerezový dvoudřez; Rodina a typ: Nerezový dvoudřez: Nerezový dvoudřez š.1400; Typ: Nerezový dvoudřez š.1400; Výška linky: 0 mm
Name (Nerezový dvoudřez:Nerezový dvoudřez š.1400:...) | Fáze vytvoření | Kód prvku | Označení
14006964 | Fáze 1 | ZT06.47.0869 | 0869
14007358 | Fáze 2 | ZT06.47.0898 | 0898
14007360 | Fáze 2 | ZT06.47.0899 | 0899

# IfcFlowTerminal: Nohy ke sprchové vaničce 900x900mm:Nohy ke sprchové vaničce 900x900mm (8)
Type - Classification: MT03 SNIM (SNIM); Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: OP; Kód sestavy: MT03; Komentáře k typům: Nohy ke sprchové vaničce, nastavitelná výška; Model: Model; Název typu: Nohy ke sprchové vaničce 900x900mm; Označení typu: 02; Popis: Nohy ke sprchové vaničce; Popis sestavy: Držák; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Nohy ke sprchové vaničce 900x900mm
Classification: MT03 SNIM (SNIM); MT03 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABE; CCI Technický systém: JB
Vazby - Přesunout s blízkými prvky: no; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Kóty - Objem: 0.000571142 m3; Výška nožiček: 80 mm
Identifikační data - Název sestavy: Sprchový kout - vanička (nástěnná baterie)
