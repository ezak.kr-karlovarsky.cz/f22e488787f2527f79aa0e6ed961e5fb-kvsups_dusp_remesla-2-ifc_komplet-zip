Properties of the parts of a building model (IFC4), part 38 of 60

# IfcPipeFitting: M_Přechod, obecný:Standardní (15)
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Název systému = Group | Odskok – šířka | Odskok – výška | Délka (mm) | Jmenovitý poloměr 1 (mm) | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Výškové odsazení (mm) | Viditelnost 2 | Viditelnost 3 | Max. vnější průměr tvarovky 12 (mm) | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm)
13068533 | -1.PP_SO-102 | ø50 mm-ø40 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | WS_"Jiný typ" studená vnitřní 1 | 25 | 25 | 13.4938 | 25 | 20 | 50 | 40 | 50 | 40 | 0.0000241362 | 0.00346833 | ø50-ø40 | 21.59 | 16.51 | 53.975 | 41.275 | TT00.05.0745 | 0745 | yes | 3048 | yes | no | 53.975 | 20.6375 | 26.9875
13068564 | 4.NP_SO-102 | ø40 mm-ø25 mm | 4.NP_SO-102 | 1406.02 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 12.5 | 10.3188 | 12.5 | 20 | 25 | 40 | 40 | 25 | 0.00000997107 | 0.00193705 | ø40-ø25 | 11.43 | 16.51 | 28.575 | 41.275 | TT00.05.0747 | 0747 | no | 3048 | no | yes | 41.275 | 20.6375 | 14.2875
13641188 | -1.PP_SO-102 | ø32 mm-ø20 mm | -1.PP_SO-102 | 3299.83 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | WS_"Jiný typ" studená vnitřní 1 | 16.0001 | 16.1269 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 0.00129978 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1485 | 1485 | yes | 3048.13 | yes | no | 34.925 | 11.1125 | 17.4625 | Mechanické – tok - Tlaková ztráta: 0 Pa
13645930 | 3.NP_SO-102 | ø40 mm-ø25 mm | 3.NP_SO-102 | 1500 | Fáze 1 | WS_Studená vnitřní | WS_Studená vnitřní 134 | 12.5 | 12.5 | 10.3188 | 12.5 | 20 | 25 | 40 | 40 | 25 | 0.00000997107 | 0.00193705 | ø40-ø25 | 11.43 | 16.51 | 28.575 | 41.275 | TT00.05.1537 | 1537 | no | 3048 | no | yes | 41.275 | 20.6375 | 14.2875
13651546 | -1.PP_SO-102 | ø63 mm-ø50 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | WS_"Jiný typ" studená vnitřní 1 | 31.5 | 31.5 | 16.5437 | 31.5 | 25 | 63 | 50 | 63 | 50 | 0.000047016 | 0.00542487 | ø63-ø50 | 26.47 | 21.59 | 66.175 | 53.975 | TT00.05.1567 | 1567 | yes | 3048 | yes | no | 66.175 | 26.9875 | 33.0875
13706103 | -1.PP_SO-102 | ø63 mm-ø50 mm | -1.PP_SO-102 | 3226.44 | Fáze 1 | WS_Studená vnitřní | WS_Studená vnitřní 134 | 31.5 | 31.5 | 16.5437 | 31.5 | 25 | 63 | 50 | 63 | 50 | 0.000047016 | 0.00542487 | ø63-ø50 | 26.47 | 21.59 | 66.175 | 53.975 | TT00.05.1744 | 1744 | yes | 3048 | yes | no | 66.175 | 26.9875 | 33.0875
13825720 | -1.PP_SO-102 | ø63 mm-ø25 mm | -1.PP_SO-102 | 3254.21 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | WS_"Jiný typ" studená vnitřní 1 | 31.5 | 31.5 | 16.5437 | 31.5 | 12.5 | 63 | 25 | 63 | 25 | 0.0000306546 | 0.00420842 | ø63-ø25 | 26.47 | 11.43 | 66.175 | 28.575 | TT00.05.1854 | 1854 | yes | 3048 | yes | no | 66.175 | 14.2875 | 33.0875
13831183 | -1.PP_SO-102 | ø50 mm-ø40 mm | -1.PP_SO-102 | 3360.31 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | WS_"Jiný typ" studená vnitřní 1 | 25 | 25 | 13.4938 | 25 | 20 | 50 | 40 | 50 | 40 | 0.0000241362 | 0.00346833 | ø50-ø40 | 21.59 | 16.51 | 53.975 | 41.275 | TT00.05.1904 | 1904 | yes | 3048 | yes | no | 53.975 | 20.6375 | 26.9875

# IfcPipeFitting: M_Přechod, obecný:Standardní (18)
Type - Classification: TT00 SNIM (SNIM); Material: 175-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 05; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_Požární nezavodněný
Grafika - Použít měřítko poznámky: no
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Šířkové odsazení: 3048 mm; Viditelnost 1: no
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Klasifikace systému | Název systému = Group | Délka (mm) | Jmenovitý poloměr 1 (mm) = Odskok – šířka | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Odskok – výška | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Viditelnost 2 | Viditelnost 3 | Výškové odsazení (mm) | Max. vnější průměr tvarovky 12 (mm) | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm)
13356897 | -1.PP_SO-102 | ø89 mm-ø15 mm | -1.PP_SO-102 | 1337.33 | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 23.0438 | 44.5 | 7.5 | 89 | 15 | 89 | 15 | 0.0000615004 | 44.5 | 0.00724106 | ø89-ø15 | 36.87 | 6.35 | 92.175 | 15.875 | TT00.05.1092 | 1092 | yes | no | 3048 | 92.175 | 7.9375 | 46.0875
13358433 | 1.NP_SO-102 | ø89 mm-ø50 mm | 1.NP_SO-102 | 1300 | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 23.0438 | 44.5 | 25 | 89 | 50 | 89 | 50 | 0.000098742 | 44.5 | 0.00909361 | ø89-ø50 | 36.87 | 21.59 | 92.175 | 53.975 | TT00.05.1101 | 1101 | yes | no | 3048 | 92.175 | 26.9875 | 46.0875
13358521 | 2.NP_SO-102 | ø89 mm-ø50 mm | 2.NP_SO-102 | 1941.21 | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 23.0438 | 44.5 | 25 | 89 | 50 | 89 | 50 | 0.000098742 | 44.5 | 0.00909361 | ø89-ø50 | 36.87 | 21.59 | 92.175 | 53.975 | TT00.05.1104 | 1104 | yes | no | 3048 | 92.175 | 26.9875 | 46.0875
13359148 | 3.NP_SO-102 | ø89 mm-ø50 mm | 3.NP_SO-102 | 1333.34 | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 23.0438 | 25 | 44.5 | 50 | 89 | 89 | 50 | 0.0000987712 | 25 | 0.00909361 | ø89-ø50 | 21.59 | 36.87 | 53.975 | 92.175 | TT00.05.1113 | 1113 | no | yes | 3048 | 92.175 | 46.0875 | 26.9875
13359453 | 1.NP_SO-102 | ø89 mm-ø50 mm | 1.NP_SO-102 | 1300 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 23.0438 | 25 | 44.5 | 50 | 89 | 89 | 50 | 0.0000987712 | 25 | 0.00909361 | ø89-ø50 | 21.59 | 36.87 | 53.975 | 92.175 | TT00.05.1116 | 1116 | no | yes | 3048 | 92.175 | 46.0875 | 26.9875
13359549 | 2.NP_SO-102 | ø89 mm-ø54 mm | 2.NP_SO-102 | 1300 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 23.0438 | 44.5 | 27 | 89 | 54 | 89 | 54 | 0.000102667 | 44.5 | 0.00932515 | ø89-ø54 | 36.87 | 22.87 | 92.175 | 57.175 | TT00.05.1118 | 1118 | yes | no | 3048 | 92.175 | 28.5875 | 46.0875
13359551 | 2.NP_SO-102 | ø54 mm-ø50 mm | 2.NP_SO-102 | 1300 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 14.2937 | 27 | 25 | 54 | 50 | 54 | 50 | 0.0000346307 | 27 | 0.00444055 | ø54-ø50 | 22.87 | 21.59 | 57.175 | 53.975 | TT00.05.1119 | 1119 | yes | no | 3048 | 57.175 | 26.9875 | 28.5875
13359807 | 3.NP_SO-102 | ø89 mm-ø54 mm | 3.NP_SO-102 | 1300 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 23.0438 | 44.5 | 27 | 89 | 54 | 89 | 54 | 0.000102667 | 44.5 | 0.00932515 | ø89-ø54 | 36.87 | 22.87 | 92.175 | 57.175 | TT00.05.1121 | 1121 | yes | no | 3048 | 92.175 | 28.5875 | 46.0875
13359809 | 3.NP_SO-102 | ø54 mm-ø50 mm | 3.NP_SO-102 | 1300 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 14.2937 | 27 | 25 | 54 | 50 | 54 | 50 | 0.0000346307 | 27 | 0.00444055 | ø54-ø50 | 22.87 | 21.59 | 57.175 | 53.975 | TT00.05.1122 | 1122 | yes | no | 3048 | 57.175 | 26.9875 | 28.5875
13359969 | 4.NP_SO-102 | ø89 mm-ø50 mm | 4.NP_SO-102 | 800 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 23.0438 | 25 | 44.5 | 50 | 89 | 89 | 50 | 0.0000987712 | 63.7875 | 0.0100554 | ø89-ø50 | 21.59 | 36.87 | 53.975 | 92.175 | TT00.05.1123 | 1123 | no | yes | 3086.79 | 92.175 | 46.0875 | 26.9875
13361092 | -1.PP_SO-102 | ø89 mm-ø54 mm | -1.PP_SO-102 | 1300 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 23.0438 | 44.5 | 27 | 89 | 54 | 89 | 54 | 0.000102667 | 44.5 | 0.00932515 | ø89-ø54 | 36.87 | 22.87 | 92.175 | 57.175 | TT00.05.1125 | 1125 | yes | no | 3048 | 92.175 | 28.5875 | 46.0875
13361095 | -1.PP_SO-102 | ø54 mm-ø50 mm | -1.PP_SO-102 | 1300 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 14.2937 | 27 | 25 | 54 | 50 | 54 | 50 | 0.0000346307 | 27 | 0.00444055 | ø54-ø50 | 22.87 | 21.59 | 57.175 | 53.975 | TT00.05.1126 | 1126 | yes | no | 3048 | 57.175 | 26.9875 | 28.5875
13404250 | -1.PP_SO-102 | ø89 mm-ø15 mm | -1.PP_SO-102 | 2800 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 23.0438 | 44.5 | 7.5 | 89 | 15 | 89 | 15 | 0.0000615004 | 44.5 | 0.00724106 | ø89-ø15 | 36.87 | 6.35 | 92.175 | 15.875 | TT00.05.1163 | 1163 | yes | no | 3048 | 92.175 | 7.9375 | 46.0875
13764118 | -1.PP_SO-102 | ø89 mm-ø75 mm | -1.PP_SO-102 | 850.487 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 23.0438 | 37.5 | 44.5 | 75 | 89 | 89 | 75 | 0.000131522 | 37.5 | 0.0109622 | ø89-ø75 | 31.27 | 36.87 | 78.175 | 92.175 | TT00.05.1753 | 1753 | no | yes | 3048 | 92.175 | 46.0875 | 39.0875
13764569 | -1.PP_SO-102 | ø80 mm-ø75 mm | -1.PP_SO-102 | 2914.72 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 19.8438 | 37.5 | 40 | 75 | 80 | 80 | 75 | 0.0000966516 | 37.5 | 0.00920219 | ø80-ø75 | 31.27 | 31.75 | 78.175 | 79.375 | TT00.05.1761 | 1761 | no | yes | 3048 | 79.375 | 39.6875 | 39.0875
13764626 | -1.PP_SO-102 | ø89 mm-ø80 mm | -1.PP_SO-102 | 2904.52 | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 23.0438 | 44.5 | 40 | 89 | 80 | 89 | 80 | 0.0001333 | 44.5 | 0.0112403 | ø89-ø80 | 36.87 | 31.75 | 92.175 | 79.375 | TT00.05.1763 | 1763 | yes | no | 3048 | 92.175 | 39.6875 | 46.0875
13915802 | -1.PP_SO-102 | ø50 mm-ø15 mm | -1.PP_SO-102 | 1300 | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 13.4938 | 25 | 7.5 | 50 | 15 | 50 | 15 | 0.000014165 | 25 | 0.00255798 | ø50-ø15 | 21.59 | 6.35 | 53.975 | 15.875 | TT00.05.1982 | 1982 | yes | no | 3048 | 53.975 | 7.9375 | 26.9875
14022625 | 4.NP_SO-102 | ø89 mm-ø50 mm | 4.NP_SO-102 | 1312 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 2 | 23.0438 | 25 | 44.5 | 50 | 89 | 89 | 50 | 0.0000987712 | 25 | 0.00909361 | ø89-ø50 | 21.59 | 36.87 | 53.975 | 92.175 | TT00.05.2180 | 2180 | no | yes | 3048 | 92.175 | 46.0875 | 26.9875

# IfcPipeFitting: M_Přechod, obecný:Standardní (184)
Type - Classification: TT00 SNIM (SNIM); Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 05; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Viditelnost 1: no
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Délka (mm) | Jmenovitý poloměr 1 (mm) | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Max. vnější průměr tvarovky 12 (mm) | Šířkové odsazení (mm) | Viditelnost 2 | Viditelnost 3 | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm) | Výškové odsazení (mm) | Group
12954711 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0055 | 0055 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12954887 | 4.NP_SO-102 | ø32 mm-ø20 mm | 4.NP_SO-102 | 3360.03 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0056 | 0056 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12967298 | 3.NP_SO-102 | ø32 mm-ø25 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0096 | 0096 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12967311 | 3.NP_SO-102 | ø32 mm-ø25 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0097 | 0097 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12967313 | 3.NP_SO-102 | ø32 mm-ø25 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0098 | 0098 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12967322 | 3.NP_SO-102 | ø32 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0099 | 0099 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12967368 | 3.NP_SO-102 | ø32 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0100 | 0100 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12967403 | 3.NP_SO-102 | ø32 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0102 | 0102 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12967949 | 3.NP_SO-102 | ø32 mm-ø25 mm | 3.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0109 | 0109 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12968632 | 4.NP_SO-102 | ø32 mm-ø20 mm | 4.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0121 | 0121 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12968657 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0122 | 0122 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12968709 | 4.NP_SO-102 | ø32 mm-ø20 mm | 4.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0124 | 0124 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12968729 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0125 | 0125 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12968731 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0126 | 0126 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12968815 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0127 | 0127 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12971332 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0153 | 0153 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12971334 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0154 | 0154 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12971336 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0155 | 0155 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12971338 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0156 | 0156 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12971340 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0157 | 0157 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12971344 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0159 | 0159 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12971374 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0166 | 0166 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12984532 | 1.NP_SO-102 | ø32 mm-ø25 mm | 1.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0175 | 0175 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
12999458 | 2.NP_SO-102 | ø20 mm-ø15 mm | 2.NP_SO-102 | 580 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 5.55625 | 10 | 7.5 | 20 | 15 | 20 | 15 | 0.00000157471 | 10 | 10 | 0.000554533 | ø20-ø15 | 8.89 | 6.35 | 22.225 | 15.875 | TT00.05.0231 | 0231 | no | 22.225 | 3048 | yes | no | 7.9375 | 11.1125 | 3048 | WS_Teplá vnitřní 83 | Mechanické – tok - Tlaková ztráta: 0 Pa
12999766 | 2.NP_SO-102 | ø50 mm-ø32 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.05.0234 | 0234 | no | 53.975 | 3048 | yes | no | 17.4625 | 26.9875 | 3048 | WS_Teplá vnitřní 83
12999775 | 2.NP_SO-102 | ø50 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.05.0236 | 0236 | no | 53.975 | 3048 | yes | no | 17.4625 | 26.9875 | 3048 | WS_Studená vnitřní 134
13000525 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 2403.74 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0257 | 0257 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Studená vnitřní 134
13000546 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0258 | 0258 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13000564 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0259 | 0259 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 134
13000580 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0260 | 0260 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13000796 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0263 | 0263 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Cirkulace vnitřní 9
13001165 | 1.NP_SO-102 | ø32 mm-ø25 mm | 1.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0267 | 0267 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13001189 | 1.NP_SO-102 | ø32 mm-ø25 mm | 1.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0268 | 0268 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13001322 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0270 | 0270 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13003709 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 3309.84 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0288 | 0288 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13003717 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0289 | 0289 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13003931 | 1.NP_SO-102 | ø32 mm-ø20 mm | 1.NP_SO-102 | 3360.03 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0303 | 0303 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13003939 | 1.NP_SO-102 | ø32 mm-ø25 mm | 1.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0304 | 0304 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13007460 | 1.NP_SO-102 | ø32 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0333 | 0333 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 134
13007462 | 1.NP_SO-102 | ø32 mm-ø20 mm | 1.NP_SO-102 | 3319.84 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0334 | 0334 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Studená vnitřní 134
13007473 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0335 | 0335 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 134
13007475 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 3309.84 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0336 | 0336 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Studená vnitřní 134
13010179 | 1.NP_SO-102 | ø32 mm-ø25 mm | 1.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0360 | 0360 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13010195 | 1.NP_SO-102 | ø32 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0361 | 0361 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 134
13012102 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0377 | 0377 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13012161 | 3.NP_SO-102 | ø40 mm-ø25 mm | 3.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10.3188 | 20 | 12.5 | 40 | 25 | 40 | 25 | 0.00000994592 | 20 | 20 | 0.00193705 | ø40-ø25 | 16.51 | 11.43 | 41.275 | 28.575 | TT00.05.0378 | 0378 | no | 41.275 | 3048 | yes | no | 14.2875 | 20.6375 | 3048 | WS_Teplá vnitřní 83
13012648 | 1.NP_SO-102 | ø40 mm-ø32 mm | 1.NP_SO-102 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT00.05.0381 | 0381 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | 3048 | WS_Teplá vnitřní 83
13013099 | 3.NP_SO-102 | ø40 mm-ø32 mm | 3.NP_SO-102 | 1283.34 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT00.05.0384 | 0384 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | 3048 | WS_Teplá vnitřní 83
13013112 | 3.NP_SO-102 | ø40 mm-ø32 mm | 3.NP_SO-102 | 1533.34 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT00.05.0385 | 0385 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | 3048 | WS_Studená vnitřní 134
13013556 | 1.NP_SO-102 | ø40 mm-ø25 mm | 1.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10.3188 | 20 | 12.5 | 40 | 25 | 40 | 25 | 0.00000994592 | 20 | 20 | 0.00193705 | ø40-ø25 | 16.51 | 11.43 | 41.275 | 28.575 | TT00.05.0386 | 0386 | no | 41.275 | 3048 | yes | no | 14.2875 | 20.6375 | 3048 | WS_Teplá vnitřní 83
13014028 | 1.NP_SO-102 | ø32 mm-ø20 mm | 1.NP_SO-102 | 3289.84 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0392 | 0392 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13014067 | 1.NP_SO-102 | ø32 mm-ø20 mm | 1.NP_SO-102 | 3319.84 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0393 | 0393 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Studená vnitřní 134
13015394 | 3.NP_SO-102 | ø40 mm-ø32 mm | 3.NP_SO-102 | 3423.53 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT00.05.0408 | 0408 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | 3048 | WS_Teplá vnitřní 83
13015396 | 3.NP_SO-102 | ø40 mm-ø32 mm | 3.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT00.05.0409 | 0409 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | 3048 | WS_Teplá vnitřní 83
13015490 | 2.NP_SO-102 | ø40 mm-ø32 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT00.05.0412 | 0412 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | 3048 | WS_Teplá vnitřní 83
13015536 | 1.NP_SO-102 | ø40 mm-ø32 mm | 1.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT00.05.0415 | 0415 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | 3048 | WS_Teplá vnitřní 83
13015598 | 1.NP_SO-102 | ø40 mm-ø25 mm | 1.NP_SO-102 | 3226.99 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10.3188 | 20 | 12.5 | 40 | 25 | 40 | 25 | 0.00000994592 | 20 | 20 | 0.00193705 | ø40-ø25 | 16.51 | 11.43 | 41.275 | 28.575 | TT00.05.0416 | 0416 | yes | 41.275 | 3048 | yes | no | 14.2875 | 20.6375 | 3048 | WS_Teplá vnitřní 83
13015907 | 3.NP_SO-102 | ø32 mm-ø20 mm | 3.NP_SO-102 | 3319.84 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0418 | 0418 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Studená vnitřní 134
13015969 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0419 | 0419 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 134
13016006 | 4.NP_SO-102 | ø32 mm-ø20 mm | 4.NP_SO-102 | 3319.84 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0421 | 0421 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Studená vnitřní 134
13018610 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 3270.63 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0424 | 0424 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83; WS_Cirkulace vnitřní 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13018620 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0426 | 0426 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83 | Mechanické – tok - Tlaková ztráta: 0 Pa
13020911 | -1.PP_SO-102 | ø63 mm-ø20 mm | -1.PP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16.5437 | 31.5 | 10 | 63 | 20 | 63 | 20 | 0.0000274375 | 31.5 | 31.5 | 0.00400175 | ø63-ø20 | 26.47 | 8.89 | 66.175 | 22.225 | TT00.05.0428 | 0428 | no | 66.175 | 3048 | yes | no | 11.1125 | 33.0875 | 3048 | WS_Teplá vnitřní 83
13028415 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0482 | 0482 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 8
13028426 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0483 | 0483 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 6
13028494 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0484 | 0484 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 8
13028496 | 4.NP_SO-102 | ø32 mm-ø20 mm | 4.NP_SO-102 | 3314.76 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0485 | 0485 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 8
13028556 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0487 | 0487 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 6
13028573 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0488 | 0488 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 6
13028575 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0489 | 0489 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 6
13028577 | 4.NP_SO-102 | ø32 mm-ø20 mm | 4.NP_SO-102 | 3254.76 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0490 | 0490 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Studená vnitřní 6
13030652 | 3.NP_SO-102 | ø32 mm-ø25 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0528 | 0528 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 8
13030654 | 3.NP_SO-102 | ø32 mm-ø25 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0529 | 0529 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 6
13030658 | 3.NP_SO-102 | ø32 mm-ø20 mm | 3.NP_SO-102 | 3314.76 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0530 | 0530 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 8
13030670 | 3.NP_SO-102 | ø32 mm-ø25 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0532 | 0532 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 6
13030674 | 3.NP_SO-102 | ø32 mm-ø25 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0533 | 0533 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 6
13030676 | 3.NP_SO-102 | ø32 mm-ø20 mm | 3.NP_SO-102 | 3254.76 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0534 | 0534 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Studená vnitřní 6
13031059 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0574 | 0574 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 8
13031061 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0575 | 0575 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 6
13031065 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 3314.76 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0576 | 0576 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 8
13031077 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0578 | 0578 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 6
13031081 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0579 | 0579 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 6
13031083 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 3254.76 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0580 | 0580 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Studená vnitřní 6
13031468 | 1.NP_SO-102 | ø32 mm-ø25 mm | 1.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0606 | 0606 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 8
13031470 | 1.NP_SO-102 | ø32 mm-ø25 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0607 | 0607 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 6
13031474 | 1.NP_SO-102 | ø32 mm-ø20 mm | 1.NP_SO-102 | 3314.76 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0608 | 0608 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 8
13031490 | 1.NP_SO-102 | ø32 mm-ø25 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0609 | 0609 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 6
13031492 | 1.NP_SO-102 | ø32 mm-ø20 mm | 1.NP_SO-102 | 3254.76 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0610 | 0610 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Studená vnitřní 6
13032916 | 3.NP_SO-102 | ø32 mm-ø25 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0635 | 0635 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 6
13032990 | 3.NP_SO-102 | ø32 mm-ø25 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0637 | 0637 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 8
13033076 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 12.4997 | 0.000934647 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0640 | 0640 | yes | 28.575 | 3048 | yes | no | 11.1125 | 14.2875 | 3048 | WS_Teplá vnitřní 8
13034740 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 17.5744 | 0.00100265 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0668 | 0668 | yes | 28.575 | 3048 | yes | no | 11.1125 | 14.2875 | 3053.07 | WS_Teplá vnitřní 8
13034762 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0669 | 0669 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 6
13034806 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0671 | 0671 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 8
13037235 | 2.NP_SO-102 | ø40 mm-ø32 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT00.05.0693 | 0693 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | 3048 | WS_Teplá vnitřní 8
13037247 | 2.NP_SO-102 | ø40 mm-ø32 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT00.05.0694 | 0694 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | 3048 | WS_Studená vnitřní 6
13037259 | 1.NP_SO-102 | ø50 mm-ø40 mm | 1.NP_SO-102 | 3311.59 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 13.4938 | 20 | 25 | 40 | 50 | 50 | 40 | 0.0000241169 | 20 | 20 | 0.00346833 | ø50-ø40 | 16.51 | 21.59 | 41.275 | 53.975 | TT00.05.0695 | 0695 | yes | 53.975 | 3048 | no | yes | 26.9875 | 20.6375 | 3048 | WS_Teplá vnitřní 8
13037261 | 1.NP_SO-102 | ø40 mm-ø32 mm | 1.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT00.05.0696 | 0696 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | 3048 | WS_Teplá vnitřní 8
13037273 | 1.NP_SO-102 | ø50 mm-ø40 mm | 1.NP_SO-102 | 3251.59 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 13.4938 | 20 | 25 | 40 | 50 | 50 | 40 | 0.0000241169 | 20 | 20 | 0.00346833 | ø50-ø40 | 16.51 | 21.59 | 41.275 | 53.975 | TT00.05.0697 | 0697 | yes | 53.975 | 3048 | no | yes | 26.9875 | 20.6375 | 3048 | WS_Studená vnitřní 6
13037275 | 1.NP_SO-102 | ø40 mm-ø32 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT00.05.0698 | 0698 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | 3048 | WS_Studená vnitřní 6
13037440 | -1.PP_SO-102 | ø32 mm-ø20 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0701 | 0701 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_"ŠEDÁ" studená vnitřní 2
13037755 | 1.NP_SO-102 | ø32 mm-ø25 mm | 1.NP_SO-102 | 1230.16 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0702 | 0702 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_"Jiný typ" studená vnitřní 1
13069128 | -1.PP_SO-102 | ø63 mm-ø20 mm | -1.PP_SO-102 | 3254.21 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16.5437 | 31.5 | 10 | 63 | 20 | 63 | 20 | 0.0000274375 | 31.5 | 31.5 | 0.00400175 | ø63-ø20 | 26.47 | 8.89 | 66.175 | 22.225 | TT00.05.0749 | 0749 | yes | 66.175 | 3048 | yes | no | 11.1125 | 33.0875 | 3048 | WS_"Jiný typ" studená vnitřní 1
13071903 | 1.NP_SO-102 | ø32 mm-ø25 mm | 1.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0755 | 0755 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13074226 | -1.PP_SO-102 | ø63 mm-ø50 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16.5437 | 25 | 31.5 | 50 | 63 | 63 | 50 | 0.0000470007 | 25 | 25 | 0.00542487 | ø63-ø50 | 21.59 | 26.47 | 53.975 | 66.175 | TT00.05.0758 | 0758 | yes | 66.175 | 3048 | no | yes | 33.0875 | 26.9875 | 3048 | WS_Teplá vnitřní 83
13074401 | -1.PP_SO-102 | ø63 mm-ø50 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16.5437 | 25 | 31.5 | 50 | 63 | 63 | 50 | 0.0000470007 | 25 | 25 | 0.00542487 | ø63-ø50 | 21.59 | 26.47 | 53.975 | 66.175 | TT00.05.0761 | 0761 | yes | 66.175 | 3048 | no | yes | 33.0875 | 26.9875 | 3048 | WS_Studená vnitřní 134
13080854 | -1.PP_SO-102 | ø50 mm-ø16 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 13.4938 | 25 | 8 | 50 | 16 | 50 | 16 | 0.0000152029 | 25 | 25 | 0.00262154 | ø50-ø16 | 21.59 | 7.67 | 53.975 | 19.175 | TT00.05.0776 | 0776 | yes | 53.975 | 3048 | yes | no | 9.5875 | 26.9875 | 3048 | WS_Teplá vnitřní 83 | Mechanické – tok - Tlaková ztráta: 0 Pa
13081071 | -1.PP_SO-102 | ø63 mm-ø20 mm | -1.PP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16.5437 | 31.5 | 10 | 63 | 20 | 63 | 20 | 0.0000274375 | 31.5 | 31.5 | 0.00400175 | ø63-ø20 | 26.47 | 8.89 | 66.175 | 22.225 | TT00.05.0778 | 0778 | no | 66.175 | 3048 | yes | no | 11.1125 | 33.0875 | 3048 | WS_Studená vnitřní 134
13083348 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0779 | 0779 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Studená vnitřní 134
13083350 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0780 | 0780 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Studená vnitřní 134
13083352 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0781 | 0781 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 134
13083354 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0782 | 0782 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13154315 | 1.NP_SO-102 | ø32 mm-ø25 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0853 | 0853 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 6
13154323 | 1.NP_SO-102 | ø32 mm-ø25 mm | 1.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.0855 | 0855 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 8
13169615 | 1.NP_SO-102 | ø40 mm-ø25 mm | 1.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10.3188 | 20 | 12.5 | 40 | 25 | 40 | 25 | 0.00000994592 | 20 | 20 | 0.00193705 | ø40-ø25 | 16.51 | 11.43 | 41.275 | 28.575 | TT00.05.0898 | 0898 | yes | 41.275 | 3048 | yes | no | 14.2875 | 20.6375 | 3048 | WS_"ŠEDÁ" studená vnitřní 2
13347287 | 2.NP_SO-102 | ø50 mm-ø32 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.05.1075 | 1075 | no | 53.975 | 3048 | yes | no | 17.4625 | 26.9875 | 3048 | WS_Teplá vnitřní 83
13347295 | 2.NP_SO-102 | ø50 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.05.1077 | 1077 | no | 53.975 | 3048 | yes | no | 17.4625 | 26.9875 | 3048 | WS_Studená vnitřní 134
13357403 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 15.6377 | 0.00129521 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1096 | 1096 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3047.64 | WS_Teplá vnitřní 83
13402006 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 2373.58 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.1151 | 1151 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 134
13402076 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 2369.84 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.1154 | 1154 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13473808 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1239 | 1239 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Studená vnitřní 134
13473823 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1243 | 1243 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13473899 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.1248 | 1248 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13473901 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.1249 | 1249 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13473905 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 1430.16 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1251 | 1251 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13473909 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 2002.33 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1253 | 1253 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13473920 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.1255 | 1255 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 134
