Properties of the parts of a building model (IFC4), part 58 of 60

# IfcValve: Kulový kohout závitový.LH:DN15 (9)
Name (Kulový kohout závitový.LH:DN15:...) | In | Podlaží | Výška od podlaží (mm) | Typ systému | Název systému = Group | Kód prvku | Označení
12967657 | 3.NP_SO-102 | 3.NP_SO-102 | 1530.16 | WS_Studená vnitřní | WS_Studená vnitřní 134 | VE01.10.0317 | 0317 | Identifikační data - Komentáře: UMÍSTĚNO NA SVISLÉM POTRUBÍ, PŘÍSTUP REVIZNÍMI DVÍŘKY
12971365 | 2.NP_SO-102 | 2.NP_SO-102 | 1530.16 | WS_Studená vnitřní | WS_Studená vnitřní 134 | VE01.10.0323 | 0323
12984944 | 1.NP_SO-102 | 1.NP_SO-102 | 1479.17 | WS_Studená vnitřní | WS_Studená vnitřní 179 | VE01.10.0328 | 0328
13010639 | 1.NP_SO-102 | 1.NP_SO-102 | 1426.66 | WS_"ŠEDÁ" studená vnitřní | WS_"Jiný typ" studená vnitřní 1 | VE01.10.0351 | 0351
13644954 | 1.NP_SO-102 | 1.NP_SO-102 | 3350 | WS_Studená vnitřní | WS_Studená vnitřní 134 | VE01.10.0650 | 0650 | Mechanické – tok - Tlaková ztráta: 0 Pa
13645190 | 2.NP_SO-102 | 2.NP_SO-102 | 3340 | WS_Studená vnitřní | WS_Studená vnitřní 134 | VE01.10.0651 | 0651 | Mechanické – tok - Tlaková ztráta: 0 Pa
13645359 | 3.NP_SO-102 | 3.NP_SO-102 | 3350 | WS_Studená vnitřní | WS_Studená vnitřní 134 | VE01.10.0653 | 0653 | Mechanické – tok - Tlaková ztráta: 0 Pa
13645513 | 4.NP_SO-102 | 4.NP_SO-102 | 3350 | WS_Studená vnitřní | WS_Studená vnitřní 134 | VE01.10.0655 | 0655 | Mechanické – tok - Tlaková ztráta: 0 Pa

# IfcValve: Kulový kohout závitový.LH:DN15 (25)
Type - Classification: VE01 SNIM (SNIM); Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Koeficient K: 0
Type - Kóty - DÉLKA: 54 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; JMENOVITÝ PRŮMĚR: 15 mm; VÝŠKA: 33.7 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.14.17; Kód sestavy: VE01; Komentáře k typům: KK DN15; Nadpis OmniClass: Adjusting/Controlling Valves for Liquid Services; Název typu: DN15; Označení typu: 10; Popis: Ventil; Popis sestavy: Kulový kohout
Type - Jiné - Kategorie: Příslušenství trubek; Body Diameter: 16.5 mm; Body Height: 24.3389 mm; Body Radius: 8.25 mm; Half Nut Height: 2.475 mm; Handle Width: 9.5 mm; Length 1: 26 mm; Length 2: 11.6 mm; Lookup Table Name: Závitový_Plnící a vypouštěcí kohout; Název rodiny: Kulový kohout závitový.LH; Nut Diameter: 4.5 mm; Nut Height: 4.95 mm; Nut Radius: 2.25 mm; Páka_Délka: 78 mm; Páka_Tloušťka: 4.95 mm; Příruba_Průměr: 23 mm; Příruba_Tloušťka: 14 mm; Radius: 23.2 mm; Seal Length: 15.4 mm; Stem Diameter: 3 mm; Stem Height: 9.36111 mm; Stem Radius: 1.5 mm; VS: 54 mm
Classification: VE01 SNIM (SNIM); VE01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø20 mm-ø20 mm
Text - CCI Funkční systém: F; CCI Komponenta: FMD; CCI Technický systém: JB
Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 20 mm; Minimální velikost: 20 mm; Objem: 0.0000248726 m3; Průměr připojení: 20 mm; Velikost: ø20-ø20
Jiné - Rodina: Kulový kohout závitový.LH; Id typu: 12958572; Rodina a typ: Kulový kohout závitový.LH: DN15; Typ: DN15
Name (Kulový kohout závitový.LH:DN15:...) | In | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Kód prvku | Označení | Páteřní trasa
12966747 | 4.NP_SO-102 | 4.NP_SO-102 | 1713.97 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.10.0308 | 0308 | no
12967641 | 3.NP_SO-102 | 3.NP_SO-102 | 1530.16 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.10.0316 | 0316 | no
12971362 | 2.NP_SO-102 | 2.NP_SO-102 | 1530.16 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.10.0322 | 0322 | no
12984924 | 1.NP_SO-102 | 1.NP_SO-102 | 1506.17 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 193 | VE01.10.0327 | 0327 | no
13010412 | 1.NP_SO-102 | 1.NP_SO-102 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | VE01.10.0347 | 0347 | no
13036820 | 3.NP_SO-102 | 3.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | VE01.10.0377 | 0377 | yes
13046567 | 2.NP_SO-102 | 2.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 23 | VE01.10.0387 | 0387 | no | Mechanické – tok - Tlaková ztráta: 0 Pa
13069469 | -1.PP_SO-102 | -1.PP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.10.0405 | 0405 | no
13070210 | 4.NP_SO-102 | 4.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | VE01.10.0408 | 0408 | no | Mechanické – tok - Tlaková ztráta: 0 Pa
13070638 | 3.NP_SO-102 | 3.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 3 | VE01.10.0412 | 0412 | no | Mechanické – tok - Tlaková ztráta: 0 Pa
13071427 | 1.NP_SO-102 | 1.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | VE01.10.0418 | 0418 | no | Mechanické – tok - Tlaková ztráta: 0 Pa
13080082 | -1.PP_SO-102 | -1.PP_SO-102 | 2600 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | VE01.10.0429 | 0429 | no
13080143 | 2.NP_SO-102 | 2.NP_SO-102 | 1858.37 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | VE01.10.0430 | 0430 | no
13081094 | -1.PP_SO-102 | -1.PP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.10.0432 | 0432 | no
13402161 | 2.NP_SO-102 | 2.NP_SO-102 | 2402 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.10.0520 | 0520 | no
13402181 | 2.NP_SO-102 | 2.NP_SO-102 | 2399.64 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.10.0521 | 0521 | no
13402205 | 2.NP_SO-102 | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.10.0522 | 0522 | no
13402540 | 2.NP_SO-102 | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | VE01.10.0526 | 0526 | no
13464890 | 2.NP_SO-102 | 2.NP_SO-102 | 2402.33 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.10.0542 | 0542 | no
13486272 | 2.NP_SO-102 | 2.NP_SO-102 | 2399.87 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.10.0555 | 0555 | no
13502301 | 2.NP_SO-102 | 2.NP_SO-102 | 2403.02 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.10.0556 | 0556 | no
13502428 | 2.NP_SO-102 | 2.NP_SO-102 | 2403.02 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.10.0557 | 0557 | no
13502481 | 2.NP_SO-102 | 2.NP_SO-102 | 2399.87 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.10.0558 | 0558 | no
13502704 | 2.NP_SO-102 | 2.NP_SO-102 | 2401.56 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.10.0559 | 0559 | no
13502735 | 2.NP_SO-102 | 2.NP_SO-102 | 2400.58 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.10.0560 | 0560 | no

# IfcValve: Kulový kohout závitový.LH:DN20 (31)
Type - Classification: VE01 SNIM (SNIM); Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Koeficient K: 0
Type - Kóty - DÉLKA: 62 mm; Jmenovitá velikost vstupu: 20 mm; Jmenovitá velikost výstupu: 20 mm; JMENOVITÝ PRŮMĚR: 20 mm; VÝŠKA: 45.5 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.14.17; Kód sestavy: VE01; Komentáře k typům: KK DN20; Nadpis OmniClass: Adjusting/Controlling Valves for Liquid Services; Název typu: DN20; Označení typu: 09; Popis: Ventil; Popis sestavy: Kulový kohout
Type - Jiné - Kategorie: Příslušenství trubek; Body Diameter: 22 mm; Body Height: 32.8611 mm; Body Radius: 11 mm; Half Nut Height: 3.3 mm; Handle Width: 10 mm; Length 1: 34 mm; Length 2: 15.6 mm; Lookup Table Name: Závitový_Plnící a vypouštěcí kohout; Název rodiny: Kulový kohout závitový.LH; Nut Diameter: 6 mm; Nut Height: 6.6 mm; Nut Radius: 3 mm; Páka_Délka: 96 mm; Páka_Tloušťka: 6.6 mm; Příruba_Průměr: 29 mm; Příruba_Tloušťka: 14 mm; Radius: 31.2 mm; Seal Length: 15.4 mm; Stem Diameter: 4 mm; Stem Height: 12.6389 mm; Stem Radius: 2 mm; VS: 62 mm
Classification: VE01 SNIM (SNIM); VE01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø25 mm-ø25 mm
Text - CCI Funkční systém: F; CCI Komponenta: FMD; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 25 mm; Minimální velikost: 25 mm; Objem: 0.0000472561 m3; Průměr připojení: 25 mm; Velikost: ø25-ø25
Jiné - Id typu: 12958580; Rodina: Kulový kohout závitový.LH; Rodina a typ: Kulový kohout závitový.LH: DN20; Typ: DN20
Name (Kulový kohout závitový.LH:DN20:...) | In | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Kód prvku | Označení | Páteřní trasa
12958678 | 4.NP_SO-102 | 4.NP_SO-102 | 3350 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.09.0306 | 0306 | yes | Identifikační data - ID pozice: KK 3/4"
12966891 | 4.NP_SO-102 | 4.NP_SO-102 | 1500 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.09.0309 | 0309 | no | Identifikační data - ID pozice: KK DN20
12967249 | 3.NP_SO-102 | 3.NP_SO-102 | 1500 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.09.0313 | 0313 | no
12967451 | 3.NP_SO-102 | 3.NP_SO-102 | 3350 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.09.0314 | 0314 | yes
12967541 | 3.NP_SO-102 | 3.NP_SO-102 | 3350 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.09.0315 | 0315 | yes
12971329 | 2.NP_SO-102 | 2.NP_SO-102 | 1500 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.09.0319 | 0319 | no
12971346 | 2.NP_SO-102 | 2.NP_SO-102 | 3320 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.09.0320 | 0320 | yes
12971349 | 2.NP_SO-102 | 2.NP_SO-102 | 3350 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.09.0321 | 0321 | yes
12984669 | 1.NP_SO-102 | 1.NP_SO-102 | 1500 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.09.0324 | 0324 | no
13005468 | 4.NP_SO-102 | 4.NP_SO-102 | 3350 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.09.0335 | 0335 | yes
13005495 | 4.NP_SO-102 | 4.NP_SO-102 | 3366.66 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.09.0336 | 0336 | yes
13005935 | 3.NP_SO-102 | 3.NP_SO-102 | 3350 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 3 | VE01.09.0339 | 0339 | yes
13005951 | 3.NP_SO-102 | 3.NP_SO-102 | 3366.66 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.09.0340 | 0340 | yes
13008586 | 2.NP_SO-102 | 2.NP_SO-102 | 3340 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.09.0343 | 0343 | yes
13008606 | 2.NP_SO-102 | 2.NP_SO-102 | 3366.66 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.09.0344 | 0344 | yes
13010560 | 1.NP_SO-102 | 1.NP_SO-102 | 3350 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.09.0348 | 0348 | yes
13010578 | 1.NP_SO-102 | 1.NP_SO-102 | 3366.66 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.09.0349 | 0349 | yes
13010593 | 1.NP_SO-102 | 1.NP_SO-102 | 3350 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | VE01.09.0350 | 0350 | yes
13011255 | 2.NP_SO-102 | 2.NP_SO-102 | 1426.66 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 1 | VE01.09.0354 | 0354 | no
13011306 | 3.NP_SO-102 | 3.NP_SO-102 | 1426.66 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | VE01.09.0355 | 0355 | no
13011334 | 4.NP_SO-102 | 4.NP_SO-102 | 1426.66 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | VE01.09.0356 | 0356 | no
13047666 | -1.PP_SO-102 | -1.PP_SO-102 | 3300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.09.0395 | 0395 | no
13047688 | -1.PP_SO-102 | -1.PP_SO-102 | 3300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.09.0396 | 0396 | no
13069675 | -1.PP_SO-102 | -1.PP_SO-102 | 1000 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.09.0406 | 0406 | no
13069703 | -1.PP_SO-102 | -1.PP_SO-102 | 1000 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.09.0407 | 0407 | no
13076552 | -1.PP_SO-102 | -1.PP_SO-102 | 3100 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | VE01.09.0425 | 0425 | yes
13401934 | 2.NP_SO-102 | 2.NP_SO-102 | 2402.33 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.09.0517 | 0517 | no
13402110 | 2.NP_SO-102 | 2.NP_SO-102 | 1300 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.09.0518 | 0518 | no
13402126 | 2.NP_SO-102 | 2.NP_SO-102 | 1300 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.09.0519 | 0519 | no
13464828 | 2.NP_SO-102 | 2.NP_SO-102 | 2400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.09.0541 | 0541 | no
13484698 | 2.NP_SO-102 | 2.NP_SO-102 | 2400 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | VE01.09.0552 | 0552 | no

# IfcValve: Kulový kohout závitový.LH:DN20 (6)
Type - Classification: VE01 SNIM (SNIM); Material: 128-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Koeficient K: 0
Type - Kóty - DÉLKA: 62 mm; Jmenovitá velikost vstupu: 20 mm; Jmenovitá velikost výstupu: 20 mm; JMENOVITÝ PRŮMĚR: 20 mm; VÝŠKA: 45.5 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.14.17; Kód sestavy: VE01; Komentáře k typům: KK DN20; Nadpis OmniClass: Adjusting/Controlling Valves for Liquid Services; Název typu: DN20; Označení typu: 09; Popis: Ventil; Popis sestavy: Kulový kohout
Type - Jiné - Kategorie: Příslušenství trubek; Body Diameter: 22 mm; Body Height: 32.8611 mm; Body Radius: 11 mm; Half Nut Height: 3.3 mm; Handle Width: 10 mm; Length 1: 34 mm; Length 2: 15.6 mm; Lookup Table Name: Závitový_Plnící a vypouštěcí kohout; Název rodiny: Kulový kohout závitový.LH; Nut Diameter: 6 mm; Nut Height: 6.6 mm; Nut Radius: 3 mm; Páka_Délka: 96 mm; Páka_Tloušťka: 6.6 mm; Příruba_Průměr: 29 mm; Příruba_Tloušťka: 14 mm; Radius: 31.2 mm; Seal Length: 15.4 mm; Stem Diameter: 4 mm; Stem Height: 12.6389 mm; Stem Radius: 2 mm; VS: 62 mm
Classification: VE01 SNIM (SNIM); VE01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø20 mm-ø20 mm
Text - CCI Funkční systém: F; CCI Komponenta: FMD; CCI Technický systém: JB
Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 20 mm; Minimální velikost: 20 mm; Objem: 0.0000472561 m3; Průměr připojení: 20 mm; Velikost: ø20-ø20
Jiné - Páteřní trasa: no; Id typu: 12958580; Rodina: Kulový kohout závitový.LH; Rodina a typ: Kulový kohout závitový.LH: DN20; Typ: DN20
Name (Kulový kohout závitový.LH:DN20:...) | In | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Kód prvku | Označení
13046549 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | VE01.09.0381 | 0381
13046558 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 22 | VE01.09.0384 | 0384
13046576 | 1.NP_SO-102 | 0 | 1.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 24 | VE01.09.0390 | 0390
13071152 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | VE01.09.0415 | 0415
13836648 | 1.NP_SO-102 |  | 1.NP_SO-102 | 500 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.09.0674 | 0674
13836674 | 1.NP_SO-102 |  | 1.NP_SO-102 | 500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.09.0675 | 0675

# IfcValve: Kulový kohout závitový.LH:DN20 (5)
Type - Classification: VE01 SNIM (SNIM); Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Koeficient K: 0
Type - Kóty - DÉLKA: 62 mm; Jmenovitá velikost vstupu: 20 mm; Jmenovitá velikost výstupu: 20 mm; JMENOVITÝ PRŮMĚR: 20 mm; VÝŠKA: 45.5 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.14.17; Kód sestavy: VE01; Komentáře k typům: KK DN20; Nadpis OmniClass: Adjusting/Controlling Valves for Liquid Services; Název typu: DN20; Označení typu: 09; Popis: Ventil; Popis sestavy: Kulový kohout
Type - Jiné - Kategorie: Příslušenství trubek; Body Diameter: 22 mm; Body Height: 32.8611 mm; Body Radius: 11 mm; Half Nut Height: 3.3 mm; Handle Width: 10 mm; Length 1: 34 mm; Length 2: 15.6 mm; Lookup Table Name: Závitový_Plnící a vypouštěcí kohout; Název rodiny: Kulový kohout závitový.LH; Nut Diameter: 6 mm; Nut Height: 6.6 mm; Nut Radius: 3 mm; Páka_Délka: 96 mm; Páka_Tloušťka: 6.6 mm; Příruba_Průměr: 29 mm; Příruba_Tloušťka: 14 mm; Radius: 31.2 mm; Seal Length: 15.4 mm; Stem Diameter: 4 mm; Stem Height: 12.6389 mm; Stem Radius: 2 mm; VS: 62 mm
Classification: VE01 SNIM (SNIM); VE01 Uniformat (Uniformat); Group: WS_Teplá vnitřní 83
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø32 mm-ø32 mm
Text - CCI Funkční systém: F; CCI Komponenta: FMD; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_Teplá vnitřní; Klasifikace systému: Teplá voda v domácnosti; Název systému: WS_Teplá vnitřní 83; PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 32 mm; Minimální velikost: 32 mm; Objem: 0.0000472561 m3; Průměr připojení: 32 mm; Velikost: ø32-ø32
Jiné - Id typu: 12958580; Rodina: Kulový kohout závitový.LH; Rodina a typ: Kulový kohout závitový.LH: DN20; Typ: DN20
Name (Kulový kohout závitový.LH:DN20:...) | In | Podlaží | Výška od podlaží (mm) | Kód prvku | Označení | Páteřní trasa | ID pozice
12958659 | 4.NP_SO-102 | 4.NP_SO-102 | 3320 | VE01.09.0305 | 0305 | yes
12966909 | 4.NP_SO-102 | 4.NP_SO-102 | 1250 | VE01.09.0310 | 0310 | no | KK DN20
12967166 | 3.NP_SO-102 | 3.NP_SO-102 | 1250 | VE01.09.0311 | 0311 | no | KK DN20
12967214 | 1.NP_SO-102 | 1.NP_SO-102 | 1250 | VE01.09.0312 | 0312 | no | KK DN20
12971326 | 2.NP_SO-102 | 2.NP_SO-102 | 1250 | VE01.09.0318 | 0318 | no | KK DN20

# IfcValve: Kulový kohout závitový.LH:DN25 (29)
Type - Classification: VE01 SNIM (SNIM); Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Koeficient K: 0
Type - Kóty - DÉLKA: 71 mm; Jmenovitá velikost vstupu: 25 mm; Jmenovitá velikost výstupu: 25 mm; JMENOVITÝ PRŮMĚR: 25 mm; VÝŠKA: 49.6 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.14.17; Kód sestavy: VE01; Komentáře k typům: KK DN25; Nadpis OmniClass: Adjusting/Controlling Valves for Liquid Services; Název typu: DN25; Označení typu: 11; Popis: Ventil; Popis sestavy: Kulový kohout
Type - Jiné - Kategorie: Příslušenství trubek; Body Diameter: 27.5 mm; Body Height: 35.8222 mm; Body Radius: 13.75 mm; Half Nut Height: 4.125 mm; Handle Width: 10.5 mm; Length 1: 36 mm; Length 2: 16.25 mm; Lookup Table Name: Závitový_Plnící a vypouštěcí kohout; Název rodiny: Kulový kohout závitový.LH; Nut Diameter: 7.5 mm; Nut Height: 8.25 mm; Nut Radius: 3.75 mm; Páka_Délka: 96 mm; Páka_Tloušťka: 7 mm; Příruba_Průměr: 35 mm; Příruba_Tloušťka: 17.5 mm; Radius: 32.5 mm; Seal Length: 19.25 mm; Stem Diameter: 5 mm; Stem Height: 13.7778 mm; Stem Radius: 2.5 mm; VS: 71 mm
Classification: VE01 SNIM (SNIM); VE01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: FMD; CCI Technický systém: JB
Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Objem: 0.0000753155 m3
Jiné - Rodina: Kulový kohout závitový.LH; Id typu: 12958586; Rodina a typ: Kulový kohout závitový.LH: DN25; Typ: DN25
Name (Kulový kohout závitový.LH:DN25:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Maximální velikost (mm) = Minimální velikost (mm) = Průměr připojení (mm) | Velikost | Kód prvku | Označení | Páteřní trasa
13005514 | 4.NP_SO-102 | ø32 mm-ø32 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 32 | ø32-ø32 | VE01.11.0337 | 0337 | yes
13005538 | 4.NP_SO-102 | ø32 mm-ø32 mm | 4.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 32 | ø32-ø32 | VE01.11.0338 | 0338 | yes
13005979 | 3.NP_SO-102 | ø32 mm-ø32 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 32 | ø32-ø32 | VE01.11.0341 | 0341 | yes
13006126 | 3.NP_SO-102 | ø32 mm-ø32 mm | 3.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 32 | ø32-ø32 | VE01.11.0342 | 0342 | yes
13008630 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 32 | ø32-ø32 | VE01.11.0345 | 0345 | yes
13008646 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 32 | ø32-ø32 | VE01.11.0346 | 0346 | yes
13010744 | 1.NP_SO-102 | ø32 mm-ø32 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 32 | ø32-ø32 | VE01.11.0352 | 0352 | yes
13010762 | 1.NP_SO-102 | ø32 mm-ø32 mm | 1.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 32 | ø32-ø32 | VE01.11.0353 | 0353 | yes
13021084 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 32 | ø32-ø32 | VE01.11.0358 | 0358 | yes | Mechanické – tok - Tlaková ztráta: 0 Pa
13028211 | 4.NP_SO-102 | ø32 mm-ø32 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 32 | ø32-ø32 | VE01.11.0360 | 0360 | yes
13028229 | 4.NP_SO-102 | ø32 mm-ø32 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 32 | ø32-ø32 | VE01.11.0361 | 0361 | yes
13030640 | 3.NP_SO-102 | ø32 mm-ø32 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 32 | ø32-ø32 | VE01.11.0364 | 0364 | yes
13030643 | 3.NP_SO-102 | ø32 mm-ø32 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 32 | ø32-ø32 | VE01.11.0365 | 0365 | yes
13031047 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 32 | ø32-ø32 | VE01.11.0368 | 0368 | yes
13031050 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 32 | ø32-ø32 | VE01.11.0369 | 0369 | yes
13031456 | 1.NP_SO-102 | ø32 mm-ø32 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 32 | ø32-ø32 | VE01.11.0372 | 0372 | yes
13031459 | 1.NP_SO-102 | ø32 mm-ø32 mm | 1.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 32 | ø32-ø32 | VE01.11.0373 | 0373 | yes
13036769 | 4.NP_SO-102 | ø32 mm-ø32 mm | 4.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 32 | ø32-ø32 | VE01.11.0376 | 0376 | yes
13036862 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 32 | ø32-ø32 | VE01.11.0378 | 0378 | yes
13047312 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 32 | ø32-ø32 | VE01.11.0394 | 0394 | yes
13076568 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 3100 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 32 | ø32-ø32 | VE01.11.0426 | 0426 | yes
13079766 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 32 | ø32-ø32 | VE01.11.0428 | 0428 | yes | Mechanické – tok - Tlaková ztráta: 0 Pa
13402291 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 32 | ø32-ø32 | VE01.11.0523 | 0523 | no
13402489 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 32 | ø32-ø32 | VE01.11.0524 | 0524 | no
13402505 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2402.33 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 32 | ø32-ø32 | VE01.11.0525 | 0525 | no
13486206 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 32 | ø32-ø32 | VE01.11.0554 | 0554 | no
13536650 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 3300.03 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 32 | ø32-ø32 | VE01.11.0595 | 0595 | yes
13642687 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 3 | 32 | ø32-ø32 | VE01.11.0643 | 0643 | yes | Mechanické – tok - Tlaková ztráta: 0 Pa
13987714 | -1.PP_SO-102 | ø75 mm-ø75 mm | -1.PP_SO-102 | 1521.55 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 75 | ø75-ø75 | VE01.11.0677 | 0677 | yes

# IfcValve: Kulový kohout závitový.LH:DN25 (11)
Type - Classification: VE01 SNIM (SNIM); Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Koeficient K: 0
Type - Kóty - DÉLKA: 71 mm; Jmenovitá velikost vstupu: 25 mm; Jmenovitá velikost výstupu: 25 mm; JMENOVITÝ PRŮMĚR: 25 mm; VÝŠKA: 49.6 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.14.17; Kód sestavy: VE01; Komentáře k typům: KK DN25; Nadpis OmniClass: Adjusting/Controlling Valves for Liquid Services; Název typu: DN25; Označení typu: 11; Popis: Ventil; Popis sestavy: Kulový kohout
Type - Jiné - Kategorie: Příslušenství trubek; Body Diameter: 27.5 mm; Body Height: 35.8222 mm; Body Radius: 13.75 mm; Half Nut Height: 4.125 mm; Handle Width: 10.5 mm; Length 1: 36 mm; Length 2: 16.25 mm; Lookup Table Name: Závitový_Plnící a vypouštěcí kohout; Název rodiny: Kulový kohout závitový.LH; Nut Diameter: 7.5 mm; Nut Height: 8.25 mm; Nut Radius: 3.75 mm; Páka_Délka: 96 mm; Páka_Tloušťka: 7 mm; Příruba_Průměr: 35 mm; Příruba_Tloušťka: 17.5 mm; Radius: 32.5 mm; Seal Length: 19.25 mm; Stem Diameter: 5 mm; Stem Height: 13.7778 mm; Stem Radius: 2.5 mm; VS: 71 mm
Classification: VE01 SNIM (SNIM); VE01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø25 mm-ø25 mm
Text - CCI Funkční systém: F; CCI Komponenta: FMD; CCI Technický systém: JB
Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 25 mm; Minimální velikost: 25 mm; Objem: 0.0000753155 m3; Průměr připojení: 25 mm; Velikost: ø25-ø25
Jiné - Rodina: Kulový kohout závitový.LH; Id typu: 12958586; Rodina a typ: Kulový kohout závitový.LH: DN25; Typ: DN25
Name (Kulový kohout závitový.LH:DN25:...) | In | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Kód prvku | Označení | Páteřní trasa
12984685 | 1.NP_SO-102 | 1.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.11.0325 | 0325 | yes
12984701 | 1.NP_SO-102 | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.11.0326 | 0326 | yes
13028307 | 4.NP_SO-102 | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | VE01.11.0362 | 0362 | no
13028323 | 4.NP_SO-102 | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | VE01.11.0363 | 0363 | no
13030646 | 3.NP_SO-102 | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | VE01.11.0366 | 0366 | no
13030649 | 3.NP_SO-102 | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | VE01.11.0367 | 0367 | no
13031053 | 2.NP_SO-102 | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | VE01.11.0370 | 0370 | no
13031056 | 2.NP_SO-102 | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | VE01.11.0371 | 0371 | no
13031462 | 1.NP_SO-102 | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | VE01.11.0374 | 0374 | no
13031465 | 1.NP_SO-102 | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | VE01.11.0375 | 0375 | no
13036902 | 1.NP_SO-102 | 1.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | VE01.11.0379 | 0379 | yes

# IfcValve: Kulový kohout závitový.LH:DN32 (6)
In: -1.PP_SO-102
Type - Classification: VE01 SNIM (SNIM); Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Koeficient K: 0
Type - Kóty - DÉLKA: 84 mm; Jmenovitá velikost vstupu: 32 mm; Jmenovitá velikost výstupu: 32 mm; JMENOVITÝ PRŮMĚR: 32 mm; VÝŠKA: 53.7 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.14.17; Kód sestavy: VE01; Komentáře k typům: KK DN32; Nadpis OmniClass: Adjusting/Controlling Valves for Liquid Services; Název typu: DN32; Označení typu: 17; Popis: Ventil; Popis sestavy: Kulový kohout
Type - Jiné - Kategorie: Příslušenství trubek; Body Diameter: 35.2 mm; Body Height: 38.7833 mm; Body Radius: 17.6 mm; Half Nut Height: 5.28 mm; Handle Width: 11.2 mm; Length 1: 48 mm; Length 2: 22.2 mm; Lookup Table Name: Závitový_Plnící a vypouštěcí kohout; Název rodiny: Kulový kohout závitový.LH; Nut Diameter: 9.6 mm; Nut Height: 10.56 mm; Nut Radius: 4.8 mm; Páka_Délka: 96 mm; Páka_Tloušťka: 7 mm; Příruba_Průměr: 43.4 mm; Příruba_Tloušťka: 18 mm; Radius: 44.4 mm; Seal Length: 19.8 mm; Stem Diameter: 6.4 mm; Stem Height: 14.9167 mm; Stem Radius: 3.2 mm; VS: 84 mm
Classification: VE01 SNIM (SNIM); VE01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø40 mm-ø40 mm
Text - CCI Funkční systém: F; CCI Komponenta: FMD; CCI Technický systém: JB
Vazby - Podlaží: -1.PP_SO-102
Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 40 mm; Minimální velikost: 40 mm; Objem: 0.000135563 m3; Průměr připojení: 40 mm; Velikost: ø40-ø40
Jiné - Páteřní trasa: yes; Rodina: Kulový kohout závitový.LH; Id typu: 12958588; Rodina a typ: Kulový kohout závitový.LH: DN32; Typ: DN32
Name (Kulový kohout závitový.LH:DN32:...) | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Kód prvku | Označení
13076510 | 3100 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.17.0423 | 0423
13076532 | 3100 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.17.0424 | 0424
13079425 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.17.0427 | 0427
13523641 | 3300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.17.0580 | 0580
13533892 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | VE01.17.0594 | 0594
13642648 | 2649.1 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | VE01.17.0641 | 0641

# IfcValve: Kulový kohout závitový.LH:DN40, Kulový kohout závitový.LH:DN40:13082999
In: -1.PP_SO-102
Type - Classification: VE01 SNIM (SNIM); Material: 128-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Koeficient K: 0
Type - Kóty - DÉLKA: 93 mm; Jmenovitá velikost vstupu: 40 mm; Jmenovitá velikost výstupu: 40 mm; JMENOVITÝ PRŮMĚR: 40 mm; VÝŠKA: 68 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.14.17; Kód sestavy: VE01; Komentáře k typům: KK DN40; Nadpis OmniClass: Adjusting/Controlling Valves for Liquid Services; Název typu: DN40; Označení typu: 12; Popis: Ventil; Popis sestavy: Kulový kohout
Type - Jiné - Kategorie: Příslušenství trubek; Body Diameter: 44 mm; Body Height: 49.1111 mm; Body Radius: 22 mm; Half Nut Height: 6.6 mm; Handle Width: 12 mm; Length 1: 56 mm; Length 2: 26.15 mm; Lookup Table Name: Závitový_Plnící a vypouštěcí kohout; Název rodiny: Kulový kohout závitový.LH; Nut Diameter: 12 mm; Nut Height: 13.2 mm; Nut Radius: 6 mm; Páka_Délka: 138 mm; Páka_Tloušťka: 7 mm; Příruba_Průměr: 53 mm; Příruba_Tloušťka: 18.5 mm; Radius: 52.3 mm; Seal Length: 20.35 mm; Stem Diameter: 8 mm; Stem Height: 18.8889 mm; Stem Radius: 4 mm; VS: 93 mm
Classification: VE01 SNIM (SNIM); VE01 Uniformat (Uniformat); Group: WS_"Jiný typ" studená vnitřní 1
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø40 mm-ø40 mm
Text - CCI Funkční systém: F; CCI Komponenta: FMD; CCI Technický systém: JB
Vazby - Podlaží: -1.PP_SO-102; Výška od podlaží: 2600 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_"ŠEDÁ" studená vnitřní; Klasifikace systému: Studená voda v domácnosti; Název systému: WS_"Jiný typ" studená vnitřní 1; PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 40 mm; Minimální velikost: 40 mm; Objem: 0.000228158 m3; Průměr připojení: 40 mm; Velikost: ø40-ø40
Identifikační data - Kód prvku: VE01.12.0433; Označení: 0433
Jiné - Páteřní trasa: yes; Rodina: Kulový kohout závitový.LH; Id typu: 12958590; Rodina a typ: Kulový kohout závitový.LH: DN40; Typ: DN40

# IfcValve: Kulový kohout závitový.LH:DN40 (6)
In: -1.PP_SO-102
Type - Classification: VE01 SNIM (SNIM); Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Koeficient K: 0
Type - Kóty - DÉLKA: 93 mm; Jmenovitá velikost vstupu: 40 mm; Jmenovitá velikost výstupu: 40 mm; JMENOVITÝ PRŮMĚR: 40 mm; VÝŠKA: 68 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.14.17; Kód sestavy: VE01; Komentáře k typům: KK DN40; Nadpis OmniClass: Adjusting/Controlling Valves for Liquid Services; Název typu: DN40; Označení typu: 12; Popis: Ventil; Popis sestavy: Kulový kohout
Type - Jiné - Kategorie: Příslušenství trubek; Body Diameter: 44 mm; Body Height: 49.1111 mm; Body Radius: 22 mm; Half Nut Height: 6.6 mm; Handle Width: 12 mm; Length 1: 56 mm; Length 2: 26.15 mm; Lookup Table Name: Závitový_Plnící a vypouštěcí kohout; Název rodiny: Kulový kohout závitový.LH; Nut Diameter: 12 mm; Nut Height: 13.2 mm; Nut Radius: 6 mm; Páka_Délka: 138 mm; Páka_Tloušťka: 7 mm; Příruba_Průměr: 53 mm; Příruba_Tloušťka: 18.5 mm; Radius: 52.3 mm; Seal Length: 20.35 mm; Stem Diameter: 8 mm; Stem Height: 18.8889 mm; Stem Radius: 4 mm; VS: 93 mm
Classification: VE01 SNIM (SNIM); VE01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø50 mm-ø50 mm
Text - CCI Funkční systém: F; CCI Komponenta: FMD; CCI Technický systém: JB
Vazby - Podlaží: -1.PP_SO-102
Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 50 mm; Minimální velikost: 50 mm; Objem: 0.000228158 m3; Průměr připojení: 50 mm; Velikost: ø50-ø50
Jiné - Páteřní trasa: yes; Rodina: Kulový kohout závitový.LH; Id typu: 12958590; Rodina a typ: Kulový kohout závitový.LH: DN40; Typ: DN40
Name (Kulový kohout závitový.LH:DN40:...) | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Kód prvku | Označení
13021063 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.12.0357 | 0357
13021102 | 3300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.12.0359 | 0359
13047252 | 2600 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | VE01.12.0392 | 0392
13047268 | 2600 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE01.12.0393 | 0393
13642668 | 2648.9 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | VE01.12.0642 | 0642
13642704 | 2649.55 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | VE01.12.0644 | 0644

# IfcValve: Mechanická zápachová klapka:Mechanická zápachová klapka (6)
Type - Classification: ZU00 SNIM (SNIM); Material: Plast - šedý
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Jmenovitá velikost vstupu: 110 mm; Jmenovitá velikost výstupu: 1100 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: ©TOPWET; Kód sestavy: ZU00; Komentáře k typům: Mechanická zápachová klapka TOPWET se zvýšenou odtokovou kapacitou a samočisticí schopností. Určena pro střešní vpusti, terasové vpusti a nástavce TOPWET. Klapku není vhodné umisťovat do prostředí bez volné cirkulace vzduchu.; Model: viz OBJEDNACÍ KÓD; Název typu: Mechanická zápachová klapka; Označení typu: 19; Popis: Příslušenství vpusti; Popis sestavy: Obecný prvek; URL: http://www.topwet.cz/produkty/265-mechanicka-zapachova-klapka; Výrobce: TOPWET
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Mechanická zápachová klapka
Classification: ZU00 SNIM (SNIM); ZU00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: RMD; CCI Technický systém: JD
Vazby - Přesunout s blízkými prvky: no; Výška od podlaží: -24.1537 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.000244974 m3
Identifikační data - OBJEDNACÍ KÓD: TWZU KL
Jiné - Id typu: 13201256; Rodina: Mechanická zápachová klapka; Rodina a typ: Mechanická zápachová klapka: Mechanická zápachová klapka; Typ: Mechanická zápachová klapka
Name (Mechanická zápachová klapka:Mechanická zápachová klapka:...) | In | Kód prvku | Označení
13238314 | 3.NP_SO-102 | ZU00.19.0451 | 0451
13239430 | 3.NP_SO-102 | ZU00.19.0457 | 0457
13239431 | 3.NP_SO-102 | ZU00.19.0458 | 0458
13239432 | 4.NP_SO-102 | ZU00.19.0459 | 0459
13239433 | 4.NP_SO-102 | ZU00.19.0460 | 0460
13706113 | 3.NP_SO-102 | ZU00.19.0659 | 0659

# IfcValve: Nezámrzný ventil:G 1/2" (3)
Type - Classification: VE24 SNIM (SNIM); Material: 128-128-128
Type - Mechanické – tok - Průtok: 0 m3/s
Type - Text - Profese: Vodovod; Tabulka rozměrů: Voda_kohout kulovy
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Jmenovitá velikost vstupu: 20 mm; Jmenovitá velikost výstupu: 20 mm
Type - Identifikační data - ID kategorie: NV.01; Kód sestavy: VE24; Komentáře k typům: NZV; Název typu: G 1/2"; Označení typu: 25; Popis sestavy: Mrazuvzdorný
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Nezámrzný ventil
Classification: VE24 SNIM (SNIM); VE24 Uniformat (Uniformat); Group: WS_"Jiný typ" studená vnitřní 1
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø20 mm
Text - CCI Funkční systém: F; CCI Komponenta: WPC; CCI Technický systém: JB
Vazby - Pomocná 1: 30 mm; Pomocná 2: 35 mm; Pomocná 3: 30 mm; Pomocná 4: 9 mm; Pomocná 5: 9 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_"ŠEDÁ" studená vnitřní; Klasifikace systému: Studená voda v domácnosti; Název systému: WS_"Jiný typ" studená vnitřní 1
Grafika - Použít měřítko poznámky: no
Kóty - A1: 14.5 mm; L1: 65 mm; Maximální velikost: 20 mm; Minimální velikost: 20 mm; Objem: 0.000230089 m3; t1: 5 mm; Velikost: ø20
Jiné - Páteřní trasa: no; Id typu: 13326738; Rodina: Nezámrzný ventil; Rodina a typ: Nezámrzný ventil: G 1/2"; Typ: G 1/2"
Name (Nezámrzný ventil:G 1/2":...) | In | Podlaží | Výška od podlaží (mm) | Kód prvku | Označení
13335102 | 1.NP_SO-102 | 1.NP_SO-102 | 346.904 | VE24.25.0475 | 0475
13486119 | 4.NP_SO-102 | 4.NP_SO-102 | 1000 | VE24.25.0553 | 0553
13645730 | 3.NP_SO-102 | 3.NP_SO-102 | 1000 | VE24.25.0657 | 0657

# IfcValve: Otvor čištění, 90 stupňů:Standardní (4)
In: -1.PP_SO-102
Type - Classification: CT00 SNIM (SNIM); Material: 0-128-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Jmenovitá velikost vstupu: 250 mm; Jmenovitá velikost výstupu: 250 mm
Type - Identifikační data - Kód sestavy: CT00; Komentáře k typům: ČISTÍCÍ TVAROVKA V REVIZNÍ ŠACHTĚ; Název typu: Standardní; Označení typu: 34; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Otvor čištění, 90 stupňů
Classification: CT00 SNIM (SNIM); CT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø125 mm-ø125 mm
Text - CCI Funkční systém: G; CCI Komponenta: XTA; CCI Technický systém: JD
Vazby - Podlaží: -1.PP_SO-102
Mechanické - Klasifikace systému: Sanitární; Tlaková ztráta: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Délka: 145 mm; Jmenovitý poloměr: 62.5 mm; Jmenovitý průměr: 125 mm; Maximální velikost: 125 mm; Minimální velikost: 125 mm; Objem: 0.00663484 m3; Poloměr trubky 1: 66.5 mm; Poloměr trubky 2: 72.5 mm; Poloměr uzavření: 29 mm; Šířka: 375 mm; Šroub, poloměr: 8.7 mm; Velikost: ø125-ø125; Výška: 0 mm; Výška šroubu: 8 mm; Výška uzavření: 15 mm; Výška X: 168 mm; W1: 75 mm; W1R: 10 mm
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 13610518; Rodina: Otvor čištění, 90 stupňů; Rodina a typ: Otvor čištění, 90 stupňů: Standardní
Name (Otvor čištění, 90 stupňů:Standardní:...) | Tlaková ztráta (Pa) | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Název systému = Group | Kód prvku | Označení
13611676 | 0 | -1500.66 | Fáze 1 | SW_Deště vnitřní gravitační | SW_Deště vnitřní gravitační 2 | CT00.34.0617 | 0617
13613048 | 0 | -2713.88 | Fáze 1 | SW_Deště vnitřní gravitační | SW_Deště vnitřní gravitační 2 | CT00.34.0619 | 0619
13613535 | 0 | -2487.09 | Fáze 1 | SW_Deště vnitřní gravitační | SW_Deště vnitřní gravitační 2 | CT00.34.0624 | 0624
13614102 |  | -1699.33 | Fáze 2 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | CT00.34.0629 | 0629

# IfcValve: Otvor čištění, 90 stupňů:Standardní (6)
In: -1.PP_SO-102
Type - Classification: CT00 SNIM (SNIM); Material: 128-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Jmenovitá velikost vstupu: 250 mm; Jmenovitá velikost výstupu: 250 mm
Type - Identifikační data - Kód sestavy: CT00; Komentáře k typům: ČISTÍCÍ TVAROVKA V REVIZNÍ ŠACHTĚ; Název typu: Standardní; Označení typu: 34; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Otvor čištění, 90 stupňů
Classification: CT00 SNIM (SNIM); CT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: G; CCI Komponenta: XTA; CCI Technický systém: JD
Vazby - Podlaží: -1.PP_SO-102
Mechanické - Typ systému: SW_Splašky vnitřní gravitační; Klasifikace systému: Sanitární; Tlaková ztráta: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Výška: 0 mm; Výška šroubu: 8 mm; Výška uzavření: 15 mm; W1R: 10 mm
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 13610518; Rodina: Otvor čištění, 90 stupňů; Rodina a typ: Otvor čištění, 90 stupňů: Standardní
Name (Otvor čištění, 90 stupňů:Standardní:...) | Celková velikost | Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Délka (mm) | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Poloměr trubky 1 (mm) | Poloměr trubky 2 (mm) | Poloměr uzavření (mm) | Šířka (mm) | Šroub, poloměr (mm) | Velikost | Výška X (mm) | W1 (mm) | Kód prvku | Označení
13612981 | ø160 mm-ø160 mm | -2407.01 | Fáze 1 | SW_Splašky vnitřní gravitační 3 | 180 | 80 | 160 | 0.0132882 | 84 | 90 | 36 | 480 | 10.8 | ø160-ø160 | 203 | 96 | CT00.34.0618 | 0618
13613063 | ø160 mm-ø160 mm | -3270.19 | Fáze 1 | SW_Splašky vnitřní gravitační 3 | 180 | 80 | 160 | 0.0132882 | 84 | 90 | 36 | 480 | 10.8 | ø160-ø160 | 203 | 96 | CT00.34.0620 | 0620
13613077 | ø250 mm-ø250 mm | -1277.39 | Fáze 1 | SW_Splašky vnitřní gravitační 35 (1) | 270 | 125 | 250 | 0.0477646 | 129 | 135 | 54 | 750 | 16.2 | ø250-ø250 | 293 | 150 | CT00.34.0621 | 0621
13613132 | ø160 mm-ø160 mm | -2101.5 | Fáze 1 | SW_Splašky vnitřní gravitační 3 | 180 | 80 | 160 | 0.0132882 | 84 | 90 | 36 | 480 | 10.8 | ø160-ø160 | 203 | 96 | CT00.34.0622 | 0622
13613591 | ø110 mm-ø110 mm | -2808.35 | Fáze 1 | SW_Splašky vnitřní gravitační 3 | 130 | 55 | 110 | 0.00465257 | 59 | 65 | 26 | 330 | 7.8 | ø110-ø110 | 153 | 66 | CT00.34.0625 | 0625
13614065 | ø110 mm-ø110 mm | -2397.13 | Fáze 2 | SW_Splašky vnitřní gravitační 3 | 130 | 55 | 110 | 0.00465257 | 59 | 65 | 26 | 330 | 7.8 | ø110-ø110 | 153 | 66 | CT00.34.0628 | 0628

# IfcValve: Plochý ochranný koš TW PLK:Plochý ochranný koš TW PLK (6)
Type - Classification: VP01 SNIM (SNIM); Material: Plast - šedý
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 145 mm; Jmenovitá velikost výstupu: 110 mm; Šířka: 145 mm; Výška: 80 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: ©TOPWET; Kód sestavy: VP01; Komentáře k typům: Plochý pochozí ochranný koš TOPWET určený pro provozní typy střech, teras a balkónů. Provedení ze silnostěnného polyamidu PA6 UV Stabil. Výška nad úroveň hydroizolace 10 mm.; Model: viz OBJEDNACÍ KÓD; Název typu: Plochý ochranný koš TW PLK; Označení typu: 20; Popis: Příslušenství vpusti; Popis sestavy: Střešní; URL: http://www.topwet.cz/produkty/268-plochy-pochozi-ochranny-kos; Výrobce: TOPWET
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Plochý ochranný koš TW PLK
Classification: VP01 SNIM (SNIM); VP01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: XKE; CCI Technický systém: JD
Vazby - Přesunout s blízkými prvky: no; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0000519832 m3
Identifikační data - OBJEDNACÍ KÓD: TW PLK
Jiné - Id typu: 13201291; Rodina: Plochý ochranný koš TW PLK; Rodina a typ: Plochý ochranný koš TW PLK: Plochý ochranný koš TW PLK; Typ: Plochý ochranný koš TW PLK
Name (Plochý ochranný koš TW PLK:Plochý ochranný koš TW PLK:...) | In | Kód prvku | Označení
13238329 | 3.NP_SO-102 | VP01.20.0452 | 0452
13239426 | 3.NP_SO-102 | VP01.20.0453 | 0453
13239427 | 3.NP_SO-102 | VP01.20.0454 | 0454
13239428 | 4.NP_SO-102 | VP01.20.0455 | 0455
13239429 | 4.NP_SO-102 | VP01.20.0456 | 0456
13706112 | 3.NP_SO-102 | VP01.20.0658 | 0658

# IfcValve: Potrubní oddělovač BA295.CC:BA295-15 (4)
Type - Material: 0-0-255
Type - Výsledky analýzy - HMOTNOST: 1.5 kg
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - DÉLKA: 195 mm; JMENOVITÝ PRŮMĚR: 15 mm; VÝŠKA: 80 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Komentáře k typům: regulační, potrubní oddělovač s kontrolovatelným redukovaným tlakovým pásmem; Model: BA295-15_A; Název typu: BA295-15; Označení typu: 39; Popis: Ventil; URL: www.cadconsulting.cz; Výrobce: Honeywell
Type - Jiné - Kategorie: Příslušenství trubek; h: 138 mm; HM: 1.5 mm; l: 135 mm; L1: 50 mm; L3: 50 mm; L4: 35 mm; Lookup Table Name: Potrubní oddělovač Honeywell BA295.CC; Název rodiny: Potrubní oddělovač BA295.CC; OD: 22.5 mm; OD2: 37.5 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø25 mm-ø25 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: WPA; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_Studená vnitřní; Klasifikace systému: Studená voda v domácnosti; Název systému: WS_Studená vnitřní 134; PRŮTOK_VODA: 0 m3/s
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 25 mm; Minimální velikost: 25 mm; Objem: 0.000525865 m3; Průměr připojení: 25 mm; Velikost: ø25-ø25
Identifikační data - Komentáře: PŘÍPRAVA PRO NÁPOJOVÝ AUTOMAT - UZÁVĚR, POTRUBNÍ ODDĚLOVAČ + ZAVÍČKOVÁNO
Jiné - Páteřní trasa: no; Id typu: 13644515; Rodina: Potrubní oddělovač BA295.CC; Rodina a typ: Potrubní oddělovač BA295.CC: BA295-15; Typ: BA295-15
Group: WS_Studená vnitřní 134
Name (Potrubní oddělovač BA295.CC:BA295-15:...) | In | Podlaží | Výška od podlaží (mm) | Kód prvku | Označení
13644780 | 1.NP_SO-102 | 1.NP_SO-102 | 3350 | .39.0649 | 0649
13645221 | 2.NP_SO-102 | 2.NP_SO-102 | 3340 | .39.0652 | 0652
13645386 | 3.NP_SO-102 | 3.NP_SO-102 | 3350 | .39.0654 | 0654
13645516 | 4.NP_SO-102 | 4.NP_SO-102 | 3350 | .39.0656 | 0656

# IfcValve: Potrubní oddělovač BA295.CC:BA295-25, Potrubní oddělovač BA295.CC:BA295-25:13991925
In: -1.PP_SO-102
Type - Material: 0-0-255
Type - Výsledky analýzy - HMOTNOST: 1.65 kg
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - DÉLKA: 225 mm; JMENOVITÝ PRŮMĚR: 25 mm; VÝŠKA: 80 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Komentáře k typům: regulační, potrubní oddělovač s kontrolovatelným redukovaným tlakovým pásmem; Model: BA295-25_B; Název typu: BA295-25; Označení typu: 42; Popis: Ventil; URL: www.cadconsulting.cz; Výrobce: Honeywell
Type - Jiné - Kategorie: Příslušenství trubek; h: 138 mm; HM: 1.65 mm; l: 146 mm; L1: 50 mm; L3: 50 mm; L4: 46 mm; Lookup Table Name: Potrubní oddělovač Honeywell BA295.CC; Název rodiny: Potrubní oddělovač BA295.CC; OD: 37.5 mm; OD2: 52.5 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø75 mm-ø75 mm
Text - CCI Funkční systém: F; CCI Komponenta: WPA; CCI Technický systém: JD
Vazby - Podlaží: -1.PP_SO-102; Výška od podlaží: 1521.55 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_Studená vnitřní; Klasifikace systému: Studená voda v domácnosti; Název systému: WS_Studená vnitřní 134; PRŮTOK_VODA: 0 m3/s
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 75 mm; Minimální velikost: 75 mm; Objem: 0.000667547 m3; Průměr připojení: 75 mm; Velikost: ø75-ø75
Identifikační data - Kód prvku: .42.0678; Označení: 0678
Jiné - Páteřní trasa: yes; Rodina: Potrubní oddělovač BA295.CC; Id typu: 13644511; Rodina a typ: Potrubní oddělovač BA295.CC: BA295-25; Typ: BA295-25
Group: WS_Studená vnitřní 134

# IfcValve: Prodloužení nástavce_03910.2E:03910.2E_Main Component (12)
Type - Classification: VP02 SNIM (SNIM); Material: Plactic - Gray, Stainless Steel
Type - Vazby - Výchozí výška: 0 mm
Type - Domovní instalace - Připojení CW: no; Připojení HW: no; Připojení odpadu: yes; Připojení ventilace: no
Type - Kóty - Délka: 145 mm; Jmenovitá velikost výstupu: 110 mm; Šířka: 146145 mm; Výška: 80 mm
Type - Identifikační data - Číslo OmniClass: 23.70.50.21.24.14; DIMENZE: d 146 mm; EAN: 9003076025626; HMOTNOST: 0,25 [kg]; Indexovaná poznámka: HL03910.2E; Kód sestavy: VP02; Komentáře k typům: HL03910.2E Nástavec d 146mm, nerezový rámeček 145x145mm včetně O-kroužku. Systém Klick-Klack.; MATERIÁL: PP-V4A; Model: HL03910.2E; Nadpis OmniClass: Deck Waste Water Drains; NÁSTAVEC: 145 x 145 mm; Název typu: 03910.2E_Main Component; Označení typu: 21; Popis: Podlahové vpustě - příslušenství; Popis sestavy: Podlahová; PRÁVNÍ OZNÁMENÍ: Copyright (©), autorská a jiná práva spojená s duševním vlastnictvím, jsou výhradním vlastnictvím společnosti HL Hutterer & Lechner GmbH. Úpravy nejsou dovoleny. Rodina je opatřená vodoznakem.; STAVEBNÍ VÝŠKA: 8 - 80 mm; URL: http://www.hutterer-lechner.com/cs/Products/catalog/floor-drains/attachments/HL03910.2E.aspx; Výrobce: HL Hutterer & Lechner GmbH
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Prodloužení nástavce_03910.2E; NL_Max: 80 mm; NL_Min: 8 mm; RD: 6.5 mm
Classification: VP02 SNIM (SNIM); VP02 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: XKE; CCI Technický systém: JD
Vazby - Přesunout s blízkými prvky: no; Výška od podlaží: -8000 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.000266268 m3; Stavební výška: 80 mm
Jiné - Id typu: 13260913; NL: 100 mm; NL_Test: yes; R: yes; RL: 84.5 mm; RN: 13; Rodina: Prodloužení nástavce_03910.2E; Rodina a typ: Prodloužení nástavce_03910.2E: 03910.2E_Main Component; Typ: 03910.2E_Main Component
Name (Prodloužení nástavce_03910.2E:03910.2E_Main Component:...) | In | Podlaží | Kód prvku | Označení
13261306 | 2.NP_SO-102 | 2.NP_SO-102 | VP02.21.0462 | 0462
13261416 | 2.NP_SO-102 | 2.NP_SO-102 | VP02.21.0466 | 0466
13261432 | 2.NP_SO-102 | 2.NP_SO-102 | VP02.21.0470 | 0470
13335884 | 2.NP_SO-102 | 2.NP_SO-102 | VP02.21.0476 | 0476
13335923 | -1.PP_SO-102 | -1.PP_SO-102 | VP02.21.0480 | 0480
13335948 | -1.PP_SO-102 | -1.PP_SO-102 | VP02.21.0484 | 0484
13335959 | -1.PP_SO-102 | -1.PP_SO-102 | VP02.21.0488 | 0488
13336007 | 4.NP_SO-102 | 4.NP_SO-102 | VP02.21.0492 | 0492
13463833 | 1.NP_SO-102 | 1.NP_SO-102 | VP02.21.0529 | 0529
13463839 | 2.NP_SO-102 | 2.NP_SO-102 | VP02.21.0533 | 0533
13463845 | 3.NP_SO-102 | 3.NP_SO-102 | VP02.21.0537 | 0537
13474056 | 2.NP_SO-102 | 2.NP_SO-102 | VP02.21.0548 | 0548

# IfcValve: Přečerpávačka_světlé rozměry2:Přečerpávačka_světlé rozměry2, Přečerpávačka_světlé rozměry2:Přečerpávačka_světlé rozměry2:13472393
In: -2.PP_SO-102
Type - Classification: CO SNIM (SNIM); Material: <Unnamed>
Type - Identifikační data - Kód sestavy: CO; Komentáře k typům: ŠACHTA ČERPACÍ STANICE; Název typu: Přečerpávačka_světlé rozměry2; Označení typu: 31; Popis sestavy: Čerpadlo
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Přečerpávačka_světlé rozměry2
Classification: CO SNIM (SNIM); CO Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: DAD; CCI Technický systém: JB
Vazby - Přesunout s blízkými prvky: no; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 15.6223 m3; Plocha: 3.95402 m2
Identifikační data - Kód prvku: CO.31.0546; Označení: 0546
Jiné - Páteřní trasa: no; Id typu: 13472391; Rodina: Přečerpávačka_světlé rozměry2; Rodina a typ: Přečerpávačka_světlé rozměry2: Přečerpávačka_světlé rozměry2; Typ: Přečerpávačka_světlé rozměry2

# IfcValve: Přečerpávačka_světlé rozměry:Přečerpávačka_světlé rozměry, Přečerpávačka_světlé rozměry:Přečerpávačka_světlé rozměry:13472486
In: -2.PP_SO-102
Type - Classification: CO00 SNIM (SNIM); Material: <Unnamed>
Type - Identifikační data - Kód sestavy: CO00; Komentáře k typům: ŠACHTA ČERPACÍ STANICE; Název typu: Přečerpávačka_světlé rozměry; Označení typu: 32; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Přečerpávačka_světlé rozměry
Classification: CO00 SNIM (SNIM); CO00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: DAD; CCI Technický systém: JB
Vazby - Přesunout s blízkými prvky: no; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 12.5246 m3; Plocha: 3.95402 m2
Identifikační data - Kód prvku: CO00.32.0547; Označení: 0547
Jiné - Páteřní trasa: no; Id typu: 13472484; Rodina: Přečerpávačka_světlé rozměry; Rodina a typ: Přečerpávačka_světlé rozměry: Přečerpávačka_světlé rozměry; Typ: Přečerpávačka_světlé rozměry

# IfcValve: Revizní šachta_světlé rozměry1:Revizní šachta_světlé rozměry, Revizní šachta_světlé rozměry1:Revizní šachta_světlé rozměry:13471820
In: -2.PP_SO-102
Type - Classification: AT01 SNIM (SNIM); Material: <Unnamed>
Type - Identifikační data - Kód sestavy: AT01; Komentáře k typům: REVIZNÍ ŠACHTA; Název typu: Revizní šachta_světlé rozměry; Označení typu: 29; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Revizní šachta_světlé rozměry1
Classification: AT01 SNIM (SNIM); AT01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: EBB; CCI Technický systém: JB
Vazby - Přesunout s blízkými prvky: no; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 3.2412 m3; Plocha: 1.2 m2
Identifikační data - Kód prvku: AT01.29.0544; Označení: 0544
Jiné - Páteřní trasa: no; Typ: Revizní šachta_světlé rozměry; Id typu: 13471818; Rodina: Revizní šachta_světlé rozměry1; Rodina a typ: Revizní šachta_světlé rozměry1: Revizní šachta_světlé rozměry

# IfcValve: Revizní šachta_světlé rozměry2:Revizní šachta_světlé rozměry, Revizní šachta_světlé rozměry2:Revizní šachta_světlé rozměry:13472197
In: -2.PP_SO-102
Type - Classification: AT01 SNIM (SNIM); Material: <Unnamed>
Type - Identifikační data - Kód sestavy: AT01; Komentáře k typům: REVIZNÍ ŠACHTA; Název typu: Revizní šachta_světlé rozměry; Označení typu: 30; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Revizní šachta_světlé rozměry2
Classification: AT01 SNIM (SNIM); AT01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: EBB; CCI Technický systém: JB
Vazby - Přesunout s blízkými prvky: no; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 4.2012 m3; Plocha: 1.2 m2
Identifikační data - Kód prvku: AT01.30.0545; Označení: 0545
Jiné - Páteřní trasa: no; Typ: Revizní šachta_světlé rozměry; Id typu: 13472195; Rodina: Revizní šachta_světlé rozměry2; Rodina a typ: Revizní šachta_světlé rozměry2: Revizní šachta_světlé rozměry

# IfcValve: Revizní šachta_světlé rozměry3:Revizní šachta_světlé rozměry, Revizní šachta_světlé rozměry3:Revizní šachta_světlé rozměry:13613251
In: -2.PP_SO-102
Type - Classification: AT01 SNIM (SNIM); Material: <Unnamed>
Type - Identifikační data - Kód sestavy: AT01; Název typu: Revizní šachta_světlé rozměry; Označení typu: 35; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Revizní šachta_světlé rozměry3
Classification: AT01 SNIM (SNIM); AT01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: EBB; CCI Technický systém: JB
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 2.47824 m3; Plocha: 1.44 m2
Identifikační data - Kód prvku: AT01.35.0623; Označení: 0623
Jiné - Páteřní trasa: no; Typ: Revizní šachta_světlé rozměry; Id typu: 13613249; Rodina: Revizní šachta_světlé rozměry3; Rodina a typ: Revizní šachta_světlé rozměry3: Revizní šachta_světlé rozměry

# IfcValve: Revizní šachta_světlé rozměry4:Revizní šachta_světlé rozměry, Revizní šachta_světlé rozměry4:Revizní šachta_světlé rozměry:13613687
In: -2.PP_SO-102
Type - Classification: AT01 SNIM (SNIM); Material: <Unnamed>
Type - Identifikační data - Kód sestavy: AT01; Komentáře k typům: REVIZNÍ ŠACHTA; Název typu: Revizní šachta_světlé rozměry; Označení typu: 36; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Revizní šachta_světlé rozměry4
Classification: AT01 SNIM (SNIM); AT01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: EBB; CCI Technický systém: JB
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 2
Kóty - Objem: 1.44072 m3; Plocha: 0.72 m2
Identifikační data - Kód prvku: AT01.36.0626; Označení: 0626
Jiné - Páteřní trasa: no; Typ: Revizní šachta_světlé rozměry; Id typu: 13613685; Rodina: Revizní šachta_světlé rozměry4; Rodina a typ: Revizní šachta_světlé rozměry4: Revizní šachta_světlé rozměry

# IfcValve: Revizní šachta_světlé rozměry5:Revizní šachta_světlé rozměry, Revizní šachta_světlé rozměry5:Revizní šachta_světlé rozměry:13530231
In: -2.PP_SO-102
Type - Classification: AT01 SNIM (SNIM); Material: <Unnamed>
