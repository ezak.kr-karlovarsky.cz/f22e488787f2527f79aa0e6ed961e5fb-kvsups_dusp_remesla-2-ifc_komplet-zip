Properties of the parts of a building model (IFC4), part 60 of 60

# IfcValve: Sifon umyvadlový:Sifon umyvadlový (122)
Name (Sifon umyvadlový:Sifon umyvadlový:...) | In | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Objem (m3) | Prodloužení 1 (mm) | Prodloužení 2 (mm) | Kód prvku | Název sestavy | Označení
12880770 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0056 | Umyvadlo + modul | 0056
12880870 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0062 | Umyvadlo + modul | 0062
12880884 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0065 | Umyvadlo + modul | 0065
12880912 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0068 | Umyvadlo + modul | 0068
12880926 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0071 | Umyvadlo + modul | 0071
12880940 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0074 | Umyvadlo + modul | 0074
12881040 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0080 | Umyvadlo + modul | 0080
12881054 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0083 | Umyvadlo + modul | 0083
12881082 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0086 | Umyvadlo + modul | 0086
12881096 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0089 | Umyvadlo + modul | 0089
12881110 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0092 | Umyvadlo + modul | 0092
12881941 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0098 | Umyvadlo + modul | 0098
12884690 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0103 | Umyvadlo | 0103
12884800 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0106 | Umyvadlo | 0106
12886226 | -2.PP_SO-102 | -1.PP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0109 | Umyvadlo + modul | 0109
12888141 | -1.PP_SO-102 | 1.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0112 | Umyvadlo + modul | 0112
12888848 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0115 | Umyvadlo + modul | 0115
12888872 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0118 | Umyvadlo + modul | 0118
12889682 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0121 | Umyvadlo + modul | 0121
12890314 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0124 | Umyvadlo + modul | 0124
12890341 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0127 | Umyvadlo + modul | 0127
12890452 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0130 | Umyvadlo + modul | 0130
12890837 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0136 | Umyvadlo + modul | 0136
12890861 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0139 | Umyvadlo + modul | 0139
12891282 | -1.PP_SO-102 | 1.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0142 | Umyvadlo + modul | 0142
12891693 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0145 | Umyvadlo + modul | 0145
12891784 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0148 | Umyvadlo + modul | 0148
12891857 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0151 | Umyvadlo + modul | 0151
12891929 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0154 | Umyvadlo + modul | 0154
12892004 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0157 | Umyvadlo + modul | 0157
12892070 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0160 | Umyvadlo + modul | 0160
12892287 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0163 | Umyvadlo + modul | 0163
12892354 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0166 | Umyvadlo + modul | 0166
12892420 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0169 | Umyvadlo + modul | 0169
12892486 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0172 | Umyvadlo + modul | 0172
12892551 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0175 | Umyvadlo + modul | 0175
12892804 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0178 | Umyvadlo + modul | 0178
12892907 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0181 | Umyvadlo + modul | 0181
12893038 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0184 | Umyvadlo + modul | 0184
12893163 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0187 | Umyvadlo + modul | 0187
12894064 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0193 | Umyvadlo + modul | 0193
12894130 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0196 | Umyvadlo + modul | 0196
12894209 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0199 | Umyvadlo + modul | 0199
12894273 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0202 | Umyvadlo + modul | 0202
12894334 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0205 | Umyvadlo + modul | 0205
12894679 | -2.PP_SO-102 | -1.PP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0208 | Umyvadlo + modul | 0208
12894793 | -1.PP_SO-102 | 1.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0211 | Umyvadlo + modul | 0211
12895103 | -1.PP_SO-102 | 1.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0215 | Umyvadlo + modul | 0215
12895286 | -1.PP_SO-102 | 1.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0218 | Umyvadlo + modul | 0218
12895310 | -1.PP_SO-102 | 1.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0221 | Umyvadlo + modul | 0221
12895441 | -1.PP_SO-102 | 1.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0224 | Umyvadlo + modul | 0224
12895787 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0227 | Umyvadlo + modul | 0227
12896141 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0231 | Umyvadlo + modul | 0231
12896341 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0234 | Umyvadlo + modul | 0234
12896409 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0237 | Umyvadlo + modul | 0237
12896722 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0240 | Umyvadlo + modul | 0240
12896782 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0243 | Umyvadlo + modul | 0243
12896898 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0246 | Umyvadlo + modul | 0246
12896922 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0249 | Umyvadlo + modul | 0249
12897295 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0253 | Umyvadlo + modul | 0253
12897368 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0256 | Umyvadlo + modul | 0256
12897419 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0259 | Umyvadlo + modul | 0259
12897450 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0262 | Umyvadlo + modul | 0262
12897757 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0265 | Umyvadlo + modul | 0265
12897781 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0268 | Umyvadlo + modul | 0268
12898205 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0272 | Umyvadlo + modul | 0272
12898229 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0275 | Umyvadlo + modul | 0275
12898551 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0278 | Umyvadlo + modul | 0278
12898602 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0281 | Umyvadlo + modul | 0281
12899107 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0284 | Umyvadlo + modul | 0284
12899478 | -1.PP_SO-102 | 1.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0289 | Umyvadlo + modul | 0289
12899628 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0294 | Umyvadlo + modul | 0294
12992020 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0331 | Umyvadlo + modul | 0331
12992038 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0334 | Umyvadlo + modul | 0334
13068784 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0401 | Umyvadlo + modul | 0401
13068922 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0404 | Umyvadlo + modul | 0404
13071953 | -1.PP_SO-102 | 1.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0422 | Umyvadlo + modul | 0422
13102573 | -1.PP_SO-102 | 1.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0439 | Umyvadlo + modul | 0439
13102688 | -1.PP_SO-102 | 1.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0442 | Umyvadlo + modul | 0442
13105043 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0445 | Umyvadlo + modul | 0445
13154259 | -1.PP_SO-102 | 1.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0448 | Umyvadlo + modul | 0448
13401880 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0516 | Umyvadlo | 0516
13505820 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0563 | Umyvadlo + modul | 0563
13505928 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0566 | Umyvadlo + modul | 0566
13506570 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0570 | Umyvadlo + modul | 0570
13506643 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0573 | Umyvadlo + modul | 0573
13506753 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0576 | Umyvadlo + modul | 0576
13506821 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0579 | Umyvadlo + modul | 0579
13525892 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0583 | Umyvadlo + modul | 0583
13526125 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0586 | Umyvadlo + modul | 0586
13526376 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0589 | Umyvadlo + modul | 0589
13526793 | -2.PP_SO-102 | -1.PP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0592 | Umyvadlo + modul | 0592
13544053 | 3.NP_SO-102 | 4.NP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0598 | Umyvadlo + modul | 0598
13544822 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0601 | Umyvadlo | 0601
13545429 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0610 | Umyvadlo + modul | 0610
13546126 | 2.NP_SO-102 | 3.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0613 | Umyvadlo | 0613
13725009 | -1.PP_SO-102 | 1.NP_SO-102 | -0.0315427 | Fáze 1 | 0.000587529 | 122.9 | 185.7 | ZU00.03.0662 | Výlevka nástěnnî | 0662
13728597 | 1.NP_SO-102 | 2.NP_SO-102 | -0.0315427 | Fáze 1 | 0.000587529 | 122.9 | 185.7 | ZU00.03.0665 | Výlevka nástěnnñ | 0665
13728673 | 1.NP_SO-102 | 2.NP_SO-102 | -0.0315427 | Fáze 1 | 0.000587529 | 122.9 | 185.7 | ZU00.03.0668 | Výlevka nástěnnñ | 0668
13733486 | 2.NP_SO-102 | 3.NP_SO-102 | -0.0315427 | Fáze 1 | 0.000587529 | 122.9 | 185.7 | ZU00.03.0671 | Výlevka nástěnnî | 0671
14005556 | -2.PP_SO-102 | -1.PP_SO-102 | -0.0315427 | Fáze 1 | 0.000587529 | 122.9 | 185.7 | ZU00.03.0681 | Výlevka nástěnnò | 0681
14005937 | -2.PP_SO-102 | -1.PP_SO-102 | -0.0315427 | Fáze 1 | 0.000587529 | 122.9 | 185.7 | ZU00.03.0684 | Výlevka nástěnnô | 0684
14007198 | 3.NP_SO-102 | 4.NP_SO-102 | -0.0315427 | Fáze 2 | 0.000587529 | 122.9 | 185.7 | ZU00.03.0687 | Výlevka nástěnnö | 0687
14007278 | 2.NP_SO-102 | 3.NP_SO-102 | -0.0315427 | Fáze 2 | 0.000587529 | 122.9 | 185.7 | ZU00.03.0690 | Výlevka nástěnnö | 0690
14007309 | 1.NP_SO-102 | 2.NP_SO-102 | -0.0315427 | Fáze 2 | 0.000587529 | 122.9 | 185.7 | ZU00.03.0693 | Výlevka nástěnnö | 0693
14007338 | -1.PP_SO-102 | 1.NP_SO-102 | -0.0315427 | Fáze 2 | 0.000587529 | 122.9 | 185.7 | ZU00.03.0696 | Výlevka nástěnnö | 0696
14030753 | -2.PP_SO-102 | -1.PP_SO-102 | 0 | Fáze 2 | 0.000597412 | 110 | 205.675 | ZU00.03.0701 | Umyvadlo | 0701

# IfcValve: Sifon vanový automat:Sifon vanový automat, Sifon vanový automat:Sifon vanový automat:12864816
In: 1.NP_SO-102
Type - Classification: ZU00 SNIM (SNIM); Material: PLAST_BÍLÝ, CHROM
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Type - Materiály a povrchové úpravy - Materiál: PLAST_BÍLÝ
Type - Kóty - Jmenovitá velikost vstupu: 50 mm; Jmenovitá velikost výstupu: 50 mm; JMENOVITÝ PRŮMĚR: 50 mm
Type - Identifikační data - Kód sestavy: ZU00; Komentáře k typům: Sifon vanový automatický; Název typu: Sifon vanový automat; Označení typu: 04; Popis: Sifon; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Sifon vanový automat
Classification: ZU00 SNIM (SNIM); ZU00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø50 mm-ø50 mm
Text - CCI Funkční systém: G; CCI Komponenta: ABA; CCI Technický systém: JD
Vazby - Podlaží: 1.NP_SO-102; Výška od podlaží: 159.948 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 50 mm; Minimální velikost: 50 mm; Natočení: 180 deg; Objem: 0.0014262 m3; Velikost: ø50-ø50
Identifikační data - Kód prvku: ZU00.04.0008; Název sestavy: Vana (nástěnná baterie); Označení: 0008
Jiné - A: 124.4 mm; B: 144.4 mm; DN40: no; DN50: yes; DO: 50 mm; Id typu: 12859104; Rodina: Sifon vanový automat; Rodina a typ: Sifon vanový automat: Sifon vanový automat; Typ: Sifon vanový automat

# IfcValve: Sifon výlevkový:Sifon výlevkový (3)
In: 3.NP_SO-102
Type - Classification: ZU00 SNIM (SNIM); Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Kóty - Jmenovitá velikost vstupu: 75 mm; Jmenovitá velikost výstupu: 75 mm; JMENOVITÝ PRŮMĚR: 40 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZU00; Komentáře k typům: Zápachová uzávěrka pro umyvadlo; Název typu: Sifon výlevkový; Označení typu: 08; Popis: ZU; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Příslušenství trubek; A: 20 mm; B: 25 mm; C: 20 mm; ID: 40 mm; Lookup Table Name: Trubky_Obecný typ; Název rodiny: Sifon výlevkový; OD: 40.8 mm
Classification: ZU00 SNIM (SNIM); ZU00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø40 mm-ø40 mm
Text - CCI Funkční systém: G; CCI Komponenta: ABA; CCI Technický systém: JD
Vazby - Výška od podlaží: 0 mm; Podlaží: 4.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární; PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 40 mm; Minimální velikost: 40 mm; Objem: 0.000524625 m3; Prodloužení 1: 110 mm; Prodloužení 2: 150 mm; Velikost: ø40-ø40; Výška odpadu: 530 mm
Identifikační data - Název sestavy: Výlevka DN50_modul+nástěnná baterie
Jiné - Id typu: 12876112; Rodina: Sifon výlevkový; Rodina a typ: Sifon výlevkový: Sifon výlevkový; Typ: Sifon výlevkový
Name (Sifon výlevkový:Sifon výlevkový:...) | Kód prvku | Označení
12932541 | ZU00.08.0301 | 0301
12937668 | ZU00.08.0302 | 0302
12937711 | ZU00.08.0303 | 0303

# IfcValve: Těleso vpusti_3100K:3100K_Main Component (12)
Type - Classification: VP02 SNIM (SNIM); Material: Plactic - Black
Type - Vazby - Výchozí výška: 0 mm
Type - Domovní instalace - Připojení CW: no; Připojení HW: no; Připojení odpadu: yes; Připojení ventilace: no
Type - Kóty - Délka: 145 mm; Jmenovitá velikost výstupu: 110 mm; Šířka: 145 mm; Výška: 80 mm
Type - Identifikační data - Číslo OmniClass: 23.70.50.21.24.14; DIMENZE: DN50/75/110; EAN: 9003076025510; HMOTNOST: 0,45 [kg]; Indexovaná poznámka: HL3100K; Kód sestavy: VP02; Komentáře k typům: HL3100K Těleso podlahové vpusti DN50/75/110, svislý odtok; MATERIÁL: PE; Model: HL3100K; Nadpis OmniClass: Deck Waste Water Drains; Název typu: 3100K_Main Component; Označení typu: 22; Popis: Podlahové vpustě - příslušenství; Popis sestavy: Podlahová; PRÁVNÍ OZNÁMENÍ: Copyright (©), autorská a jiná práva spojená s duševním vlastnictvím, jsou výhradním vlastnictvím společnosti HL Hutterer & Lechner GmbH. Úpravy nejsou dovoleny. Rodina je opatřená vodoznakem.; STAVEBNÍ VÝŠKA: 162 mm; URL: http://www.hutterer-lechner.com/cs/Products/catalog/floor-drains/attachments/HL3100K.aspx; Výrobce: HL Hutterer & Lechner GmbH
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Těleso vpusti_3100K
Classification: VP02 SNIM (SNIM); VP02 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: XKE; CCI Technický systém: JD
Vazby - Přesunout s blízkými prvky: no; Výška od podlaží: -8016.34 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.000460713 m3
Jiné - Id typu: 13261045; Rodina: Těleso vpusti_3100K; Rodina a typ: Těleso vpusti_3100K: 3100K_Main Component; Typ: 3100K_Main Component
Name (Těleso vpusti_3100K:3100K_Main Component:...) | In | Podlaží | Kód prvku | Označení
13261307 | 2.NP_SO-102 | 2.NP_SO-102 | VP02.22.0463 | 0463
13261417 | 2.NP_SO-102 | 2.NP_SO-102 | VP02.22.0467 | 0467
13261433 | 2.NP_SO-102 | 2.NP_SO-102 | VP02.22.0471 | 0471
13335885 | 2.NP_SO-102 | 2.NP_SO-102 | VP02.22.0477 | 0477
13335924 | -1.PP_SO-102 | -1.PP_SO-102 | VP02.22.0481 | 0481
13335949 | -1.PP_SO-102 | -1.PP_SO-102 | VP02.22.0485 | 0485
13335960 | -1.PP_SO-102 | -1.PP_SO-102 | VP02.22.0489 | 0489
13336008 | 4.NP_SO-102 | 4.NP_SO-102 | VP02.22.0493 | 0493
13463834 | 1.NP_SO-102 | 1.NP_SO-102 | VP02.22.0530 | 0530
13463840 | 2.NP_SO-102 | 2.NP_SO-102 | VP02.22.0534 | 0534
13463846 | 3.NP_SO-102 | 3.NP_SO-102 | VP02.22.0538 | 0538
13474057 | 2.NP_SO-102 | 2.NP_SO-102 | VP02.22.0549 | 0549

# IfcValve: Vtoková mřížka_03910.1E:03910.1E_Main Component (12)
Type - Classification: VP02 SNIM (SNIM); Material: Stainless Steel
Type - Vazby - Výchozí výška: 0 mm
Type - Domovní instalace - Připojení CW: no; Připojení HW: no; Připojení odpadu: yes; Připojení ventilace: no
Type - Kóty - Délka: 145 mm; Jmenovitá velikost výstupu: 110 mm; Šířka: 145 mm; Výška: 10 mm
Type - Identifikační data - Číslo OmniClass: 23.70.50.21.24.14; DIMENZE: 138x138mm; EAN: 9003076025633; HMOTNOST: 0,22 [kg]; Indexovaná poznámka: HL03910.1E; Kód sestavy: VP02; Komentáře k typům: HL03910.1E Nerezová vtoková mřížka 138x138mm; MATERIÁL: V2A; Model: HL03910.1E; Nadpis OmniClass: Deck Waste Water Drains; Název typu: 03910.1E_Main Component; Označení typu: 24; Popis: Podlahové vpustě - příslušenství; Popis sestavy: Podlahová; PRÁVNÍ OZNÁMENÍ: Copyright (©), autorská a jiná práva spojená s duševním vlastnictvím, jsou výhradním vlastnictvím společnosti HL Hutterer & Lechner GmbH. Úpravy nejsou dovoleny. Rodina je opatřená vodoznakem.; TŘÍDA ZATÍŽENÍ: K3 - 300 kg; URL: http://www.hutterer-lechner.com/cs/Products/catalog/floor-drains/attachments/HL03910.1E.aspx; Výrobce: HL Hutterer & Lechner GmbH
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Vtoková mřížka_03910.1E
Classification: VP02 SNIM (SNIM); VP02 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: NAC; CCI Technický systém: JD
Vazby - Přesunout s blízkými prvky: no; Výška od podlaží: -8000 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.00009522 m3
Jiné - Id typu: 13260914; Rodina: Vtoková mřížka_03910.1E; Rodina a typ: Vtoková mřížka_03910.1E: 03910.1E_Main Component; Typ: 03910.1E_Main Component
Name (Vtoková mřížka_03910.1E:03910.1E_Main Component:...) | In | Podlaží | Kód prvku | Označení
13261309 | 2.NP_SO-102 | 2.NP_SO-102 | VP02.24.0465 | 0465
13261419 | 2.NP_SO-102 | 2.NP_SO-102 | VP02.24.0469 | 0469
13261435 | 2.NP_SO-102 | 2.NP_SO-102 | VP02.24.0473 | 0473
13335887 | 2.NP_SO-102 | 2.NP_SO-102 | VP02.24.0479 | 0479
13335926 | -1.PP_SO-102 | -1.PP_SO-102 | VP02.24.0483 | 0483
13335951 | -1.PP_SO-102 | -1.PP_SO-102 | VP02.24.0487 | 0487
13335962 | -1.PP_SO-102 | -1.PP_SO-102 | VP02.24.0491 | 0491
13336010 | 4.NP_SO-102 | 4.NP_SO-102 | VP02.24.0495 | 0495
13463836 | 1.NP_SO-102 | 1.NP_SO-102 | VP02.24.0532 | 0532
13463842 | 2.NP_SO-102 | 2.NP_SO-102 | VP02.24.0536 | 0536
13463848 | 3.NP_SO-102 | 3.NP_SO-102 | VP02.24.0540 | 0540
13474059 | 2.NP_SO-102 | 2.NP_SO-102 | VP02.24.0551 | 0551

# IfcValve: Vypouštěcí kulový kohout závitový.LH:DN15 přímý vnitřní závit (15)
In: -1.PP_SO-102
Type - Classification: VE12 SNIM (SNIM); Material: MANIPULAČNÍ PROSTOR, 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Type - Kóty - DÉLKA: 63 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; JMENOVITÝ PRŮMĚR: 15 mm
Type - Identifikační data - Cena: 0; Kód sestavy: VE12; Komentáře k typům: 4xVKK DN 15; Model: DN 15 vnitřní závit; Název typu: DN15 přímý vnitřní závit; Označení typu: 18; Popis: Kulový kohout; Popis sestavy: Vypouštěcí; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; A: -12 mm; B: 19 mm; C: 16 mm; D: 44 mm; E: -12 mm; H: 37.6 mm; H1: 24.6 mm; H2: 13 mm; KL: no; L1: 28 mm; L2: 63 mm; Lookup Table Name: Vypoštěcí kulový kohout s páčkou.CC; M: 48 mm; M1: 20 mm; Název rodiny: Vypouštěcí kulový kohout závitový.LH; P: 25 mm; P1: 30 mm; P2: 14 mm; PR: yes; Typ: 1 mm; U: 0 deg; UP: 30 deg
Classification: VE12 SNIM (SNIM); VE12 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø15 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Vazby - Podlaží: -1.PP_SO-102
Mechanické - Klasifikace systému: Studená voda v domácnosti
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 15 mm; Minimální velikost: 15 mm; Objem: 0.0000642485 m3; Velikost: ø15
Jiné - Páteřní trasa: yes; Id typu: 13022243; Rodina: Vypouštěcí kulový kohout závitový.LH; Rodina a typ: Vypouštěcí kulový kohout závitový.LH: DN15 přímý vnitřní závit; Typ: DN15 přímý vnitřní závit
Name (Vypouštěcí kulový kohout závitový.LH:DN15 přímý vnitřní závit:...) | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Název systému = Group | Kód prvku | Označení
13080873 | 3300 | Fáze 1 | WS_Teplá vnitřní | WS_Teplá vnitřní 83 | VE12.18.0431 | 0431
13239519 | 1300 | Fáze 1 | WS_Požární nezavodněný | WS_Požární nezavodněný 1 | VE12.18.0461 | 0461
13404267 | 2800 | Fáze 1 | WS_Požární nezavodněný | WS_Požární nezavodněný 1 | VE12.18.0527 | 0527
13641107 | 3299.89 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | WS_"Jiný typ" studená vnitřní 1 | VE12.18.0630 | 0630
13641999 | 3301.8 | Fáze 1 | WS_Cirkulace vnitřní | WS_Cirkulace vnitřní 9 | VE12.18.0634 | 0634
13642025 | 3301.15 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | WS_"Jiný typ" studená vnitřní 1 | VE12.18.0635 | 0635
13642035 | 3301.34 | Fáze 1 | WS_Studená vnitřní | WS_Studená vnitřní 134 | VE12.18.0636 | 0636
13642358 | 3101.37 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | WS_"Jiný typ" studená vnitřní 1 | VE12.18.0637 | 0637
13642374 | 3102.37 | Fáze 1 | WS_Teplá vnitřní | WS_Teplá vnitřní 83 | VE12.18.0638 | 0638
13642390 | 3100.96 | Fáze 1 | WS_Studená vnitřní | WS_Studená vnitřní 134 | VE12.18.0639 | 0639
13642406 | 3101.95 | Fáze 1 | WS_Cirkulace vnitřní | WS_Cirkulace vnitřní 9 | VE12.18.0640 | 0640
13642817 | 2651.76 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | WS_"ŠEDÁ" studená vnitřní 2 | VE12.18.0645 | 0645
13642829 | 2652.56 | Fáze 2 | WS_Studená vnitřní | WS_Studená vnitřní 6 | VE12.18.0646 | 0646
13642849 | 2652.06 | Fáze 2 | WS_Cirkulace vnitřní | WS_Cirkulace vnitřní 3 | VE12.18.0647 | 0647
13642863 | 2651.46 | Fáze 2 | WS_Teplá vnitřní | WS_Teplá vnitřní 8 | VE12.18.0648 | 0648

# IfcValve: Vypouštěcí kulový kohout závitový.LH:DN15 přímý vnější závit (3)
In: -1.PP_SO-102
Type - Classification: VE12 SNIM (SNIM); Material: MANIPULAČNÍ PROSTOR, 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Type - Kóty - DÉLKA: 63 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; JMENOVITÝ PRŮMĚR: 15 mm
Type - Identifikační data - Cena: 0; Kód sestavy: VE12; Komentáře k typům: Přímý vypouštěcí kulový kohout s páčkou s vnějším závitem DN 15; Model: DN 15 vnější závit; Název typu: DN15 přímý vnější závit; Označení typu: 38; Popis: Kulový kohout; Popis sestavy: Vypouštěcí; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; KL: no; PR: yes; U: 0 deg; UP: 30 deg; A: -15 mm; B: 19 mm; C: 16 mm; D: 44 mm; E: -15 mm; H: 37.6 mm; H1: 24.6 mm; H2: 13 mm; L1: 31 mm; L2: 63 mm; Lookup Table Name: Vypoštěcí kulový kohout s páčkou.CC; M: 48 mm; M1: 20 mm; Název rodiny: Vypouštěcí kulový kohout závitový.LH; P: 25 mm; P1: 30 mm; P2: 14 mm; Typ: 2 mm
Classification: VE12 SNIM (SNIM); VE12 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø15 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Vazby - Podlaží: -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Studená voda v domácnosti
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 15 mm; Minimální velikost: 15 mm; Objem: 0.0000657211 m3; Velikost: ø15
Jiné - Páteřní trasa: yes; Rodina: Vypouštěcí kulový kohout závitový.LH; Id typu: 13022241; Rodina a typ: Vypouštěcí kulový kohout závitový.LH: DN15 přímý vnější závit; Typ: DN15 přímý vnější závit
Name (Vypouštěcí kulový kohout závitový.LH:DN15 přímý vnější závit:...) | Výška od podlaží (mm) | Typ systému | Název systému = Group | Kód prvku | Označení
13641442 | 3301.17 | WS_Teplá vnitřní | WS_Teplá vnitřní 83 | VE12.38.0631 | 0631
13641540 | 3301.2 | WS_Studená vnitřní | WS_Studená vnitřní 134 | VE12.38.0632 | 0632
13641789 | 3301.46 | WS_Cirkulace vnitřní | WS_Cirkulace vnitřní 9 | VE12.38.0633 | 0633

# IfcValve: Větrací hlavice:Uzavření_kanalizace_HT (13)
In: 4.NP_SO-102
Type - Classification: HV01 SNIM (SNIM); Material: 255-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 110 mm; Jmenovitá velikost vstupu: 110 mm; Šířka: 110 mm; Výška: 189 mm
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; Kód sestavy: HV01; Komentáře k typům: VĚTRACÍ HLAVICE; Nadpis OmniClass: Pipework Fittings; Název typu: Uzavření_kanalizace_HT; Označení typu: 07; Popis sestavy: Větrací
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Větrací hlavice; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: HV01 SNIM (SNIM); HV01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: G; CCI Komponenta: WPA; CCI Technický systém: JD
Vazby - Podlaží: STŘECHA_SO-102; Výška od podlaží: 1650 mm
Mechanické - Typ systému: SW_Odvětrání kanalizace; Klasifikace systému: Sanitární
Grafika - Použít měřítko poznámky: no
Jiné - Páteřní trasa: yes; Id typu: 12917422; Rodina: Větrací hlavice; Rodina a typ: Větrací hlavice: Uzavření_kanalizace_HT; Typ: Uzavření_kanalizace_HT
Name (Větrací hlavice:Uzavření_kanalizace_HT:...) | Celková velikost | Tlaková ztráta (Pa) | Fáze vytvoření | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Plocha (m2) | Velikost | Vnější průměr tvarovky (mm) | Výš. (mm) = Vnější poloměr tvarovky (mm) | Vzdálenost šipky (mm) | Kód prvku | Označení
12917557 | ø160 mm | 0 | Fáze 1 | SW_Odvětrání kanalizace 1 | 80 | 160 | 0.00218722 | 0.0853457 | ø160 | 163.175 | 81.5875 | 335 | HV01.07.0295 | 0295
12917858 | ø110 mm | 0 | Fáze 1 | SW_Odvětrání kanalizace 2 | 55 | 110 | 0.000717025 | 0.0403753 | ø110 | 113.175 | 56.5875 | 285 | HV01.07.0296 | 0296
12917992 | ø110 mm | 0 | Fáze 1 | SW_Odvětrání kanalizace 3 | 55 | 110 | 0.000717025 | 0.0403753 | ø110 | 113.175 | 56.5875 | 285 | HV01.07.0297 | 0297
12924280 | ø160 mm | 0 | Fáze 1 | SW_Odvětrání kanalizace 7 | 80 | 160 | 0.00218722 | 0.0853457 | ø160 | 163.175 | 81.5875 | 335 | HV01.07.0298 | 0298
12924316 | ø78 mm | 0 | Fáze 1 | SW_Odvětrání kanalizace 8 | 39 | 78 | 0.000258589 | 0.0203238 | ø78 | 81.175 | 40.5875 | 253 | HV01.07.0299 | 0299
12924343 | ø78 mm | 0 | Fáze 1 | SW_Odvětrání kanalizace 9 | 39 | 78 | 0.000258589 | 0.0203238 | ø78 | 81.175 | 40.5875 | 253 | HV01.07.0300 | 0300
12941588 | ø78 mm | 0 | Fáze 1 | SW_Odvětrání kanalizace 4 | 39 | 78 | 0.000258589 | 0.0203238 | ø78 | 81.175 | 40.5875 | 253 | HV01.07.0304 | 0304
13096102 | ø78 mm | 0 | Fáze 2 | SW_Odvětrání kanalizace 11 | 39 | 78 | 0.000258589 | 0.0203238 | ø78 | 81.175 | 40.5875 | 253 | HV01.07.0434 | 0434 | Identifikační data - Komentáře: S19
13096685 | ø78 mm | 0 | Fáze 2 | SW_Odvětrání kanalizace 10 | 39 | 78 | 0.000258589 | 0.0203238 | ø78 | 81.175 | 40.5875 | 253 | HV01.07.0435 | 0435 | Identifikační data - Komentáře: S18
13099817 | ø78 mm | 0 | Fáze 2 | SW_Odvětrání kanalizace 17 | 39 | 78 | 0.000258589 | 0.0203238 | ø78 | 81.175 | 40.5875 | 253 | HV01.07.0436 | 0436 | Identifikační data - Komentáře: S16
13181480 | ø135 mm |  | Fáze 1 | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.00131855 | 0.0607814 | ø135 | 138.175 | 69.0875 | 310 | HV01.07.0450 | 0450
13444260 | ø160 mm | 0 | Fáze 2 | SW_Odvětrání kanalizace 15 | 80 | 160 | 0.00218722 | 0.0853457 | ø160 | 163.175 | 81.5875 | 335 | HV01.07.0528 | 0528 | Identifikační data - Komentáře: S20
13506497 | ø78 mm | 0 | Fáze 2 | SW_Odvětrání kanalizace 19 | 39 | 78 | 0.000258589 | 0.0203238 | ø78 | 81.175 | 40.5875 | 253 | HV01.07.0567 | 0567 | Identifikační data - Komentáře: S21

# IfcValve: Zpětná klapka závitová.LH:DN 15 (4)
Type - Classification: VE15 SNIM (SNIM); Material: 128-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - DÉLKA: 45 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; JMENOVITÝ PRŮMĚR: 15 mm; PRŮMĚR: 31 mm
Type - Identifikační data - Kód sestavy: VE15; Komentáře k typům: ZV DN15; Model: Model; Název typu: DN 15; Označení typu: 16; Popis: Ventil; Popis sestavy: Zpětný; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Zpětná klapka závitová.LH; ODSAZENí: 15 mm; OSAZENÍ BOČNÉ: 11.25 mm; VS: 90 mm
Classification: VE15 SNIM (SNIM); VE15 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø20 mm-ø20 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: RMB; CCI Technický systém: JB
Mechanické - Typ systému: WS_"ŠEDÁ" studená vnitřní; Klasifikace systému: Studená voda v domácnosti; PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 20 mm; Minimální velikost: 20 mm; Objem: 0.0000339629 m3; Průměr připojení: 20 mm; Velikost: ø20-ø20
Jiné - Páteřní trasa: no; Rodina: Zpětná klapka závitová.LH; Typ: DN 15; Id typu: 13046473; Rodina a typ: Zpětná klapka závitová.LH: DN 15
Name (Zpětná klapka závitová.LH:DN 15:...) | In | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Kód prvku | Označení
13046568 | 2.NP_SO-102 | 2.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní 23 | VE15.16.0388 | 0388
13070297 | 4.NP_SO-102 | 4.NP_SO-102 | 1426.66 | Fáze 1 | WS_"Jiný typ" studená vnitřní 1 | VE15.16.0410 | 0410
13070616 | 3.NP_SO-102 | 3.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní 3 | VE15.16.0411 | 0411
13071395 | 1.NP_SO-102 | 1.NP_SO-102 | 1426.66 | Fáze 1 | WS_"Jiný typ" studená vnitřní 1 | VE15.16.0417 | 0417

# IfcValve: Zpětná klapka závitová.LH:DN 20 (4)
Type - Classification: VE15 SNIM (SNIM); Material: 128-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - DÉLKA: 50 mm; Jmenovitá velikost vstupu: 20 mm; Jmenovitá velikost výstupu: 20 mm; JMENOVITÝ PRŮMĚR: 20 mm; PRŮMĚR: 39 mm
Type - Identifikační data - Kód sestavy: VE15; Komentáře k typům: ZV DN20; Model: Model; Název typu: DN 20; Označení typu: 14; Popis: Ventil; Popis sestavy: Zpětný; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Zpětná klapka závitová.LH; ODSAZENí: 16.6667 mm; OSAZENÍ BOČNÉ: 12.5 mm; VS: 100 mm
Classification: VE15 SNIM (SNIM); VE15 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø20 mm-ø20 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: RMB; CCI Technický systém: JB
Mechanické - Typ systému: WS_"ŠEDÁ" studená vnitřní; Klasifikace systému: Studená voda v domácnosti; PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 20 mm; Minimální velikost: 20 mm; Objem: 0.0000597267 m3; Průměr připojení: 20 mm; Velikost: ø20-ø20
Jiné - Páteřní trasa: no; Typ: DN 20; Id typu: 13046471; Rodina: Zpětná klapka závitová.LH; Rodina a typ: Zpětná klapka závitová.LH: DN 20
Name (Zpětná klapka závitová.LH:DN 20:...) | In | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Kód prvku | Označení
13046552 | 4.NP_SO-102 | 4.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní 2 | VE15.14.0382 | 0382
13046559 | 3.NP_SO-102 | 3.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní 22 | VE15.14.0385 | 0385
13046577 | 1.NP_SO-102 | 1.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní 24 | VE15.14.0391 | 0391
13071176 | 2.NP_SO-102 | 2.NP_SO-102 | 1426.66 | Fáze 1 | WS_"Jiný typ" studená vnitřní 1 | VE15.14.0416 | 0416

# IfcValve: Zápachový uzávěr vložka_2100:2100_Main Component (12)
Type - Classification: ZU00 SNIM (SNIM); Material: Plactic - White, Plactic - Black
Type - Vazby - Výchozí výška: 0 mm
Type - Domovní instalace - Připojení CW: no; Připojení HW: no; Připojení odpadu: yes; Připojení ventilace: no
Type - Kóty - Jmenovitá velikost vstupu: 110 mm; Jmenovitá velikost výstupu: 110 mm
Type - Identifikační data - Číslo OmniClass: 23.70.50.21.24.14; EAN: 9003076025619; HMOTNOST: 0,18 [kg]; Indexovaná poznámka: HL2100; Kód sestavy: ZU00; Komentáře k typům: HL2100 Zápachový uzávěr "Primus" k HL3100Pr a HL5100Pr; MATERIÁL: PP/ABS; Model: HL2100; Nadpis OmniClass: Deck Waste Water Drains; Název typu: 2100_Main Component; Označení typu: 23; Popis: Podlahové vpustě - příslušenství; Popis sestavy: Obecný prvek; PRÁVNÍ OZNÁMENÍ: Copyright (©), autorská a jiná práva spojená s duševním vlastnictvím, jsou výhradním vlastnictvím společnosti HL Hutterer & Lechner GmbH. Úpravy nejsou dovoleny. Rodina je opatřená vodoznakem.; URL: http://www.hutterer-lechner.com/cs/Products/catalog/floor-drains/attachments/HL2100.aspx; Výrobce: HL Hutterer & Lechner GmbH
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Zápachový uzávěr vložka_2100
Classification: ZU00 SNIM (SNIM); ZU00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: RMD; CCI Technický systém: JD
Vazby - Přesunout s blízkými prvky: no; Výška od podlaží: -8005 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.000483318 m3
Jiné - Id typu: 13261132; Rodina: Zápachový uzávěr vložka_2100; Rodina a typ: Zápachový uzávěr vložka_2100: 2100_Main Component; Typ: 2100_Main Component
Name (Zápachový uzávěr vložka_2100:2100_Main Component:...) | In | Podlaží | Kód prvku | Označení
13261308 | 2.NP_SO-102 | 2.NP_SO-102 | ZU00.23.0464 | 0464
13261418 | 2.NP_SO-102 | 2.NP_SO-102 | ZU00.23.0468 | 0468
13261434 | 2.NP_SO-102 | 2.NP_SO-102 | ZU00.23.0472 | 0472
13335886 | 2.NP_SO-102 | 2.NP_SO-102 | ZU00.23.0478 | 0478
13335925 | -1.PP_SO-102 | -1.PP_SO-102 | ZU00.23.0482 | 0482
13335950 | -1.PP_SO-102 | -1.PP_SO-102 | ZU00.23.0486 | 0486
13335961 | -1.PP_SO-102 | -1.PP_SO-102 | ZU00.23.0490 | 0490
13336009 | 4.NP_SO-102 | 4.NP_SO-102 | ZU00.23.0494 | 0494
13463835 | 1.NP_SO-102 | 1.NP_SO-102 | ZU00.23.0531 | 0531
13463841 | 2.NP_SO-102 | 2.NP_SO-102 | ZU00.23.0535 | 0535
13463847 | 3.NP_SO-102 | 3.NP_SO-102 | ZU00.23.0539 | 0539
13474058 | 2.NP_SO-102 | 2.NP_SO-102 | ZU00.23.0550 | 0550

# IfcValve: Závitový_Hydrantový ventil C52 mosaz se spojkou Al.CC:DN 50 (10)
Type - Classification: HS03 SNIM (SNIM); Material: 175-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - JMENOVITÝ PRŮMĚR: 50 mm
Type - Identifikační data - Cena: 700; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: HS03; Komentáře k typům: hydrantový C52 mosaz se spojkou Al DN 50; Model: DN50; Název typu: DN 50; Označení typu: 26; Popis: Ventil; Popis sestavy: Ventil; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Závitový_Hydrantový ventil C52 mosaz se spojkou Al.CC
Classification: HS03 SNIM (SNIM); HS03 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø50 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: FMD; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_Požární nezavodněný; PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 50 mm; Minimální velikost: 50 mm; Objem: 0.000433766 m3; Velikost: ø50
Jiné - Páteřní trasa: yes; Id typu: 13139543; Rodina: Závitový_Hydrantový ventil C52 mosaz se spojkou Al.CC; Rodina a typ: Závitový_Hydrantový ventil C52 mosaz se spojkou Al.CC: DN 50; Typ: DN 50
Name (Závitový_Hydrantový ventil C52 mosaz se spojkou Al.CC:DN 50:...) | In | Podlaží | Výška od podlaží (mm) | Klasifikace systému | Název systému = Group | Kód prvku | Označení
13347475 | 1.NP_SO-102 | 1.NP_SO-102 | 1300 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | HS03.26.0496 | 0496
13347479 | 2.NP_SO-102 | 2.NP_SO-102 | 1300 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | HS03.26.0497 | 0497
13347483 | 3.NP_SO-102 | 3.NP_SO-102 | 1300 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | HS03.26.0498 | 0498
13347487 | 4.NP_SO-102 | 4.NP_SO-102 | 800 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | HS03.26.0499 | 0499
13348071 | -1.PP_SO-102 | -1.PP_SO-102 | 1300 | Studená voda v domácnosti | WS_Požární nezavodněný 1 | HS03.26.0500 | 0500
13348072 | 1.NP_SO-102 | 1.NP_SO-102 | 1300 | Studená voda v domácnosti | WS_Požární nezavodněný 1 | HS03.26.0501 | 0501
13348073 | 2.NP_SO-102 | 2.NP_SO-102 | 1300 | Studená voda v domácnosti | WS_Požární nezavodněný 1 | HS03.26.0502 | 0502
13348074 | 3.NP_SO-102 | 3.NP_SO-102 | 1300 | Studená voda v domácnosti | WS_Požární nezavodněný 1 | HS03.26.0503 | 0503
13360671 | -1.PP_SO-102 | -1.PP_SO-102 | 1300 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | HS03.26.0504 | 0504
14022620 | 4.NP_SO-102 | 4.NP_SO-102 | 1312 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 2 | HS03.26.0697 | 0697

# IfcValve: Zázitový_Pevná spojka tlaková_B75:Pevná tlakový spojka B75, DN80 (2)
In: -1.PP_SO-102
Type - Classification: VE00 SNIM (SNIM); Material: 175-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s
Type - Kóty - Jmenovitá velikost vstupu: 80 mm; Jmenovitá velikost výstupu: 80 mm; JMENOVITÝ PRŮMĚR: 80 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VE00; Komentáře k typům: Pevná tlaková spojka B75; Model: Spojka, DN65; Název typu: Pevná tlakový spojka B75, DN80; Označení typu: 40; Popis: Spojka; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Zázitový_Pevná spojka tlaková_B75
Classification: VE00 SNIM (SNIM); VE00 Uniformat (Uniformat); Group: WS_Požární nezavodněný 1
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø80 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: NAC; CCI Technický systém: JD
Vazby - Podlaží: -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_Požární nezavodněný; Název systému: WS_Požární nezavodněný 1
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 80 mm; Minimální velikost: 80 mm; Objem: 0.000192724 m3; Velikost: ø80
Jiné - Páteřní trasa: yes; D: 40 mm; Id typu: 13142130; Rodina: Zázitový_Pevná spojka tlaková_B75; Rodina a typ: Zázitový_Pevná spojka tlaková_B75: Pevná tlakový spojka B75, DN80; Typ: Pevná tlakový spojka B75, DN80; Z: 44 mm
Name (Zázitový_Pevná spojka tlaková_B75:Pevná tlakový spojka B75, DN80:...) | Výška od podlaží (mm) | Klasifikace systému | Kód prvku | Označení
13764567 | 2914.72 | Požární ochrana – suché prostředky | VE00.40.0672 | 0672
13764624 | 2904.52 | Studená voda v domácnosti | VE00.40.0673 | 0673

# IfcValve: Šachta kanalizační kruhová:Šachta kanalizační kruhová D.1, Šachta kanalizační kruhová:Šachta kanalizační kruhová D.1:13980119
In: -1.PP_SO-102
Type - Classification: AT02 SNIM (SNIM); Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Tloušťka dna: 200 mm; Tloušťka stěny: 120 mm; Vnější průměr_Dolní: 1200 mm; Vnější průměr_Horní: 625 mm; Výška přechodu: 600 mm; Výška šachty: 3400 mm; Výška vyrovnávací skruže: 250 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: DŠ; Kód sestavy: AT02; Komentáře k typům: kanalizační kruhová; Název typu: Šachta kanalizační kruhová D.1; Označení typu: 41; Popis: Šachta; Popis sestavy: Betonová; URL: www.cadconsulting.cz; Version: 1.0
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Šachta kanalizační kruhová; o: 287.5 mm; rt: 480 mm; rth: 192.5 mm; vp: 600 mm; vph: 312.5 mm; vz: 2350 mm
Classification: AT02 SNIM (SNIM); AT02 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: NAC; CCI Technický systém: JD
Vazby - Přesunout s blízkými prvky: no; Podlaží: -1.PP_SO-102; Výška od podlaží: 1760 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 1.41575 m3
Identifikační data - ID pozice: 01; Kód prvku: AT02.41.0676; Komentáře: OPATŘENO ZPĚTNOU KLAPKOU; Označení: 0676
Jiné - Páteřní trasa: yes; Id typu: 13980101; Rodina: Šachta kanalizační kruhová; Rodina a typ: Šachta kanalizační kruhová: Šachta kanalizační kruhová D.1; Typ: Šachta kanalizační kruhová D.1

# IfcValve: Šachta kanalizační kruhová:Šachta kanalizační kruhová D.1 2, Šachta kanalizační kruhová:Šachta kanalizační kruhová D.1 2:14027060
In: -1.PP_SO-102
Type - Classification: AT02 SNIM (SNIM); Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Tloušťka dna: 200 mm; Tloušťka stěny: 120 mm; Vnější průměr_Dolní: 1200 mm; Vnější průměr_Horní: 625 mm; Výška přechodu: 600 mm; Výška šachty: 2900 mm; Výška vyrovnávací skruže: 250 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: DŠ; Kód sestavy: AT02; Komentáře k typům: kanalizační kruhová; Název typu: Šachta kanalizační kruhová D.1 2; Označení typu: 43; Popis: Šachta; Popis sestavy: Betonová; URL: www.cadconsulting.cz; Version: 1.0
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Šachta kanalizační kruhová; o: 287.5 mm; rt: 480 mm; rth: 192.5 mm; vp: 600 mm; vph: 312.5 mm; vz: 1850 mm
Classification: AT02 SNIM (SNIM); AT02 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JD
Vazby - Přesunout s blízkými prvky: no; Podlaží: -1.PP_SO-102; Výška od podlaží: 1120 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 1.21216 m3
Identifikační data - ID pozice: 02; Kód prvku: AT02.43.0698; Označení: 0698
Jiné - Páteřní trasa: yes; Rodina: Šachta kanalizační kruhová; Id typu: 14027257; Rodina a typ: Šachta kanalizační kruhová: Šachta kanalizační kruhová D.1 2; Typ: Šachta kanalizační kruhová D.1 2

# IfcWasteTerminal: Liniový žlab:Šířka 150 mm (2)
In: -1.PP_SO-102
Type - PredefinedType: USERDEFINED; Classification: BC04 SNIM (SNIM); Material: PC, Stahl, verzinkt, UP-GF(grey)
Type - Celá legenda - B_cw: NW 150; B_Modelltext: MEA channel; grating depth: 20 mm
Type - Data - execution documents: according to drawing and description; Installation technology: einclusive foundation; Material foundation: concrete; Typ drainage: Typ M
Type - Vlastnosti modelu - clear width mm drainage system: 150; Construction drainage system: box channel, U-form; Part, drainage: Drainage channel
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Material channel: UP-GF(grey); Material Endcap: PC
Type - Kóty - channel body height: 75 mm; channel body width: 186 mm; clear width: 150 mm; Diameter outside outlet: 110 mm
Type - Identifikační data - Číslo OmniClass: 23.70.50.00; Hersteller und Typ - Ausschreibender gleichwertig: wie MEA Bautechnik GmbH, Modell MEARIN Plus F; Indexovaná poznámka: Drainage channel for surface water; Kód sestavy: BC04; Komentáře k typům: LINIOVÝ ODVODŇOVACÍ ŽLAB - OŽ1; Model: MEARIN Plus F; Nadpis OmniClass: Liquid Waste Handling Services; Název typu: Šířka 150 mm; Označení typu: 36; Popis sestavy: Liniové; URL: https://www.mea-group.com; Výrobce: MEA Bautechnik GmbH business unit MEA Water Management
Type - Jiné - Kategorie: Instalační zařizovací předměty; MEA- clear width: 150; Název rodiny: Liniový žlab
Classification: BC04 SNIM (SNIM); BC04 Uniformat (Uniformat)
Celá legenda - B_Abd show G2: no; B_Abd show G3: no; B_Abd show G4: no; B_offset end: 0 mm; B_Revision shown: no; B_Abd show G1: yes; B_Abd show G5: no; B_cover group: 1; B_cover width: 172 mm; B_end revision element: 1 mm; B_Revision left: 158 mm; B_Revision right: 8 mm; B_TopSlot height: 1 mm; B_TopSlot side: 8 mm; B_vertical offset: 0 mm; Foundation width: 100 mm
Data - MEA planing help: https://www.mea-group.com/de/en/services/
Vlastnosti modelu - Loading class drainage system: B 125; Product website: https://www.mea-group.com/de/en/products/drainage-channel-mearin-plus/; Slope type/percent drainage component: ohne Gefälle; suitable drainage component: not suitable for the diagonal or transvers travel of motorways and highway; technical product information: https://www.mea-group.com/de/en/services/technical-documentation/
Text - CCI Funkční systém: F; CCI Komponenta: WMB; CCI Technický systém: JB
Vazby - Pracovní rovina: Podlaží : 1.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární
Stavba - Foundation view: no; Revision element beginning: no; TopSlot left: no; Cover: slotted; Def Cover: 1; Def Loading class: 2; Loading class: B 125; TopSlot middle: no
Kóty - Jmenovitá velikost výstupu: 125 mm
Jiné - Páteřní trasa: yes; MEA- revision TopSlot: 0; Rodina: Liniový žlab; Id typu: 13316717; MEA- cover: slotted; MEA- edge: GFK; MEA- endcap: 1; MEA- loading class: B 125; Rodina a typ: Liniový žlab: Šířka 150 mm; Typ: Šířka 150 mm
Name (Liniový žlab:Šířka 150 mm:...) | B_channel body end (mm) | offset outlet (mm) | B_channel body start (mm) | B_Foundation length (mm) = MEA- channel length (mm) | Délka (mm) | Odsazení od hostitele (mm) | Endcap start | Endcap end = outlet | Objem (m3) | Plocha (m2) | Kód prvku | Označení
13395911 | 0 | 0 | 6 | 3856 | 3856 | -2275.5 | yes | no | 0.0276094 | 6.80082 | BC04.36.0725 | 0725
13514350 | 6 | 150 | 150 | 8150 | 8000 | 0 | no | yes | 0.058514 | 14.2248 | BC04.36.0768 | 0768 | Mechanické - Typ systému: SW_Deště vnitřní gravitační; Název systému: SW_Deště vnitřní gravitační 2; Group: SW_Deště vnitřní gravitační 2

# IfcWasteTerminal: Liniový žlab:Šířka 150 mm 2, Liniový žlab:Šířka 150 mm 2:13395970
In: -1.PP_SO-102
Type - PredefinedType: USERDEFINED; Material: PC, Stahl, verzinkt, UP-GF(grey)
Type - Celá legenda - B_cw: NW 150; B_Modelltext: MEA channel; grating depth: 20 mm
Type - Data - execution documents: according to drawing and description; Installation technology: einclusive foundation; Material foundation: concrete; Typ drainage: Typ M
Type - Vlastnosti modelu - clear width mm drainage system: 150; Construction drainage system: box channel, U-form; Part, drainage: Drainage channel
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Material channel: UP-GF(grey); Material Endcap: PC
Type - Kóty - channel body height: 75 mm; channel body width: 186 mm; clear width: 150 mm; Diameter outside outlet: 110 mm
Type - Identifikační data - Číslo OmniClass: 23.70.50.00; Hersteller und Typ - Ausschreibender gleichwertig: wie MEA Bautechnik GmbH, Modell MEARIN Plus F; Indexovaná poznámka: Drainage channel for surface water; Komentáře k typům: LINIOVÝ ODVODŇOVACÍ ŽLAB - OŽ2; Model: MEARIN Plus F; Nadpis OmniClass: Liquid Waste Handling Services; Název typu: Šířka 150 mm 2; Označení typu: 37; URL: https://www.mea-group.com; Výrobce: MEA Bautechnik GmbH business unit MEA Water Management
Type - Jiné - Kategorie: Instalační zařizovací předměty; MEA- clear width: 150; Název rodiny: Liniový žlab
Celá legenda - B_Abd show G2: no; B_Abd show G3: no; B_Abd show G4: no; B_offset end: 0 mm; B_Revision shown: no; B_Abd show G1: yes; B_Abd show G5: no; B_cover group: 1; B_vertical offset: 0 mm; B_channel body end: 6 mm; B_channel body start: 150 mm; B_cover width: 172 mm; B_end revision element: 1 mm; B_Foundation length: 4150 mm; B_Revision left: 158 mm; B_Revision right: 8 mm; B_TopSlot height: 1 mm; B_TopSlot side: 8 mm; Foundation width: 100 mm; offset outlet: 150 mm
Data - MEA planing help: https://www.mea-group.com/de/en/services/
Vlastnosti modelu - Loading class drainage system: B 125; Product website: https://www.mea-group.com/de/en/products/drainage-channel-mearin-plus/; Slope type/percent drainage component: ohne Gefälle; suitable drainage component: not suitable for the diagonal or transvers travel of motorways and highway; technical product information: https://www.mea-group.com/de/en/services/technical-documentation/
Text - CCI Funkční systém: F; CCI Komponenta: WMB; CCI Technický systém: JB
Vazby - Délka: 4000 mm; Odsazení od hostitele: -2275.5 mm; Pracovní rovina: Podlaží : 1.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: SW_Deště vnitřní gravitační; Klasifikace systému: Sanitární; Název systému: SW_Deště vnitřní gravitační 1
Stavba - Endcap end: yes; Endcap start: no; outlet: yes; Foundation view: no; Revision element beginning: no; TopSlot left: no; Def Cover: 1; Def Loading class: 2; TopSlot middle: no; Cover: slotted; Loading class: B 125
Kóty - Jmenovitá velikost výstupu: 125 mm; Objem: 0.0300308 m3; Plocha: 7.30055 m2
Identifikační data - Kód prvku: .37.0726; Komentáře: ŠÍŘKA 150 mm, VÝŠKA 75 mm; Označení: 0726
Jiné - Páteřní trasa: yes; MEA- revision TopSlot: 0; Rodina: Liniový žlab; MEA- endcap: 1; Id typu: 13979026; MEA- channel length: 4150 mm; MEA- cover: slotted; MEA- edge: GFK; MEA- loading class: B 125; Rodina a typ: Liniový žlab: Šířka 150 mm 2; Typ: Šířka 150 mm 2
Group: SW_Deště vnitřní gravitační 1

# IfcWasteTerminal: Liniový žlab:Šířka 150 mm 3, Liniový žlab:Šířka 150 mm 3:13319594
In: -2.PP_SO-102
Type - PredefinedType: USERDEFINED; Material: UP-GF(grey)
Type - Celá legenda - B_cw: NW 150; B_Modelltext: MEA channel; grating depth: 20 mm
Type - Data - execution documents: according to drawing and description; Installation technology: einclusive foundation; Material foundation: concrete; Typ drainage: Typ M
Type - Vlastnosti modelu - clear width mm drainage system: 150; Construction drainage system: box channel, U-form; Part, drainage: Drainage channel
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Material channel: UP-GF(grey); Material Endcap: PC
Type - Kóty - channel body height: 75 mm; channel body width: 186 mm; clear width: 150 mm; Diameter outside outlet: 110 mm
Type - Identifikační data - Číslo OmniClass: 23.70.50.00; Hersteller und Typ - Ausschreibender gleichwertig: wie MEA Bautechnik GmbH, Modell MEARIN Plus F; Indexovaná poznámka: Drainage channel for surface water; Komentáře k typům: LINIOVÝ ODVODŇOVACÍ ŽLAB; Model: MEARIN Plus F; Nadpis OmniClass: Liquid Waste Handling Services; Název typu: Šířka 150 mm 3; Označení typu: 35; URL: https://www.mea-group.com; Výrobce: MEA Bautechnik GmbH business unit MEA Water Management
Type - Jiné - Kategorie: Instalační zařizovací předměty; MEA- clear width: 150; Název rodiny: Liniový žlab
Celá legenda - B_Abd show G1: no; B_Abd show G2: no; B_Abd show G3: no; B_Abd show G4: no; B_Abd show G5: yes; B_channel body end: 0 mm; B_channel body start: 0 mm; B_cover group: 5; B_cover width: 172 mm; B_end revision element: 1 mm; B_Foundation length: 5000 mm; B_offset end: 0 mm; B_Revision left: 83 mm; B_Revision right: 83 mm; B_Revision shown: no; B_TopSlot height: 140 mm; B_TopSlot side: 83 mm; B_vertical offset: 140 mm; Foundation width: 80 mm; offset outlet: 0 mm
Data - MEA planing help: https://www.mea-group.com/de/en/services/
Vlastnosti modelu - Loading class drainage system: A 15; Product website: https://www.mea-group.com/de/en/products/drainage-channel-mearin-plus/; Slope type/percent drainage component: ohne Gefälle; suitable drainage component: not suitable for the diagonal or transvers travel of motorways and highway; technical product information: https://www.mea-group.com/de/en/services/technical-documentation/
Text - CCI Funkční systém: F; CCI Komponenta: WMB; CCI Technický systém: JB
Vazby - Délka: 5000 mm; Odsazení od hostitele: 1 mm; Pracovní rovina: Podlaží : -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární; Název systému: SW_Deště vnitřní gravitační 2; Typ systému: SW_Deště vnitřní gravitační
Stavba - Endcap start: no; Endcap end: no; Cover: please join a cover; Def Cover: 11; Def Loading class: 1; Foundation view: no; Loading class: A 15; outlet: no; Revision element beginning: no; TopSlot left: no; TopSlot middle: yes
Kóty - Jmenovitá velikost výstupu: 135 mm; Objem: 0.0185555 m3; Plocha: 9.18511 m2
Identifikační data - Kód prvku: .35.0714; Komentáře: ŠÍŘKA 150 mm, VÝŠKA 75 mm; Označení: 0714
Jiné - Páteřní trasa: yes; Id typu: 13979078; MEA- channel length: 5000 mm; MEA- cover: please join a cover; MEA- edge: GFK; MEA- endcap: 0; MEA- loading class: A 15; MEA- revision TopSlot: 0; Rodina: Liniový žlab; Rodina a typ: Liniový žlab: Šířka 150 mm 3; Typ: Šířka 150 mm 3
Group: SW_Deště vnitřní gravitační 2

# IfcWasteTerminal: Vypařovací žlab:Šířka 150 mm šedá (4)
In: -1.PP_SO-102
Type - PredefinedType: USERDEFINED; Classification: BC01 SNIM (SNIM); Material: <Unnamed>, UP-GF(grey)
Type - Celá legenda - Einbau als AS: no
Type - Data - article number: 010141800; execution documents: according to drawing and description; Installation technology: Rinne allein; Material foundation: PCC-Mörtel/Epoxy-Mörtel; MEA planing help: https://www.mea-group.com/de/en/services/; STLB-Bau Mustervorlage: https://www.stlb-bau-online.de/Mustervorlagen/MEA-GROUP/Node; technical product information: https://www.mea-group.com/de/en/services/technical-documentation/; Typ Drainage: Typ M; weight: 18.32KGM
Type - Vlastnosti modelu - clear width mm drainage system: 150; Loading class drainage system: C 250; Part, drainage: Drainage channel
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Material: UP-GF(grey)
Type - Stavba - construction drainage system: comb channel
Type - Kóty - clear width: 150 mm; Diameter outside outlet: 0 mm; heigth: 30 mm; width: 180 mm
Type - Identifikační data - Číslo OmniClass: 23.70.50.00; Indexovaná poznámka: Drainage channel for surface water; Kód sestavy: BC01; Komentáře k typům: VYPAŘOVACÍ ŽLAB; Nadpis OmniClass: Liquid Waste Handling Services; Název typu: Šířka 150 mm šedá; Označení typu: 34; Popis sestavy: Obecný prvek; URL: https://www.mea-group.com/; Výrobce: MEA Bautechnik GmbH business unit MEA Water Management
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Vypařovací žlab
Classification: BC01 SNIM (SNIM); BC01 Uniformat (Uniformat)
Celá legenda - length endcap: 15 mm; offset_dif_gully: 0 mm; offset gully: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: WMB; CCI Technický systém: JB
Vazby - connection left: yes; connection version gully: 2; Gully beginning: no; Odsazení od hostitele: 1 mm; outlet: yes; Pracovní rovina: Podlaží : -1.PP_SO-102
Kóty - floor level: 0 mm
Jiné - Páteřní trasa: yes; Id typu: 13295708; MEA- number: 010141800; MEA- number gully: -; Rodina: Vypařovací žlab; Rodina a typ: Vypařovací žlab: Šířka 150 mm šedá; Typ: Šířka 150 mm šedá
Name (Vypařovací žlab:Šířka 150 mm šedá:...) | offset_dif_endcap (mm) | offset endcap (mm) = length channel (mm) = MEA- channel length (mm) | offset length (mm) = Délka (mm) | Endcap end | Endcap start | Fáze vytvoření | Objem (m3) | Plocha (m2) | Kód prvku | Označení | MEA- number endcap
13278788 | 15 | 32449 | 32464 | yes | no | Fáze 1 | 0.103225 | 12.1208 | BC01.34.0710 | 0710 | 010141808
13285857 | 15 | 7135 | 7150 | yes | yes | Fáze 1 | 0.0231697 | 2.78371 | BC01.34.0711 | 0711 | 010141808 | Identifikační data - Komentáře: ŠÍŘKA 150 mm, VÝŠKA 30 mm
13286394 | 15 | 8535 | 8550 | yes | yes | Fáze 2 | 0.0275972 | 3.3001 | BC01.34.0712 | 0712 | 010141808
13286575 | 0 | 9039 | 9039 | no | yes | Fáze 2 | 0.0291911 | 3.486 | BC01.34.0713 | 0713 | - | Identifikační data - Komentáře: ŠÍŘKA 150 mm

# IfcZone, Výchozí:102462
Energetická analýza - Možnost pro prostor s venkovním vzduchem: Z typu prostoru; Nastavená hodnota chlazení: 23.3333 C; Nastavená hodnota odvlhčování: 0; Nastavená hodnota topení: 21.1111 C; Nastavená hodnota zvlhčování: 0; Obtokový součinitel: 0; Použít nastavenou hodnotu odvlhčování: no; Použít nastavenou hodnotu zvlhčování: no; Použít vnější vzduch na osobu: no; Použít vnější vzduch na plochu: no; Použít výměnu vzduchu na hodinu: no; Proudění venkovního vzduchu / výměna vzduchu na hodinu: 0; Teplota chladicího vzduchu: 12.2222 C; Teplota vzduchu topení: 32.2222 C; Typ služby: <Budova>; Venkovní vzduch na osobu: 0 m3/s; Venkovní vzduch na plochu: 0
Kóty - Hrubá plocha: 6562.99 m2; Hrubý objem: 14699.6 m3; Obsazená plocha: 6562.99 m2; Obsazený objem: 14699.6 m3
Identifikační data - Název: Výchozí
Jiné - Kategorie: Zóny VZT
