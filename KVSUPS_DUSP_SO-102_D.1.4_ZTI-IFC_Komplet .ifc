Properties of the parts of a building model (IFC4), part 30 of 60

# IfcPipeFitting: M_Koleno, obecné:Standardní (1248)
Name (M_Koleno, obecné:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm) | Group
13003595 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 580 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0283 | 0283 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
13003645 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0285 | 0285 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13003703 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 580 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0287 | 0287 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
13003781 | 1.NP_SO-102 | ø32 mm-ø32 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0290 | 0290 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13003817 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 580 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0292 | 0292 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
13003819 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0293 | 0293 | yes | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13003867 | 1.NP_SO-102 | ø40 mm-ø40 mm | 1.NP_SO-102 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0296 | 0296 | yes | 26.9875 | 20.6375 | WS_Teplá vnitřní 83
13003869 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0297 | 0297 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13003873 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0298 | 0298 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13003907 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0300 | 0300 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13003925 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 580 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0302 | 0302 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
13004677 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0306 | 0306 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
13004705 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0308 | 0308 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
13004840 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0310 | 0310 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
13004955 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0312 | 0312 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
13005088 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0313 | 0313 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
13005090 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0314 | 0314 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
13005156 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0315 | 0315 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
13005158 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0316 | 0316 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
13005657 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 1170 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 3 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0323 | 0323 | no | 17.4625 | 11.1125 | WS_"ŠEDÁ" studená vnitřní 3
13005692 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 1170 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0327 | 0327 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13005725 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 1170 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0330 | 0330 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13008280 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.02.0340 | 0340 | yes | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
13008284 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.02.0342 | 0342 | yes | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
13008383 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0344 | 0344 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13008412 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0346 | 0346 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
13008450 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0347 | 0347 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
13008948 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0350 | 0350 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13009405 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0351 | 0351 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
13009601 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0353 | 0353 | yes | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13009647 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0354 | 0354 | yes | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13009673 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0355 | 0355 | no | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13009764 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0356 | 0356 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13009766 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 580 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0357 | 0357 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13009833 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 580 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0358 | 0358 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13010263 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0364 | 0364 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13010321 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0365 | 0365 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13010334 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0366 | 0366 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13010958 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0367 | 0367 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13010960 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 1227.42 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0368 | 0368 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13011076 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0369 | 0369 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13011078 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0370 | 0370 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13011687 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0371 | 0371 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
13011722 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0372 | 0372 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
13012636 | 1.NP_SO-102 | ø32 mm-ø32 mm | 1.NP_SO-102 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0379 | 0379 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 83
13013806 | 1.NP_SO-102 | ø32 mm-ø32 mm | 1.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0387 | 0387 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 83
13013924 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0388 | 0388 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
13014016 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0390 | 0390 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
13014457 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0394 | 0394 | yes | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13014511 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0395 | 0395 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13014585 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0398 | 0398 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13014812 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0402 | 0402 | yes | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13015237 | 3.NP_SO-102 | ø32 mm-ø32 mm | 3.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0406 | 0406 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 83
13015480 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0410 | 0410 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 83
13015526 | 1.NP_SO-102 | ø32 mm-ø32 mm | 1.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0413 | 0413 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 83
13018608 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0423 | 0423 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 83 | Mechanické – tok - Tlaková ztráta: 0 Pa
13022788 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0432 | 0432 | yes | 33.3375 | 26.9875 | WS_Studená vnitřní 6
13022834 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0433 | 0433 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 3 | Mechanické – tok - Tlaková ztráta: 0 Pa
13022911 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0434 | 0434 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 8
13023040 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0435 | 0435 | yes | 26.9875 | 20.6375 | WS_"ŠEDÁ" studená vnitřní 2
13024742 | 4.NP_SO-102 | ø32 mm-ø32 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0437 | 0437 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 8
13024809 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0438 | 0438 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13024908 | 4.NP_SO-102 | ø32 mm-ø32 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0439 | 0439 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 6
13024928 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0440 | 0440 | yes | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13024981 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0441 | 0441 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13025087 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0442 | 0442 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13025188 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0444 | 0444 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13025374 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0446 | 0446 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13025384 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0447 | 0447 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13025471 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0448 | 0448 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13025479 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0449 | 0449 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13025503 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0450 | 0450 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13025528 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0452 | 0452 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13025671 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 1250 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0455 | 0455 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13025703 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 1250 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0457 | 0457 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13025946 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0458 | 0458 | yes | 17.4625 | 11.1125 | WS_"ŠEDÁ" studená vnitřní 2
13026167 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0459 | 0459 | no | 17.4625 | 11.1125 | WS_"ŠEDÁ" studená vnitřní 2
13026546 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000103942 | 8.54833 | 45 | ø25-ø25 | 4.73446 | 28.575 | TT01.02.0462 | 0462 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13026554 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0463 | 0463 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13026556 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000103942 | 8.54833 | 45 | ø25-ø25 | 4.73446 | 28.575 | TT01.02.0464 | 0464 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13027004 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0466 | 0466 | no | 20.6375 | 14.2875 | WS_"ŠEDÁ" studená vnitřní 2
13027021 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0468 | 0468 | no | 17.4625 | 11.1125 | WS_"ŠEDÁ" studená vnitřní 2
13027356 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0469 | 0469 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13027391 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0470 | 0470 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13027477 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.02.0472 | 0472 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13027485 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0473 | 0473 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13027487 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.02.0474 | 0474 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13027510 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0475 | 0475 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13027949 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0479 | 0479 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13028367 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0481 | 0481 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13030376 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0495 | 0495 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13030394 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0497 | 0497 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13030398 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0498 | 0498 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13030402 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0499 | 0499 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13030406 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0500 | 0500 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13030410 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0501 | 0501 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13030418 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0503 | 0503 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13030432 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 1250 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0506 | 0506 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13030438 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 1250 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0508 | 0508 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13030450 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0509 | 0509 | no | 17.4625 | 11.1125 | WS_"ŠEDÁ" studená vnitřní 2
13030466 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000103942 | 8.54833 | 45 | ø25-ø25 | 4.73446 | 28.575 | TT01.02.0512 | 0512 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13030468 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0513 | 0513 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13030470 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000103942 | 8.54833 | 45 | ø25-ø25 | 4.73446 | 28.575 | TT01.02.0514 | 0514 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13030490 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0516 | 0516 | no | 20.6375 | 14.2875 | WS_"ŠEDÁ" studená vnitřní 2
13030498 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0517 | 0517 | no | 20.6375 | 14.2875 | WS_"ŠEDÁ" studená vnitřní 2
13030550 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0518 | 0518 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13030558 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0519 | 0519 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13030568 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.02.0521 | 0521 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13030570 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0522 | 0522 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13030572 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.02.0523 | 0523 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13030574 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0524 | 0524 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13030783 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0539 | 0539 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13030801 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0541 | 0541 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13030805 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0542 | 0542 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13030809 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0543 | 0543 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13030813 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0544 | 0544 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13030817 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0545 | 0545 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13030825 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0547 | 0547 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13030839 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 1250 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0550 | 0550 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13030845 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 1250 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0552 | 0552 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13030857 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0553 | 0553 | no | 17.4625 | 11.1125 | WS_"ŠEDÁ" studená vnitřní 2
13030873 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000103942 | 8.54833 | 45 | ø25-ø25 | 4.73446 | 28.575 | TT01.02.0556 | 0556 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13030875 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0557 | 0557 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13030877 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000103942 | 8.54833 | 45 | ø25-ø25 | 4.73446 | 28.575 | TT01.02.0558 | 0558 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13030897 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0560 | 0560 | yes | 20.6375 | 14.2875 | WS_"ŠEDÁ" studená vnitřní 2
13030905 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0561 | 0561 | no | 17.4625 | 11.1125 | WS_"ŠEDÁ" studená vnitřní 2
13030941 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0562 | 0562 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13030949 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0563 | 0563 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13030957 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0564 | 0564 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13030965 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0565 | 0565 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13030975 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.02.0567 | 0567 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13030977 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0568 | 0568 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13030979 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.02.0569 | 0569 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13030981 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0570 | 0570 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13030989 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0572 | 0572 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13030997 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0573 | 0573 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13031192 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0585 | 0585 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13031210 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0587 | 0587 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13031214 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0588 | 0588 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13031218 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0589 | 0589 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13031222 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0590 | 0590 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13031226 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0591 | 0591 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13031234 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0593 | 0593 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13031248 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 1250 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0596 | 0596 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13031254 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 1250 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0598 | 0598 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13031266 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0599 | 0599 | no | 17.4625 | 11.1125 | WS_"ŠEDÁ" studená vnitřní 2
13031282 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000103942 | 8.54833 | 45 | ø25-ø25 | 4.73446 | 28.575 | TT01.02.0602 | 0602 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13031284 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0603 | 0603 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13031286 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000103942 | 8.54833 | 45 | ø25-ø25 | 4.73446 | 28.575 | TT01.02.0604 | 0604 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13031314 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0605 | 0605 | no | 17.4625 | 11.1125 | WS_"ŠEDÁ" studená vnitřní 2
13032173 | 4.NP_SO-102 | ø32 mm-ø32 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0627 | 0627 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 3 | Mechanické – tok - Tlaková ztráta: 0 Pa
13032611 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0629 | 0629 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13032721 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0631 | 0631 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13032918 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0636 | 0636 | yes | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13032992 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0638 | 0638 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13033760 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0646 | 0646 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13033823 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0647 | 0647 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13033861 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3284.9 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0650 | 0650 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13034112 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3284.9 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0651 | 0651 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13034263 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0658 | 0658 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13034299 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0660 | 0660 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13034337 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3350 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0661 | 0661 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13034395 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3350 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0662 | 0662 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13034433 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3284.97 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0664 | 0664 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13034720 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3284.97 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0665 | 0665 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13034777 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0670 | 0670 | yes | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13034821 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0672 | 0672 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13035622 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0677 | 0677 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13035624 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0678 | 0678 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13035682 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0680 | 0680 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13035684 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0681 | 0681 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13035971 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 2649.95 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0683 | 0683 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 8
13036027 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 2649.8 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0685 | 0685 | yes | 33.3375 | 26.9875 | WS_Studená vnitřní 6
13036056 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0687 | 0687 | yes | 26.9875 | 20.6375 | WS_"ŠEDÁ" studená vnitřní 2
13037318 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0699 | 0699 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 3 | Mechanické – tok - Tlaková ztráta: 0 Pa
13037320 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 3 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0700 | 0700 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 3 | Mechanické – tok - Tlaková ztráta: 0 Pa
13046544 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0704 | 0704 | yes | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13047055 | -1.PP_SO-102 | ø20 mm-ø20 mm | -1.PP_SO-102 | 3100 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0705 | 0705 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13048114 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3100 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0710 | 0710 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13048162 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 3100 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 4 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0711 | 0711 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 4
13048247 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3100 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0714 | 0714 | yes | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13048379 | -1.PP_SO-102 | ø20 mm-ø20 mm | -1.PP_SO-102 | 3100 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0716 | 0716 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13048381 | -1.PP_SO-102 | ø20 mm-ø20 mm | -1.PP_SO-102 | 3100 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0717 | 0717 | yes | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13071848 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0753 | 0753 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13071850 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0754 | 0754 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13071921 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0756 | 0756 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13071923 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0757 | 0757 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13074243 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.0759 | 0759 | yes | 39.4375 | 33.0875 | WS_Teplá vnitřní 83
13074403 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.0762 | 0762 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
13074604 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3100 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0763 | 0763 | yes | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13074650 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 3100 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0765 | 0765 | yes | 26.9875 | 20.6375 | WS_Teplá vnitřní 83
13074775 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 3100 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0767 | 0767 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9
13074809 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 3100 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0769 | 0769 | yes | 26.9875 | 20.6375 | WS_Studená vnitřní 134
13076135 | -1.PP_SO-102 | ø20 mm-ø20 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0771 | 0771 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13078604 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0773 | 0773 | yes | 26.9875 | 20.6375 | WS_Cirkulace vnitřní 9
13095098 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 3286.87 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0787 | 0787 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S19
13095242 | 3.NP_SO-102 | ø78 mm-ø78 mm | 3.NP_SO-102 | 3366.44 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0788 | 0788 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S19
13095246 | 3.NP_SO-102 | ø78 mm-ø78 mm | 3.NP_SO-102 | 3370.41 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0789 | 0789 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S19
13095459 | 4.NP_SO-102 | ø78 mm-ø78 mm | 4.NP_SO-102 | 3368.51 | Fáze 2 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 11 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0790 | 0790 | yes | 46.9375 | 40.5875 | SW_Odvětrání kanalizace 11 | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S19
13095765 | 4.NP_SO-102 | ø78 mm-ø78 mm | 4.NP_SO-102 | 3353.55 | Fáze 2 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 11 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0792 | 0792 | yes | 46.9375 | 40.5875 | SW_Odvětrání kanalizace 11 | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S19
13096233 | 4.NP_SO-102 | ø78 mm-ø78 mm | 4.NP_SO-102 | 3416.35 | Fáze 2 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 10 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0793 | 0793 | yes | 46.9375 | 40.5875 | SW_Odvětrání kanalizace 10 | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S18
13096422 | 4.NP_SO-102 | ø78 mm-ø78 mm | 4.NP_SO-102 | 3397.47 | Fáze 2 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 10 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0795 | 0795 | yes | 46.9375 | 40.5875 | SW_Odvětrání kanalizace 10 | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S18
13098740 | 3.NP_SO-102 | ø78 mm-ø78 mm | 3.NP_SO-102 | 3323.04 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0796 | 0796 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S16
13098744 | 3.NP_SO-102 | ø78 mm-ø78 mm | 3.NP_SO-102 | 3364.19 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0797 | 0797 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S16
13099003 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 2935.74 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0798 | 0798 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S16
13099007 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 2976.89 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0799 | 0799 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S16
