Properties of the parts of a building model (IFC4), part 20 of 60

# IfcDistributionPort (11856)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_13324308_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324386_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324312_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324320_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324312_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324341_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324322_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324337_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324322_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324341_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324331_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324333_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324331_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324337_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324377_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324385_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324377_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324399_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324385_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324386_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324389_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324399_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324389_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324485_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324422_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324485_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324422_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324487_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324475_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324477_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324475_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324487_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324796_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13325001_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324796_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13325003_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324825_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13325001_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324825_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324952_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324940_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324942_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324940_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324952_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324975_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13325004_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324979_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324998_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324998_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13325003_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13325003_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13325004_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13325302_1 | SINK | PIPE | SEWAGE
OutPort_13325301_1 | SOURCE | PIPE | SEWAGE
Port_13325302_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13325307_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 16
OutPort_13325309_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 16
InPort_13325308_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_13325308_2 | SINK | PIPE | DOMESTICCOLDWATER
InPort_13325309_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 16
OutPort_13325308_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 16
Port_13325900_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13325916_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13325900_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13370521_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13325992_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13835653_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13325992_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13370576_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13326042_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13835692_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13326042_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13370627_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13335102_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13356995_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335173_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13647998_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335173_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13648014_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335181_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13648010_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335181_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13648014_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335301_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335332_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335303_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335332_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335567_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335753_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335567_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645650_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335584_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335594_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335584_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335753_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335586_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335587_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335586_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335594_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335712_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645648_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335712_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13357714_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335758_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645648_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335758_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645650_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13336054_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13833035_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13336054_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13336136_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13833054_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13336136_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13347265_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13347267_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13347265_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13347271_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13347269_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13347271_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13347269_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13347273_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13533801_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13347273_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13347279_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13347277_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13347279_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13347277_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13347287_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402491_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13347289_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402293_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13347289_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474044_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13347295_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13402507_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13347297_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13486208_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13347297_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473841_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13347305_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473966_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13347305_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13347475_1 | SINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
OutPort_13359453_1 | SOURCE | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
InPort_13347479_1 | SINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
OutPort_13359551_2 | SOURCE | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
InPort_13347483_1 | SINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
OutPort_13359809_2 | SOURCE | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
InPort_13347487_1 | SINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
OutPort_13359967_0 | SOURCE | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
InPort_13348071_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
OutPort_13915802_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
InPort_13348072_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
OutPort_13358353_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
InPort_13348073_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
OutPort_13358482_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
InPort_13348074_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
OutPort_13358756_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13348471_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13348479_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13348471_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764281_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13348479_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13763913_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13348578_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13763799_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13348578_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13348603_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13348603_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13348623_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13348623_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13348637_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13348631_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13348637_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13348631_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13348647_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13348639_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13348647_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13348639_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356212_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13349032_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13651742_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13349032_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13651744_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13349034_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13651742_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13349034_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13349047_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13349067_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358513_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13349067_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13349179_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13349179_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358770_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356024_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14037156_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13356032_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14037132_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13356053_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13532202_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13356053_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13361196_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13356061_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13361317_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13356212_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356243_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356233_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356242_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356233_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356708_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356238_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358514_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356238_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358426_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356242_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356243_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356242_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358368_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356522_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356897_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356522_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356708_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356678_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356913_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356895_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356897_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356895_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356914_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356905_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356913_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356905_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356930_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356913_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356914_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356917_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13915802_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356917_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356930_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13356995_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13647837_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13356996_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13647837_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13356996_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13648010_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13357395_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13573401_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13357395_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13357396_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13357395_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13357403_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13357396_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402068_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13357403_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402183_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13357427_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13401999_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13357427_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473988_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13357427_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13357435_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13357435_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13402163_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13357712_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13357714_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13357712_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13486144_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13358353_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358433_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358368_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358425_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358425_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358426_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358425_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358433_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358482_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358500_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358492_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358500_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358492_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358528_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358502_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358524_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358502_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358528_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358511_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358521_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358511_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358524_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358513_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358514_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358513_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358521_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358610_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13358622_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13358610_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13358632_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13358624_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13358632_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13358624_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13358640_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13358634_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13358640_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13358634_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13358650_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13358642_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13358650_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13358642_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13358756_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13359146_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358757_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13359148_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358757_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13359150_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358770_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13359014_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358900_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_14022400_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13358900_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359014_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13359151_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13359073_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_14022355_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13359073_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_14022400_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13359143_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13359150_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13359143_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_14022355_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13359146_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13359148_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13359150_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13359151_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13359250_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359426_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359250_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359453_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359426_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359427_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359426_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359542_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359427_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808526_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359474_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359549_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359474_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359551_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359541_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359542_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359541_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359800_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359541_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359549_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359581_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359807_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359581_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359809_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359799_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359800_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359799_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359807_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359953_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359969_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359953_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359972_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359967_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359969_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13360366_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808268_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13360366_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808271_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13360448_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808268_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13360448_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13361092_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
InPort_13360671_1 | SINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
OutPort_13361095_2 | SOURCE | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13361079_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13361092_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13361079_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13361095_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13361184_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13361196_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13361184_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13361394_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13361214_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13361431_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13361309_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13361317_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13361309_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13361450_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13361336_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13361485_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13361394_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13361412_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13361412_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13535104_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13361423_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13535104_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13361423_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13645316_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13361423_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13361431_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13361450_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13361466_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13361466_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13535120_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13361477_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13535120_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13361477_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13361478_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13361477_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13361485_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13361478_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13544832_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13361598_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13645315_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13361598_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13544863_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13362690_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13362698_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13362698_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13362692_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13362692_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_13362702_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13362977_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 20
OutPort_13402674_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 20
InPort_13363554_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 20
OutPort_13362977_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 20
InPort_13363037_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13363545_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13402674_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 20
OutPort_13363259_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 20
InPort_13363259_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 20
OutPort_13402627_1 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 20
InPort_13363342_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 20
OutPort_13363554_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 20
InPort_13363566_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13363342_1 | SOURCE | PIPE | VENT | SW_Splašky vnitřní gravitační 35 (1)
InPort_13363545_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13363558_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13363558_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13363559_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13363558_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13363566_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13370207_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13545678_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13370207_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13370349_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13621412_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13370349_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432886_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13370507_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13370521_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13370507_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13370533_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13370523_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13370533_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13370523_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13370562_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13370576_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13370562_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13370586_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13370578_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13370586_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13370578_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13370615_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13370627_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13370615_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13370639_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13370629_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13370639_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13370629_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
OutPort_13395911_1 | SOURCE | PIPE | SEWAGE
InPort_13399581_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 1
OutPort_13395970_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 1
InPort_13399271_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 1
OutPort_13399296_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 1
InPort_13399426_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 1
OutPort_13399271_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 1
InPort_13399291_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 1
OutPort_13399581_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 1
InPort_13399296_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 1
OutPort_13399291_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 1
InPort_13399350_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 1
OutPort_13399426_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 1
OutPort_13399350_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 1
InPort_13401570_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 21
InPort_13401579_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 21
OutPort_13401570_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 21
InPort_13401571_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 19
InPort_13401577_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 19
OutPort_13401571_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 19
Port_13401572_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13401573_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13401572_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13401575_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 21
OutPort_13401579_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 21
InPort_13401575_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 19
OutPort_13401577_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 19
InPort_13401597_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 17
InPort_13401606_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 17
OutPort_13401597_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 17
InPort_13401598_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 18
InPort_13401604_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 18
OutPort_13401598_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 18
Port_13401599_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13401600_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13401599_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13401602_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 17
OutPort_13401606_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 17
InPort_13401602_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 18
OutPort_13401604_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 18
Port_13401657_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13401665_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13401718_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 33
InPort_13401727_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 33
OutPort_13401718_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 33
InPort_13401719_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 89
InPort_13401725_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 89
OutPort_13401719_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 89
Port_13401720_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13401721_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13401720_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13401723_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 33
OutPort_13401727_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 33
InPort_13401723_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 89
OutPort_13401725_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 89
InPort_13401880_1 | SINK | PIPE | SEWAGE
OutPort_13401871_1 | SOURCE | PIPE | SEWAGE
InPort_13401872_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 36
InPort_13401874_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 36
OutPort_13401872_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 36
InPort_13401873_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 91
InPort_13401876_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 91
OutPort_13401873_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 91
InPort_13401878_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 36
OutPort_13401874_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 36
InPort_13401878_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 91
OutPort_13401876_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 91
Port_13401880_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_13401934_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13401936_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13401981_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13402110_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13401981_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13401996_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13402006_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13401996_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13402008_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13401998_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13401999_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13401998_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13402006_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13402008_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13402112_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13402053_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402126_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402053_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402066_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402076_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402066_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402078_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402068_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402069_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402068_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402076_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402078_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402128_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402110_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13402112_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13402126_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402128_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402161_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13402163_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13402181_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402183_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402205_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402207_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402291_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402293_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402291_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13483691_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402489_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402491_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402505_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13402507_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13402540_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13402542_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
InPort_13403161_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13403175_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13403209_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13403161_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13403288_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13403209_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13403271_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13427238_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13427242_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13403271_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13427238_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13403288_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13403767_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 14
OutPort_13403769_1 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 14
InPort_13403836_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 14
OutPort_13403767_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 14
InPort_14033720_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 14
OutPort_13403836_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 14
InPort_13403976_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 14
OutPort_14033867_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 14
InPort_13404007_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13403976_1 | SOURCE | PIPE | VENT | SW_Splašky vnitřní gravitační 35 (1)
Port_13404201_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13404250_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13404201_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13404267_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13404222_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808522_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13404222_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13404250_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
InPort_13404267_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
OutPort_13404201_1 | SOURCE | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13414023_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13483695_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13414023_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13624579_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13418990_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14028059_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13418990_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13419357_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027448_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13419357_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027465_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13426696_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13426717_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13672746_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13426696_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13426717_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13426715_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689997_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13427018_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13428667_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13427242_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13428709_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13428667_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13428690_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13428709_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13428747_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13428690_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13428913_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13428859_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13428903_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13428913_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13428991_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13428903_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13429070_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13689240_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13429070_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13438554_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13438665_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13429118_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13429118_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13429330_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13429304_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13429314_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13429326_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13429304_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13439205_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13429326_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13429330_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13439196_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13431874_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13673131_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13673135_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13431874_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13431975_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13690097_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13673131_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13431975_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13432491_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13673743_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13432491_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13675041_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13432491_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675043_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13675041_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13432492_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13432492_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13434331_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13432652_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432691_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432671_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13616591_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432671_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13614102_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432691_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432831_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432693_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13616591_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432693_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432713_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432707_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432713_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432707_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432732_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432717_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432732_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432717_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432742_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432736_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432742_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432736_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432891_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432831_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432833_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432833_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13616403_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432858_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432886_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432858_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432891_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13434092_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13646635_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13434331_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13434320_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13434320_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13434341_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13434341_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13434335_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13434335_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13434366_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13434345_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13434362_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13434366_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13434345_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13434462_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
