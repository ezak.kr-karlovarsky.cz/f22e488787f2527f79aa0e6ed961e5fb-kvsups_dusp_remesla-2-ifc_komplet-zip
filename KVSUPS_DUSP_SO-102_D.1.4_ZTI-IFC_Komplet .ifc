Properties of the parts of a building model (IFC4), part 55 of 60

# IfcPipeSegment: Typy trubek:PP_Skolan SAFE dB (426)
Name (Typy trubek:PP_Skolan SAFE dB:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Relativní drsnost | CCI Funkční systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) | Spodní výška (mm) | Střední výška (mm) | Fáze vytvoření | Drsnost (mm) | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Typ systému | Úsek potrubí | Výkaz/typ | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Instalační jednotky | Sklon
13399271 | -1.PP_SO-102 | 302.436 | 0.0143117 | 0.128267 | ø135 mm | 0.0000803859 | G | -1.PP_SO-102 | 1009.59 | 748.002 | 961.856 | 700.272 | 961.856 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Deště vnitřní gravitační 1 | -3295.98 | PP–SKEM | 135 | 2 | SW_Deště vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1320 | 1320 | yes | SW_Deště vnitřní gravitační 1 | 0 | 100
13399291 | -1.PP_SO-102 | 564.758 | 0.0143117 | 0.239522 | ø135 mm | 0 | G | -1.PP_SO-102 | 1579.96 | 1015.2 | 1579.96 | 1015.2 | 1579.96 | Fáze 1 | 0 | Sanitární |  | SW_Deště vnitřní gravitační 1 | -2984.8 |  | 135 | 2 | SW_Deště vnitřní gravitační |  |  | ø135 | 135 | TR08.01.1321 | 1321 | yes | SW_Deště vnitřní gravitační 1 | 0
13399350 | -1.PP_SO-102 | 229.194 | 0.0143117 | 0.0972045 | ø135 mm | 0.0000803859 | G | -1.PP_SO-102 | 793.407 | 723.619 | 725.91 | 656.122 | 725.91 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Deště vnitřní gravitační 1 | -3338.58 | PP–SKEM | 135 | 2 | SW_Deště vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1322 | 1322 | yes | SW_Deště vnitřní gravitační 1 | 0 | 1
13403161 | 2.NP_SO-102 | 1033.04 | 0.00950189 | 0.356994 | ø110 mm | 0.000100604 | G | 2.NP_SO-102 | 1593.1 | 1517.45 | 1538.11 | 1462.46 | 1538.11 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 5467.76 | PP–SKEM | 110 | 280 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1341 | 1341 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13403271 | 1.NP_SO-102 | 608.969 | 0.00950189 | 0.210444 | ø110 mm | 0.000100604 | G | 1.NP_SO-102 | 3369.34 | 3314.34 | 3314.34 | 3259.34 | 3314.34 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3264.64 | PP–SKEM | 110 | 280 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1342 | 1342 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 0
13403288 | 2.NP_SO-102 | 2077.25 | 0.00950189 | 0.717845 | ø110 mm | 0.000100604 | G | 2.NP_SO-102 | 1454.53 | -622.721 | 1454.53 | -622.721 | 1454.53 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3377.28 | PP–SKEM | 110 | 280 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1343 | 1343 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
13403767 | 3.NP_SO-102 | 1077.2 | 0.00950189 | 0.372253 | ø110 mm | 0.000100604 | G | 3.NP_SO-102 | 2888.36 | 2888.36 | 1811.16 | 1811.16 | 1811.16 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 14 | 9811.16 | PP–SKEM | 110 | 15 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1344 | 1344 | yes | SW_Odvětrání kanalizace 14 | Identifikační data - Komentáře: S5
13403976 | 3.NP_SO-102 | 304.993 | 0.00950189 | 0.105398 | ø110 mm | 0.000100604 | G | 3.NP_SO-102 | 3319.74 | 3065.19 | 3280.85 | 3026.3 | 3280.85 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 14 | 11030 | PP–SKEM | 110 | 15 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1345 | 1345 | yes | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 14 |  | 100
13428667 | 1.NP_SO-102 | 3438.12 | 0.00950189 | 1.18813 | ø110 mm | 0.000100604 | G | 1.NP_SO-102 | 3251.4 | -186.722 | 3251.4 | -186.722 | 3251.4 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -186.722 | PP–SKEM | 110 | 280 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1352 | 1352 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S5
13428690 | -1.PP_SO-102 | 185.571 | 0.00950189 | 0.0641287 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 3807.67 | 3637.56 | 3768.77 | 3598.66 | 3768.77 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -397.587 | PP–SKEM | 110 | 280 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1353 | 1353 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13428859 | 3.NP_SO-102 | 7067.9 | 0.00950189 | 2.44249 | ø110 mm | 0.000100604 | G | 3.NP_SO-102 | 2514.04 | -4553.86 | 2514.04 | -4553.86 | 2514.04 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3446.14 | PP–SKEM | 110 | 6 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1354 | 1354 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S6
13428903 | 1.NP_SO-102 | 1820.26 | 0.00950189 | 0.629036 | ø110 mm | 0.000100604 | G | 1.NP_SO-102 | 3440.53 | 2114.52 | 3401.64 | 2075.63 | 3401.64 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2079.38 | PP–SKEM | 110 | 6 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1355 | 1355 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13429304 | -1.PP_SO-102 | 345.742 | 0.00950189 | 0.11948 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 3047.15 | 2763.78 | 3008.26 | 2724.89 | 3008.26 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1271.36 | PP–SKEM | 110 | 280 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1358 | 1358 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13431975 | -1.PP_SO-102 | 756.091 | 0.00950189 | 0.261286 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2941.42 | 2871.31 | 2886.43 | 2816.32 | 2886.43 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1178.38 | PP–SKEM | 110 | 234 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1360 | 1360 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2 | Identifikační data - Komentáře: S19
13432492 | -1.PP_SO-102 | 914.694 | 0.00477764 | 0.22414 | ø78 mm | 0.000144928 | G | -1.PP_SO-102 | 3002.9 | 2963.91 | 2945.62 | 2906.63 | 2945.62 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1088.87 | PP–SKEM | 78 | 242 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1361 | 1361 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2 | Identifikační data - Komentáře: S16
13434320 | -1.PP_SO-102 | 182.613 | 0.00477764 | 0.0447482 | ø78 mm | 0.000144928 | G | -1.PP_SO-102 | 3007.33 | 2968.33 | 2964.69 | 2925.69 | 2964.69 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1069.81 | PP–SKEM | 78 | 242 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1369 | 1369 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1.99757 | Identifikační data - Komentáře: S16
13434335 | -1.PP_SO-102 | 73.3627 | 0.00477764 | 0.0179771 | ø78 mm | 0.000144928 | G | -1.PP_SO-102 | 3009.57 | 2970.58 | 2969.11 | 2930.12 | 2969.11 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1065.38 | PP–SKEM | 78 | 242 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1370 | 1370 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2 | Identifikační data - Komentáře: S16
13434345 | -1.PP_SO-102 | 167.448 | 0.00477764 | 0.0410321 | ø78 mm | 0.000144928 | G | -1.PP_SO-102 | 3130.3 | 2984.32 | 3102.72 | 2956.74 | 3102.72 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1040.08 | PP–SKEM | 78 | 242 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1371 | 1371 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100 | Identifikační data - Komentáře: S16
13434462 | -1.PP_SO-102 | 321.847 | 0.00950189 | 0.111222 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 3225.69 | 2959.22 | 3186.8 | 2920.33 | 2959.22 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1075.93 | PP–SKEM | 110 | 592 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1372 | 1372 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100 | Identifikační data - Komentáře: S18
13436845 | -1.PP_SO-102 | 245.045 | 0.00950189 | 0.0846816 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2969.67 | 2914.67 | 2912.22 | 2857.22 | 2912.22 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1137.48 | PP–SKEM | 110 | 592 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1376 | 1376 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1 | Identifikační data - Komentáře: S18
13436855 | -1.PP_SO-102 | 1436.99 | 0.00950189 | 0.496589 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2984.56 | 2929.56 | 2915.19 | 2860.19 | 2915.19 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1134.51 | PP–SKEM | 110 | 592 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1377 | 1377 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1 | Identifikační data - Komentáře: S18
13436875 | -1.PP_SO-102 | 686.965 | 0.00950189 | 0.237398 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2995.78 | 2933.92 | 2940.79 | 2878.92 | 2940.79 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1115.78 | PP–SKEM | 110 | 592 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1378 | 1378 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1 | Identifikační data - Komentáře: S18
13437680 | -1.PP_SO-102 | 230.478 | 0.0201032 | 0.115851 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | 3249.49 | 3029.95 | 3192.92 | 2973.38 | 3192.92 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1022.87 | PP–SKEM | 160 | 248 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.1379 | 1379 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100.002 | Identifikační data - Komentáře: S20
13438298 | -1.PP_SO-102 | 612.899 | 0.00950189 | 0.211803 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 3173.54 | 2701.27 | 3134.65 | 2662.38 | 3134.65 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1333.88 | PP–SKEM | 110 | 264 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1381 | 1381 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13439080 | -1.PP_SO-102 | 93.9826 | 0.00950189 | 0.0324781 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2803.34 | 2697.99 | 2764.45 | 2659.1 | 2697.99 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1337.15 | PP–SKEM | 110 | 6 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1382 | 1382 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 99.9999
13440265 | -1.PP_SO-102 | 264.828 | 0.00950189 | 0.091518 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2887.45 | 2829.81 | 2832.46 | 2774.81 | 2832.46 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1219.89 | PP–SKEM | 110 | 518 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1389 | 1389 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1
13444201 | 4.NP_SO-102 | 16522.6 | 0.0201032 | 8.30518 | ø160 mm | 0.0000669344 | G | STŘECHA_SO-102 | 23.0988 | 23.0987 | -16499.5 | -16499.5 | -16499.5 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -649.541 | PP–SKEM | 160 | 248 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.1390 | 1390 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S20
13456536 | -1.PP_SO-102 | 341.592 | 0.00950189 | 0.118046 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 3193.49 | 2913.06 | 3154.6 | 2874.17 | 3154.6 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1122.09 | PP–SKEM | 110 | 534 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1391 | 1391 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13456629 | -1.PP_SO-102 | 554.126 | 0.00950189 | 0.191492 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2949.63 | 2883.56 | 2894.64 | 2828.57 | 2894.64 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1166.13 | PP–SKEM | 110 | 534 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1392 | 1392 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13461353 | 3.NP_SO-102 | 3641.02 | 0.00477764 | 0.892211 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 3401.4 | 3362.4 | 3362.4 | 3323.4 | 3362.4 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 18 | 11327.9 | PP–SKEM | 78 | 1 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1393 | 1393 | yes | SW_Odvětrání kanalizace 18 |  | 0
13461355 | 3.NP_SO-102 | 2021.23 | 0.00477764 | 0.49529 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 3315.47 | 1294.23 | 3315.46 | 1294.23 | 3315.46 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 18 | 9294.23 | PP–SKEM | 78 | 1 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1394 | 1394 | yes | SW_Odvětrání kanalizace 18 |  | 532664 | Identifikační data - Komentáře: S12
13461357 | 3.NP_SO-102 | 84.238 | 0.00477764 | 0.020642 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 3376.23 | 3289.09 | 3348.65 | 3261.51 | 3348.65 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 18 | 11264.7 | PP–SKEM | 78 | 1 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1395 | 1395 | yes | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 18 |  | 99.9962
13461506 | 3.NP_SO-102 | 82.062 | 0.00477764 | 0.0201088 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 3121.81 | 3039.75 | 3121.81 | 3039.75 | 3121.81 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11039.8 | PP–SKEM | 78 | 505 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1396 | 1396 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
13461523 | 4.NP_SO-102 | 2662.34 | 0.00477764 | 0.652391 | ø78 mm | 0.000144928 | G | 4.NP_SO-102 | 1980.13 | -682.214 | 1980.13 | -682.214 | 1980.13 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11317.8 | PP–SKEM | 78 | 3 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1397 | 1397 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
13461546 | 3.NP_SO-102 | 5872.71 | 0.00477764 | 1.43907 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 1253.65 | 1253.65 | -4619.07 | -4619.07 | -4619.07 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3380.93 | PP–SKEM | 78 | 220 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1398 | 1398 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S12
13461884 | -1.PP_SO-102 | 124.188 | 0.00950189 | 0.0429162 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2962.01 | 2923.12 | 2835.31 | 2796.42 | 2835.31 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1199.84 | PP–SKEM | 110 | 726 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1399 | 1399 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13461903 | -1.PP_SO-102 | 11.2484 | 0.00950189 | 0.00388716 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2871.87 | 2816.66 | 2816.89 | 2761.67 | 2816.89 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1233.03 | PP–SKEM | 110 | 726 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1400 | 1400 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13461914 | -1.PP_SO-102 | 248.524 | 0.00950189 | 0.0858836 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2870.61 | 2815.62 | 2810.65 | 2755.66 | 2810.65 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1239.04 | PP–SKEM | 110 | 726 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1401 | 1401 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13462308 | 3.NP_SO-102 | 1953.32 | 0.00477764 | 0.47865 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 3369.95 | 3291.9 | 3330.96 | 3252.91 | 3330.96 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11257.4 | PP–SKEM | 78 | 305 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1402 | 1402 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13462585 | 2.NP_SO-102 | 258.595 | 0.00477764 | 0.0633673 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 2898.29 | 2687.86 | 2870.71 | 2660.28 | 2870.71 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 6663.46 | PP–SKEM | 78 | 550 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1403 | 1403 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 99.9999
13462668 | 2.NP_SO-102 | 3100.58 | 0.00477764 | 0.75978 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 2520.58 | -580 | 2520.58 | -580 | 2520.58 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3420 | PP–SKEM | 78 | 312 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1404 | 1404 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S13
13462678 | 2.NP_SO-102 | 568.598 | 0.00477764 | 0.139332 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3285.16 | 2716.56 | 3285.16 | 2716.56 | 3285.16 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 6716.56 | PP–SKEM | 78 | 305 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1405 | 1405 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S13
13463581 | 3.NP_SO-102 | 1608.7 | 0.00950189 | 0.555926 | ø110 mm | 0.000100604 | G | 3.NP_SO-102 | 3401.4 | 3314.24 | 3346.41 | 3259.25 | 3346.41 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11264.5 | PP–SKEM | 110 | 317 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1406 | 1406 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2.00029
13463595 | 3.NP_SO-102 | 427.717 | 0.00950189 | 0.147808 | ø110 mm | 0.000100604 | G | 3.NP_SO-102 | 3837.05 | 3837.05 | 3409.34 | 3409.34 | 3409.34 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11409.3 | PP–SKEM | 110 | 317 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1407 | 1407 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
13463723 | -1.PP_SO-102 | 1095.9 | 0.00950189 | 0.378714 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 3837.05 | 2741.16 | 3837.05 | 2741.16 | 3837.05 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1258.84 | PP–SKEM | 110 | 430 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1408 | 1408 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
13463734 | 1.NP_SO-102 | 1348.06 | 0.00950189 | 0.465857 | ø110 mm | 0.000100604 | G | 1.NP_SO-102 | 3184.26 | 3102.31 | 3129.27 | 3047.32 | 3129.27 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3052.62 | PP–SKEM | 110 | 323 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1409 | 1409 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2.00035
13463736 | 2.NP_SO-102 | 644.855 | 0.00950189 | 0.222846 | ø110 mm | 0.000100604 | G | 2.NP_SO-102 | -162.945 | -162.946 | -807.801 | -807.802 | -807.801 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3192.2 | PP–SKEM | 110 | 323 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1410 | 1410 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
13463740 | 1.NP_SO-102 | 1715.67 | 0.00950189 | 0.592892 | ø110 mm | 0.000100604 | G | 1.NP_SO-102 | 3156.26 | 3066.96 | 3101.27 | 3011.97 | 3066.96 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3017.27 | PP–SKEM | 110 | 323 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1411 | 1411 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1.99999
13463747 | 2.NP_SO-102 | 1609.68 | 0.00950189 | 0.556266 | ø110 mm | 0.000100604 | G | 2.NP_SO-102 | 3411.39 | 3324.21 | 3356.4 | 3269.22 | 3356.4 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7274.52 | PP–SKEM | 110 | 320 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1412 | 1412 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13463749 | 3.NP_SO-102 | 417.732 | 0.00950189 | 0.144358 | ø110 mm | 0.000100604 | G | 3.NP_SO-102 | -162.946 | -162.946 | -580.678 | -580.678 | -580.678 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7419.32 | PP–SKEM | 110 | 320 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1413 | 1413 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
13463753 | 2.NP_SO-102 | 1132.78 | 0.00950189 | 0.391462 | ø110 mm | 0.000100604 | G | 2.NP_SO-102 | 3378.15 | 3300.56 | 3323.17 | 3245.57 | 3300.56 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7250.87 | PP–SKEM | 110 | 320 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1414 | 1414 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1.9963
13487358 | 2.NP_SO-102 | 3820.56 | 0.00477764 | 0.936207 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3099.42 | 3099.42 | -721.144 | -721.144 | -721.144 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3278.86 | PP–SKEM | 78 | 676 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1486 | 1486 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: Umyvadlo
13487369 | 2.NP_SO-102 | 2130.45 | 0.00264168 | 0.388195 | ø58 mm | 0.0002 | G | 2.NP_SO-102 | 1487.19 | 1487.19 | -643.259 | -643.259 | -643.259 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3356.74 | PP–SKEM | 58 | 398 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø58 | 50 | TR08.01.1487 | 1487 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: Konvektomat
13487384 | 2.NP_SO-102 | 2078.31 | 0.00264168 | 0.378694 | ø58 mm | 0.0002 | G | 2.NP_SO-102 | 1487.19 | 1487.19 | -591.121 | -591.121 | -591.121 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3408.88 | PP–SKEM | 58 | 361 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø58 | 50 | TR08.01.1488 | 1488 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: Vyhřívaný výdejní pult
13487395 | 2.NP_SO-102 | 2123.97 | 0.00264168 | 0.387013 | ø58 mm | 0.0002 | G | 2.NP_SO-102 | 1229.41 | 1229.41 | -894.558 | -894.559 | -894.558 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3105.44 | PP–SKEM | 58 | 628 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø58 | 50 | TR08.01.1489 | 1489 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: Změkčovač, myčka, dřez
13487452 | 2.NP_SO-102 | 3721.57 | 0.00477764 | 0.91195 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3091.62 | 3091.62 | -629.946 | -629.946 | -629.946 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3370.05 | PP–SKEM | 78 | 707 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1490 | 1490 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S1
13488238 | 3.NP_SO-102 | 3314.72 | 0.00477764 | 0.812253 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 3062.68 | -252.043 | 3062.68 | -252.043 | 3062.68 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7747.96 | PP–SKEM | 78 | 727 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1491 | 1491 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: Mobilní dřez
13489247 | 3.NP_SO-102 | 400.266 | 0.00477764 | 0.0980829 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 3406.47 | 3378.9 | 3095.87 | 3068.29 | 3095.87 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11071.5 | PP–SKEM | 78 | 727 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1492 | 1492 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13489273 | 4.NP_SO-102 | 1537.87 | 0.00477764 | 0.376847 | ø78 mm | 0.000144928 | G | 4.NP_SO-102 | 949.961 | 949.961 | -587.913 | -587.913 | -587.913 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11412.1 | PP–SKEM | 78 | 727 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1493 | 1493 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S4
13491158 | 1.NP_SO-102 | 278.909 | 0.00477764 | 0.0683451 | ø78 mm | 0.000144928 | G | 1.NP_SO-102 | 3092.55 | 2867.75 | 3064.97 | 2840.18 | 3064.97 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2843.36 | PP–SKEM | 78 | 717 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1494 | 1494 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13493925 | 1.NP_SO-102 | 257.107 | 0.00950189 | 0.0888498 | ø110 mm | 0.000100604 | G | 1.NP_SO-102 | 3374.97 | 3154.28 | 3336.08 | 3115.39 | 3336.08 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3119.14 | PP–SKEM | 110 | 672 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1495 | 1495 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13493941 | 1.NP_SO-102 | 2010.83 | 0.00950189 | 0.694891 | ø110 mm | 0.000100604 | G | 1.NP_SO-102 | 3190.85 | 3135.86 | 3095.65 | 3040.66 | 3095.65 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3045.96 | PP–SKEM | 110 | 672 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1496 | 1496 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13495539 | 1.NP_SO-102 | 181.834 | 0.00477764 | 0.0445574 | ø78 mm | 0.000144928 | G | 1.NP_SO-102 | 3178.67 | 3139.68 | 3136.04 | 3097.05 | 3136.04 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3101.55 | PP–SKEM | 78 | 707 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1497 | 1497 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13495683 | 1.NP_SO-102 | 244.479 | 0.00477764 | 0.0599081 | ø78 mm | 0.000144928 | G | 1.NP_SO-102 | 3174.25 | 3130.37 | 3135.26 | 3091.38 | 3135.26 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3095.88 | PP–SKEM | 78 | 707 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1498 | 1498 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13496680 | 1.NP_SO-102 | 69.7566 | 0.0143117 | 0.0295848 | ø135 mm | 0.0000803859 | G | 1.NP_SO-102 | 2757.99 | 2710.26 | 2660.94 | 2613.21 | 2660.94 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2616.96 | PP–SKEM | 135 | 379 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1499 | 1499 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13496693 | 1.NP_SO-102 | 3138.07 | 0.0143117 | 1.3309 | ø135 mm | 0.0000803859 | G | 1.NP_SO-102 | 2603.96 | 2536.48 | 2473.73 | 2406.24 | 2473.73 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2411.54 | PP–SKEM | 135 | 380 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1500 | 1500 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13496811 | 2.NP_SO-102 | 2088.32 | 0.00264168 | 0.380518 | ø58 mm | 0.0002 | G | 2.NP_SO-102 | 1487.19 | 1487.19 | -601.128 | -601.128 | -601.128 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3398.87 | PP–SKEM | 58 | 374 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø58 | 50 | TR08.01.1501 | 1501 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: Umyvadlo
13496977 | 1.NP_SO-102 | 244.965 | 0.00477764 | 0.0600271 | ø78 mm | 0.000144928 | G | 1.NP_SO-102 | 3372.97 | 3172.17 | 3345.39 | 3144.59 | 3345.39 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3147.78 | PP–SKEM | 78 | 657 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1502 | 1502 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13497917 | 1.NP_SO-102 | 418.976 | 0.00950189 | 0.144788 | ø110 mm | 0.000100604 | G | 1.NP_SO-102 | 3786.26 | 3786.25 | 3367.28 | 3367.28 | 3367.28 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3367.28 | PP–SKEM | 110 | 596 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1503 | 1503 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: Umyvadlo
13499771 | 1.NP_SO-102 | 322.161 | 0.00264168 | 0.0587017 | ø58 mm | 0.0002 | G | 1.NP_SO-102 | 3351.13 | 3102.82 | 3330.62 | 3082.31 | 3330.62 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3085.14 | PP–SKEM | 58 | 398 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø58 | 50 | TR08.01.1504 | 1504 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13500526 | -1.PP_SO-102 | 726.446 | 0.00950189 | 0.251042 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 4059.32 | 3332.88 | 4059.32 | 3332.88 | 4059.32 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 11 | -667.122 | PP–SKEM | 110 | 100 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1505 | 1505 | no | SW_Splašky vnitřní gravitační 11 | 0 | Identifikační data - Komentáře: ODVODNĚNÍ ŽLÁBKU
13503089 | -1.PP_SO-102 | 2928.31 | 0.00950189 | 1.01195 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -29.8216 | -29.8216 | -2958.13 | -2958.13 | -2958.13 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6958.13 | PP–SKEM | 110 | 115 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1511 | 1511 | yes | SW_Splašky vnitřní gravitační 3 | 0
13505173 | -1.PP_SO-102 | 394.452 | 0.00950189 | 0.136313 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -2964.65 | -3019.64 | -3027.52 | -3082.51 | -3027.52 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -7077.21 | PP–SKEM | 110 | 111 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1513 | 1513 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 2
13506046 | 4.NP_SO-102 | 3988.25 | 0.00477764 | 0.977297 | ø78 mm | 0.000144928 | G | STŘECHA_SO-102 | 1650 | 1650 | -2338.25 | -2338.25 | -2338.25 | Fáze 2 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 19 | 13511.8 | PP–SKEM | 78 | 4 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1514 | 1514 | yes | SW_Odvětrání kanalizace 19 | Identifikační data - Komentáře: S21
13506054 | 4.NP_SO-102 | 2482 | 0.00477764 | 0.608199 | ø78 mm | 0.000144928 | G | 4.NP_SO-102 | 1471.16 | -1010.83 | 1471.16 | -1010.83 | 1471.16 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 10989.2 | PP–SKEM | 78 | 402 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1515 | 1515 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S21
13506116 | 3.NP_SO-102 | 1946.11 | 0.00477764 | 0.476884 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 2981.23 | 2942.24 | 2903.33 | 2864.33 | 2903.33 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 10868.8 | PP–SKEM | 78 | 402 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1516 | 1516 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2 | Identifikační data - Komentáře: S21
13506140 | 3.NP_SO-102 | 7697.65 | 0.00477764 | 1.88627 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 2848.97 | 2848.97 | -4848.68 | -4848.68 | -4848.68 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3151.32 | PP–SKEM | 78 | 237 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1517 | 1517 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S18
13516215 | -1.PP_SO-102 | 1248.13 | 0.00950189 | 0.431324 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -2488.55 | -2543.54 | -2568.49 | -2623.48 | -2568.49 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6618.18 | PP–SKEM | 110 | 127 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1525 | 1525 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 2
13516229 | -1.PP_SO-102 | 9908.74 | 0.00950189 | 3.42422 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -1345.07 | -1598.19 | -1400.06 | -1653.18 | -1400.06 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -5647.88 | PP–SKEM | 110 | 127 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1526 | 1526 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 2
13516707 | -1.PP_SO-102 | 1221.29 | 0.00950189 | 0.422048 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -2463.08 | -2518.07 | -2542.49 | -2597.48 | -2542.49 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6592.18 | PP–SKEM | 110 | 127 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1528 | 1528 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 2
13517164 | -1.PP_SO-102 | 4530.76 | 0.00950189 | 1.56572 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 3324.94 | 3179.36 | 3269.95 | 3124.37 | 3269.95 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 11 | -870.334 | PP–SKEM | 110 | 100 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1532 | 1532 | no | SW_Splašky vnitřní gravitační 11 | 0 | 2
13517225 | -1.PP_SO-102 | 7284.3 | 0.00950189 | 2.51727 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2061.17 | 1860.52 | 2006.18 | 1805.53 | 2006.18 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 11 | -2189.17 | PP–SKEM | 110 | 100 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1533 | 1533 | no | SW_Splašky vnitřní gravitační 11 | 0 | 2
13517738 | -1.PP_SO-102 | 655.396 | 0.00950189 | 0.226489 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 1912.99 | 1844.9 | 1858 | 1789.91 | 1858 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 11 | -2204.79 | PP–SKEM | 110 | 100 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1534 | 1534 | no | SW_Splašky vnitřní gravitační 11 | 0 | 2
13517809 | -1.PP_SO-102 | 1072.14 | 0.00950189 | 0.370505 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 1781.97 | 709.835 | 1781.97 | 709.835 | 1781.97 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 11 | -3290.16 | PP–SKEM | 110 | 100 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1535 | 1535 | no | SW_Splašky vnitřní gravitační 11 | 0
13517920 | -1.PP_SO-102 | 269.336 | 0.00950189 | 0.0930757 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 979.171 | 709.835 | 979.171 | 709.835 | 979.171 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 11 | -3290.16 | PP–SKEM | 110 | 100 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1536 | 1536 | no | SW_Splašky vnitřní gravitační 11 | 0
13518297 | -1.PP_SO-102 | 276.732 | 0.00950189 | 0.0956317 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 701.898 | 646.898 | 646.898 | 591.898 | 646.898 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 11 | -3402.8 | PP–SKEM | 110 | 100 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1537 | 1537 | no | SW_Splašky vnitřní gravitační 11 | 0 | 0
13520035 | 1.NP_SO-102 | 524.876 | 0.00950189 | 0.181384 | ø110 mm | 0.000100604 | G | 1.NP_SO-102 | 3786.26 | 3261.38 | 3786.25 | 3261.38 | 3786.25 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3261.38 | PP–SKEM | 110 | 424 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1539 | 1539 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: Vyhřívaný výdejní pult
13527988 | -1.PP_SO-102 | 765.939 | 0.00950189 | 0.26469 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -2966.07 | -3021.06 | -3036.37 | -3091.36 | -3036.37 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -7086.06 | PP–SKEM | 110 | 115 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1561 | 1561 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 2
13528001 | -1.PP_SO-102 | 409.408 | 0.00950189 | 0.141481 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -2978 | -3032.99 | -3041.18 | -3096.16 | -3041.18 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -7090.87 | PP–SKEM | 110 | 117 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1562 | 1562 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 2
13528607 | -1.PP_SO-102 | 2818.73 | 0.00950189 | 0.974084 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 1633.52 | 1633.52 | -1185.21 | -1185.21 | -1185.21 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -5185.21 | PP–SKEM | 110 | 127 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1563 | 1563 | yes | SW_Splašky vnitřní gravitační 3 | 0
13528830 | -1.PP_SO-102 | 1085.01 | 0.00950189 | 0.374953 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -1322.33 | -1377.32 | -1399.01 | -1454 | -1399.01 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -5448.7 | PP–SKEM | 110 | 127 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1564 | 1564 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 2
13528848 | -1.PP_SO-102 | 172.558 | 0.00950189 | 0.0596319 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -1190.82 | -1351.73 | -1229.71 | -1390.62 | -1229.71 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -5386.88 | PP–SKEM | 110 | 127 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1565 | 1565 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 100
13531471 | -1.PP_SO-102 | 580.847 | 0.00950189 | 0.200726 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2733.22 | 2666.62 | 2678.23 | 2611.63 | 2678.23 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1383.07 | PP–SKEM | 110 | 430 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1566 | 1566 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13531530 | -1.PP_SO-102 | 1292.98 | 0.00950189 | 0.446823 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2720.57 | 2665.58 | 2639.72 | 2584.73 | 2639.72 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1409.97 | PP–SKEM | 110 | 430 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1567 | 1567 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13538002 | 1.NP_SO-102 | 1330.09 | 0.00950189 | 0.459645 | ø110 mm | 0.000100604 | G | 1.NP_SO-102 | 1217.37 | 1217.37 | -112.719 | -112.719 | -112.719 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -112.719 | PP–SKEM | 110 | 626 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1577 | 1577 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
13545668 | 2.NP_SO-102 | 3507.74 | 0.00477764 | 0.859552 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3123.08 | 3013.94 | 3084.08 | 2974.95 | 3084.08 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 6979.45 | PP–SKEM | 78 | 436 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1581 | 1581 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13545682 | 2.NP_SO-102 | 749.386 | 0.00477764 | 0.183633 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3052.13 | 2998.15 | 3013.13 | 2959.16 | 3013.13 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 6963.66 | PP–SKEM | 78 | 436 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1582 | 1582 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13546050 | 2.NP_SO-102 | 486.933 | 0.00477764 | 0.11932 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3041.12 | 2992.3 | 3002.13 | 2953.31 | 3002.13 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 6957.81 | PP–SKEM | 78 | 15 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1583 | 1583 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2.01907
13546164 | 3.NP_SO-102 | 3300.28 | 0.00477764 | 0.808715 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 796.457 | 796.457 | -2503.82 | -2503.82 | -2503.82 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 5496.18 | PP–SKEM | 78 | 443 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1584 | 1584 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S3
13546177 | 3.NP_SO-102 | 1513.99 | 0.00477764 | 0.370995 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 708.506 | 708.506 | -805.486 | -805.486 | -805.486 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7194.51 | PP–SKEM | 78 | 676 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1585 | 1585 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S2
13546441 | 2.NP_SO-102 | 75.9635 | 0.00950189 | 0.0262511 | ø110 mm | 0.000100604 | G | 2.NP_SO-102 | 1482.16 | 1389.72 | 1442.84 | 1350.4 | 1442.84 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 5354.19 | PP–SKEM | 110 | 442 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1586 | 1586 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 97.8153
13546846 | 2.NP_SO-102 | 93.0603 | 0.0143117 | 0.0394683 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 1508.01 | 1414.95 | 1508.01 | 1414.95 | 1508.01 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 5414.95 | PP–SKEM | 135 | 440 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1587 | 1587 | yes | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 16 | 0
13547277 | 2.NP_SO-102 | 14.5063 | 0.00477764 | 0.00355469 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3186.58 | 3147.59 | 3147.3 | 3108.3 | 3147.3 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7112.8 | PP–SKEM | 78 | 676 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1588 | 1588 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13547290 | 2.NP_SO-102 | 773.165 | 0.00477764 | 0.18946 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3185.36 | 3146.36 | 3146.36 | 3107.36 | 3146.36 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7111.86 | PP–SKEM | 78 | 676 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1589 | 1589 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 0
13550252 | 3.NP_SO-102 | 917.661 | 0.00264168 | 0.167209 | ø58 mm | 0.0002 | G | 3.NP_SO-102 | 315.75 | 315.75 | -601.911 | -601.911 | -601.911 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7398.09 | PP–SKEM | 58 | 451 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø58 | 50 | TR08.01.1590 | 1590 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S1
13550320 | 2.NP_SO-102 | 1239.2 | 0.00477764 | 0.30366 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3369.86 | 3306.09 | 3330.87 | 3267.1 | 3330.87 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7271.59 | PP–SKEM | 78 | 707 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1591 | 1591 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13550347 | 2.NP_SO-102 | 6338.74 | 0.00477764 | 1.55327 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3344.31 | 3181.25 | 3305.32 | 3142.25 | 3305.32 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7146.75 | PP–SKEM | 78 | 707 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1592 | 1592 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1.95776
13550629 | 2.NP_SO-102 | 2096.58 | 0.00477764 | 0.513754 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3219.47 | 3180.48 | 3138.55 | 3099.56 | 3138.55 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7104.06 | PP–SKEM | 78 | 707 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1593 | 1593 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13614068 | -1.PP_SO-102 | 5826.59 | 0.00950189 | 2.01352 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -2345.44 | -2400.43 | -2516.94 | -2571.93 | -2516.94 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6566.63 | PP–SKEM | 110 | 127 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1604 | 1604 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 2
13621213 | -1.PP_SO-102 | 1466.37 | 0.00950189 | 0.506741 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -2309.52 | -2364.51 | -2393.83 | -2448.82 | -2393.83 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6443.52 | PP–SKEM | 110 | 127 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1606 | 1606 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 2
13621291 | -1.PP_SO-102 | 1031.64 | 0.00950189 | 0.356508 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -1577.72 | -2346.09 | -1616.61 | -2384.98 | -1616.61 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6381.23 | PP–SKEM | 110 | 127 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1607 | 1607 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 100
13621396 | -1.PP_SO-102 | 2463.98 | 0.00477764 | 0.603785 | ø78 mm | 0.000144928 | G | -1.PP_SO-102 | 2096.14 | -367.846 | 2096.14 | -367.846 | 2096.14 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -4367.85 | PP–SKEM | 78 | 128 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1608 | 1608 | yes | SW_Splašky vnitřní gravitační 3 | 0
13624091 | -1.PP_SO-102 | 306.226 | 0.00950189 | 0.105824 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -1315.16 | -1376.28 | -1370.15 | -1431.27 | -1370.15 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -5425.97 | PP–SKEM | 110 | 127 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1610 | 1610 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 2
13624518 | -1.PP_SO-102 | 199.471 | 0.0201032 | 0.100265 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | -2966.19 | -3046.17 | -3050.16 | -3130.15 | -3050.16 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -7124.85 | PP–SKEM | 160 | 40 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.1614 | 1614 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 2
13646560 | 3.NP_SO-102 | 83.5493 | 0.00477764 | 0.0204733 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 3210.93 | 3123.23 | 3184.33 | 3096.63 | 3184.33 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11099.7 | PP–SKEM | 78 | 4 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1686 | 1686 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 107.237 | Identifikační data - Komentáře: S17
13646635 | 3.NP_SO-102 | 7511.98 | 0.00477764 | 1.84077 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 2944.83 | 2944.83 | -4567.15 | -4567.15 | -4567.15 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3432.85 | PP–SKEM | 78 | 593 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1687 | 1687 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S17
13652325 | -1.PP_SO-102 | 272.846 | 0.00950189 | 0.0942888 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2415 | 2360 | 2360 | 2305 | 2360 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | -1689.7 | PP–SKEM | 110 | 139 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1701 | 1701 | yes | SW_Odvětrání kanalizace 16 |  | 0
13652478 | -1.PP_SO-102 | 916.001 | 0.00950189 | 0.316547 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2415 | 2360 | 2360 | 2305 | 2360 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | -1689.7 | PP–SKEM | 110 | 127 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1702 | 1702 | yes | SW_Odvětrání kanalizace 16 |  | 0
13652541 | -1.PP_SO-102 | 7350.52 | 0.00950189 | 2.54016 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2865 | 2810 | 2810 | 2755 | 2810 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | -1239.7 | PP–SKEM | 110 | 127 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1703 | 1703 | yes | SW_Odvětrání kanalizace 16 |  | 0
13653122 | -1.PP_SO-102 | 89.125 | 0.00950189 | 0.0307994 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2415 | 2360 | 2360 | 2305 | 2360 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | -1689.7 | PP–SKEM | 110 | 24 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1704 | 1704 | yes | SW_Odvětrání kanalizace 16 |  | 0
13653315 | -1.PP_SO-102 | 1212.34 | 0.00950189 | 0.418956 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 1355.56 | 1355.56 | 143.219 | 143.219 | 143.219 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -3856.78 | PP–SKEM | 110 | 6 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1705 | 1705 | yes | SW_Splašky vnitřní gravitační 3 | 0
13653545 | -1.PP_SO-102 | 324.125 | 0.00950189 | 0.11201 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2747.06 | 2422.94 | 2747.06 | 2422.94 | 2747.06 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | -1577.06 | PP–SKEM | 110 | 127 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1706 | 1706 | yes | SW_Odvětrání kanalizace 16
13653600 | -1.PP_SO-102 | 89.125 | 0.00950189 | 0.0307994 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2865 | 2810 | 2810 | 2755 | 2810 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | -1239.7 | PP–SKEM | 110 | 127 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1707 | 1707 | yes | SW_Odvětrání kanalizace 16 |  | 0
13653639 | -1.PP_SO-102 | 89.125 | 0.00950189 | 0.0307994 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2075 | 2020 | 2020 | 1965 | 2020 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | -2029.7 | PP–SKEM | 110 | 91 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1708 | 1708 | yes | SW_Odvětrání kanalizace 16 |  | 0
13653669 | -1.PP_SO-102 | 207.775 | 0.00950189 | 0.0718019 | ø110 mm | 0 | G | -1.PP_SO-102 | 2290.71 | 2082.94 | 2290.71 | 2082.94 | 2290.71 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | -1917.06 | PP–SKEM | 110 | 91 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1709 | 1709 | yes | SW_Odvětrání kanalizace 16
13653672 | -1.PP_SO-102 | 7710.94 | 0.00950189 | 2.66471 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2415 | 2360 | 2360 | 2305 | 2360 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | -1689.7 | PP–SKEM | 110 | 24 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1710 | 1710 | yes | SW_Odvětrání kanalizace 16 |  | 0
13656215 | 2.NP_SO-102 | 2064.67 | 0.0143117 | 0.875658 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 1479.14 | -585.529 | 1479.14 | -585.529 | 1479.14 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3414.47 | PP–SKEM | 135 | 133 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1717 | 1717 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
13656334 | 2.NP_SO-102 | 1810.8 | 0.0143117 | 0.767987 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 1465.46 | -345.342 | 1465.46 | -345.343 | 1465.46 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3654.66 | PP–SKEM | 135 | 134 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1718 | 1718 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
13656393 | 2.NP_SO-102 | 2405.08 | 0.0143117 | 1.02003 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 1839 | -566.08 | 1839 | -566.08 | 1839 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3433.92 | PP–SKEM | 135 | 632 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1719 | 1719 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
13656691 | 2.NP_SO-102 | 3989.01 | 0.00477764 | 0.977483 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3228.67 | -760.333 | 3228.67 | -760.333 | 3228.67 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3239.67 | PP–SKEM | 78 | 727 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1720 | 1720 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S4
13658774 | -1.PP_SO-102 | 1703.35 | 0.00950189 | 0.588635 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -2481.55 | -2536.54 | -2570.6 | -2625.59 | -2570.6 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6620.29 | PP–SKEM | 110 | 137 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1721 | 1721 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 2
13658792 | -1.PP_SO-102 | 326.89 | 0.00950189 | 0.112965 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -2516.62 | -2577.7 | -2571.61 | -2632.69 | -2571.61 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6627.4 | PP–SKEM | 110 | 137 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1722 | 1722 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 1.86589
13659003 | -1.PP_SO-102 | 324.215 | 0.00950189 | 0.112041 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -2249.97 | -2518.12 | -2288.86 | -2557.01 | -2288.86 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6553.26 | PP–SKEM | 110 | 137 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1724 | 1724 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 100
13659236 | -1.PP_SO-102 | 201.663 | 0.00477764 | 0.0494164 | ø78 mm | 0.000144928 | G | -1.PP_SO-102 | -985.178 | -1012.76 | -1155.35 | -1182.93 | -1155.35 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -5179.75 | PP–SKEM | 78 | 43 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1725 | 1725 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 100
13659290 | -1.PP_SO-102 | 602.211 | 0.00477764 | 0.147568 | ø78 mm | 0.000144928 | G | -1.PP_SO-102 | -1130.1 | -1181.13 | -1169.09 | -1220.13 | -1169.09 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -5215.63 | PP–SKEM | 78 | 43 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1726 | 1726 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 2
13659337 | -1.PP_SO-102 | 738.239 | 0.00950189 | 0.255117 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -1513.57 | -1513.57 | -2251.8 | -2251.8 | -2251.8 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6251.8 | PP–SKEM | 110 | 136 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1727 | 1727 | yes | SW_Splašky vnitřní gravitační 3 | 0
13659865 | -1.PP_SO-102 | 155.122 | 0.00950189 | 0.0536063 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -2478.93 | -2533.92 | -2537.02 | -2592.01 | -2537.02 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6586.71 | PP–SKEM | 110 | 136 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1728 | 1728 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 2
13660054 | -1.PP_SO-102 | 271.12 | 0.00950189 | 0.0936925 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -2257.42 | -2488.02 | -2296.31 | -2526.91 | -2296.31 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6523.16 | PP–SKEM | 110 | 136 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1730 | 1730 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 100
13660086 | -1.PP_SO-102 | 1322.04 | 0.00950189 | 0.456865 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -2451.45 | -2506.44 | -2532.88 | -2587.87 | -2532.88 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6582.57 | PP–SKEM | 110 | 136 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1731 | 1731 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 2
13660536 | -1.PP_SO-102 | 174.128 | 0.00477764 | 0.042669 | ø78 mm | 0.000144928 | G | -1.PP_SO-102 | -1167.29 | -1194.87 | -1318 | -1345.58 | -1318 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -5342.39 | PP–SKEM | 78 | 43 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1732 | 1732 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 100
13660771 | -1.PP_SO-102 | 2053.93 | 0.00950189 | 0.709787 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -190.428 | -190.428 | -2244.36 | -2244.36 | -2244.36 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6244.36 | PP–SKEM | 110 | 137 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1733 | 1733 | yes | SW_Splašky vnitřní gravitační 3 | 0
13661001 | 2.NP_SO-102 | 1091.35 | 0.00477764 | 0.267429 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3376.15 | 3315.34 | 3337.16 | 3276.34 | 3337.16 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7280.84 | PP–SKEM | 78 | 727 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1734 | 1734 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13661221 | 2.NP_SO-102 | 1948.25 | 0.00477764 | 0.477407 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3353.55 | 3275.6 | 3314.56 | 3236.61 | 3314.56 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7241.11 | PP–SKEM | 78 | 727 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1735 | 1735 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13665575 | 2.NP_SO-102 | 726.445 | 0.0143117 | 0.308096 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 2639.81 | 2572.31 | 2572.31 | 2504.81 | 2572.31 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 6510.11 | PP–SKEM | 135 | 136 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1736 | 1736 | yes | SW_Odvětrání kanalizace 16 |  | 0
