Properties of the parts of a building model (IFC4), part 18 of 60

# IfcDistributionPort (11856)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_13825635_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13074780_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13078602_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13074809_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13642187_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13074813_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13076445_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13074813_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13807274_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13074813_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13825678_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13075475_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13823054_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13075475_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705735_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13075622_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13654083_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13075622_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705040_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13075648_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13654094_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13075648_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13704707_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13075689_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13823091_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13075689_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13651771_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13075758_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13654105_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13075758_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13704703_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13075804_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13823127_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13075804_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13706074_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13075876_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13654116_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13075876_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13654120_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13076135_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13080084_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13076289_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13654114_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13076445_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13654103_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13076510_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13076512_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13076510_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13825658_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13076512_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13642186_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13076532_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13076534_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13076532_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13825591_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13076534_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13642256_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13076552_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13076554_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13076552_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13825692_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13076554_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13642303_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13076568_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13076571_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13076568_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13825639_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13076571_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13642219_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13077343_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13840288_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13077343_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13840292_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13077916_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13650969_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13077916_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13840186_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13078288_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13807730_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13078602_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13807255_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13078604_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13079628_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13079140_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13828947_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13079140_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13807401_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_13079766_2 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
OutPort_13079342_0 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
InPort_13079342_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
OutPort_13828832_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13079425_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13079427_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13079425_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13641418_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13079427_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13828963_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13079628_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13828816_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
InPort_13641662_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
OutPort_13079766_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13080082_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13080084_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13080143_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13080145_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13080143_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13080175_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13080175_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13080210_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13080210_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13080211_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13080211_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13080830_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_13080854_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_13080873_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Teplá vnitřní 83
OutPort_13080830_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13080846_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13080847_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_13080854_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_13080846_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13080847_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13830849_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13081063_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13831927_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13081063_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13081064_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13081063_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13081071_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13081064_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13704850_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13081071_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13081096_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13081094_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13081096_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13082999_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13083002_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13083002_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13827095_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13690091_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13095079_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13095079_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13095098_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13095765_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 11
OutPort_13095166_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 11
InPort_13095166_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 11
OutPort_13095690_2 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 11
InPort_13095242_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13095230_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13095230_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13095246_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13095246_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13095688_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13095290_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 11
OutPort_13095459_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 11
InPort_13096102_1 | SINK | PIPE | SEWAGE | SW_Odvětrání kanalizace 11
OutPort_13095290_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 11
InPort_13095443_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 11
OutPort_13095765_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 11
InPort_13095459_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 11
OutPort_13095443_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 11
InPort_13095688_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13095690_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13096172_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 10
OutPort_13096233_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 10
InPort_13096685_1 | SINK | PIPE | SEWAGE | SW_Odvětrání kanalizace 10
OutPort_13096172_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 10
InPort_13096217_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 10
OutPort_13096422_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 10
InPort_13096233_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 10
OutPort_13096217_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 10
InPort_13506139_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13096382_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13096382_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13096384_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13434505_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13096969_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13096969_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13645843_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13098740_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13098728_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13098728_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13098744_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13098744_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13099713_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13098789_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13099003_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13434362_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13098789_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13099003_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13098991_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13098991_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13099007_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13099215_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 17
OutPort_13099765_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 17
InPort_13099817_1 | SINK | PIPE | SEWAGE | SW_Odvětrání kanalizace 17
OutPort_13099215_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 17
InPort_13099713_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13099715_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13099749_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 17
OutPort_13099792_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 17
InPort_13099765_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 17
OutPort_13099749_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 17
Port_13099952_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13099975_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13099952_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13646630_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13099967_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13646634_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13099967_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13100043_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13100062_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13100043_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13434092_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13100056_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13100058_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13100056_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13100062_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13434227_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13100421_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13100421_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13434231_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13100831_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13462271_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13100831_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13461899_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13462267_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13100927_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13100927_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13100943_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13101490_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 9
OutPort_13101492_1 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 9
InPort_13101940_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 9
OutPort_13101490_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 9
InPort_13101582_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 9
OutPort_13412935_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 9
InPort_13101928_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 9
OutPort_13101940_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 9
InPort_13412935_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 9
OutPort_13101928_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 9
InPort_13101981_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13101983_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13462326_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13101981_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13102247_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 8
OutPort_13101983_2 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 8
InPort_13102087_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 8
OutPort_13412962_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 8
InPort_13102412_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 8
OutPort_13102247_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 8
InPort_13102400_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 8
OutPort_13102412_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 8
InPort_13412962_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 8
OutPort_13102400_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 8
InPort_13102573_1 | SINK | PIPE | SEWAGE
OutPort_13102564_1 | SOURCE | PIPE | SEWAGE
InPort_13102565_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 12
InPort_13102567_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 12
OutPort_13102565_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 12
InPort_13102566_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 4
InPort_13102569_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 4
OutPort_13102566_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 4
InPort_13102571_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 12
OutPort_13102567_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 12
InPort_13102571_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 4
OutPort_13102569_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 4
Port_13102573_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13102688_1 | SINK | PIPE | SEWAGE
OutPort_13102679_1 | SOURCE | PIPE | SEWAGE
InPort_13102680_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 14
InPort_13102682_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 14
OutPort_13102680_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 14
InPort_13102681_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 9
InPort_13102684_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 9
OutPort_13102681_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 9
InPort_13102686_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 14
OutPort_13102682_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 14
InPort_13102686_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 9
OutPort_13102684_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 9
Port_13102688_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_13102789_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13102970_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13102789_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764231_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13102970_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13763906_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13103544_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13916173_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13103544_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13916177_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13103556_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13823651_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13103556_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13822868_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13103598_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13840327_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13103598_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13840329_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13103613_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13825233_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13103613_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13654131_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13103947_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359799_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13103947_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13359972_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
InPort_13105043_1 | SINK | PIPE | SEWAGE
OutPort_13105034_1 | SOURCE | PIPE | SEWAGE
InPort_13105035_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 15
InPort_13105037_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 15
OutPort_13105035_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 15
InPort_13105036_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 10
InPort_13105039_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 10
OutPort_13105036_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 10
InPort_13105041_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 15
OutPort_13105037_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 15
InPort_13105041_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 10
OutPort_13105039_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 10
Port_13105043_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13124349_1 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 2
InPort_13124349_2 | SINK | PIPE | FIREPROTECTION
InPort_13124349_4 | SINK | PIPE | FIREPROTECTION
InPort_13124349_6 | SINK | PIPE | FIREPROTECTION
InPort_13124349_7 | SINK | PIPE | FIREPROTECTION
InPort_13124349_8 | SINK | PIPE | FIREPROTECTION
InPort_13124773_1 | SINK | PIPE | FIREPROTECTION
InPort_13124773_2 | SINK | PIPE | FIREPROTECTION
InPort_13124773_4 | SINK | PIPE | FIREPROTECTION
InPort_13124773_6 | SINK | PIPE | FIREPROTECTION
InPort_13124773_7 | SINK | PIPE | FIREPROTECTION
InPort_13124773_8 | SINK | PIPE | FIREPROTECTION
InPort_13124775_1 | SINK | PIPE | FIREPROTECTION
InPort_13124775_2 | SINK | PIPE | FIREPROTECTION
InPort_13124775_4 | SINK | PIPE | FIREPROTECTION
InPort_13124775_6 | SINK | PIPE | FIREPROTECTION
InPort_13124775_7 | SINK | PIPE | FIREPROTECTION
InPort_13124775_8 | SINK | PIPE | FIREPROTECTION
InPort_13124777_1 | SINK | PIPE | FIREPROTECTION
InPort_13124777_2 | SINK | PIPE | FIREPROTECTION
InPort_13124777_4 | SINK | PIPE | FIREPROTECTION
InPort_13124777_6 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
OutPort_13647428_0 | SOURCE | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13124777_7 | SINK | PIPE | FIREPROTECTION
InPort_13124777_8 | SINK | PIPE | FIREPROTECTION
InPort_13142251_1 | SINK | PIPE | FIREPROTECTION
InPort_13142251_2 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
OutPort_13175652_1 | SOURCE | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13142251_4 | SINK | PIPE | FIREPROTECTION
InPort_13142251_6 | SINK | PIPE | FIREPROTECTION
InPort_13142251_7 | SINK | PIPE | FIREPROTECTION
InPort_13142251_8 | SINK | PIPE | FIREPROTECTION
InPort_13142254_1 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
OutPort_13323052_1 | SOURCE | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13142254_2 | SINK | PIPE | FIREPROTECTION
InPort_13142254_4 | SINK | PIPE | FIREPROTECTION
InPort_13142254_6 | SINK | PIPE | FIREPROTECTION
InPort_13142254_7 | SINK | PIPE | FIREPROTECTION
InPort_13142254_8 | SINK | PIPE | FIREPROTECTION
InPort_13142257_1 | SINK | PIPE | FIREPROTECTION
InPort_13142257_2 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
OutPort_13169346_0 | SOURCE | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
InPort_13142257_4 | SINK | PIPE | FIREPROTECTION
InPort_13142257_6 | SINK | PIPE | FIREPROTECTION
InPort_13142257_7 | SINK | PIPE | FIREPROTECTION
InPort_13142257_8 | SINK | PIPE | FIREPROTECTION
InPort_13142401_1 | SINK | PIPE | FIREPROTECTION
InPort_13142401_2 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
OutPort_13175688_1 | SOURCE | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
InPort_13142401_4 | SINK | PIPE | FIREPROTECTION
InPort_13142401_6 | SINK | PIPE | FIREPROTECTION
InPort_13142401_7 | SINK | PIPE | FIREPROTECTION
InPort_13142401_8 | SINK | PIPE | FIREPROTECTION
InPort_13143120_1 | SINK | PIPE | FIREPROTECTION
InPort_13143120_2 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13143120_4 | SINK | PIPE | FIREPROTECTION
InPort_13143120_6 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
OutPort_13324362_1 | SOURCE | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13143120_7 | SINK | PIPE | FIREPROTECTION
InPort_13143120_8 | SINK | PIPE | FIREPROTECTION
InPort_13143321_1 | SINK | PIPE | FIREPROTECTION
InPort_13143321_2 | SINK | PIPE | FIREPROTECTION
InPort_13143321_4 | SINK | PIPE | FIREPROTECTION
InPort_13143321_6 | SINK | PIPE | FIREPROTECTION
InPort_13143321_7 | SINK | PIPE | FIREPROTECTION
InPort_13143321_8 | SINK | PIPE | FIREPROTECTION
InPort_13143670_1 | SINK | PIPE | FIREPROTECTION
InPort_13143670_2 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
OutPort_13175704_1 | SOURCE | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
InPort_13143670_4 | SINK | PIPE | FIREPROTECTION
InPort_13143670_6 | SINK | PIPE | FIREPROTECTION
InPort_13143670_7 | SINK | PIPE | FIREPROTECTION
InPort_13143670_8 | SINK | PIPE | FIREPROTECTION
InPort_13143847_1 | SINK | PIPE | FIREPROTECTION
InPort_13143847_2 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
OutPort_13175716_1 | SOURCE | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
InPort_13143847_4 | SINK | PIPE | FIREPROTECTION
InPort_13143847_6 | SINK | PIPE | FIREPROTECTION
InPort_13143847_7 | SINK | PIPE | FIREPROTECTION
InPort_13143847_8 | SINK | PIPE | FIREPROTECTION
InPort_13143854_1 | SINK | PIPE | FIREPROTECTION
InPort_13143854_2 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
OutPort_13175737_1 | SOURCE | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
InPort_13143854_4 | SINK | PIPE | FIREPROTECTION
InPort_13143854_6 | SINK | PIPE | FIREPROTECTION
InPort_13143854_7 | SINK | PIPE | FIREPROTECTION
InPort_13143854_8 | SINK | PIPE | FIREPROTECTION
Port_13144264_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13144276_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13144264_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13144286_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13144278_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13144286_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13144278_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13144336_1 | SINK | PIPE | FIREPROTECTION
InPort_13144336_2 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13144336_4 | SINK | PIPE | FIREPROTECTION
InPort_13144336_6 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
OutPort_13324291_1 | SOURCE | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13144336_7 | SINK | PIPE | FIREPROTECTION
InPort_13144336_8 | SINK | PIPE | FIREPROTECTION
Port_13144478_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13150694_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13144478_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13152924_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13144486_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13467065_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13144486_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13467115_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13144545_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13467065_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13144545_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13144624_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13144622_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13144624_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13144622_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13144740_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13144748_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13144740_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13144760_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13144748_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13157390_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13144748_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13467076_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13144754_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13613132_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13144754_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13432652_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13144760_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13613135_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13144999_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13145069_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13144999_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13152150_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13145012_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13152150_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13145028_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13145012_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13145022_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13145028_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13150590_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13145022_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13145032_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13150590_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13152861_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13145032_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13145069_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13155543_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13150415_1 | SOURCE | PIPE | SEWAGE | SW_Splašky čerpání 1
OutPort_13150415_3 | SOURCE | PIPE
OutPort_13150415_4 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13150415_5 | SOURCE | PIPE
InPort_13150415_6 | SINK | PIPE
InPort_13150415_7 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 15
InPort_13150415_8 | SINK | PIPE
InPort_13150415_9 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 65
InPort_13150415_10 | SINK | PIPE
InPort_13150415_12 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13150613_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13150415_13 | SOURCEANDSINK | CABLE | ELECTRICAL
InPort_13150613_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13150416_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13150416_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13152865_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13150420_0 | SOURCE | PIPE | SEWAGE | SW_Splašky čerpání 2
InPort_13150420_1 | SINK | PIPE | SEWAGE | SW_Splašky čerpání 2
OutPort_13484938_1 | SOURCE | PIPE | SEWAGE | SW_Splašky čerpání 2
InPort_13150426_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13152861_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13152865_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13150426_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13150532_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13150550_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13150532_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13150694_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13150546_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13150546_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13150550_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
InPort_13151320_1 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13151320_2 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13151320_4 | SINK | PIPE | FIREPROTECTION
InPort_13151320_6 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
OutPort_13323501_1 | SOURCE | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13151320_7 | SINK | PIPE | FIREPROTECTION
InPort_13151320_8 | SINK | PIPE | FIREPROTECTION
InPort_13151325_1 | SINK | PIPE | FIREPROTECTION
InPort_13151325_2 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13151325_4 | SINK | PIPE | FIREPROTECTION
InPort_13151325_6 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
OutPort_13323171_1 | SOURCE | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13151325_7 | SINK | PIPE | FIREPROTECTION
InPort_13151325_8 | SINK | PIPE | FIREPROTECTION
Port_13152106_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13152114_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13152106_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13152192_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13152114_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13153986_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13152118_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13152192_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13152118_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13152188_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13152150_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13152161_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13152161_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13152188_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13156404_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13152532_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13152532_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13152534_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13153282_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
OutPort_13152736_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
InPort_13152736_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
OutPort_13152738_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13152888_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13152920_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13152888_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13152924_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13152920_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153316_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153097_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153533_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153097_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153278_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153126_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153503_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153126_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153311_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153193_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153278_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153193_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153282_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153225_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153311_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153225_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153315_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153282_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153283_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153283_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153315_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153315_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153316_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153421_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153529_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153421_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153533_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153457_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153499_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153457_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153503_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
InPort_13653317_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13153594_0 | SOURCE | PIPE | VENT | SW_Splašky vnitřní gravitační 3
InPort_13653681_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13153594_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13153752_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13153771_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13153752_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13153862_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13153818_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13154012_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13153818_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13154016_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13153862_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13154017_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13153862_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13153875_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13153875_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13154098_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13153937_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13153985_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13153937_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13859227_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13153985_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13153986_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13153985_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13156404_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13154009_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13154016_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13154009_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13859227_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13154016_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13154017_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13154090_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13154098_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13154090_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13154214_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13154173_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13154214_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13154173_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13154247_1 | SINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
OutPort_13175729_1 | SOURCE | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
InPort_13154247_2 | SINK | PIPE | FIREPROTECTION
InPort_13154247_4 | SINK | PIPE | FIREPROTECTION
InPort_13154247_6 | SINK | PIPE | FIREPROTECTION
InPort_13154247_7 | SINK | PIPE | FIREPROTECTION
InPort_13154247_8 | SINK | PIPE | FIREPROTECTION
InPort_13154259_1 | SINK | PIPE | SEWAGE
OutPort_13154250_1 | SOURCE | PIPE | SEWAGE
InPort_13154251_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 13
InPort_13154253_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 13
OutPort_13154251_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 13
InPort_13154252_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 8
InPort_13154255_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 8
OutPort_13154252_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 8
InPort_13154257_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 13
OutPort_13154253_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 13
InPort_13154257_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 8
OutPort_13154255_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 8
Port_13154259_2 | SOURCEANDSINK | PIPE | SEWAGE
OutPort_13154274_1 | SOURCE | PIPE | SEWAGE
InPort_13154275_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_13154276_1 | SOURCE | PIPE | SEWAGE
Port_13154276_2 | SOURCEANDSINK | PIPE
Port_13154281_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13154284_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_13154289_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13154295_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13154289_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13976198_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13154293_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13154295_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13154293_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13154299_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13154297_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13154299_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13154297_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13154301_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13154307_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13154301_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13976251_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13154305_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13154307_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13154305_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13154311_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13154309_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13154311_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13154309_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13154313_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13976257_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13154313_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13976261_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13154317_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13976116_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13154317_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13154318_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13154321_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13976204_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13154321_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13976208_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13154325_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13976075_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13154325_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13154326_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13154384_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13154411_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13154401_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13154410_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13154401_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13976153_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13154410_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13154411_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13154461_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13976145_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13154461_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13976304_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13154481_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13976310_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13154481_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13976312_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13154491_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13976310_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13154491_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13154507_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13154499_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13154507_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13154499_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13155534_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13527388_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13155534_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13527507_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13155543_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13613063_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13155565_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13161571_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13155565_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13624518_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13155565_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13527388_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13155598_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13155695_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13155598_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13155686_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13155695_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13155686_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13155834_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13155772_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13155834_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13155772_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_14036854_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13155838_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13155839_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13155838_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13653315_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13155838_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_14036854_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13155839_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_14036856_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13156047_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13156735_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13156750_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13156047_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13156174_0 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13156692_2 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13156174_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13156466_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13156466_2 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13981228_0 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13156488_0 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13156498_2 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13156488_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_14019756_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13156498_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13981216_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13156665_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13156786_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14023405_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13156665_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13156692_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13156740_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13156750_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13156786_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13156740_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13484938_2 | SINK | PIPE | SEWAGE | SW_Splašky čerpání 2
OutPort_13156801_0 | SOURCE | PIPE | SEWAGE | SW_Splašky čerpání 2
InPort_13156801_1 | SINK | PIPE | SEWAGE | SW_Splašky čerpání 2
OutPort_14026135_2 | SOURCE | PIPE | SEWAGE | SW_Splašky čerpání 2
Port_13157016_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13157459_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13157016_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13157463_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13157381_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13157389_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13157381_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13157399_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13157389_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13622195_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13157389_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13659880_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13157390_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13612981_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13157393_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13157399_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13157393_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13157459_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13157463_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_14036856_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13157471_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13823017_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157471_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13651690_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157475_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13840145_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157475_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13840149_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157479_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157481_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157479_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13654070_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157481_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13839483_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
