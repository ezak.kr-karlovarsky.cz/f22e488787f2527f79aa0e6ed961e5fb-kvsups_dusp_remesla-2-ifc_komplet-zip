Properties of the parts of a building model (IFC4), part 46 of 60

# IfcPipeSegment: Typy trubek:PP-RCT (1338)
Name (Typy trubek:PP-RCT:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Instalační jednotky = Reynoldsovo číslo = Třecí faktor = Tření = Průtok (m3/s) = Rychlost (m/s) = Tlaková ztráta (Pa) | Stav průtoku | Doplňkový průtok (m3/s) | Relativní drsnost | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) | Spodní výška (mm) | Střední výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Délka (mm) | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
12995570 | 2.NP_SO-102 | 69.4593 | 0.000314112 | 0.00436425 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5242.3 | PP–RCT S4 | 20 | 236 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 69.4593 | ø20 | 15.4 | TR10.03.0273 | 0273 | no | WS_Teplá vnitřní 83 | 0
12995580 | 2.NP_SO-102 | 447.023 | 0.000314112 | 0.0280873 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5242.3 | PP–RCT S4 | 20 | 235 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 447.023 | ø20 | 15.4 | TR10.03.0274 | 0274 | no | WS_Teplá vnitřní 83 | 0
12995589 | 2.NP_SO-102 | 126.187 | 0.000314112 | 0.00792859 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5242.3 | PP–RCT S4 | 20 | 237 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 126.187 | ø20 | 15.4 | TR10.03.0275 | 0275 | no | WS_Teplá vnitřní 83 | 0
12995638 | 2.NP_SO-102 | 126.187 | 0.000314112 | 0.00792859 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5242.3 | PP–RCT S4 | 20 | 239 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 126.187 | ø20 | 15.4 | TR10.03.0276 | 0276 | no | WS_Teplá vnitřní 83 | 0
12995645 | 2.NP_SO-102 | 56.6392 | 0.000314112 | 0.00355875 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5242.3 | PP–RCT S4 | 20 | 238 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 56.6392 | ø20 | 15.4 | TR10.03.0277 | 0277 | no | WS_Teplá vnitřní 83 | 0
12995761 | 2.NP_SO-102 | 1098.41 | 0.0004908 | 0.0862686 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2379.36 | 2379.36 | 1280.96 | 1280.96 | 1280.96 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5280.96 | PP–RCT S4 | 25 | 233 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1098.41 | ø25 | 19.4 | TR10.03.0278 | 0278 | no | WS_Teplá vnitřní 83
12995764 | 2.NP_SO-102 | 264.004 | 0.000314112 | 0.0165878 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5242.3 | PP–RCT S4 | 20 | 40 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 264.004 | ø20 | 15.4 | TR10.03.0279 | 0279 | no | WS_Teplá vnitřní 83 | 0
12995772 | 2.NP_SO-102 | 1828.24 | 0.00125645 | 0.229744 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 2.NP_SO-102 | 2420 | 2400 | 2400 | 2380 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6384.5 | PP–RCT S4 | 40 | 346 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1828.24 | ø40 | 31 | TR10.03.0280 | 0280 | no | WS_Teplá vnitřní 83 | 0
12995788 | 2.NP_SO-102 | 3666.73 | 0.0004908 | 0.287984 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2416.24 | 2403.74 | 2403.74 | 2391.24 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6394.04 | PP–RCT S4 | 25 | 168 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3666.73 | ø25 | 19.4 | TR10.03.0281 | 0281 | no | WS_Studená vnitřní 134 | 0
12995801 | 2.NP_SO-102 | 499.233 | 0.00125645 | 0.0627355 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 2.NP_SO-102 | 2023.74 | 2003.74 | 2003.74 | 1983.74 | 2003.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5988.24 | PP–RCT S4 | 40 | 514 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 499.233 | ø40 | 31 | TR10.03.0282 | 0282 | no | WS_Studená vnitřní 134 | 0
12995804 | 2.NP_SO-102 | 39.5054 | 0.000314112 | 0.0024822 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5242.3 | PP–RCT S4 | 20 | 43 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 39.5054 | ø20 | 15.4 | TR10.03.0283 | 0283 | no | WS_Studená vnitřní 134 | 0
12995869 | 2.NP_SO-102 | 66.1875 | 0.000314112 | 0.00415868 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5242.3 | PP–RCT S4 | 20 | 44 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 66.1875 | ø20 | 15.4 | TR10.03.0284 | 0284 | no | WS_Studená vnitřní 134 | 0
12995876 | 2.NP_SO-102 | 31.2271 | 0.000314112 | 0.00196206 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5242.3 | PP–RCT S4 | 20 | 437 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 31.2271 | ø20 | 15.4 | TR10.03.0285 | 0285 | no | WS_Studená vnitřní 134 | 0
12995956 | 2.NP_SO-102 | 66.1875 | 0.000314112 | 0.00415868 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5242.3 | PP–RCT S4 | 20 | 438 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 66.1875 | ø20 | 15.4 | TR10.03.0286 | 0286 | no | WS_Studená vnitřní 134 | 0
12995963 | 2.NP_SO-102 | 320.341 | 0.000314112 | 0.0201276 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5242.3 | PP–RCT S4 | 20 | 45 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 320.341 | ø20 | 15.4 | TR10.03.0287 | 0287 | no | WS_Studená vnitřní 134 | 0
12996023 | 2.NP_SO-102 | 1102.15 | 0.0004908 | 0.0865623 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2383.1 | 2383.1 | 1280.96 | 1280.96 | 1280.96 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5280.96 | PP–RCT S4 | 25 | 168 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1102.15 | ø25 | 19.4 | TR10.03.0288 | 0288 | no | WS_Studená vnitřní 134
12996026 | 2.NP_SO-102 | 689.057 | 0.000314112 | 0.0432947 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5242.3 | PP–RCT S4 | 20 | 169 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 689.057 | ø20 | 15.4 | TR10.03.0289 | 0289 | no | WS_Studená vnitřní 134 | 0
12996051 | 2.NP_SO-102 | 659.424 | 0.0004908 | 0.051791 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2012.5 | 2000 | 2000 | 1987.5 | 2000 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5990.3 | PP–RCT S4 | 25 | 192 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 659.424 | ø25 | 19.4 | TR10.03.0290 | 0290 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12996442 | 2.NP_SO-102 | 1466.17 | 0.000314112 | 0.0921223 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2410 | 2400 | 2400 | 2390 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 6392.3 | PP–RCT S4 | 20 | 25 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1466.17 | ø20 | 15.4 | TR10.03.0291 | 0291 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12996500 | 2.NP_SO-102 | 302.538 | 0.000314112 | 0.019009 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5242.3 | PP–RCT S4 | 20 | 25 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 302.538 | ø20 | 15.4 | TR10.03.0292 | 0292 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12996559 | 2.NP_SO-102 | 1115.07 | 0.000314112 | 0.0700622 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2382.54 | 2382.54 | 1267.46 | 1267.46 | 1267.46 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5267.46 | PP–RCT S4 | 20 | 25 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1115.07 | ø20 | 15.4 | TR10.03.0293 | 0293 | no | WS_"Jiný typ" studená vnitřní 1
12996638 | 2.NP_SO-102 | 1076.44 | 0.000314112 | 0.0676347 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2350.56 | 1274.12 | 2350.56 | 1274.12 | 2350.56 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5274.12 | PP–RCT S4 | 20 | 160 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1076.44 | ø20 | 15.4 | TR10.03.0294 | 0294 | no | WS_Studená vnitřní 134
12996669 | 2.NP_SO-102 | 1075.84 | 0.000314112 | 0.0675968 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2346.82 | 1270.98 | 2346.82 | 1270.98 | 2346.82 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5270.98 | PP–RCT S4 | 20 | 217 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1075.84 | ø20 | 15.4 | TR10.03.0295 | 0295 | no | WS_Teplá vnitřní 83
12996752 | 2.NP_SO-102 | 929.356 | 0.000314112 | 0.0583932 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2346.82 | 1417.46 | 2346.82 | 1417.46 | 2346.82 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5417.46 | PP–RCT S4 | 20 | 220 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 929.356 | ø20 | 15.4 | TR10.03.0296 | 0296 | no | WS_Teplá vnitřní 83
12996755 | 2.NP_SO-102 | 1583.77 | 0.000804127 | 0.159218 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2416 | 2400 | 2400 | 2384 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6387.6 | PP–RCT S4 | 32 | 299 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1583.77 | ø32 | 24.8 | TR10.03.0297 | 0297 | no | WS_Teplá vnitřní 83 | 0
12996785 | 2.NP_SO-102 | 922.776 | 0.000314112 | 0.0579798 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2350.56 | 1427.78 | 2350.56 | 1427.78 | 2350.56 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5427.78 | PP–RCT S4 | 20 | 162 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 922.776 | ø20 | 15.4 | TR10.03.0298 | 0298 | no | WS_Studená vnitřní 134
12996788 | 2.NP_SO-102 | 1743.72 | 0.000804127 | 0.175298 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 416 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1743.72 | ø32 | 24.8 | TR10.03.0299 | 0299 | no | WS_Studená vnitřní 134 | 0
12997360 | 2.NP_SO-102 | 1102.37 | 0.000314112 | 0.0692643 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2376.19 | 1273.81 | 2376.19 | 1273.81 | 2376.19 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5273.81 | PP–RCT S4 | 20 | 41 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1102.37 | ø20 | 15.4 | TR10.03.0300 | 0300 | no | WS_"Jiný typ" studená vnitřní 1
12997363 | 2.NP_SO-102 | 1065.68 | 0.000314112 | 0.0669589 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2410 | 2400 | 2400 | 2390 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 6392.3 | PP–RCT S4 | 20 | 25 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1065.68 | ø20 | 15.4 | TR10.03.0301 | 0301 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12997440 | 2.NP_SO-102 | 1116.19 | 0.000314112 | 0.0701321 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5242.3 | PP–RCT S4 | 20 | 42 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1116.19 | ø20 | 15.4 | TR10.03.0302 | 0302 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12997448 | 2.NP_SO-102 | 756.187 | 0.000314112 | 0.0475127 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5242.3 | PP–RCT S4 | 20 | 43 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 756.187 | ø20 | 15.4 | TR10.03.0303 | 0303 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12997712 | 2.NP_SO-102 | 2258.17 | 0.000314112 | 0.141885 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2410 | 2400 | 2400 | 2390 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 6392.3 | PP–RCT S4 | 20 | 20 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2258.17 | ø20 | 15.4 | TR10.03.0304 | 0304 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12997768 | 2.NP_SO-102 | 477.622 | 0.0004908 | 0.0375124 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2412.5 | 2400 | 2400 | 2387.5 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 6390.3 | PP–RCT S4 | 25 | 35 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 477.622 | ø25 | 19.4 | TR10.03.0305 | 0305 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12997772 | 2.NP_SO-102 | 4480 | 0.000314112 | 0.281487 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1410 | 1400 | 1400 | 1390 | 1400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5392.3 | PP–RCT S4 | 20 | 334 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4480 | ø20 | 15.4 | TR10.03.0306 | 0306 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12997961 | 2.NP_SO-102 | 1378.72 | 0.000314112 | 0.0866278 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2410 | 2400 | 2400 | 2390 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 6392.3 | PP–RCT S4 | 20 | 342 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1378.72 | ø20 | 15.4 | TR10.03.0307 | 0307 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12997970 | 2.NP_SO-102 | 3078 | 0.000314112 | 0.193397 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2410 | 2400 | 2400 | 2390 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 6392.3 | PP–RCT S4 | 20 | 39 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3078 | ø20 | 15.4 | TR10.03.0308 | 0308 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12997973 | 2.NP_SO-102 | 640.427 | 0.000314112 | 0.0402392 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2410 | 2400 | 2400 | 2390 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 6392.3 | PP–RCT S4 | 20 | 342 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 640.427 | ø20 | 15.4 | TR10.03.0309 | 0309 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12997981 | 2.NP_SO-102 | 3062.54 | 0.000314112 | 0.192425 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2410 | 2400 | 2400 | 2390 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 6392.3 | PP–RCT S4 | 20 | 342 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3062.54 | ø20 | 15.4 | TR10.03.0310 | 0310 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12998016 | 2.NP_SO-102 | 1262.54 | 0.000314112 | 0.0793276 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1245.78 | 1235.78 | 1235.78 | 1225.78 | 1235.78 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5228.08 | PP–RCT S4 | 20 | 335 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1262.54 | ø20 | 15.4 | TR10.03.0311 | 0311 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12998027 | 2.NP_SO-102 | 14385.7 | 0.0004908 | 1.12985 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2412.5 | 2400 | 2400 | 2387.5 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 6390.3 | PP–RCT S4 | 25 | 35 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 14385.7 | ø25 | 19.4 | TR10.03.0312 | 0312 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12998069 | 2.NP_SO-102 | 1122.94 | 0.000314112 | 0.0705565 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2376.19 | 1253.25 | 2376.19 | 1253.25 | 2376.19 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5253.25 | PP–RCT S4 | 20 | 335 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1122.94 | ø20 | 15.4 | TR10.03.0313 | 0313 | no | WS_"Jiný typ" studená vnitřní 1
12998152 | 2.NP_SO-102 | 1150.45 | 0.000314112 | 0.0722851 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2361.11 | 2361.11 | 1210.65 | 1210.65 | 1210.65 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5210.65 | PP–RCT S4 | 20 | 229 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1150.45 | ø20 | 15.4 | TR10.03.0314 | 0314 | no | WS_Teplá vnitřní 83
12998181 | 2.NP_SO-102 | 1179.17 | 0.000314112 | 0.0740893 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2364.85 | 2364.85 | 1185.68 | 1185.68 | 1185.68 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5185.68 | PP–RCT S4 | 20 | 166 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1179.17 | ø20 | 15.4 | TR10.03.0315 | 0315 | no | WS_Studená vnitřní 134
12998202 | 2.NP_SO-102 | 1187.47 | 0.000314112 | 0.0746108 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2413.41 | 2403.41 | 2403.41 | 2393.41 | 2403.41 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6395.71 | PP–RCT S4 | 20 | 349 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1187.47 | ø20 | 15.4 | TR10.03.0316 | 0316 | no | WS_Studená vnitřní 134 | 0
12998229 | 2.NP_SO-102 | 9955.77 | 0.0004908 | 0.781925 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2412.5 | 2400 | 2400 | 2387.5 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 6390.3 | PP–RCT S4 | 25 | 192 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 9955.77 | ø25 | 19.4 | TR10.03.0317 | 0317 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12998349 | 2.NP_SO-102 | 1677.69 | 0.000804127 | 0.168659 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 350 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1677.69 | ø32 | 24.8 | TR10.03.0318 | 0318 | no | WS_Studená vnitřní 134 | 0
12998424 | 2.NP_SO-102 | 977.333 | 0.000314112 | 0.0614076 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2409.64 | 2399.64 | 2399.64 | 2389.64 | 2399.64 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6391.94 | PP–RCT S4 | 20 | 301 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 977.333 | ø20 | 15.4 | TR10.03.0319 | 0319 | no | WS_Teplá vnitřní 83 | 0
12998581 | 2.NP_SO-102 | 3416.19 | 0.000804127 | 0.343433 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2416 | 2400 | 2400 | 2384 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6387.6 | PP–RCT S4 | 32 | 213 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3416.19 | ø32 | 24.8 | TR10.03.0320 | 0320 | no | WS_Teplá vnitřní 83 | 0
12998824 | 2.NP_SO-102 | 3306.29 | 0.000804127 | 0.332385 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 27 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3306.29 | ø32 | 24.8 | TR10.03.0321 | 0321 | no | WS_Studená vnitřní 134 | 0
12998826 | 2.NP_SO-102 | 1090.33 | 0.0004908 | 0.085634 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2416.24 | 2403.74 | 2403.74 | 2391.24 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6394.04 | PP–RCT S4 | 25 | 155 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1090.33 | ø25 | 19.4 | TR10.03.0322 | 0322 | no | WS_Studená vnitřní 134 | 0
12998877 | 2.NP_SO-102 | 1542.2 | 0.0004908 | 0.121124 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2412.5 | 2400 | 2400 | 2387.5 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6390.3 | PP–RCT S4 | 25 | 385 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1542.2 | ø25 | 19.4 | TR10.03.0323 | 0323 | no | WS_Teplá vnitřní 83 | 0
12998879 | 2.NP_SO-102 | 1880.12 | 0.000314112 | 0.118132 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2410 | 2400 | 2400 | 2390 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6392.3 | PP–RCT S4 | 20 | 215 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1880.12 | ø20 | 15.4 | TR10.03.0324 | 0324 | no | WS_Teplá vnitřní 83 | 0
12999007 | 2.NP_SO-102 | 26.3012 | 0.000314112 | 0.00165255 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 590 | 580 | 580 | 570 | 580 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 4572.3 | PP–RCT S4 | 20 | 61 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 26.3012 | ø20 | 15.4 | TR10.03.0325 | 0325 | no | WS_Teplá vnitřní 83 | 0
12999016 | 2.NP_SO-102 | 3208.94 | 0.000314112 | 0.201624 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2410 | 2400 | 2400 | 2390 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6392.3 | PP–RCT S4 | 20 | 68 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3208.94 | ø20 | 15.4 | TR10.03.0326 | 0326 | no | WS_Teplá vnitřní 83 | 0
12999057 | 2.NP_SO-102 | 1768.41 | 0.000314112 | 0.111112 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2365.87 | 597.463 | 2365.87 | 597.462 | 2365.87 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 4597.46 | PP–RCT S4 | 20 | 61 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1768.41 | ø20 | 15.4 | TR10.03.0327 | 0327 | no | WS_Teplá vnitřní 83
12999060 | 2.NP_SO-102 | 356.894 | 0.0004908 | 0.0280304 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2412.5 | 2400 | 2400 | 2387.5 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6390.3 | PP–RCT S4 | 25 | 55 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 356.894 | ø25 | 19.4 | TR10.03.0328 | 0328 | no | WS_Teplá vnitřní 83 | 0
12999095 | 2.NP_SO-102 | 85.9631 | 0.000314112 | 0.00540122 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 793.001 | 783.001 | 783.001 | 773.001 | 783.001 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 4775.3 | PP–RCT S4 | 20 | 157 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 85.9631 | ø20 | 15.4 | TR10.03.0329 | 0329 | no | WS_Studená vnitřní 134 | 0
12999104 | 2.NP_SO-102 | 3098.41 | 0.000314112 | 0.194679 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2413.74 | 2403.74 | 2403.74 | 2393.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6396.04 | PP–RCT S4 | 20 | 343 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3098.41 | ø20 | 15.4 | TR10.03.0330 | 0330 | no | WS_Studená vnitřní 134 | 0
12999181 | 2.NP_SO-102 | 1566.82 | 0.000314112 | 0.098446 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2367.28 | 800.464 | 2367.28 | 800.464 | 2367.28 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 4800.46 | PP–RCT S4 | 20 | 157 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1566.82 | ø20 | 15.4 | TR10.03.0331 | 0331 | no | WS_Studená vnitřní 134
12999184 | 2.NP_SO-102 | 402.375 | 0.0004908 | 0.0316025 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2416.24 | 2403.74 | 2403.74 | 2391.24 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6394.04 | PP–RCT S4 | 25 | 155 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 402.375 | ø25 | 19.4 | TR10.03.0332 | 0332 | no | WS_Studená vnitřní 134 | 0
12999936 | 2.NP_SO-102 | 104.019 | 0.000314112 | 0.00653569 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 590 | 580 | 580 | 570 | 580 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 4572.3 | PP–RCT S4 | 20 | 80 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 104.019 | ø20 | 15.4 | TR10.03.0333 | 0333 | no | WS_Studená vnitřní 134 | 0
13000000 | 2.NP_SO-102 | 778.725 | 0.000314112 | 0.0489287 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1376.19 | 597.463 | 1376.19 | 597.463 | 1376.19 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 4597.46 | PP–RCT S4 | 20 | 80 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 778.725 | ø20 | 15.4 | TR10.03.0334 | 0334 | no | WS_Studená vnitřní 134
13000003 | 2.NP_SO-102 | 47.5311 | 0.000314112 | 0.00298647 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1410 | 1400 | 1400 | 1390 | 1400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5392.3 | PP–RCT S4 | 20 | 163 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 47.5311 | ø20 | 15.4 | TR10.03.0335 | 0335 | no | WS_Studená vnitřní 134 | 0
13000025 | 2.NP_SO-102 | 57.5375 | 0.000314112 | 0.00361519 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 590 | 580 | 580 | 570 | 580 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 4572.3 | PP–RCT S4 | 20 | 224 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 57.5375 | ø20 | 15.4 | TR10.03.0336 | 0336 | no | WS_Teplá vnitřní 83 | 0
13000072 | 2.NP_SO-102 | 778.725 | 0.000314112 | 0.0489287 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1376.19 | 597.462 | 1376.19 | 597.462 | 1376.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 4597.46 | PP–RCT S4 | 20 | 224 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 778.725 | ø20 | 15.4 | TR10.03.0337 | 0337 | no | WS_Teplá vnitřní 83
13000075 | 2.NP_SO-102 | 264.217 | 0.000314112 | 0.0166012 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1410 | 1400 | 1400 | 1390 | 1400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5392.3 | PP–RCT S4 | 20 | 223 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 264.217 | ø20 | 15.4 | TR10.03.0338 | 0338 | no | WS_Teplá vnitřní 83 | 0
13000748 | 2.NP_SO-102 | 1870.14 | 0.000804127 | 0.188007 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2416 | 2400 | 2400 | 2384 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | 6387.6 | PP–RCT S4 | 32 | 267 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1870.14 | ø32 | 24.8 | TR10.03.0339 | 0339 | no | WS_Cirkulace vnitřní 9 | 0
13001416 | 4.NP_SO-102 | 52.5375 | 0.000314112 | 0.00330103 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1180 | 1170 | 1170 | 1160 | 1170 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 13162.3 | PP–RCT S4 | 20 | 49 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 52.5375 | ø20 | 15.4 | TR10.03.0340 | 0340 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13001600 | 4.NP_SO-102 | 205.069 | 0.000314112 | 0.0128848 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1392.53 | 1187.46 | 1392.53 | 1187.46 | 1392.53 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 13187.5 | PP–RCT S4 | 20 | 49 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 205.069 | ø20 | 15.4 | TR10.03.0341 | 0341 | no | WS_"Jiný typ" studená vnitřní 1
13001613 | 4.NP_SO-102 | 1319 | 0.0004908 | 0.103594 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 1439.16 | 1426.66 | 1426.66 | 1414.16 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 13417 | PP–RCT S4 | 25 | 40 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1319 | ø25 | 19.4 | TR10.03.0342 | 0342 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13001967 | 1.NP_SO-102 | 1883.32 | 0.00125645 | 0.236666 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 1.NP_SO-102 | 3166.66 | 3166.66 | 1283.34 | 1283.34 | 1283.34 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 1283.34 | PP–RCT S4 | 40 | 107 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1883.32 | ø40 | 31 | TR10.03.0343 | 0343 | yes | WS_Teplá vnitřní 83
13003331 | 3.NP_SO-102 | 2763.98 | 0.0004908 | 0.217083 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11340.3 | PP–RCT S4 | 25 | 461 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2763.98 | ø25 | 19.4 | TR10.03.0344 | 0344 | yes | WS_Studená vnitřní 134 | 0
13003335 | 3.NP_SO-102 | 733.012 | 0.0004908 | 0.0575707 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11340.3 | PP–RCT S4 | 25 | 464 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 733.012 | ø25 | 19.4 | TR10.03.0345 | 0345 | no | WS_Studená vnitřní 134 | 0
13003337 | 3.NP_SO-102 | 300.882 | 0.000804127 | 0.0302479 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11337.6 | PP–RCT S4 | 32 | 452 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 300.882 | ø32 | 24.8 | TR10.03.0346 | 0346 | yes | WS_Studená vnitřní 134 | 0
13003341 | 3.NP_SO-102 | 381.975 | 0.000804127 | 0.0384003 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11337.6 | PP–RCT S4 | 32 | 223 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 381.975 | ø32 | 24.8 | TR10.03.0347 | 0347 | yes | WS_Studená vnitřní 134 | 0
13003355 | 3.NP_SO-102 | 6042.54 | 0.000314112 | 0.379664 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11342.3 | PP–RCT S4 | 20 | 59 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6042.54 | ø20 | 15.4 | TR10.03.0348 | 0348 | no | WS_Studená vnitřní 134 | 0
13003365 | 3.NP_SO-102 | 2713.64 | 0.000314112 | 0.170503 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3311.11 | 3311.11 | 597.462 | 597.462 | 597.462 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 8597.46 | PP–RCT S4 | 20 | 193 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2713.64 | ø20 | 15.4 | TR10.03.0349 | 0349 | no | WS_Studená vnitřní 134
13003413 | 3.NP_SO-102 | 465.706 | 0.0004908 | 0.0365765 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3212.5 | 3200 | 3200 | 3187.5 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11190.3 | PP–RCT S4 | 25 | 58 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 465.706 | ø25 | 19.4 | TR10.03.0350 | 0350 | yes | WS_Teplá vnitřní 83 | 0
13003421 | 3.NP_SO-102 | 1977.17 | 0.0004908 | 0.155287 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3379.16 | 3366.66 | 3366.66 | 3354.16 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11357 | PP–RCT S4 | 25 | 58 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1977.17 | ø25 | 19.4 | TR10.03.0351 | 0351 | yes | WS_Teplá vnitřní 83 | 0
13003423 | 3.NP_SO-102 | 125.387 | 0.0004908 | 0.00984791 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3346.02 | 3346.02 | 3220.64 | 3220.64 | 3220.64 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11220.6 | PP–RCT S4 | 25 | 58 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 125.387 | ø25 | 19.4 | TR10.03.0352 | 0352 | yes | WS_Teplá vnitřní 83
13003445 | 3.NP_SO-102 | 805.869 | 0.000314112 | 0.0506342 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3376.66 | 3366.66 | 3366.66 | 3356.66 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11359 | PP–RCT S4 | 20 | 163 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 805.869 | ø20 | 15.4 | TR10.03.0353 | 0353 | no | WS_Teplá vnitřní 83 | 0
13003455 | 3.NP_SO-102 | 234.09 | 0.000804127 | 0.0235333 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3406.19 | 3390.19 | 3390.19 | 3374.19 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11377.8 | PP–RCT S4 | 32 | 136 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 234.09 | ø32 | 24.8 | TR10.03.0354 | 0354 | yes | WS_Teplá vnitřní 83 | 0
13003467 | 3.NP_SO-102 | 6187.54 | 0.000314112 | 0.388774 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3400.19 | 3390.19 | 3390.19 | 3380.19 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11382.5 | PP–RCT S4 | 20 | 142 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6187.54 | ø20 | 15.4 | TR10.03.0355 | 0355 | no | WS_Teplá vnitřní 83 | 0
13003475 | 3.NP_SO-102 | 70.0455 | 0.000314112 | 0.00440109 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 590 | 580 | 580 | 570 | 580 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 8572.3 | PP–RCT S4 | 20 | 380 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 70.0455 | ø20 | 15.4 | TR10.03.0356 | 0356 | no | WS_Teplá vnitřní 83 | 0
13003477 | 3.NP_SO-102 | 2753.83 | 0.000314112 | 0.173029 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3351.3 | 3351.3 | 597.462 | 597.462 | 597.462 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 8597.46 | PP–RCT S4 | 20 | 380 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2753.83 | ø20 | 15.4 | TR10.03.0357 | 0357 | no | WS_Teplá vnitřní 83
13003551 | 2.NP_SO-102 | 2044.27 | 0.0004908 | 0.160557 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3352.5 | 3340 | 3340 | 3327.5 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7330.3 | PP–RCT S4 | 25 | 196 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2044.27 | ø25 | 19.4 | TR10.03.0358 | 0358 | yes | WS_Studená vnitřní 134 | 0
13003555 | 2.NP_SO-102 | 1586.29 | 0.0004908 | 0.124587 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3352.5 | 3340 | 3340 | 3327.5 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7330.3 | PP–RCT S4 | 25 | 200 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1586.29 | ø25 | 19.4 | TR10.03.0359 | 0359 | no | WS_Studená vnitřní 134 | 0
13003557 | 2.NP_SO-102 | 300.882 | 0.000804127 | 0.0302479 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3356 | 3340 | 3340 | 3324 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7327.6 | PP–RCT S4 | 32 | 446 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 300.882 | ø32 | 24.8 | TR10.03.0360 | 0360 | yes | WS_Studená vnitřní 134 | 0
13003571 | 2.NP_SO-102 | 5021.72 | 0.0004908 | 0.394405 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3352.5 | 3340 | 3340 | 3327.5 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7330.3 | PP–RCT S4 | 25 | 50 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5021.72 | ø25 | 19.4 | TR10.03.0361 | 0361 | yes | WS_Studená vnitřní 134 | 0
13003585 | 2.NP_SO-102 | 2703.64 | 0.000314112 | 0.169875 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3301.11 | 597.462 | 3301.11 | 597.462 | 3301.11 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 4597.46 | PP–RCT S4 | 20 | 451 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2703.64 | ø20 | 15.4 | TR10.03.0362 | 0362 | no | WS_Studená vnitřní 134
13003587 | 2.NP_SO-102 | 2623.39 | 0.0004908 | 0.20604 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3352.5 | 3340 | 3340 | 3327.5 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7330.3 | PP–RCT S4 | 25 | 50 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2623.39 | ø25 | 19.4 | TR10.03.0363 | 0363 | yes | WS_Studená vnitřní 134 | 0
13003590 | 2.NP_SO-102 | 77.0984 | 0.000804127 | 0.00775077 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3356 | 3340 | 3340 | 3324 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7327.6 | PP–RCT S4 | 32 | 446 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 77.0984 | ø32 | 24.8 | TR10.03.0364 | 0364 | yes | WS_Studená vnitřní 134 | 0
13003633 | 2.NP_SO-102 | 465.706 | 0.0004908 | 0.0365765 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3212.5 | 3200 | 3200 | 3187.5 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7190.3 | PP–RCT S4 | 25 | 167 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 465.706 | ø25 | 19.4 | TR10.03.0365 | 0365 | yes | WS_Teplá vnitřní 83 | 0
13003638 | 2.NP_SO-102 | 73.325 | 0.00125645 | 0.00921429 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 2.NP_SO-102 | 3306.66 | 3233.34 | 3306.66 | 3233.34 | 3306.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7233.34 | PP–RCT S4 | 40 | 332 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 73.325 | ø40 | 31 | TR10.03.0366 | 0366 | yes | WS_Teplá vnitřní 83
13003641 | 2.NP_SO-102 | 1933.27 | 0.0004908 | 0.151839 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3379.16 | 3366.66 | 3366.66 | 3354.16 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7356.96 | PP–RCT S4 | 25 | 167 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1933.27 | ø25 | 19.4 | TR10.03.0367 | 0367 | yes | WS_Teplá vnitřní 83 | 0
13003643 | 2.NP_SO-102 | 125.387 | 0.0004908 | 0.00984791 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3346.02 | 3346.02 | 3220.64 | 3220.64 | 3220.64 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7220.64 | PP–RCT S4 | 25 | 167 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 125.387 | ø25 | 19.4 | TR10.03.0368 | 0368 | yes | WS_Teplá vnitřní 83
13003665 | 2.NP_SO-102 | 1666.29 | 0.0004908 | 0.13087 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3379.16 | 3366.66 | 3366.66 | 3354.16 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7356.96 | PP–RCT S4 | 25 | 171 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1666.29 | ø25 | 19.4 | TR10.03.0369 | 0369 | no | WS_Teplá vnitřní 83 | 0
13003668 | 2.NP_SO-102 | 6023.9 | 0.0004908 | 0.473116 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3379.16 | 3366.66 | 3366.66 | 3354.16 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7356.96 | PP–RCT S4 | 25 | 171 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6023.9 | ø25 | 19.4 | TR10.03.0370 | 0370 | yes | WS_Teplá vnitřní 83 | 0
13003675 | 2.NP_SO-102 | 234.09 | 0.000804127 | 0.0235333 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3356 | 3340 | 3340 | 3324 | 3340 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7327.6 | PP–RCT S4 | 32 | 74 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 234.09 | ø32 | 24.8 | TR10.03.0371 | 0371 | yes | WS_Teplá vnitřní 83 | 0
13003679 | 2.NP_SO-102 | 2461.58 | 0.0004908 | 0.193332 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3352.5 | 3340 | 3340 | 3327.5 | 3340 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7330.3 | PP–RCT S4 | 25 | 447 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2461.58 | ø25 | 19.4 | TR10.03.0372 | 0372 | yes | WS_Teplá vnitřní 83 | 0
13003683 | 2.NP_SO-102 | 5559.4 | 0.0004908 | 0.436634 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3352.5 | 3340 | 3340 | 3327.5 | 3340 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7330.3 | PP–RCT S4 | 25 | 447 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5559.4 | ø25 | 19.4 | TR10.03.0373 | 0373 | yes | WS_Teplá vnitřní 83 | 0
13003687 | 2.NP_SO-102 | 3185.08 | 0.0004908 | 0.250155 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3352.5 | 3340 | 3340 | 3327.5 | 3340 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7330.3 | PP–RCT S4 | 25 | 447 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3185.08 | ø25 | 19.4 | TR10.03.0374 | 0374 | no | WS_Teplá vnitřní 83 | 0
13003695 | 2.NP_SO-102 | 70.0455 | 0.000314112 | 0.00440109 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 590 | 580 | 580 | 570 | 580 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 4572.3 | PP–RCT S4 | 20 | 134 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 70.0455 | ø20 | 15.4 | TR10.03.0375 | 0375 | no | WS_Teplá vnitřní 83 | 0
13003697 | 2.NP_SO-102 | 2703.64 | 0.000314112 | 0.169875 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3301.11 | 597.462 | 3301.11 | 597.462 | 3301.11 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 4597.46 | PP–RCT S4 | 20 | 134 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2703.64 | ø20 | 15.4 | TR10.03.0376 | 0376 | no | WS_Teplá vnitřní 83
13003700 | 2.NP_SO-102 | 169.426 | 0.000804127 | 0.0170326 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3356 | 3340 | 3340 | 3324 | 3340 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7327.6 | PP–RCT S4 | 32 | 74 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 169.426 | ø32 | 24.8 | TR10.03.0377 | 0377 | yes | WS_Teplá vnitřní 83 | 0
13003773 | 1.NP_SO-102 | 690.757 | 0.0004908 | 0.0542519 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3340.3 | PP–RCT S4 | 25 | 209 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 690.757 | ø25 | 19.4 | TR10.03.0378 | 0378 | yes | WS_Studená vnitřní 134 | 0
13003775 | 1.NP_SO-102 | 4362.74 | 0.000314112 | 0.274119 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3342.3 | PP–RCT S4 | 20 | 408 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4362.74 | ø20 | 15.4 | TR10.03.0379 | 0379 | yes | WS_Studená vnitřní 134 | 0
13003777 | 1.NP_SO-102 | 5265.87 | 0.000314112 | 0.330864 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3342.3 | PP–RCT S4 | 20 | 211 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5265.87 | ø20 | 15.4 | TR10.03.0380 | 0380 | no | WS_Studená vnitřní 134 | 0 | Identifikační data - Komentáře: vana ( voda + odpad)
13003779 | 1.NP_SO-102 | 300.882 | 0.000804127 | 0.0302479 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3337.6 | PP–RCT S4 | 32 | 3 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 300.882 | ø32 | 24.8 | TR10.03.0381 | 0381 | yes | WS_Studená vnitřní 134 | 0
13003789 | 1.NP_SO-102 | 120.722 | 0.000804127 | 0.0121363 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3337.6 | PP–RCT S4 | 32 | 3 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 120.722 | ø32 | 24.8 | TR10.03.0382 | 0382 | yes | WS_Studená vnitřní 134 | 0
13003793 | 1.NP_SO-102 | 5485.06 | 0.0004908 | 0.430796 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3340.3 | PP–RCT S4 | 25 | 440 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5485.06 | ø25 | 19.4 | TR10.03.0383 | 0383 | yes | WS_Studená vnitřní 134 | 0
13003797 | 1.NP_SO-102 | 8309.71 | 0.0004908 | 0.652643 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3340.3 | PP–RCT S4 | 25 | 47 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 8309.71 | ø25 | 19.4 | TR10.03.0384 | 0384 | no | WS_Studená vnitřní 134 | 0
13003807 | 1.NP_SO-102 | 2713.64 | 0.000314112 | 0.170503 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3311.11 | 597.462 | 3311.11 | 597.463 | 3311.11 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 597.463 | PP–RCT S4 | 20 | 404 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2713.64 | ø20 | 15.4 | TR10.03.0385 | 0385 | no | WS_Studená vnitřní 134
13003809 | 1.NP_SO-102 | 2427.8 | 0.0004908 | 0.190679 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3340.3 | PP–RCT S4 | 25 | 440 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2427.8 | ø25 | 19.4 | TR10.03.0386 | 0386 | yes | WS_Studená vnitřní 134 | 0
13003812 | 1.NP_SO-102 | 90.0161 | 0.000804127 | 0.00904941 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3337.6 | PP–RCT S4 | 32 | 3 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 90.0161 | ø32 | 24.8 | TR10.03.0387 | 0387 | yes | WS_Studená vnitřní 134 | 0
13003822 | 1.NP_SO-102 | 1052.38 | 0.0004908 | 0.0826533 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3340.3 | PP–RCT S4 | 25 | 209 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1052.38 | ø25 | 19.4 | TR10.03.0388 | 0388 | yes | WS_Studená vnitřní 134 | 0
13003855 | 1.NP_SO-102 | 469.675 | 0.00125645 | 0.0590211 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 1.NP_SO-102 | 3220 | 3200 | 3200 | 3180 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3184.5 | PP–RCT S4 | 40 | 90 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 469.675 | ø40 | 31 | TR10.03.0389 | 0389 | yes | WS_Teplá vnitřní 83 | 0
13003860 | 1.NP_SO-102 | 123.516 | 0.00125645 | 0.0155214 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 1.NP_SO-102 | 3356.85 | 3356.85 | 3233.34 | 3233.34 | 3233.34 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3233.34 | PP–RCT S4 | 40 | 87 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 123.516 | ø40 | 31 | TR10.03.0390 | 0390 | yes | WS_Teplá vnitřní 83
13003863 | 1.NP_SO-102 | 1906.57 | 0.0004908 | 0.149742 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3379.16 | 3366.66 | 3366.66 | 3354.16 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3356.96 | PP–RCT S4 | 25 | 180 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1906.57 | ø25 | 19.4 | TR10.03.0391 | 0391 | yes | WS_Teplá vnitřní 83 | 0
13003865 | 1.NP_SO-102 | 108.719 | 0.0004908 | 0.00853875 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3346.03 | 3346.02 | 3237.31 | 3237.31 | 3237.31 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3237.31 | PP–RCT S4 | 25 | 180 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 108.719 | ø25 | 19.4 | TR10.03.0392 | 0392 | yes | WS_Teplá vnitřní 83
13003871 | 1.NP_SO-102 | 4580.77 | 0.000314112 | 0.287818 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3376.66 | 3366.66 | 3366.66 | 3356.66 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3358.96 | PP–RCT S4 | 20 | 371 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4580.77 | ø20 | 15.4 | TR10.03.0393 | 0393 | yes | WS_Teplá vnitřní 83 | 0
13003887 | 1.NP_SO-102 | 5165.87 | 0.000314112 | 0.324581 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3376.66 | 3366.66 | 3366.66 | 3356.66 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3358.96 | PP–RCT S4 | 20 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5165.87 | ø20 | 15.4 | TR10.03.0394 | 0394 | no | WS_Teplá vnitřní 83 | 0
13003890 | 1.NP_SO-102 | 892.375 | 0.0004908 | 0.070087 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3379.16 | 3366.66 | 3366.66 | 3354.16 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3356.96 | PP–RCT S4 | 25 | 180 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 892.375 | ø25 | 19.4 | TR10.03.0395 | 0395 | yes | WS_Teplá vnitřní 83 | 0
13003897 | 1.NP_SO-102 | 234.09 | 0.000804127 | 0.0235333 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3406.19 | 3390.19 | 3390.19 | 3374.19 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3377.79 | PP–RCT S4 | 32 | 131 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 234.09 | ø32 | 24.8 | TR10.03.0396 | 0396 | yes | WS_Teplá vnitřní 83 | 0
13003901 | 1.NP_SO-102 | 2250.73 | 0.0004908 | 0.176772 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3402.69 | 3390.19 | 3390.19 | 3377.69 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3380.49 | PP–RCT S4 | 25 | 82 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2250.73 | ø25 | 19.4 | TR10.03.0397 | 0397 | yes | WS_Teplá vnitřní 83 | 0
13003905 | 1.NP_SO-102 | 5360.83 | 0.0004908 | 0.421039 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3402.69 | 3390.19 | 3390.19 | 3377.69 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3380.49 | PP–RCT S4 | 25 | 82 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5360.83 | ø25 | 19.4 | TR10.03.0398 | 0398 | yes | WS_Teplá vnitřní 83 | 0
13003909 | 1.NP_SO-102 | 8343.99 | 0.0004908 | 0.655335 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3402.69 | 3390.19 | 3390.19 | 3377.69 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3380.49 | PP–RCT S4 | 25 | 82 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 8343.99 | ø25 | 19.4 | TR10.03.0399 | 0399 | no | WS_Teplá vnitřní 83 | 0
13003917 | 1.NP_SO-102 | 70.0455 | 0.000314112 | 0.00440109 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 590 | 580 | 580 | 570 | 580 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 572.3 | PP–RCT S4 | 20 | 84 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 70.0455 | ø20 | 15.4 | TR10.03.0400 | 0400 | no | WS_Teplá vnitřní 83 | 0
13003919 | 1.NP_SO-102 | 2753.83 | 0.000314112 | 0.173029 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3351.3 | 597.462 | 3351.3 | 597.463 | 3351.3 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 597.463 | PP–RCT S4 | 20 | 84 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2753.83 | ø20 | 15.4 | TR10.03.0401 | 0401 | no | WS_Teplá vnitřní 83
13003922 | 1.NP_SO-102 | 190.016 | 0.000804127 | 0.0191025 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3406.19 | 3390.19 | 3390.19 | 3374.19 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3377.79 | PP–RCT S4 | 32 | 131 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 190.016 | ø32 | 24.8 | TR10.03.0402 | 0402 | yes | WS_Teplá vnitřní 83 | 0
13004409 | 3.NP_SO-102 | 1959.36 | 0.0004908 | 0.153888 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11340.3 | PP–RCT S4 | 25 | 49 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1959.36 | ø25 | 19.4 | TR10.03.0403 | 0403 | no | WS_Studená vnitřní 134 | 0
13004420 | 3.NP_SO-102 | 6098.17 | 0.0004908 | 0.478949 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11340.3 | PP–RCT S4 | 25 | 49 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6098.17 | ø25 | 19.4 | TR10.03.0404 | 0404 | yes | WS_Studená vnitřní 134 | 0
13004435 | 3.NP_SO-102 | 2000.15 | 0.0004908 | 0.157091 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11340.3 | PP–RCT S4 | 25 | 158 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2000.15 | ø25 | 19.4 | TR10.03.0405 | 0405 | no | WS_Teplá vnitřní 83 | 0
13004454 | 3.NP_SO-102 | 6083.41 | 0.0004908 | 0.47779 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3379.16 | 3366.66 | 3366.66 | 3354.16 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11357 | PP–RCT S4 | 25 | 158 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6083.41 | ø25 | 19.4 | TR10.03.0406 | 0406 | yes | WS_Teplá vnitřní 83 | 0
13004527 | 3.NP_SO-102 | 337.537 | 0.000314112 | 0.0212081 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 9242.3 | PP–RCT S4 | 20 | 460 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 337.537 | ø20 | 15.4 | TR10.03.0407 | 0407 | no | WS_Studená vnitřní 134 | 0
13004547 | 3.NP_SO-102 | 417.537 | 0.000314112 | 0.0262347 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 9242.3 | PP–RCT S4 | 20 | 144 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 417.537 | ø20 | 15.4 | TR10.03.0408 | 0408 | no | WS_Teplá vnitřní 83 | 0
13004671 | 3.NP_SO-102 | 2098.92 | 0.000314112 | 0.131879 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3366.38 | 1267.46 | 3366.38 | 1267.46 | 3366.38 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 9267.46 | PP–RCT S4 | 20 | 144 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2098.92 | ø20 | 15.4 | TR10.03.0409 | 0409 | no | WS_Teplá vnitřní 83
13004699 | 3.NP_SO-102 | 2058.72 | 0.000314112 | 0.129354 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3326.19 | 1267.46 | 3326.19 | 1267.46 | 3326.19 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 9267.46 | PP–RCT S4 | 20 | 460 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2058.72 | ø20 | 15.4 | TR10.03.0410 | 0410 | no | WS_Studená vnitřní 134
13004770 | 3.NP_SO-102 | 422.537 | 0.000314112 | 0.0265488 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 9242.3 | PP–RCT S4 | 20 | 459 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 422.537 | ø20 | 15.4 | TR10.03.0411 | 0411 | no | WS_Studená vnitřní 134 | 0
13004834 | 3.NP_SO-102 | 2058.72 | 0.000314112 | 0.129354 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3326.19 | 1267.46 | 3326.19 | 1267.46 | 3326.19 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 9267.46 | PP–RCT S4 | 20 | 459 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2058.72 | ø20 | 15.4 | TR10.03.0412 | 0412 | no | WS_Studená vnitřní 134
13004837 | 3.NP_SO-102 | 1982.96 | 0.0004908 | 0.155741 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11340.3 | PP–RCT S4 | 25 | 457 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1982.96 | ø25 | 19.4 | TR10.03.0413 | 0413 | no | WS_Studená vnitřní 134 | 0
