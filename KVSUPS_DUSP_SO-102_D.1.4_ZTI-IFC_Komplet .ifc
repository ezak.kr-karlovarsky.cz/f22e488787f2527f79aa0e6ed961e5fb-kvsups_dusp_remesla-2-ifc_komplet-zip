Properties of the parts of a building model (IFC4), part 45 of 60

# IfcPipeSegment: Typy trubek:PP-RCT (1338)
Name (Typy trubek:PP-RCT:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Instalační jednotky = Reynoldsovo číslo = Třecí faktor = Tření = Průtok (m3/s) = Rychlost (m/s) = Tlaková ztráta (Pa) | Stav průtoku | Doplňkový průtok (m3/s) | Relativní drsnost | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) | Spodní výška (mm) | Střední výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Délka (mm) | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
12956458 | 1.NP_SO-102 | 2306.8 | 0.000314112 | 0.14494 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 1242.3 | PP–RCT S4 | 20 | 54 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2306.8 | ø20 | 15.4 | TR10.03.0130 | 0130 | no | WS_Studená vnitřní 134 | 0
12956467 | 1.NP_SO-102 | 6922.55 | 0.0004908 | 0.543696 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3340.3 | PP–RCT S4 | 25 | 1 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6922.55 | ø25 | 19.4 | TR10.03.0131 | 0131 | yes | WS_Studená vnitřní 134 | 0
12956501 | 1.NP_SO-102 | 7003.26 | 0.0004908 | 0.550035 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3332.5 | 3320 | 3320 | 3307.5 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3310.3 | PP–RCT S4 | 25 | 83 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 7003.26 | ø25 | 19.4 | TR10.03.0132 | 0132 | yes | WS_Teplá vnitřní 83 | 0
12956504 | 1.NP_SO-102 | 443.145 | 0.000804127 | 0.0445498 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3216 | 3200 | 3200 | 3184 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3187.6 | PP–RCT S4 | 32 | 65 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 443.145 | ø32 | 24.8 | TR10.03.0133 | 0133 | yes | WS_Teplá vnitřní 83 | 0
12956506 | 1.NP_SO-102 | 72.375 | 0.000804127 | 0.00727593 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3296.19 | 3223.81 | 3296.19 | 3223.81 | 3296.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3223.81 | PP–RCT S4 | 32 | 65 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 72.375 | ø32 | 24.8 | TR10.03.0134 | 0134 | yes | WS_Teplá vnitřní 83
12956522 | 1.NP_SO-102 | 2098.73 | 0.0004908 | 0.164833 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3340.3 | PP–RCT S4 | 25 | 1 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2098.73 | ø25 | 19.4 | TR10.03.0135 | 0135 | no | WS_Studená vnitřní 134 | 0
12956526 | 1.NP_SO-102 | 2053.72 | 0.0004908 | 0.161299 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3332.5 | 3320 | 3320 | 3307.5 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3310.3 | PP–RCT S4 | 25 | 83 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2053.72 | ø25 | 19.4 | TR10.03.0136 | 0136 | no | WS_Teplá vnitřní 83 | 0
12956532 | 1.NP_SO-102 | 767.13 | 0.0004908 | 0.0602502 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3340.3 | PP–RCT S4 | 25 | 86 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 767.13 | ø25 | 19.4 | TR10.03.0137 | 0137 | no | WS_Studená vnitřní 134 | 0
12956536 | 1.NP_SO-102 | 778.725 | 0.0004908 | 0.0611609 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3332.5 | 3320 | 3320 | 3307.5 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3310.3 | PP–RCT S4 | 25 | 70 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 778.725 | ø25 | 19.4 | TR10.03.0138 | 0138 | no | WS_Teplá vnitřní 83 | 0
12958662 | 4.NP_SO-102 | 1783.69 | 0.0004908 | 0.14009 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3332.5 | 3320 | 3320 | 3307.5 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15310.3 | PP–RCT S4 | 25 | 36 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1783.69 | ø25 | 19.4 | TR10.03.0139 | 0139 | yes | WS_Teplá vnitřní 83 | 0
12958680 | 4.NP_SO-102 | 1931.28 | 0.0004908 | 0.151682 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15340.3 | PP–RCT S4 | 25 | 48 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1931.28 | ø25 | 19.4 | TR10.03.0140 | 0140 | yes | WS_Studená vnitřní 134 | 0
12963601 | 4.NP_SO-102 | 367.498 | 0.000314112 | 0.0230906 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1634.96 | 1634.96 | 1267.46 | 1267.46 | 1267.46 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 13267.5 | PP–RCT S4 | 20 | 58 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 367.498 | ø20 | 15.4 | TR10.03.0141 | 0141 | no | WS_Studená vnitřní 134
12965090 | 4.NP_SO-102 | 4865.08 | 0.000314112 | 0.305682 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 13242.3 | PP–RCT S4 | 20 | 119 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4865.08 | ø20 | 15.4 | TR10.03.0142 | 0142 | no | WS_Teplá vnitřní 83 | 0
12965152 | 4.NP_SO-102 | 419.512 | 0.000314112 | 0.0263587 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1686.97 | 1267.46 | 1686.97 | 1267.46 | 1686.97 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 13267.5 | PP–RCT S4 | 20 | 119 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 419.512 | ø20 | 15.4 | TR10.03.0143 | 0143 | no | WS_Teplá vnitřní 83
12965155 | 4.NP_SO-102 | 541.232 | 0.0004908 | 0.0425083 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3332.5 | 3320 | 3320 | 3307.5 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15310.3 | PP–RCT S4 | 25 | 12 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 541.232 | ø25 | 19.4 | TR10.03.0144 | 0144 | yes | WS_Teplá vnitřní 83 | 0
12965204 | 4.NP_SO-102 | 1058.28 | 0.000314112 | 0.0664936 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 13242.3 | PP–RCT S4 | 20 | 119 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1058.28 | ø20 | 15.4 | TR10.03.0145 | 0145 | no | WS_Teplá vnitřní 83 | 0
12965424 | 3.NP_SO-102 | 4865.08 | 0.000314112 | 0.305682 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 9242.3 | PP–RCT S4 | 20 | 390 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4865.08 | ø20 | 15.4 | TR10.03.0146 | 0146 | no | WS_Teplá vnitřní 83 | 0
12965426 | 3.NP_SO-102 | 1758.71 | 0.000314112 | 0.110503 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3315.87 | 3315.87 | 1557.16 | 1557.16 | 1557.16 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 9557.16 | PP–RCT S4 | 20 | 390 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1758.71 | ø20 | 15.4 | TR10.03.0147 | 0147 | no | WS_Teplá vnitřní 83
12965432 | 3.NP_SO-102 | 2482.54 | 0.000314112 | 0.155982 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 9242.3 | PP–RCT S4 | 20 | 390 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2482.54 | ø20 | 15.4 | TR10.03.0148 | 0148 | no | WS_Teplá vnitřní 83 | 0
12965474 | 1.NP_SO-102 | 4865.08 | 0.000314112 | 0.305682 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 1242.3 | PP–RCT S4 | 20 | 112 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4865.08 | ø20 | 15.4 | TR10.03.0149 | 0149 | no | WS_Teplá vnitřní 83 | 0
12965476 | 1.NP_SO-102 | 2013.64 | 0.000314112 | 0.126521 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3281.11 | 3281.11 | 1267.46 | 1267.46 | 1267.46 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 1267.46 | PP–RCT S4 | 20 | 112 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2013.64 | ø20 | 15.4 | TR10.03.0150 | 0150 | no | WS_Teplá vnitřní 83
12965482 | 1.NP_SO-102 | 2242.54 | 0.000314112 | 0.140903 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 1242.3 | PP–RCT S4 | 20 | 112 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2242.54 | ø20 | 15.4 | TR10.03.0151 | 0151 | no | WS_Teplá vnitřní 83 | 0
12965891 | 3.NP_SO-102 | 722.538 | 0.000314112 | 0.0453984 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11342.3 | PP–RCT S4 | 20 | 95 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 722.538 | ø20 | 15.4 | TR10.03.0152 | 0152 | no | WS_Studená vnitřní 134 | 0
12965921 | 3.NP_SO-102 | 642.538 | 0.000314112 | 0.0403718 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11342.3 | PP–RCT S4 | 20 | 47 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 642.537 | ø20 | 15.4 | TR10.03.0153 | 0153 | no | WS_Teplá vnitřní 83 | 0
12965945 | 3.NP_SO-102 | 745.26 | 0.000314112 | 0.046826 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11342.3 | PP–RCT S4 | 20 | 54 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 745.26 | ø20 | 15.4 | TR10.03.0154 | 0154 | no | WS_Teplá vnitřní 83 | 0
12965956 | 3.NP_SO-102 | 338.725 | 0.000314112 | 0.0212827 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11342.3 | PP–RCT S4 | 20 | 54 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 338.725 | ø20 | 15.4 | TR10.03.0155 | 0155 | no | WS_Teplá vnitřní 83 | 0
12965993 | 3.NP_SO-102 | 8169.29 | 0.000314112 | 0.513292 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11342.3 | PP–RCT S4 | 20 | 366 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 8169.29 | ø20 | 15.4 | TR10.03.0156 | 0156 | yes | WS_Teplá vnitřní 83 | 0
12966001 | 3.NP_SO-102 | 5372 | 0.0004908 | 0.421916 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11340.3 | PP–RCT S4 | 25 | 49 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5372 | ø25 | 19.4 | TR10.03.0157 | 0157 | yes | WS_Teplá vnitřní 83 | 0
12966145 | 3.NP_SO-102 | 669.307 | 0.000314112 | 0.0420538 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3330 | 3320 | 3320 | 3310 | 3320 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11312.3 | PP–RCT S4 | 20 | 101 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 669.307 | ø20 | 15.4 | TR10.03.0158 | 0158 | no | WS_Studená vnitřní 134 | 0
12966224 | 3.NP_SO-102 | 15.7161 | 0.0004908 | 0.00123434 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11340.3 | PP–RCT S4 | 25 | 99 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 15.7161 | ø25 | 19.4 | TR10.03.0159 | 0159 | no | WS_Studená vnitřní 134 | 0
12966225 | 3.NP_SO-102 | 15.2833 | 0.000804127 | 0.00153644 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3349.1 | 3326.97 | 3337.78 | 3315.66 | 3337.78 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11318.2 | PP–RCT S4 | 32 | 100 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 15.2833 | ø32 | 24.8 | TR10.03.0160 | 0160 | no | WS_Studená vnitřní 134 | 100
12966229 | 3.NP_SO-102 | 8014.05 | 0.000314112 | 0.503538 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11342.3 | PP–RCT S4 | 20 | 389 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 8014.05 | ø20 | 15.4 | TR10.03.0161 | 0161 | yes | WS_Studená vnitřní 134 | 0
12966412 | 3.NP_SO-102 | 418.725 | 0.000314112 | 0.0263093 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3330 | 3320 | 3320 | 3310 | 3320 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11312.3 | PP–RCT S4 | 20 | 101 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 418.725 | ø20 | 15.4 | TR10.03.0162 | 0162 | no | WS_Studená vnitřní 134 | 0
12966552 | 4.NP_SO-102 | 340.77 | 0.0004908 | 0.026764 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 1262.5 | 1250 | 1250 | 1237.5 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 13240.3 | PP–RCT S4 | 25 | 38 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 340.77 | ø25 | 19.4 | TR10.03.0163 | 0163 | no | WS_Teplá vnitřní 83 | 0
12966561 | 4.NP_SO-102 | 1545 | 0.000314112 | 0.0970752 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 13242.3 | PP–RCT S4 | 20 | 41 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1545 | ø20 | 15.4 | TR10.03.0164 | 0164 | no | WS_Teplá vnitřní 83 | 0
12966622 | 4.NP_SO-102 | 1989.68 | 0.000804127 | 0.200024 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 1219.84 | 1219.84 | -769.837 | -769.837 | -769.837 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11230.2 | PP–RCT S4 | 32 | 105 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1989.68 | ø32 | 24.8 | TR10.03.0165 | 0165 | yes | WS_Teplá vnitřní 83
12966750 | 4.NP_SO-102 | 1544.89 | 0.000314112 | 0.0970686 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3285.87 | 1740.97 | 3285.87 | 1740.97 | 3285.87 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 13741 | PP–RCT S4 | 20 | 119 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1544.89 | ø20 | 15.4 | TR10.03.0166 | 0166 | no | WS_Teplá vnitřní 83
12966893 | 4.NP_SO-102 | 191.43 | 0.0004908 | 0.0150349 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 1512.5 | 1500 | 1500 | 1487.5 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 13490.3 | PP–RCT S4 | 25 | 387 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 191.43 | ø25 | 19.4 | TR10.03.0167 | 0167 | no | WS_Studená vnitřní 134 | 0
12966911 | 4.NP_SO-102 | 225.186 | 0.0004908 | 0.0176861 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 1262.5 | 1250 | 1250 | 1237.5 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 13240.3 | PP–RCT S4 | 25 | 38 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 225.186 | ø25 | 19.4 | TR10.03.0168 | 0168 | no | WS_Teplá vnitřní 83 | 0
12967160 | 3.NP_SO-102 | 336.008 | 0.0004908 | 0.02639 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 1262.5 | 1250 | 1250 | 1237.5 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 9240.3 | PP–RCT S4 | 25 | 114 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 336.008 | ø25 | 19.4 | TR10.03.0169 | 0169 | no | WS_Teplá vnitřní 83 | 0
12967162 | 3.NP_SO-102 | 1718.41 | 0.000314112 | 0.107971 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 9242.3 | PP–RCT S4 | 20 | 24 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1718.41 | ø20 | 15.4 | TR10.03.0170 | 0170 | no | WS_Teplá vnitřní 83 | 0
12967167 | 3.NP_SO-102 | 130.186 | 0.0004908 | 0.0102248 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 1262.5 | 1250 | 1250 | 1237.5 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 9240.3 | PP–RCT S4 | 25 | 114 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 130.186 | ø25 | 19.4 | TR10.03.0171 | 0171 | no | WS_Teplá vnitřní 83 | 0
12967208 | 1.NP_SO-102 | 336.008 | 0.0004908 | 0.02639 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 1262.5 | 1250 | 1250 | 1237.5 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 1240.3 | PP–RCT S4 | 25 | 62 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 336.008 | ø25 | 19.4 | TR10.03.0172 | 0172 | no | WS_Teplá vnitřní 83 | 0
12967210 | 1.NP_SO-102 | 1616.27 | 0.0004908 | 0.126941 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 1262.5 | 1250 | 1250 | 1237.5 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 1240.3 | PP–RCT S4 | 25 | 64 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1616.27 | ø25 | 19.4 | TR10.03.0173 | 0173 | no | WS_Teplá vnitřní 83 | 0
12967215 | 1.NP_SO-102 | 285.186 | 0.0004908 | 0.0223985 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 1262.5 | 1250 | 1250 | 1237.5 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 1240.3 | PP–RCT S4 | 25 | 62 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 285.186 | ø25 | 19.4 | TR10.03.0174 | 0174 | no | WS_Teplá vnitřní 83 | 0
12967251 | 3.NP_SO-102 | 38.8605 | 0.0004908 | 0.0030521 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 1512.5 | 1500 | 1500 | 1487.5 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 9490.3 | PP–RCT S4 | 25 | 444 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 38.8605 | ø25 | 19.4 | TR10.03.0175 | 0175 | no | WS_Studená vnitřní 134 | 0
12967453 | 3.NP_SO-102 | 1923.73 | 0.0004908 | 0.151089 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11340.3 | PP–RCT S4 | 25 | 44 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1923.73 | ø25 | 19.4 | TR10.03.0176 | 0176 | yes | WS_Teplá vnitřní 83 | 0
12967543 | 3.NP_SO-102 | 2030.64 | 0.0004908 | 0.159486 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11340.3 | PP–RCT S4 | 25 | 93 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2030.64 | ø25 | 19.4 | TR10.03.0177 | 0177 | yes | WS_Studená vnitřní 134 | 0
12967602 | 3.NP_SO-102 | 250.206 | 0.000804127 | 0.0251535 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11337.6 | PP–RCT S4 | 32 | 42 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 250.206 | ø32 | 24.8 | TR10.03.0178 | 0178 | yes | WS_Teplá vnitřní 83 | 0
12967616 | 3.NP_SO-102 | 418.651 | 0.0004908 | 0.0328808 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11340.3 | PP–RCT S4 | 25 | 44 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 418.651 | ø25 | 19.4 | TR10.03.0179 | 0179 | yes | WS_Teplá vnitřní 83 | 0
12967643 | 3.NP_SO-102 | 235.7 | 0.000314112 | 0.0148095 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1503.16 | 1503.16 | 1267.46 | 1267.46 | 1267.46 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 9267.46 | PP–RCT S4 | 20 | 390 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 235.7 | ø20 | 15.4 | TR10.03.0180 | 0180 | no | WS_Teplá vnitřní 83
12967659 | 3.NP_SO-102 | 232.525 | 0.0004908 | 0.0182625 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 1503.16 | 1503.16 | 1270.64 | 1270.64 | 1270.64 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 9270.64 | PP–RCT S4 | 25 | 104 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 232.525 | ø25 | 19.4 | TR10.03.0181 | 0181 | no | WS_Studená vnitřní 134
12968203 | 1.NP_SO-102 | 1889.68 | 0.00125645 | 0.237464 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 1.NP_SO-102 | 1216.66 | -673.013 | 1216.66 | -673.013 | 1216.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -673.012 | PP–RCT S4 | 40 | 352 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1889.68 | ø40 | 31 | TR10.03.0182 | 0182 | yes | WS_Teplá vnitřní 83
12969021 | 3.NP_SO-102 | 1876.18 | 0.000804127 | 0.188614 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3169.84 | 3169.84 | 1293.66 | 1293.66 | 1293.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 9293.66 | PP–RCT S4 | 32 | 88 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1876.18 | ø32 | 24.8 | TR10.03.0183 | 0183 | yes | WS_Teplá vnitřní 83
12971202 | 2.NP_SO-102 | 902.676 | 0.000314112 | 0.0567168 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1510 | 1500 | 1500 | 1490 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5492.3 | PP–RCT S4 | 20 | 127 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 902.676 | ø20 | 15.4 | TR10.03.0184 | 0184 | no | WS_Studená vnitřní 134 | 0
12971204 | 2.NP_SO-102 | 68.4063 | 0.000314112 | 0.00429809 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1210 | 1200 | 1200 | 1190 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5192.3 | PP–RCT S4 | 20 | 26 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 68.4063 | ø20 | 15.4 | TR10.03.0185 | 0185 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
12971206 | 2.NP_SO-102 | 4108.28 | 0.000314112 | 0.258131 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1210 | 1200 | 1200 | 1190 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5192.3 | PP–RCT S4 | 20 | 26 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4108.28 | ø20 | 15.4 | TR10.03.0186 | 0186 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12971210 | 2.NP_SO-102 | 454.701 | 0.0004908 | 0.0357122 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 1512.5 | 1500 | 1500 | 1487.5 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5490.3 | PP–RCT S4 | 25 | 390 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 454.701 | ø25 | 19.4 | TR10.03.0187 | 0187 | no | WS_Studená vnitřní 134 | 0
12971212 | 2.NP_SO-102 | 5014.76 | 0.000314112 | 0.315086 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5242.3 | PP–RCT S4 | 20 | 60 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5014.76 | ø20 | 15.4 | TR10.03.0188 | 0188 | no | WS_Studená vnitřní 134 | 0
12971214 | 2.NP_SO-102 | 354.392 | 0.0004908 | 0.0278339 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7340.3 | PP–RCT S4 | 25 | 375 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 354.392 | ø25 | 19.4 | TR10.03.0189 | 0189 | yes | WS_Studená vnitřní 134 | 0
12971216 | 2.NP_SO-102 | 846.797 | 0.000314112 | 0.0532058 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5242.3 | PP–RCT S4 | 20 | 60 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 846.797 | ø20 | 15.4 | TR10.03.0190 | 0190 | no | WS_Studená vnitřní 134 | 0
12971220 | 2.NP_SO-102 | 2347.71 | 0.000314112 | 0.147511 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3330 | 3320 | 3320 | 3310 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7312.3 | PP–RCT S4 | 20 | 363 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2347.71 | ø20 | 15.4 | TR10.03.0191 | 0191 | yes | WS_Teplá vnitřní 83 | 0
12971223 | 2.NP_SO-102 | 5555.81 | 0.0004908 | 0.436352 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7340.3 | PP–RCT S4 | 25 | 53 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5555.81 | ø25 | 19.4 | TR10.03.0192 | 0192 | yes | WS_Studená vnitřní 134 | 0
12971228 | 2.NP_SO-102 | 1751.56 | 0.000314112 | 0.110054 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3315.87 | 3315.87 | 1564.31 | 1564.31 | 1564.31 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5564.31 | PP–RCT S4 | 20 | 62 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1751.56 | ø20 | 15.4 | TR10.03.0193 | 0193 | no | WS_Studená vnitřní 134 | Identifikační data - Komentáře: UMÍSTĚNO NA STOUPAČCE, V REVIZNÍCH DVÍŘKÁCH
12971234 | 2.NP_SO-102 | 124.38 | 0.000804127 | 0.0125041 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7337.6 | PP–RCT S4 | 32 | 373 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 124.38 | ø32 | 24.8 | TR10.03.0194 | 0194 | yes | WS_Studená vnitřní 134 | 0
12971242 | 2.NP_SO-102 | 443.145 | 0.000804127 | 0.0445498 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3216 | 3200 | 3200 | 3184 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7187.6 | PP–RCT S4 | 32 | 361 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 443.145 | ø32 | 24.8 | TR10.03.0195 | 0195 | yes | WS_Teplá vnitřní 83 | 0
12971244 | 2.NP_SO-102 | 72.375 | 0.000804127 | 0.00727593 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3296.19 | 3223.81 | 3296.19 | 3223.81 | 3296.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7223.81 | PP–RCT S4 | 32 | 361 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 72.375 | ø32 | 24.8 | TR10.03.0196 | 0196 | yes | WS_Teplá vnitřní 83
12971256 | 2.NP_SO-102 | 742.538 | 0.000314112 | 0.046655 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7342.3 | PP–RCT S4 | 20 | 68 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 742.538 | ø20 | 15.4 | TR10.03.0197 | 0197 | no | WS_Studená vnitřní 134 | 0
12971260 | 2.NP_SO-102 | 837.538 | 0.000314112 | 0.052624 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3330 | 3320 | 3320 | 3310 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7312.3 | PP–RCT S4 | 20 | 52 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 837.538 | ø20 | 15.4 | TR10.03.0198 | 0198 | no | WS_Teplá vnitřní 83 | 0
12971264 | 2.NP_SO-102 | 2192.48 | 0.000314112 | 0.137757 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7342.3 | PP–RCT S4 | 20 | 377 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2192.48 | ø20 | 15.4 | TR10.03.0199 | 0199 | yes | WS_Studená vnitřní 134 | 0
12971266 | 2.NP_SO-102 | 745.075 | 0.000314112 | 0.0468144 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7342.3 | PP–RCT S4 | 20 | 377 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 745.075 | ø20 | 15.4 | TR10.03.0200 | 0200 | no | WS_Studená vnitřní 134 | 0
12971270 | 2.NP_SO-102 | 765.075 | 0.000314112 | 0.0480711 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3330 | 3320 | 3320 | 3310 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7312.3 | PP–RCT S4 | 20 | 363 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 765.075 | ø20 | 15.4 | TR10.03.0201 | 0201 | no | WS_Teplá vnitřní 83 | 0
12971274 | 2.NP_SO-102 | 4865.08 | 0.000314112 | 0.305682 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5242.3 | PP–RCT S4 | 20 | 365 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4865.08 | ø20 | 15.4 | TR10.03.0202 | 0202 | no | WS_Teplá vnitřní 83 | 0
12971276 | 2.NP_SO-102 | 1728.71 | 0.000314112 | 0.108618 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3285.87 | 3285.87 | 1557.16 | 1557.16 | 1557.16 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5557.16 | PP–RCT S4 | 20 | 365 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1728.71 | ø20 | 15.4 | TR10.03.0203 | 0203 | no | WS_Teplá vnitřní 83
12971278 | 2.NP_SO-102 | 782.538 | 0.000314112 | 0.0491683 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5242.3 | PP–RCT S4 | 20 | 365 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 782.538 | ø20 | 15.4 | TR10.03.0204 | 0204 | no | WS_Teplá vnitřní 83 | 0
12971282 | 2.NP_SO-102 | 722.538 | 0.000314112 | 0.0453984 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7342.3 | PP–RCT S4 | 20 | 377 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 722.538 | ø20 | 15.4 | TR10.03.0205 | 0205 | no | WS_Studená vnitřní 134 | 0
12971286 | 2.NP_SO-102 | 642.538 | 0.000314112 | 0.0403718 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3330 | 3320 | 3320 | 3310 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7312.3 | PP–RCT S4 | 20 | 363 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 642.538 | ø20 | 15.4 | TR10.03.0206 | 0206 | no | WS_Teplá vnitřní 83 | 0
12971290 | 2.NP_SO-102 | 745.26 | 0.000314112 | 0.046826 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3330 | 3320 | 3320 | 3310 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7312.3 | PP–RCT S4 | 20 | 319 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 745.26 | ø20 | 15.4 | TR10.03.0207 | 0207 | no | WS_Teplá vnitřní 83 | 0
12971292 | 2.NP_SO-102 | 338.725 | 0.000314112 | 0.0212827 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3330 | 3320 | 3320 | 3310 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7312.3 | PP–RCT S4 | 20 | 319 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 338.725 | ø20 | 15.4 | TR10.03.0208 | 0208 | no | WS_Teplá vnitřní 83 | 0
12971294 | 2.NP_SO-102 | 7846.98 | 0.000314112 | 0.49304 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3330 | 3320 | 3320 | 3310 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7312.3 | PP–RCT S4 | 20 | 52 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 7846.98 | ø20 | 15.4 | TR10.03.0209 | 0209 | yes | WS_Teplá vnitřní 83 | 0
12971299 | 2.NP_SO-102 | 5372 | 0.0004908 | 0.421916 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3332.5 | 3320 | 3320 | 3307.5 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7310.3 | PP–RCT S4 | 25 | 315 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5372 | ø25 | 19.4 | TR10.03.0210 | 0210 | yes | WS_Teplá vnitřní 83 | 0
12971302 | 2.NP_SO-102 | 669.307 | 0.000314112 | 0.0420538 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3330 | 3320 | 3320 | 3310 | 3320 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7312.3 | PP–RCT S4 | 20 | 379 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 669.307 | ø20 | 15.4 | TR10.03.0211 | 0211 | no | WS_Studená vnitřní 134 | 0
12971304 | 2.NP_SO-102 | 15.7161 | 0.0004908 | 0.00123434 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7340.3 | PP–RCT S4 | 25 | 90 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 15.7161 | ø25 | 19.4 | TR10.03.0212 | 0212 | no | WS_Studená vnitřní 134 | 0
12971305 | 2.NP_SO-102 | 15.2833 | 0.000804127 | 0.00153644 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3349.1 | 3326.97 | 3337.78 | 3315.66 | 3337.78 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7318.21 | PP–RCT S4 | 32 | 378 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 15.2833 | ø32 | 24.8 | TR10.03.0213 | 0213 | no | WS_Studená vnitřní 134 | 100
12971309 | 2.NP_SO-102 | 7691.74 | 0.000314112 | 0.483286 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7342.3 | PP–RCT S4 | 20 | 68 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 7691.74 | ø20 | 15.4 | TR10.03.0214 | 0214 | yes | WS_Studená vnitřní 134 | 0
12971318 | 2.NP_SO-102 | 418.725 | 0.000314112 | 0.0263093 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3330 | 3320 | 3320 | 3310 | 3320 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7312.3 | PP–RCT S4 | 20 | 379 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 418.725 | ø20 | 15.4 | TR10.03.0215 | 0215 | no | WS_Studená vnitřní 134 | 0
12971322 | 2.NP_SO-102 | 336.268 | 0.0004908 | 0.0264104 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 1262.5 | 1250 | 1250 | 1237.5 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5240.3 | PP–RCT S4 | 25 | 22 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 336.268 | ø25 | 19.4 | TR10.03.0216 | 0216 | no | WS_Teplá vnitřní 83 | 0
12971324 | 2.NP_SO-102 | 1129.1 | 0.000314112 | 0.0709434 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5242.3 | PP–RCT S4 | 20 | 359 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1129.1 | ø20 | 15.4 | TR10.03.0217 | 0217 | no | WS_Teplá vnitřní 83 | 0
12971327 | 2.NP_SO-102 | 126.037 | 0.0004908 | 0.00989893 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 1262.5 | 1250 | 1250 | 1237.5 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5240.3 | PP–RCT S4 | 25 | 22 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 126.037 | ø25 | 19.4 | TR10.03.0218 | 0218 | no | WS_Teplá vnitřní 83 | 0
12971330 | 2.NP_SO-102 | 139.595 | 0.0004908 | 0.0109638 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 1512.5 | 1500 | 1500 | 1487.5 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5490.3 | PP–RCT S4 | 25 | 390 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 139.595 | ø25 | 19.4 | TR10.03.0219 | 0219 | no | WS_Studená vnitřní 134 | 0
12971347 | 2.NP_SO-102 | 1923.73 | 0.0004908 | 0.151089 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3332.5 | 3320 | 3320 | 3307.5 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7310.3 | PP–RCT S4 | 25 | 362 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1923.73 | ø25 | 19.4 | TR10.03.0220 | 0220 | yes | WS_Teplá vnitřní 83 | 0
12971350 | 2.NP_SO-102 | 2030.64 | 0.0004908 | 0.159486 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7340.3 | PP–RCT S4 | 25 | 375 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2030.64 | ø25 | 19.4 | TR10.03.0221 | 0221 | yes | WS_Studená vnitřní 134 | 0
12971352 | 2.NP_SO-102 | 250.206 | 0.000804127 | 0.0251535 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3336 | 3320 | 3320 | 3304 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7307.6 | PP–RCT S4 | 32 | 361 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 250.206 | ø32 | 24.8 | TR10.03.0222 | 0222 | yes | WS_Teplá vnitřní 83 | 0
12971357 | 2.NP_SO-102 | 418.651 | 0.0004908 | 0.0328808 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3332.5 | 3320 | 3320 | 3307.5 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7310.3 | PP–RCT S4 | 25 | 362 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 418.651 | ø25 | 19.4 | TR10.03.0223 | 0223 | yes | WS_Teplá vnitřní 83 | 0
12971363 | 2.NP_SO-102 | 235.7 | 0.000314112 | 0.0148095 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1503.16 | 1503.16 | 1267.46 | 1267.46 | 1267.46 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5267.46 | PP–RCT S4 | 20 | 365 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 235.7 | ø20 | 15.4 | TR10.03.0224 | 0224 | no | WS_Teplá vnitřní 83
12971366 | 2.NP_SO-102 | 232.525 | 0.0004908 | 0.0182625 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 1503.16 | 1503.16 | 1270.64 | 1270.64 | 1270.64 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5270.64 | PP–RCT S4 | 25 | 63 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 232.525 | ø25 | 19.4 | TR10.03.0225 | 0225 | no | WS_Studená vnitřní 134
12984168 | 1.NP_SO-102 | 5478.4 | 0.0004908 | 0.430273 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3332.5 | 3320 | 3320 | 3307.5 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3310.3 | PP–RCT S4 | 25 | 83 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5478.4 | ø25 | 19.4 | TR10.03.0226 | 0226 | no | WS_Teplá vnitřní 83 | 0
12984245 | 1.NP_SO-102 | 5603.6 | 0.0004908 | 0.440106 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3340.3 | PP–RCT S4 | 25 | 1 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5603.6 | ø25 | 19.4 | TR10.03.0227 | 0227 | no | WS_Studená vnitřní 134 | 0
12984341 | 1.NP_SO-102 | 299.363 | 0.0004908 | 0.0235119 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3332.5 | 3320 | 3320 | 3307.5 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3310.3 | PP–RCT S4 | 25 | 70 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 299.363 | ø25 | 19.4 | TR10.03.0228 | 0228 | no | WS_Teplá vnitřní 83 | 0
12984380 | 1.NP_SO-102 | 399.033 | 0.0004908 | 0.03134 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3340.3 | PP–RCT S4 | 25 | 86 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 399.033 | ø25 | 19.4 | TR10.03.0229 | 0229 | no | WS_Studená vnitřní 134 | 0
12984671 | 1.NP_SO-102 | 73.5822 | 0.0004908 | 0.00577913 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 1512.5 | 1500 | 1500 | 1487.5 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 1490.3 | PP–RCT S4 | 25 | 394 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 73.5822 | ø25 | 19.4 | TR10.03.0230 | 0230 | no | WS_Studená vnitřní 134 | 0
12984687 | 1.NP_SO-102 | 1944.22 | 0.000804127 | 0.195454 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3336 | 3320 | 3320 | 3304 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3307.6 | PP–RCT S4 | 32 | 387 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1944.22 | ø32 | 24.8 | TR10.03.0231 | 0231 | yes | WS_Teplá vnitřní 83 | 0
12984703 | 1.NP_SO-102 | 2019.62 | 0.000804127 | 0.203034 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3337.6 | PP–RCT S4 | 32 | 110 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2019.62 | ø32 | 24.8 | TR10.03.0232 | 0232 | yes | WS_Studená vnitřní 134 | 0
12984946 | 1.NP_SO-102 | 2043.64 | 0.000314112 | 0.128406 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3311.11 | 3311.11 | 1267.46 | 1267.46 | 1267.46 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 1267.46 | PP–RCT S4 | 20 | 54 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2043.64 | ø20 | 15.4 | TR10.03.0233 | 0233 | no | WS_Studená vnitřní 134
12990764 | -1.PP_SO-102 | 2339.68 | 0.000314112 | 0.147006 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -657.7 | PP–RCT S4 | 20 | 353 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2339.68 | ø20 | 15.4 | TR10.03.0234 | 0234 | no | WS_Studená vnitřní 134 | 0
12990860 | 2.NP_SO-102 | 6849.76 | 0.00125645 | 0.860767 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 2.NP_SO-102 | 1976.75 | 1976.75 | -4873.01 | -4873.01 | -4873.01 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -873.012 | PP–RCT S4 | 40 | 514 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6849.76 | ø40 | 31 | TR10.03.0235 | 0235 | yes | WS_Studená vnitřní 134 | Identifikační data - Komentáře: V1
12991266 | -1.PP_SO-102 | 316.206 | 0.0019632 | 0.0496696 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3325 | 3300 | 3300 | 3275 | 3300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -719.4 | PP–RCT S4 | 50 | 400 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 316.206 | ø50 | 38.8 | TR10.03.0236 | 0236 | yes | WS_Studená vnitřní 134 | 0
12991788 | -1.PP_SO-102 | 1883.36 | 0.0004908 | 0.147919 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 1012.5 | 1000 | 1000 | 987.5 | 1000 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -3009.7 | PP–RCT S4 | 25 | 497 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1883.36 | ø25 | 19.4 | TR10.03.0237 | 0237 | no | WS_Studená vnitřní 134 | 0
12991856 | -1.PP_SO-102 | 5710.44 | 0.00311678 | 1.13021 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2931.5 | 2900 | 2900 | 2868.5 | 2900 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1124.4 | PP–RCT S4 | 63 | 24 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5710.44 | ø63 | 48.8 | TR10.03.0238 | 0238 | yes | WS_Studená vnitřní 134 | 0
12991886 | -1.PP_SO-102 | 5901.71 | 0.00311678 | 1.16807 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2931.5 | 2900 | 2900 | 2868.5 | 2900 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1124.4 | PP–RCT S4 | 63 | 247 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5901.71 | ø63 | 48.8 | TR10.03.0239 | 0239 | yes | WS_Teplá vnitřní 83 | 0
12991988 | -1.PP_SO-102 | 3794.76 | 0.0004908 | 0.29804 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3112.5 | 3100 | 3100 | 3087.5 | 3100 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -909.7 | PP–RCT S4 | 25 | 249 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3794.76 | ø25 | 19.4 | TR10.03.0240 | 0240 | no | WS_Studená vnitřní 134 | 0
12992472 | 2.NP_SO-102 | 411.088 | 0.00125645 | 0.0516588 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 2.NP_SO-102 | 2023.74 | 2003.74 | 2003.74 | 1983.74 | 2003.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5988.24 | PP–RCT S4 | 40 | 514 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 411.088 | ø40 | 31 | TR10.03.0241 | 0241 | no | WS_Studená vnitřní 134 | 0
12992644 | 2.NP_SO-102 | 6852.38 | 0.000804127 | 0.688876 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 1976.19 | -4876.19 | 1976.19 | -4876.19 | 1976.19 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -876.187 | PP–RCT S4 | 32 | 267 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6852.38 | ø32 | 24.8 | TR10.03.0242 | 0242 | yes | WS_Cirkulace vnitřní 9 | Identifikační data - Komentáře: V1
12992675 | 2.NP_SO-102 | 6846.03 | 0.00125645 | 0.860297 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 2.NP_SO-102 | 1973.01 | -4873.01 | 1973.01 | -4873.01 | 1973.01 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -873.012 | PP–RCT S4 | 40 | 346 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6846.03 | ø40 | 31 | TR10.03.0243 | 0243 | yes | WS_Teplá vnitřní 83
12992720 | 2.NP_SO-102 | 6858.73 | 0.0004908 | 0.538683 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 1979.36 | -4879.36 | 1979.36 | -4879.36 | 1979.36 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -879.362 | PP–RCT S4 | 25 | 192 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6858.73 | ø25 | 19.4 | TR10.03.0244 | 0244 | yes | WS_"Jiný typ" studená vnitřní 1
12992798 | 2.NP_SO-102 | 492.375 | 0.000804127 | 0.0494989 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2016 | 2000 | 2000 | 1984 | 2000 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | 5987.6 | PP–RCT S4 | 32 | 267 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 492.375 | ø32 | 24.8 | TR10.03.0245 | 0245 | no | WS_Cirkulace vnitřní 9 | 0
12992818 | 2.NP_SO-102 | 17565.8 | 0.0004908 | 1.37962 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2412.5 | 2400 | 2400 | 2387.5 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | 6390.3 | PP–RCT S4 | 25 | 242 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 17565.8 | ø25 | 19.4 | TR10.03.0246 | 0246 | no | WS_Cirkulace vnitřní 9 | 0
12993154 | 2.NP_SO-102 | 8046.35 | 0.000314112 | 0.505567 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2410 | 2400 | 2400 | 2390 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | 6392.3 | PP–RCT S4 | 20 | 2 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 8046.35 | ø20 | 15.4 | TR10.03.0247 | 0247 | no | WS_Cirkulace vnitřní 9 | 0
12993194 | 2.NP_SO-102 | 566.724 | 0.00125645 | 0.0712166 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 2.NP_SO-102 | 2020 | 2000 | 2000 | 1980 | 2000 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5984.5 | PP–RCT S4 | 40 | 346 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 566.724 | ø40 | 31 | TR10.03.0248 | 0248 | no | WS_Teplá vnitřní 83 | 0
12993653 | 2.NP_SO-102 | 1602.54 | 0.000314112 | 0.10069 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2410 | 2400 | 2400 | 2390 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6392.3 | PP–RCT S4 | 20 | 215 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1602.54 | ø20 | 15.4 | TR10.03.0249 | 0249 | no | WS_Teplá vnitřní 83 | 0
12994262 | 2.NP_SO-102 | 1681.44 | 0.000314112 | 0.105648 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2410 | 2400 | 2400 | 2390 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | 6392.3 | PP–RCT S4 | 20 | 2 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1681.44 | ø20 | 15.4 | TR10.03.0250 | 0250 | no | WS_Cirkulace vnitřní 9 | 0
12994445 | 2.NP_SO-102 | 1761.44 | 0.000314112 | 0.110675 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2413.74 | 2403.74 | 2403.74 | 2393.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6396.04 | PP–RCT S4 | 20 | 152 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1761.44 | ø20 | 15.4 | TR10.03.0251 | 0251 | no | WS_Studená vnitřní 134 | 0
12994522 | 2.NP_SO-102 | 1701.11 | 0.000314112 | 0.106884 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2413.74 | 2403.74 | 2403.74 | 2393.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6396.04 | PP–RCT S4 | 20 | 153 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1701.11 | ø20 | 15.4 | TR10.03.0252 | 0252 | no | WS_Studená vnitřní 134 | 0
12994667 | 2.NP_SO-102 | 644.545 | 0.0004908 | 0.0506225 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2416.24 | 2403.74 | 2403.74 | 2391.24 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6394.04 | PP–RCT S4 | 25 | 155 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 644.545 | ø25 | 19.4 | TR10.03.0253 | 0253 | no | WS_Studená vnitřní 134 | 0
12994691 | 2.NP_SO-102 | 644.025 | 0.0004908 | 0.0505816 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2412.5 | 2400 | 2400 | 2387.5 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6390.3 | PP–RCT S4 | 25 | 55 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 644.025 | ø25 | 19.4 | TR10.03.0254 | 0254 | no | WS_Teplá vnitřní 83 | 0
12994747 | 2.NP_SO-102 | 1144.41 | 0.000314112 | 0.0719053 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1234.15 | 1224.15 | 1224.15 | 1214.15 | 1224.15 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5216.45 | PP–RCT S4 | 20 | 391 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1144.41 | ø20 | 15.4 | TR10.03.0255 | 0255 | no | WS_Teplá vnitřní 83 | 0
12994771 | 2.NP_SO-102 | 1303.31 | 0.000314112 | 0.0818895 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1237.29 | 1227.29 | 1227.29 | 1217.29 | 1227.29 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5219.59 | PP–RCT S4 | 20 | 161 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1303.31 | ø20 | 15.4 | TR10.03.0256 | 0256 | no | WS_Studená vnitřní 134 | 0
12994838 | 2.NP_SO-102 | 314.775 | 0.0004908 | 0.0247224 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 1412.5 | 1400 | 1400 | 1387.5 | 1400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5390.3 | PP–RCT S4 | 25 | 421 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 314.775 | ø25 | 19.4 | TR10.03.0257 | 0257 | no | WS_Studená vnitřní 134 | 0
12994847 | 2.NP_SO-102 | 2089.82 | 0.000314112 | 0.131307 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2413.74 | 2403.74 | 2403.74 | 2393.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6396.04 | PP–RCT S4 | 20 | 152 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2089.82 | ø20 | 15.4 | TR10.03.0258 | 0258 | no | WS_Studená vnitřní 134 | 0
12994899 | 2.NP_SO-102 | 341.275 | 0.0004908 | 0.0268036 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 1412.5 | 1400 | 1400 | 1387.5 | 1400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5390.3 | PP–RCT S4 | 25 | 320 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 341.275 | ø25 | 19.4 | TR10.03.0259 | 0259 | no | WS_Teplá vnitřní 83 | 0
12994999 | 2.NP_SO-102 | 386.223 | 0.000314112 | 0.0242671 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1178.22 | 1168.22 | 1168.22 | 1158.22 | 1168.22 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5160.52 | PP–RCT S4 | 20 | 166 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 386.223 | ø20 | 15.4 | TR10.03.0260 | 0260 | no | WS_Studená vnitřní 134 | 0
12995042 | 2.NP_SO-102 | 546.177 | 0.000314112 | 0.0343173 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1203.19 | 1193.19 | 1193.19 | 1183.19 | 1193.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5185.49 | PP–RCT S4 | 20 | 229 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 546.177 | ø20 | 15.4 | TR10.03.0261 | 0261 | no | WS_Teplá vnitřní 83 | 0
12995065 | 2.NP_SO-102 | 1419.33 | 0.000314112 | 0.0891789 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2410 | 2400 | 2400 | 2390 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6392.3 | PP–RCT S4 | 20 | 225 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1419.33 | ø20 | 15.4 | TR10.03.0262 | 0262 | no | WS_Teplá vnitřní 83 | 0
12995079 | 2.NP_SO-102 | 182.538 | 0.000314112 | 0.0114692 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2410 | 2400 | 2400 | 2390 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6392.3 | PP–RCT S4 | 20 | 225 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 182.538 | ø20 | 15.4 | TR10.03.0263 | 0263 | no | WS_Teplá vnitřní 83 | 0
12995101 | 2.NP_SO-102 | 316.335 | 0.000314112 | 0.0198759 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2413.74 | 2403.74 | 2403.74 | 2393.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6396.04 | PP–RCT S4 | 20 | 164 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 316.335 | ø20 | 15.4 | TR10.03.0264 | 0264 | no | WS_Studená vnitřní 134 | 0
12995122 | 2.NP_SO-102 | 269.858 | 0.000314112 | 0.0169557 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2414.44 | 2404.44 | 2404.44 | 2394.44 | 2404.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6396.74 | PP–RCT S4 | 20 | 164 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 269.858 | ø20 | 15.4 | TR10.03.0265 | 0265 | no | WS_Studená vnitřní 134 | 0
12995255 | 2.NP_SO-102 | 2100.48 | 0.000804127 | 0.211163 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 150 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2100.48 | ø32 | 24.8 | TR10.03.0266 | 0266 | no | WS_Studená vnitřní 134 | 0
12995276 | 2.NP_SO-102 | 1993.8 | 0.000804127 | 0.200439 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2416 | 2400 | 2400 | 2384 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6387.6 | PP–RCT S4 | 32 | 59 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1993.8 | ø32 | 24.8 | TR10.03.0267 | 0267 | no | WS_Teplá vnitřní 83 | 0
12995286 | 2.NP_SO-102 | 1922.54 | 0.000314112 | 0.120797 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1410 | 1400 | 1400 | 1390 | 1400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5392.3 | PP–RCT S4 | 20 | 427 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1922.54 | ø20 | 15.4 | TR10.03.0268 | 0268 | no | WS_Studená vnitřní 134 | 0
12995312 | 2.NP_SO-102 | 1756.06 | 0.000314112 | 0.110336 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1410 | 1400 | 1400 | 1390 | 1400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5392.3 | PP–RCT S4 | 20 | 307 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1756.06 | ø20 | 15.4 | TR10.03.0269 | 0269 | no | WS_Teplá vnitřní 83 | 0
12995397 | 2.NP_SO-102 | 1902.54 | 0.000314112 | 0.11954 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2410 | 2400 | 2400 | 2390 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6392.3 | PP–RCT S4 | 20 | 68 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1902.54 | ø20 | 15.4 | TR10.03.0270 | 0270 | no | WS_Teplá vnitřní 83 | 0
12995421 | 2.NP_SO-102 | 1683.36 | 0.000314112 | 0.105768 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2413.74 | 2403.74 | 2403.74 | 2393.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6396.04 | PP–RCT S4 | 20 | 343 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1683.36 | ø20 | 15.4 | TR10.03.0271 | 0271 | no | WS_Studená vnitřní 134 | 0
12995444 | 2.NP_SO-102 | 3440.66 | 0.0004908 | 0.270229 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2412.5 | 2400 | 2400 | 2387.5 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6390.3 | PP–RCT S4 | 25 | 233 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3440.66 | ø25 | 19.4 | TR10.03.0272 | 0272 | no | WS_Teplá vnitřní 83 | 0
