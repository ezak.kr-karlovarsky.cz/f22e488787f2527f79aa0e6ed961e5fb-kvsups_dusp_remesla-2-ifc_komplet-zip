Properties of the parts of a building model (IFC4), part 35 of 60

# IfcPipeFitting: M_Koleno, obecné:Standardní (1248)
Name (M_Koleno, obecné:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm) | Group
13993637 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 3029.72 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.2034 | 2034 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13993641 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 7112.69 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.2035 | 2035 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13993752 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 3274.68 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.2036 | 2036 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13993934 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | -779.776 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190777 | 19.4422 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.2037 | 2037 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13994072 | 2.NP_SO-102 | ø110 mm-ø110 mm | 2.NP_SO-102 | -828.486 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.2040 | 2040 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13994336 | 1.NP_SO-102 | ø135 mm-ø135 mm | 1.NP_SO-102 | 3266.23 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.000888398 | 31.2472 | 45 | ø135-ø135 | 22.8936 | 138.175 | TT01.02.2041 | 2041 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1)
13994756 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 3158.81 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000185977 | 18.901 | 43.8677 | ø78-ø78 | 13.0752 | 81.175 | TT01.02.2043 | 2043 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13994947 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 3138.03 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000186107 | 18.9157 | 43.8985 | ø78-ø78 | 13.0853 | 81.175 | TT01.02.2044 | 2044 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13995018 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 3089.33 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.00025437 | 27.0994 | 60 | ø78-ø78 | 18.7466 | 81.175 | TT01.02.2045 | 2045 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13995073 | 2.NP_SO-102 | ø110 mm-ø110 mm | 2.NP_SO-102 | -532.764 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.2048 | 2048 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13995757 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 2985.55 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000652685 | 35.6567 | 59.0667 | ø110-ø110 | 25.6473 | 113.175 | TT01.02.2051 | 2051 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13995761 | 2.NP_SO-102 | ø110 mm-ø110 mm | 2.NP_SO-102 | -930.409 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.2052 | 2052 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13995923 | 2.NP_SO-102 | ø58 mm-ø58 mm | 2.NP_SO-102 | -658.559 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 29 | 58 | 0.0000852662 | 15.3 | 45 | ø58-ø58 | 10.1358 | 61.175 | TT01.02.2053 | 2053 | yes | 36.9375 | 30.5875 | SW_Splašky vnitřní gravitační 35 (1)
13996049 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | -740.587 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190777 | 19.4422 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.2054 | 2054 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13996061 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | -913.169 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000185919 | 18.8946 | 43.8542 | ø78-ø78 | 13.0707 | 81.175 | TT01.02.2055 | 2055 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13996099 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 3341.21 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.00049727 | 26.0709 | 45.0021 | ø110-ø110 | 18.7524 | 113.175 | TT01.02.2056 | 2056 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13996487 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 3055.5 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.2057 | 2057 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13996564 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 3050.42 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000652685 | 35.6567 | 59.0667 | ø110-ø110 | 25.6473 | 113.175 | TT01.02.2058 | 2058 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13996688 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | -919.728 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.2061 | 2061 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13996773 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 3084.36 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.2065 | 2065 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13996777 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 3070 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.2066 | 2066 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13996887 | 1.NP_SO-102 | ø58 mm-ø58 mm | 1.NP_SO-102 | 3081.38 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 29 | 58 | 0.0000852482 | 15.2964 | 44.9905 | ø58-ø58 | 10.1334 | 61.175 | TT01.02.2069 | 2069 | yes | 36.9375 | 30.5875 | SW_Splašky vnitřní gravitační 35 (1)
13996891 | 1.NP_SO-102 | ø58 mm-ø58 mm | 1.NP_SO-102 | 3092.31 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 29 | 58 | 0.0000830951 | 14.8691 | 43.8542 | ø58-ø58 | 9.85033 | 61.175 | TT01.02.2070 | 2070 | yes | 36.9375 | 30.5875 | SW_Splašky vnitřní gravitační 35 (1)
13997357 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | -597.327 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.000888398 | 31.2472 | 45 | ø135-ø135 | 22.8936 | 138.175 | TT01.02.2072 | 2072 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13998413 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | -616.776 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.000888398 | 31.2472 | 45 | ø135-ø135 | 22.8936 | 138.175 | TT01.02.2073 | 2073 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13998548 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | -1028.01 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.000888249 | 31.2414 | 44.9925 | ø135-ø135 | 22.8893 | 138.175 | TT01.02.2074 | 2074 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1)
13998618 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | -904.164 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00086569 | 30.3638 | 43.8498 | ø135-ø135 | 22.2463 | 138.175 | TT01.02.2077 | 2077 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13999021 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | -1033.06 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00088821 | 31.2399 | 44.9905 | ø135-ø135 | 22.8882 | 138.175 | TT01.02.2079 | 2079 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1)
13999102 | 1.NP_SO-102 | ø135 mm-ø135 mm | 1.NP_SO-102 | 3360.98 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.000865778 | 30.3672 | 43.8542 | ø135-ø135 | 22.2488 | 138.175 | TT01.02.2081 | 2081 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13999183 | 1.NP_SO-102 | ø135 mm-ø135 mm | 1.NP_SO-102 | 3368.2 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00088821 | 31.2399 | 44.9905 | ø135-ø135 | 22.8882 | 138.175 | TT01.02.2082 | 2082 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13999317 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 3235.31 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497268 | 26.0708 | 45.0019 | ø110-ø110 | 18.7523 | 113.175 | TT01.02.2085 | 2085 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13999347 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 3026.02 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.2086 | 2086 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13999352 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 2999.71 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.2088 | 2088 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13999401 | 1.NP_SO-102 | ø135 mm-ø135 mm | 1.NP_SO-102 | 3387.31 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.000888448 | 31.2492 | 45.0026 | ø135-ø135 | 22.895 | 138.175 | TT01.02.2089 | 2089 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1)
13999584 | 1.NP_SO-102 | ø135 mm-ø135 mm | 1.NP_SO-102 | 3112.55 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.000865778 | 30.3672 | 43.8542 | ø135-ø135 | 22.2488 | 138.175 | TT01.02.2090 | 2090 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1)
13999686 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 2813.91 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000250413 | 26.5921 | 59.0667 | ø78-ø78 | 18.3956 | 81.175 | TT01.02.2094 | 2094 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13999733 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 2854.39 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000185919 | 18.8946 | 43.8542 | ø78-ø78 | 13.0707 | 81.175 | TT01.02.2095 | 2095 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13999737 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 2822.31 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.2096 | 2096 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13999992 | 1.NP_SO-102 | ø135 mm-ø135 mm | 1.NP_SO-102 | 2546.87 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.000888063 | 31.2341 | 44.983 | ø135-ø135 | 22.884 | 138.175 | TT01.02.2097 | 2097 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1)
14000796 | 1.NP_SO-102 | ø135 mm-ø135 mm | 1.NP_SO-102 | 2554.43 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.000888284 | 31.2428 | 44.9943 | ø135-ø135 | 22.8903 | 138.175 | TT01.02.2099 | 2099 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1)
14000900 | 1.NP_SO-102 | ø135 mm-ø135 mm | 1.NP_SO-102 | 2461.36 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00118453 | 43.5538 | 60 | ø135-ø135 | 31.9101 | 138.175 | TT01.02.2100 | 2100 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1)
14001046 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | -474.544 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.000888398 | 31.2472 | 45 | ø135-ø135 | 22.8936 | 138.175 | TT01.02.2103 | 2103 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
14001057 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | -727.689 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.000865778 | 30.3672 | 43.8542 | ø135-ø135 | 22.2488 | 138.175 | TT01.02.2104 | 2104 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
14001123 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | -775.928 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.000865778 | 30.3672 | 43.8542 | ø135-ø135 | 22.2488 | 138.175 | TT01.02.2105 | 2105 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
14001383 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | -990.349 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.000888398 | 31.2472 | 45 | ø135-ø135 | 22.8936 | 138.175 | TT01.02.2106 | 2106 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
14001583 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | -1210.35 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.000888398 | 31.2472 | 45 | ø135-ø135 | 22.8936 | 138.175 | TT01.02.2107 | 2107 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
14001841 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | -376.589 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.000888393 | 31.2471 | 44.9998 | ø135-ø135 | 22.8935 | 138.175 | TT01.02.2109 | 2109 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
14001845 | 1.NP_SO-102 | ø135 mm-ø135 mm | 1.NP_SO-102 | 3373.26 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00116618 | 42.7414 | 59.0701 | ø135-ø135 | 31.3149 | 138.175 | TT01.02.2110 | 2110 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
14001894 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 3093.99 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.2111 | 2111 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
14001904 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 3082.71 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.2112 | 2112 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
14001914 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 3059.51 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.2113 | 2113 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
14002099 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 3048.01 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000251185 | 26.6906 | 59.2487 | ø78-ø78 | 18.4638 | 81.175 | TT01.02.2114 | 2114 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
14002302 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 2632.89 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.00049722 | 26.068 | 44.9976 | ø110-ø110 | 18.7503 | 113.175 | TT01.02.2116 | 2116 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14002312 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 2627.29 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.00049722 | 26.068 | 44.9976 | ø110-ø110 | 18.7503 | 113.175 | TT01.02.2117 | 2117 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14002408 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 2585.49 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.00049722 | 26.068 | 44.9976 | ø110-ø110 | 18.7503 | 113.175 | TT01.02.2118 | 2118 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14002418 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 2582.32 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.00049722 | 26.068 | 44.9976 | ø110-ø110 | 18.7503 | 113.175 | TT01.02.2119 | 2119 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14002432 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 2577.9 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.000490915 | 25.7017 | 44.4271 | ø110-ø110 | 18.4868 | 113.175 | TT01.02.2120 | 2120 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14002436 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 2317.03 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.2121 | 2121 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14002516 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | -890.861 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000746694 | 29.5904 | 45 | ø125-ø125 | 21.5681 | 130.175 | TT01.02.2122 | 2122 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14002530 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | -1086.91 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000737187 | 29.1728 | 44.4271 | ø125-ø125 | 21.2637 | 130.175 | TT01.02.2123 | 2123 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14002675 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | -1128.56 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000746655 | 29.5886 | 44.9976 | ø125-ø125 | 21.5668 | 130.175 | TT01.02.2124 | 2124 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14003356 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 3078.55 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000746654 | 29.5886 | 44.9976 | ø125-ø125 | 21.5668 | 130.175 | TT01.02.2126 | 2126 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14004141 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | -1075.79 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000746655 | 29.5886 | 44.9976 | ø125-ø125 | 21.5668 | 130.175 | TT01.02.2127 | 2127 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14004210 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | -1077.9 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000987842 | 40.857 | 59.5328 | ø125-ø125 | 29.7802 | 130.175 | TT01.02.2128 | 2128 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14004673 | 2.NP_SO-102 | ø110 mm-ø110 mm | 2.NP_SO-102 | -966.427 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.2132 | 2132 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
14004679 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 2938.19 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.2134 | 2134 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
14014764 | 1.NP_SO-102 | ø160 mm-ø160 mm | 1.NP_SO-102 | -4700 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 5 | 80 | 160 | 0.00144425 | 36.4249 | 45 | ø160-ø160 | 27.0357 | 163.175 | TT01.02.2135 | 2135 | yes | 87.9375 | 81.5875 | SW_Deště vnitřní gravitační 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
14014928 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -1415.13 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 5 | 80 | 160 | 0.00144417 | 36.4228 | 44.9976 | ø160-ø160 | 27.0341 | 163.175 | TT01.02.2136 | 2136 | yes | 87.9375 | 81.5875 | SW_Deště vnitřní gravitační 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
14015243 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -1233.94 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 5 | 80 | 160 | 0.00142586 | 35.9109 | 44.4271 | ø160-ø160 | 26.6542 | 163.175 | TT01.02.2137 | 2137 | yes | 87.9375 | 81.5875 | SW_Deště vnitřní gravitační 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
14015313 | -2.PP_SO-102 | ø160 mm-ø160 mm | -2.PP_SO-102 | 2755.5 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 5 | 80 | 160 | 0.00144421 | 36.4237 | 44.9986 | ø160-ø160 | 27.0348 | 163.175 | TT01.02.2138 | 2138 | yes | 87.9375 | 81.5875 | SW_Deště vnitřní gravitační 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
14015317 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -1411.02 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 5 | 80 | 160 | 0.00144417 | 36.4228 | 44.9976 | ø160-ø160 | 27.0341 | 163.175 | TT01.02.2139 | 2139 | yes | 87.9375 | 81.5875 | SW_Deště vnitřní gravitační 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
14015988 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 3010.8 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000737187 | 29.1728 | 44.4271 | ø125-ø125 | 21.2637 | 130.175 | TT01.02.2140 | 2140 |  | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14016056 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 2999.29 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000746664 | 29.589 | 44.9982 | ø125-ø125 | 21.5671 | 130.175 | TT01.02.2142 | 2142 |  | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14016068 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 2996.35 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000746655 | 29.5886 | 44.9976 | ø125-ø125 | 21.5668 | 130.175 | TT01.02.2143 | 2143 |  | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14016079 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 2993.36 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000737187 | 29.1728 | 44.4271 | ø125-ø125 | 21.2637 | 130.175 | TT01.02.2144 | 2144 |  | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14016162 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 2757.63 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000746694 | 29.5904 | 45 | ø125-ø125 | 21.5681 | 130.175 | TT01.02.2145 | 2145 |  | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14016378 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 2530.16 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000746654 | 29.5886 | 44.9976 | ø125-ø125 | 21.5668 | 130.175 | TT01.02.2146 | 2146 |  | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14016388 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 2528.64 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000746655 | 29.5886 | 44.9976 | ø125-ø125 | 21.5668 | 130.175 | TT01.02.2147 | 2147 |  | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14016446 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 2526.99 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000737187 | 29.1728 | 44.4271 | ø125-ø125 | 21.2637 | 130.175 | TT01.02.2148 | 2148 |  | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14016495 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | -487.477 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.0014839 | 70.7267 | 89.4271 | ø125-ø125 | 51.5519 | 130.175 | TT01.02.2150 | 2150 |  | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14016595 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | -492.379 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.0014839 | 70.7267 | 89.4271 | ø125-ø125 | 51.5519 | 130.175 | TT01.02.2151 | 2151 |  | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14016664 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | -1068.05 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.00148668 | 70.9342 | 89.5949 | ø125-ø125 | 51.7031 | 130.175 | TT01.02.2152 | 2152 |  | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14016675 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | -868.055 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000737187 | 29.1728 | 44.4271 | ø125-ø125 | 21.2637 | 130.175 | TT01.02.2153 | 2153 |  | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14016748 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | -862.629 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.0014839 | 70.7267 | 89.4271 | ø125-ø125 | 51.5519 | 130.175 | TT01.02.2154 | 2154 |  | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
14017485 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.2156 | 2156 |  | 20.6375 | 14.2875 | WS_Studená vnitřní 134
14017514 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.2157 | 2157 |  | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
14017545 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.2158 | 2158 |  | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
14017553 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.2159 | 2159 |  | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
14017557 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.2160 | 2160 |  | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
14017580 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.2161 | 2161 |  | 20.6375 | 14.2875 | WS_Studená vnitřní 134
14017588 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.2162 | 2162 |  | 20.6375 | 14.2875 | WS_Studená vnitřní 134
14017592 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.2163 | 2163 |  | 20.6375 | 14.2875 | WS_Studená vnitřní 134
14018344 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 3000 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.00177682 | 75.4375 | 90 | ø135-ø135 | 55.27 | 138.175 | TT01.02.2165 | 2165 | yes | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
14018379 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 3000 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.00177682 | 75.4375 | 90 | ø135-ø135 | 55.27 | 138.175 | TT01.02.2166 | 2166 | yes | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
14018457 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 2611.75 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.00177681 | 75.4372 | 89.9998 | ø135-ø135 | 55.2698 | 138.175 | TT01.02.2167 | 2167 | yes | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
14018462 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 2611.74 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.000888394 | 31.2471 | 44.9998 | ø135-ø135 | 22.8935 | 138.175 | TT01.02.2168 | 2168 | yes | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
14019199 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | -5100 | Fáze 1 | SW_Splašky čerpání | Sanitární | SW_Splašky čerpání 2 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.2169 | 2169 | yes | 62.9375 | 56.5875 | SW_Splašky čerpání 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
14019710 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2360 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.2170 | 2170 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
14019756 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -1100 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.2171 | 2171 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 16
14020057 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 3491.55 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.2173 | 2173 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
14020059 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2941.55 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.2174 | 2174 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
14020970 | 4.NP_SO-102 | ø160 mm-ø160 mm | STŘECHA_SO-102 | -1260.29 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 7 | 80 | 160 | 0.00288854 | 87.9375 | 90 | ø160-ø160 | 65.27 | 163.175 | TT01.02.2175 | 2175 | yes | 87.9375 | 81.5875 | SW_Odvětrání kanalizace 7 | Mechanické – tok - Tlaková ztráta: 0 Pa
14020974 | 4.NP_SO-102 | ø160 mm-ø160 mm | STŘECHA_SO-102 | -1260.29 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 7 | 80 | 160 | 0.00288854 | 87.9375 | 90 | ø160-ø160 | 65.27 | 163.175 | TT01.02.2176 | 2176 | yes | 87.9375 | 81.5875 | SW_Odvětrání kanalizace 7 | Mechanické – tok - Tlaková ztráta: 0 Pa
14022355 | 3.NP_SO-102 | ø89 mm-ø89 mm | 3.NP_SO-102 | 3366.44 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.2177 | 2177 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
14022400 | 3.NP_SO-102 | ø89 mm-ø89 mm | 3.NP_SO-102 | 3366.44 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.2178 | 2178 |  | 52.4375 | 46.0875 | WS_Požární nezavodněný 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
14022623 | 4.NP_SO-102 | ø89 mm-ø89 mm | 4.NP_SO-102 | 1312 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 2 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.2179 | 2179 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
14022846 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 3314.95 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190713 | 19.4349 | 44.9849 | ø78-ø78 | 13.4445 | 81.175 | TT01.02.2181 | 2181 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
14022858 | 3.NP_SO-102 | ø78 mm-ø78 mm | 3.NP_SO-102 | -268.84 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000166949 | 16.7966 | 39.3796 | ø78-ø78 | 11.6194 | 81.175 | TT01.02.2182 | 2182 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
14022860 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 3337.59 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000209747 | 21.6259 | 49.4746 | ø78-ø78 | 14.9602 | 81.175 | TT01.02.2183 | 2183 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
14023328 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2540 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.2184 | 2184 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
14023405 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 3000 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.2185 | 2185 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
14023409 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2540 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.2186 | 2186 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
14023707 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -2270.43 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.2187 | 2187 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 3
14024947 | 2.NP_SO-102 | ø40 mm-ø40 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.2188 | 2188 |  | 26.9875 | 20.6375 | WS_Studená vnitřní 134
14024955 | 2.NP_SO-102 | ø40 mm-ø40 mm | 2.NP_SO-102 | 2003.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.2189 | 2189 | no | 26.9875 | 20.6375 | WS_Studená vnitřní 134
14024957 | 2.NP_SO-102 | ø40 mm-ø40 mm | 2.NP_SO-102 | 2003.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.2190 | 2190 |  | 26.9875 | 20.6375 | WS_Studená vnitřní 134
14024984 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.2191 | 2191 |  | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9
14024992 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2000 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.2192 | 2192 | no | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9
14024994 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2000 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.2193 | 2193 |  | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9
14025020 | 2.NP_SO-102 | ø40 mm-ø40 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.2194 | 2194 |  | 26.9875 | 20.6375 | WS_Teplá vnitřní 83
14025028 | 2.NP_SO-102 | ø40 mm-ø40 mm | 2.NP_SO-102 | 2000 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.2195 | 2195 | no | 26.9875 | 20.6375 | WS_Teplá vnitřní 83
14025030 | 2.NP_SO-102 | ø40 mm-ø40 mm | 2.NP_SO-102 | 2000 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.2196 | 2196 |  | 26.9875 | 20.6375 | WS_Teplá vnitřní 83
14025058 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 2000 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.2197 | 2197 |  | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
14025074 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.2199 | 2199 |  | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
14025335 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 2900 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.00177682 | 75.4375 | 90 | ø135-ø135 | 55.27 | 138.175 | TT01.02.2200 | 2200 | yes | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
14026133 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -1100 | Fáze 1 | SW_Splašky čerpání | Sanitární | SW_Splašky čerpání 2 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.2201 | 2201 |  | 62.9375 | 56.5875 | SW_Splašky čerpání 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
14026135 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -1100 | Fáze 1 | SW_Splašky čerpání | Sanitární | SW_Splašky čerpání 2 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.2202 | 2202 | yes | 62.9375 | 56.5875 | SW_Splašky čerpání 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
14026649 | -1.PP_SO-102 | ø250 mm-ø250 mm | -1.PP_SO-102 | -1171.78 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 125 | 250 | 0.00366984 | 36.1554 | 29.9992 | ø250-ø250 | 27.5631 | 257.175 | TT01.02.2203 | 2203 | yes | 134.938 | 128.588 | SW_Splašky vnitřní gravitační 35 (1)
14027448 | 1.NP_SO-102 | ø160 mm-ø160 mm | 1.NP_SO-102 | -4922.8 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 80 | 160 | 0.00144425 | 36.425 | 45.0001 | ø160-ø160 | 27.0358 | 163.175 | TT01.02.2204 | 2204 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 35 (1)
14027465 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -1176.1 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 80 | 160 | 0.00140748 | 35.399 | 43.8542 | ø160-ø160 | 26.2743 | 163.175 | TT01.02.2205 | 2205 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 35 (1)
14027480 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -1186.68 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 80 | 160 | 0.00144395 | 36.4164 | 44.9905 | ø160-ø160 | 27.0294 | 163.175 | TT01.02.2206 | 2206 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 35 (1)
14027490 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -1197.94 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 80 | 160 | 0.00144395 | 36.4164 | 44.9905 | ø160-ø160 | 27.0294 | 163.175 | TT01.02.2207 | 2207 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 35 (1)
14027571 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -1245.26 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 80 | 160 | 0.00144395 | 36.4164 | 44.9905 | ø160-ø160 | 27.0294 | 163.175 | TT01.02.2208 | 2208 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 35 (1)
14033857 | 3.NP_SO-102 | ø110 mm-ø110 mm | 3.NP_SO-102 | 2951.29 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 14 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.2213 | 2213 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 14 | Mechanické – tok - Tlaková ztráta: 0 Pa
14033861 | 3.NP_SO-102 | ø110 mm-ø110 mm | 3.NP_SO-102 | 3299.28 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 14 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.2214 | 2214 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 14 | Mechanické – tok - Tlaková ztráta: 0 Pa
14033867 | 3.NP_SO-102 | ø110 mm-ø110 mm | 3.NP_SO-102 | 3299.28 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 14 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.2215 | 2215 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 14 | Mechanické – tok - Tlaková ztráta: 0 Pa
14035052 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 2404.78 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.00177682 | 75.4375 | 90 | ø135-ø135 | 55.27 | 138.175 | TT01.02.2216 | 2216 |  | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
14035054 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 2405 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.00177682 | 75.4375 | 90 | ø135-ø135 | 55.27 | 138.175 | TT01.02.2217 | 2217 | yes | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
14036076 | -1.PP_SO-102 | ø200 mm-ø200 mm | -1.PP_SO-102 | 2425.88 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.000959165 | 14.4202 | 14.9992 | ø200-ø200 | 10.8674 | 206.375 | TT01.02.2218 | 2218 | yes | 109.538 | 103.188 | SW_Splašky vnitřní gravitační 35 (1)
14036414 | -1.PP_SO-102 | ø200 mm-ø200 mm | -1.PP_SO-102 | 2311.86 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.000959165 | 14.4202 | 14.9992 | ø200-ø200 | 10.8674 | 206.375 | TT01.02.2219 | 2219 | yes | 109.538 | 103.188 | SW_Splašky vnitřní gravitační 35 (1)
14036452 | -1.PP_SO-102 | ø200 mm-ø200 mm | -1.PP_SO-102 | 2319.59 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.000959165 | 14.4202 | 14.9992 | ø200-ø200 | 10.8674 | 206.375 | TT01.02.2220 | 2220 | yes | 109.538 | 103.188 | SW_Splašky vnitřní gravitační 35 (1)
14036456 | -1.PP_SO-102 | ø200 mm-ø200 mm | -1.PP_SO-102 | 2418.15 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.000959165 | 14.4202 | 14.9992 | ø200-ø200 | 10.8674 | 206.375 | TT01.02.2221 | 2221 | yes | 109.538 | 103.188 | SW_Splašky vnitřní gravitační 35 (1)
14036746 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 2404.78 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.00177682 | 75.4375 | 90 | ø135-ø135 | 55.27 | 138.175 | TT01.02.2222 | 2222 |  | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
14036748 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 3111.71 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.00177682 | 75.4375 | 90 | ø135-ø135 | 55.27 | 138.175 | TT01.02.2223 | 2223 |  | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
14036752 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 3111.71 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.000296132 | 9.93155 | 15 | ø135-ø135 | 7.27645 | 138.175 | TT01.02.2224 | 2224 |  | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
14037175 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.2227 | 2227 |  | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
14037185 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.2228 | 2228 |  | 17.4625 | 11.1125 | WS_Studená vnitřní 134

# IfcPipeFitting: M_Křížení, obecné:Standardní (5)
Type - Classification: TT06 SNIM (SNIM); Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Není definováno; Tabulka koeficientů K: Converging/Diverging Tee/Wye
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; Kód sestavy: TT06; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 06; Popis: 2xT; Popis sestavy: Křížení
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Křížení, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT06 SNIM (SNIM); TT06 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: WMB; CCI Technický systém: JD
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Kóty - Úhel 1: 90 deg; Úhel 2: 90 deg
Jiné - Typ: Standardní; Úhel tvarovky 1 (sdílený): 90 deg; Id typu: 5278169; Rodina: M_Křížení, obecné; Rodina a typ: M_Křížení, obecné: Standardní; Úhel 3: 90 deg; Úhel 4: 90 deg; Úhel 5: 90 deg
Name (M_Křížení, obecné:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) = Štítek, od středu ke konci (mm) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Vnější poloměr tvarovky (mm)
12998828 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000871791 | 30.1625 | ø32-ø32-ø32-ø32 | 13.97 | 34.925 | TT06.06.0224 | 0224 | no | 17.4625
12998881 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2400 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000871791 | 30.1625 | ø32-ø32-ø32-ø32 | 13.97 | 34.925 | TT06.06.0226 | 0226 | no | 17.4625
13007389 | 2.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm-ø40 mm | 2.NP_SO-102 | 3340 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 20 | 40 | 0.000131541 | 33.3375 | ø40-ø40-ø40-ø40 | 16.51 | 41.275 | TT06.06.0331 | 0331 | yes | 20.6375
13007449 | 1.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm-ø40 mm | 1.NP_SO-102 | 3350 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 20 | 40 | 0.000131541 | 33.3375 | ø40-ø40-ø40-ø40 | 16.51 | 41.275 | TT06.06.0332 | 0332 | yes | 20.6375
13015138 | 3.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm-ø40 mm | 3.NP_SO-102 | 3350 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 20 | 40 | 0.000131541 | 33.3375 | ø40-ø40-ø40-ø40 | 16.51 | 41.275 | TT06.06.0405 | 0405 | yes | 20.6375

# IfcPipeFitting: M_Křížení, obecné:Standardní, M_Křížení, obecné:Standardní:14019771
In: -1.PP_SO-102
Type - Classification: TT06 SNIM (SNIM); Material: 255-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Není definováno; Tabulka koeficientů K: Converging/Diverging Tee/Wye
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; Kód sestavy: TT06; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 06; Popis: 2xT; Popis sestavy: Křížení
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Křížení, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT06 SNIM (SNIM); TT06 Uniformat (Uniformat); Group: SW_Odvětrání kanalizace 16
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø110 mm-ø110 mm-ø110 mm-ø110 mm
Text - CCI Funkční systém: F; CCI Komponenta: WMB; CCI Technický systém: JD
Vazby - Podlaží: -1.PP_SO-102; Výška od podlaží: 2360 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: SW_Odvětrání kanalizace; Klasifikace systému: Průduch; Název systému: SW_Odvětrání kanalizace 16
Grafika - Použít měřítko poznámky: no
Kóty - Úhel 1: 90 deg; Úhel 2: 90 deg; Jmenovitý poloměr: 55 mm; Jmenovitý průměr: 110 mm; Maximální velikost: 110 mm; Minimální velikost: 110 mm; Objem: 0.00182155 m3; Od středu ke konci: 69.2875 mm; Velikost: ø110-ø110-ø110-ø110; Velikost značky: 45.27 mm; Vnější průměr tvarovky: 113.175 mm
Identifikační data - Kód prvku: TT06.06.2172; Označení: 2172
Jiné - Páteřní trasa: yes; Typ: Standardní; Úhel tvarovky 1 (sdílený): 90 deg; Id typu: 5278169; Rodina: M_Křížení, obecné; Rodina a typ: M_Křížení, obecné: Standardní; Úhel 3: 90 deg; Úhel 4: 90 deg; Úhel 5: 90 deg; Štítek, od středu ke konci: 69.2875 mm; Vnější poloměr tvarovky: 56.5875 mm

# IfcPipeFitting: M_Přechod, obecný:Standardní (211)
Type - Classification: TT00 SNIM (SNIM); Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 05; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Šířkové odsazení: 3048 mm
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Délka (mm) | Jmenovitý poloměr 1 (mm) = Odskok – šířka | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Odskok – výška | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Viditelnost 1 | Výškové odsazení (mm) | Max. vnější průměr tvarovky 12 (mm) | Viditelnost 2 | Viditelnost 3 | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm)
12954990 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0057 | 0057 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
12964060 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 3323.01 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0077 | 0077 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
12964062 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 1642.1 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0078 | 0078 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
12964064 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 1696.1 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0079 | 0079 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
12966235 | 3.NP_SO-102 | ø32 mm-ø25 mm | 3.NP_SO-102 | 3343.96 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 12.5 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.05.0091 | 0091 | no | no | 3048 | 34.925 | no | yes | 17.4625 | 14.2875
12967375 | 3.NP_SO-102 | ø32 mm-ø20 mm | 3.NP_SO-102 | 3320 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0101 | 0101 | no | no | 3048 | 34.925 | yes | no | 11.1125 | 17.4625
12967623 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3323.01 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0105 | 0105 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
12967876 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0106 | 0106 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
12967888 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3323.01 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0107 | 0107 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
12967890 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 1557.16 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0108 | 0108 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
12967958 | 3.NP_SO-102 | ø32 mm-ø20 mm | 3.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0110 | 0110 | no | no | 3048 | 34.925 | yes | no | 11.1125 | 17.4625
12967967 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0111 | 0111 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
12968054 | 3.NP_SO-102 | ø32 mm-ø25 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 12.5 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.05.0112 | 0112 | yes | no | 3048 | 34.925 | no | yes | 17.4625 | 14.2875
12968064 | 3.NP_SO-102 | ø32 mm-ø25 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 12.5 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.05.0113 | 0113 | yes | no | 3048 | 34.925 | no | yes | 17.4625 | 14.2875
12968471 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0118 | 0118 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
