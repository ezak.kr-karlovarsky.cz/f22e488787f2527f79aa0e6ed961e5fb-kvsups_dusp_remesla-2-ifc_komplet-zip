Properties of the parts of a building model (IFC4), part 33 of 60

# IfcPipeFitting: M_Koleno, obecné:Standardní (1248)
Name (M_Koleno, obecné:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm) | Group
13545764 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 2884.07 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.00018592 | 18.8946 | 43.8543 | ø78-ø78 | 13.0707 | 81.175 | TT01.02.1442 | 1442 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13546045 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 3013.52 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190761 | 19.4403 | 44.9962 | ø78-ø78 | 13.4483 | 81.175 | TT01.02.1443 | 1443 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13546841 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 1476.43 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000193459 | 19.7465 | 45.6328 | ø78-ø78 | 13.6601 | 81.175 | TT01.02.1446 | 1446 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13547297 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 3146.36 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000381538 | 46.9335 | 89.9951 | ø78-ø78 | 32.4672 | 81.175 | TT01.02.1450 | 1450 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13547300 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 3148.51 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.1451 | 1451 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13550328 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 3331.79 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.1452 | 1452 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13550725 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 3305.7 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190738 | 19.4377 | 44.9907 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.1454 | 1454 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13550729 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 3180.86 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190738 | 19.4377 | 44.9907 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.1455 | 1455 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13573396 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 1193.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1456 | 1456 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
13573434 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1459 | 1459 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13573436 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1460 | 1460 | yes | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13573454 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1461 | 1461 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13573456 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1462 | 1462 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13616591 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | -1579.99 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 62.5 | 125 | 0.000746536 | 29.5835 | 44.9905 | ø125-ø125 | 21.563 | 130.175 | TT01.02.1463 | 1463 | yes | 71.4375 | 65.0875 | SW_Splašky vnitřní gravitační 3
13621325 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -1598.7 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.1464 | 1464 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 3
13621329 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -2364.01 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.1465 | 1465 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 3
13624170 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -1211.28 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.1467 | 1467 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 3
13624176 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -1369.65 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.1468 | 1468 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 3
13624180 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -1376.8 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.1469 | 1469 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 3
13624461 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | -1591.05 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 2 | 62.5 | 125 | 0.000807051 | 32.2834 | 48.6374 | ø125-ø125 | 23.531 | 130.175 | TT01.02.1470 | 1470 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní gravitační 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13624465 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | -2599.76 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 2 | 62.5 | 125 | 0.000807051 | 32.2834 | 48.6374 | ø125-ø125 | 23.531 | 130.175 | TT01.02.1471 | 1471 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní gravitační 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13624522 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -3045.38 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.0015613 | 39.7488 | 48.6471 | ø160-ø160 | 29.5028 | 163.175 | TT01.02.1472 | 1472 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3
13630574 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | 2811.38 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 2 | 62.5 | 125 | 0.0014839 | 70.7267 | 89.4271 | ø125-ø125 | 51.5519 | 130.175 | TT01.02.1474 | 1474 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní gravitační 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13630687 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | 2776.78 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 2 | 62.5 | 125 | 0.0014839 | 70.7267 | 89.4271 | ø125-ø125 | 51.5519 | 130.175 | TT01.02.1475 | 1475 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní gravitační 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13630835 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | -1538.87 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 2 | 62.5 | 125 | 0.000746694 | 29.5904 | 45 | ø125-ø125 | 21.5681 | 130.175 | TT01.02.1476 | 1476 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní gravitační 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13631062 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | -2414.58 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 2 | 62.5 | 125 | 0.000737187 | 29.1728 | 44.4271 | ø125-ø125 | 21.2637 | 130.175 | TT01.02.1477 | 1477 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní gravitační 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13631066 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | -2464.04 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 2 | 62.5 | 125 | 0.000746655 | 29.5886 | 44.9976 | ø125-ø125 | 21.5668 | 130.175 | TT01.02.1478 | 1478 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní gravitační 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13640730 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1480 | 1480 | yes | 26.9875 | 20.6375 | WS_Teplá vnitřní 83
13640824 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1481 | 1481 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13640844 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1482 | 1482 | yes | 26.9875 | 20.6375 | WS_Studená vnitřní 134
13640878 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 3299.71 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358503 | 23.8313 | 90.0452 | ø32-ø32 | 13.981 | 34.925 | TT01.02.1483 | 1483 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1
13643260 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000208906 | 20.7971 | 90.4414 | ø25-ø25 | 11.5184 | 28.575 | TT01.02.1515 | 1515 | no | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13643520 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1516 | 1516 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13645161 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1520 | 1520 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134 | Mechanické – tok - Tlaková ztráta: 0 Pa
13645328 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1523 | 1523 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134 | Mechanické – tok - Tlaková ztráta: 0 Pa
13645537 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1526 | 1526 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134 | Mechanické – tok - Tlaková ztráta: 0 Pa
13645648 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3308.35 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1528 | 1528 | yes | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13645650 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3308.35 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1529 | 1529 | yes | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13645715 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3320 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1531 | 1531 | yes | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13645719 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3320 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1532 | 1532 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13645725 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3320 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1533 | 1533 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13645756 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 1000 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1534 | 1534 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13645928 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1536 | 1536 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13646329 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 580 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1539 | 1539 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
13646431 | 3.NP_SO-102 | ø32 mm-ø32 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1542 | 1542 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13646484 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1544 | 1544 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13646513 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1547 | 1547 | yes | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13646630 | 3.NP_SO-102 | ø78 mm-ø78 mm | 3.NP_SO-102 | 3198.85 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000194398 | 19.8534 | 45.8542 | ø78-ø78 | 13.734 | 81.175 | TT01.02.1549 | 1549 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Identifikační data - Komentáře: S17
13646730 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 580 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1551 | 1551 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
13646886 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1553 | 1553 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13647433 | 4.NP_SO-102 | ø28 mm-ø28 mm | 4.NP_SO-102 | 1765.24 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1555 | 1555 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13647712 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1557 | 1557 | no | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13647837 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 346.904 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1558 | 1558 | no | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13647994 | -1.PP_SO-102 | ø20 mm-ø20 mm | -1.PP_SO-102 | 3374.42 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1560 | 1560 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13647998 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3374.42 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1561 | 1561 | no | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13648010 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3374.42 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1563 | 1563 | no | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13648014 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3374.42 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1564 | 1564 | no | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13651512 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1566 | 1566 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13651690 | -1.PP_SO-102 | ø42 mm-ø42 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 21 | 42 | 0.0000728541 | 28.9375 | 90 | ø42-ø42 | 18.07 | 45.175 | TT01.02.1569 | 1569 | yes | 28.9375 | 22.5875 | WS_Požární zavodněný 1
13651742 | -1.PP_SO-102 | ø28 mm-ø28 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1572 | 1572 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13651771 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1574 | 1574 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9
13651885 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1575 | 1575 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13651893 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1576 | 1576 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13653130 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2360 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.1577 | 1577 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 16
13653140 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2360 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.1578 | 1578 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 16
13653553 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2360 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.1580 | 1580 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 16
13653606 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2810 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.1581 | 1581 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 16
13653608 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2810 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.1582 | 1582 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 16
13653681 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2020 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.1584 | 1584 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
13653685 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2020 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.1585 | 1585 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
13654070 | -1.PP_SO-102 | ø42 mm-ø42 mm | -1.PP_SO-102 | 2410 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 21 | 42 | 0.0000728541 | 28.9375 | 90 | ø42-ø42 | 18.07 | 45.175 | TT01.02.1586 | 1586 | yes | 28.9375 | 22.5875 | WS_Požární zavodněný 1
13654072 | -1.PP_SO-102 | ø42 mm-ø42 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 21 | 42 | 0.0000728541 | 28.9375 | 90 | ø42-ø42 | 18.07 | 45.175 | TT01.02.1587 | 1587 | yes | 28.9375 | 22.5875 | WS_Požární zavodněný 1
13654081 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1588 | 1588 | yes | 39.4375 | 33.0875 | WS_Teplá vnitřní 83
13654083 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2410 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1589 | 1589 | yes | 39.4375 | 33.0875 | WS_Teplá vnitřní 83
13654092 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1590 | 1590 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9
13654094 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1591 | 1591 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9
13654103 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 3226.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1592 | 1592 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
13654105 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1593 | 1593 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
13654114 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1594 | 1594 | yes | 39.4375 | 33.0875 | WS_"Jiný typ" studená vnitřní 1
13654116 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1595 | 1595 | yes | 39.4375 | 33.0875 | WS_"Jiný typ" studená vnitřní 1
13654120 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1596 | 1596 | yes | 39.4375 | 33.0875 | WS_"Jiný typ" studená vnitřní 1
13654131 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 2400 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1597 | 1597 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13658165 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -2598.82 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00156152 | 39.755 | 48.6538 | ø160-ø160 | 29.5074 | 163.175 | TT01.02.1598 | 1598 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3
13659147 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -2571.12 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 55 | 110 | 0.000497086 | 26.0602 | 44.9855 | ø110-ø110 | 18.7447 | 113.175 | TT01.02.1601 | 1601 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 3
13659151 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -2536.03 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.1602 | 1602 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 3
13660156 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -2533.4 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.1605 | 1605 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 3
13660160 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -2505.93 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.1606 | 1606 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 3
13660434 | -1.PP_SO-102 | ø78 mm-ø78 mm | -1.PP_SO-102 | -1168.71 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 39 | 78 | 0.000185919 | 18.8946 | 43.8542 | ø78-ø78 | 13.0707 | 81.175 | TT01.02.1607 | 1607 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 3
13660438 | -1.PP_SO-102 | ø78 mm-ø78 mm | -1.PP_SO-102 | -999.008 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.1608 | 1608 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 3
13660554 | -1.PP_SO-102 | ø78 mm-ø78 mm | -1.PP_SO-102 | -1181.51 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 39 | 78 | 0.000185919 | 18.8946 | 43.8542 | ø78-ø78 | 13.0707 | 81.175 | TT01.02.1610 | 1610 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 3
13669853 | -1.PP_SO-102 | ø200 mm-ø200 mm | -1.PP_SO-102 | 2604.52 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.00287742 | 45.3678 | 44.9963 | ø200-ø200 | 34.1902 | 206.375 | TT01.02.1611 | 1611 | yes | 109.538 | 103.188 | SW_Splašky vnitřní gravitační 35 (1)
13672617 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2693.96 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.1618 | 1618 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13672621 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2810.13 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.1619 | 1619 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13672742 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2707.04 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.1622 | 1622 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13672746 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2767.69 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.1623 | 1623 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13673131 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2870.79 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.1628 | 1628 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S19
13673135 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2832.76 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.1629 | 1629 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S19
13673256 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2914.93 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.00049722 | 26.068 | 44.9976 | ø110-ø110 | 18.7503 | 113.175 | TT01.02.1630 | 1630 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S18
13673260 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2929.82 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.00049722 | 26.068 | 44.9976 | ø110-ø110 | 18.7503 | 113.175 | TT01.02.1631 | 1631 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S18
13673771 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2842.55 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.1634 | 1634 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13675112 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2642.34 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.1637 | 1637 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13675321 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2883.04 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.1640 | 1640 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13675325 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2677.23 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.1641 | 1641 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13675438 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | 3264.26 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 80 | 160 | 0.00285176 | 86.1963 | 88.8542 | ø160-ø160 | 63.9777 | 163.175 | TT01.02.1642 | 1642 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S20
13675646 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | 3254.21 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 80 | 160 | 0.00286195 | 86.6752 | 89.1716 | ø160-ø160 | 64.3331 | 163.175 | TT01.02.1643 | 1643 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S20
13678534 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2695.98 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.000988174 | 62.3113 | 89.4271 | ø110-ø110 | 44.8196 | 113.175 | TT01.02.1648 | 1648 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4
13679153 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 81.6808 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00174289 | 73.2083 | 88.2816 | ø135-ø135 | 53.6368 | 138.175 | TT01.02.1650 | 1650 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1)
13679157 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 111.673 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00174289 | 73.2083 | 88.2816 | ø135-ø135 | 53.6368 | 138.175 | TT01.02.1651 | 1651 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1)
13680398 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -2277.87 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.1652 | 1652 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 3
13680737 | 3.NP_SO-102 | ø110 mm-ø110 mm | 3.NP_SO-102 | 3313.72 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497361 | 26.0763 | 45.0104 | ø110-ø110 | 18.7563 | 113.175 | TT01.02.1654 | 1654 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13680811 | 2.NP_SO-102 | ø110 mm-ø110 mm | 2.NP_SO-102 | 3323.69 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000498204 | 26.1253 | 45.0866 | ø110-ø110 | 18.7916 | 113.175 | TT01.02.1657 | 1657 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13680866 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 3101.79 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497873 | 26.106 | 45.0567 | ø110-ø110 | 18.7777 | 113.175 | TT01.02.1660 | 1660 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13680912 | 3.NP_SO-102 | ø78 mm-ø78 mm | 3.NP_SO-102 | 3362.4 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 18 | 39 | 78 | 0.000381559 | 46.9375 | 90 | ø78-ø78 | 32.47 | 81.175 | TT01.02.1663 | 1663 | yes | 46.9375 | 40.5875 | SW_Odvětrání kanalizace 18 | Mechanické – tok - Tlaková ztráta: 0 Pa
13681489 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 3118.77 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190777 | 19.4422 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.1665 | 1665 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13681628 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 2572.31 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.00177682 | 75.4375 | 90 | ø135-ø135 | 55.27 | 138.175 | TT01.02.1666 | 1666 | yes | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
13681865 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 3100 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.00177683 | 75.4382 | 90.0005 | ø135-ø135 | 55.2705 | 138.175 | TT01.02.1667 | 1667 | yes | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
13682743 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 3100 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.000888398 | 31.2472 | 45 | ø135-ø135 | 22.8936 | 138.175 | TT01.02.1671 | 1671 | yes | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
13682747 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 2435.37 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.000888398 | 31.2472 | 45 | ø135-ø135 | 22.8936 | 138.175 | TT01.02.1672 | 1672 | yes | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
13682932 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 2081.01 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.000888398 | 31.2472 | 45 | ø135-ø135 | 22.8936 | 138.175 | TT01.02.1673 | 1673 | yes | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
13682976 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 2572.31 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.000888398 | 31.2472 | 45 | ø135-ø135 | 22.8936 | 138.175 | TT01.02.1674 | 1674 | yes | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
13683007 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 3100 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.000888398 | 31.2472 | 45 | ø135-ø135 | 22.8936 | 138.175 | TT01.02.1675 | 1675 | yes | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
13683133 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 3111.87 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.00177682 | 75.4375 | 90 | ø135-ø135 | 55.27 | 138.175 | TT01.02.1676 | 1676 | yes | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
13683183 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 3100 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.00177682 | 75.4375 | 90 | ø135-ø135 | 55.27 | 138.175 | TT01.02.1677 | 1677 | yes | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
13683191 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 2400 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.00177682 | 75.4375 | 90 | ø135-ø135 | 55.27 | 138.175 | TT01.02.1678 | 1678 | yes | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
13683195 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 2400 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.00177682 | 75.4375 | 90 | ø135-ø135 | 55.27 | 138.175 | TT01.02.1679 | 1679 | yes | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
13684869 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 2656.42 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000737187 | 29.1728 | 44.4271 | ø125-ø125 | 21.2637 | 130.175 | TT01.02.1680 | 1680 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13687760 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 2797.06 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000746655 | 29.5886 | 44.9976 | ø125-ø125 | 21.5668 | 130.175 | TT01.02.1681 | 1681 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13687894 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 2793.26 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000737187 | 29.1728 | 44.4271 | ø125-ø125 | 21.2637 | 130.175 | TT01.02.1683 | 1683 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13687976 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 2787.97 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000737187 | 29.1728 | 44.4271 | ø125-ø125 | 21.2637 | 130.175 | TT01.02.1684 | 1684 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13688473 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 2545.02 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000746694 | 29.5904 | 45 | ø125-ø125 | 21.5681 | 130.175 | TT01.02.1685 | 1685 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13688679 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | 2737.19 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 80 | 160 | 0.00144425 | 36.4249 | 45 | ø160-ø160 | 27.0357 | 163.175 | TT01.02.1686 | 1686 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13688785 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | 2985.42 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 80 | 160 | 0.00285176 | 86.1963 | 88.8542 | ø160-ø160 | 63.9777 | 163.175 | TT01.02.1687 | 1687 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13688918 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | 2975.42 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 80 | 160 | 0.00286254 | 86.7028 | 89.1899 | ø160-ø160 | 64.3536 | 163.175 | TT01.02.1688 | 1688 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13689358 | -1.PP_SO-102 | ø200 mm-ø200 mm | -1.PP_SO-102 | 2586.4 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.00287742 | 45.3678 | 44.9963 | ø200-ø200 | 34.1902 | 206.375 | TT01.02.1693 | 1693 | yes | 109.538 | 103.188 | SW_Splašky vnitřní gravitační 35 (1)
13689362 | -1.PP_SO-102 | ø200 mm-ø200 mm | -1.PP_SO-102 | 2476.92 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.00287753 | 45.3698 | 44.9981 | ø200-ø200 | 34.1917 | 206.375 | TT01.02.1694 | 1694 | yes | 109.538 | 103.188 | SW_Splašky vnitřní gravitační 35 (1)
13689381 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | 2450.6 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 80 | 160 | 0.00142586 | 35.9109 | 44.4271 | ø160-ø160 | 26.6542 | 163.175 | TT01.02.1695 | 1695 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13689801 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2544.84 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.1700 | 1700 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13689885 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2832.79 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.1701 | 1701 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13689889 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2544.84 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.1702 | 1702 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13689934 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2521.92 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.1705 | 1705 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13689975 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2542.32 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.1706 | 1706 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13690052 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2556.53 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.1707 | 1707 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13690056 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2548.8 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.1708 | 1708 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13690091 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 3246.46 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.1709 | 1709 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S19
13690095 | -1.PP_SO-102 | ø78 mm-ø78 mm | -1.PP_SO-102 | 2887.91 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.1710 | 1710 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S19
13690281 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2856.95 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.00049722 | 26.068 | 44.9976 | ø110-ø110 | 18.7503 | 113.175 | TT01.02.1712 | 1712 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S18
13690285 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2911.96 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.00049722 | 26.068 | 44.9976 | ø110-ø110 | 18.7503 | 113.175 | TT01.02.1713 | 1713 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S18
13690904 | -1.PP_SO-102 | ø78 mm-ø78 mm | -1.PP_SO-102 | 3249.16 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.1714 | 1714 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Identifikační data - Komentáře: S17
13691045 | -1.PP_SO-102 | ø78 mm-ø78 mm | -1.PP_SO-102 | 3044.48 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000379841 | 46.6068 | 89.5949 | ø78-ø78 | 32.2412 | 81.175 | TT01.02.1715 | 1715 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Identifikační data - Komentáře: S17
13691049 | -1.PP_SO-102 | ø78 mm-ø78 mm | -1.PP_SO-102 | 2953.76 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190765 | 19.4408 | 44.9971 | ø78-ø78 | 13.4486 | 81.175 | TT01.02.1716 | 1716 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Identifikační data - Komentáře: S17
13704170 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2810 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.1717 | 1717 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 16
13704174 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2810 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.1718 | 1718 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 16
13704669 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 2900 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.00178974 | 76.3042 | 90.6545 | ø135-ø135 | 55.905 | 138.175 | TT01.02.1720 | 1720 | yes | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
13704703 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1722 | 1722 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
13704707 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1723 | 1723 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9
13704850 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1724 | 1724 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
13705040 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2410 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1728 | 1728 | yes | 39.4375 | 33.0875 | WS_Teplá vnitřní 83
13705074 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1730 | 1730 | yes | 39.4375 | 33.0875 | WS_Teplá vnitřní 83
13705735 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1732 | 1732 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 83
13705769 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1734 | 1734 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 83
13705771 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1735 | 1735 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 83
13705992 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 4 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1738 | 1738 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 4
13705994 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 4 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1739 | 1739 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 4
13706046 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 3226.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1740 | 1740 | yes | 33.3375 | 26.9875 | WS_Studená vnitřní 134
13706050 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 3226.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1741 | 1741 | yes | 33.3375 | 26.9875 | WS_Studená vnitřní 134
13706074 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1742 | 1742 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
13706115 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 2995.58 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000746694 | 29.5904 | 45 | ø125-ø125 | 21.5681 | 130.175 | TT01.02.1745 | 1745 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13706125 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 3470.2 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000746694 | 29.5904 | 45 | ø125-ø125 | 21.5681 | 130.175 | TT01.02.1747 | 1747 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13763799 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1748 | 1748 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13764079 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 805.05 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1749 | 1749 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13764083 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1750 | 1750 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13764087 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1751 | 1751 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13764116 | -1.PP_SO-102 | ø75 mm-ø75 mm | -1.PP_SO-102 | 805.05 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 37.5 | 75 | 0.000342568 | 45.4375 | 90 | ø75-ø75 | 31.27 | 78.175 | TT01.02.1752 | 1752 | yes | 45.4375 | 39.0875 | WS_Požární nezavodněný 1
13764121 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1754 | 1754 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13764125 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1755 | 1755 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13764231 | -1.PP_SO-102 | ø75 mm-ø75 mm | -1.PP_SO-102 | 805.05 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 37.5 | 75 | 0.000342568 | 45.4375 | 90 | ø75-ø75 | 31.27 | 78.175 | TT01.02.1756 | 1756 | yes | 45.4375 | 39.0875 | WS_Požární nezavodněný 1
13764281 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 805.05 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1757 | 1757 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13764363 | -1.PP_SO-102 | ø75 mm-ø75 mm | -1.PP_SO-102 | 805.05 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 37.5 | 75 | 0.000342568 | 45.4375 | 90 | ø75-ø75 | 31.27 | 78.175 | TT01.02.1758 | 1758 | yes | 45.4375 | 39.0875 | WS_Požární nezavodněný 1
13764406 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 805.05 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1759 | 1759 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13764525 | -1.PP_SO-102 | ø75 mm-ø75 mm | -1.PP_SO-102 | 2914.72 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 37.5 | 75 | 0.000342568 | 45.4375 | 90 | ø75-ø75 | 31.27 | 78.175 | TT01.02.1760 | 1760 | yes | 45.4375 | 39.0875 | WS_Požární nezavodněný 1
13764603 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 2904.52 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1762 | 1762 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13805696 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 2900 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1764 | 1764 | yes | 26.9875 | 20.6375 | WS_Cirkulace vnitřní 9
13807358 | -1.PP_SO-102 | ø42 mm-ø42 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 21 | 42 | 0.0000728541 | 28.9375 | 90 | ø42-ø42 | 18.07 | 45.175 | TT01.02.1769 | 1769 | yes | 28.9375 | 22.5875 | WS_Požární zavodněný 1
13807374 | -1.PP_SO-102 | ø42 mm-ø42 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 21 | 42 | 0.0000728541 | 28.9375 | 90 | ø42-ø42 | 18.07 | 45.175 | TT01.02.1770 | 1770 | yes | 28.9375 | 22.5875 | WS_Požární zavodněný 1
13807401 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1771 | 1771 | yes | 39.4375 | 33.0875 | WS_Teplá vnitřní 83
13807436 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1772 | 1772 | yes | 26.9875 | 20.6375 | WS_Cirkulace vnitřní 9
13807475 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1773 | 1773 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
