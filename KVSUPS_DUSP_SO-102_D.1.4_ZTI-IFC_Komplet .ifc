Properties of the parts of a building model (IFC4), part 28 of 60

# IfcFlowTerminal: Nohy ke sprchové vaničce 900x900mm:Nohy ke sprchové vaničce 900x900mm (8)
Jiné - Id typu: 12798054; Rodina: Nohy ke sprchové vaničce 900x900mm; Rodina a typ: Nohy ke sprchové vaničce 900x900mm: Nohy ke sprchové vaničce 900x900mm; Typ: Nohy ke sprchové vaničce 900x900mm
Name (Nohy ke sprchové vaničce 900x900mm:Nohy ke sprchové vaničce 900x900mm:...) | In | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
12797921 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | MT03.02.0002 | 0002
12805481 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | MT03.02.0007 | 0007
12833681 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | MT03.02.0028 | 0028
12833745 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | MT03.02.0033 | 0033
12893440 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT03.02.0393 | 0393
12893485 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT03.02.0398 | 0398
12893964 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | MT03.02.0403 | 0403
13325303 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | MT03.02.0716 | 0716

# IfcFlowTerminal: Nožičky k vaně:Nožičky k vaně, Nožičky k vaně:Nožičky k vaně:12864815
In: 1.NP_SO-102
Type - Classification: MT03 SNIM (SNIM); Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Identifikační data - ID kategorie: OP; Kód sestavy: MT03; Komentáře k typům: vanové nohy k vanám Eurowa 5039; Název typu: Nožičky k vaně; Označení typu: 17; Popis: Nohy k vaně; Popis sestavy: Držák; Výrobce: Kaldewei
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Nožičky k vaně
Classification: MT03 SNIM (SNIM); MT03 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Přesunout s blízkými prvky: no; Podlaží: 1.NP_SO-102; Hostitel: Podlaží : 1.NP_SO-102; Odsazení od hostitele: 20 mm; Výška od podlaží: 20 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.00120912 m3; Výška vany: 535 mm
Identifikační data - Kód prvku: MT03.17.0038; Název sestavy: Vana (nástěnná baterie); Označení: 0038
Jiné - A: 390.6 mm; Id typu: 12859109; NN1: 144.4 mm; Rodina: Nožičky k vaně; Rodina a typ: Nožičky k vaně: Nožičky k vaně; Typ: Nožičky k vaně; Vmax: 535 mm; Vmin: 515 mm

# IfcFlowTerminal: Pisoár:Pisoár (20)
Type - Classification: ZT02 SNIM (SNIM); Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s
Type - Materiály a povrchové úpravy - Materiál: ZDRAVOTNÍ KERAMIKA
Type - Kóty - JMENOVITÝ PRŮMĚR: 50 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZT02; Komentáře k typům: Pisoár se zadním přívodem vody se sifonem; Název typu: Pisoár; Označení typu: 24; Popis: P; Popis sestavy: Pisoár; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Pisoár
Classification: ZT02 SNIM (SNIM); ZT02 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Mechanické - Klasifikace systému: Sanitární
Kóty - Objem: 0.0203603 m3; Tloušťka stěny: 20 mm
Identifikační data - Název sestavy: Pisoár + modul
Jiné - Id typu: 12834491; Rodina: Pisoár; Rodina a typ: Pisoár: Pisoár; Typ: Pisoár
Name (Pisoár:Pisoár:...) | In | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení | Material
12879585 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT02.24.0102 | 0102
12879627 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT02.24.0105 | 0105 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
12879639 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT02.24.0108 | 0108 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
12880776 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT02.24.0149 | 0149 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
12880781 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT02.24.0152 | 0152 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
12880786 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT02.24.0155 | 0155 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
12880946 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT02.24.0193 | 0193 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
12880951 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT02.24.0196 | 0196 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
12880956 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT02.24.0199 | 0199 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
12881116 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT02.24.0237 | 0237 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
12881121 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT02.24.0240 | 0240 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
12881126 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT02.24.0243 | 0243 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
12890550 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT02.24.0309 | 0309 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
12890559 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT02.24.0312 | 0312 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
12890571 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT02.24.0315 | 0315 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
12894934 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZT02.24.0442 | 0442 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
12895864 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZT02.24.0474 | 0474 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
12897020 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZT02.24.0517 | 0517 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
12897903 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZT02.24.0556 | 0556 | <Unnamed>, ZDRAVOTNÍ KERAMIKA
13154274 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZT02.24.0689 | 0689 | <Unnamed>, ZDRAVOTNÍ KERAMIKA

# IfcFlowTerminal: Port ZTI_TRM_voda studená.CC:Port ZTI_TRM_voda studená.CC (80)
Type - Classification: TR10 SNIM (SNIM); Material: ZDRAVOTNÍ KERAMIKA
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: –; Kód sestavy: TR10; Komentáře k typům: ZTI voda teplá; Název typu: Port ZTI_TRM_voda studená.CC; Označení typu: 15; Popis: Port; Popis sestavy: Polypropylene Random Cristallinity Temperature (PP RCT); URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Port ZTI_TRM_voda studená.CC
Classification: TR10 SNIM (SNIM); TR10 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: WPA; CCI Technický systém: JB
Mechanické - Klasifikace systému: Studená voda v domácnosti
Kóty - JMENOVITÝ PRŮMĚR: 15 mm; Objem: 8.83531e-07 m3
Jiné - Id typu: 12818271; Rodina: Port ZTI_TRM_voda studená.CC; Rodina a typ: Port ZTI_TRM_voda studená.CC: Port ZTI_TRM_voda studená.CC; Typ: Port ZTI_TRM_voda studená.CC
Name (Port ZTI_TRM_voda studená.CC:Port ZTI_TRM_voda studená.CC:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Název sestavy | Označení
12833557 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1045 | Fáze 1 | TR10.15.0023 | Toaleta + modul | 0023
12833582 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1045 | Fáze 1 | TR10.15.0026 | Toaleta + modul | 0026
12866036 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0046 | Toaleta + modul | 0046
12879219 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0064 | Toaleta + modul | 0064
12879268 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0067 | Toaleta + modul | 0067
12879279 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0070 | Toaleta + modul | 0070
12879294 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0073 | Toaleta + modul | 0073
12879307 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0076 | Toaleta + modul | 0076
12879586 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1170 | Fáze 1 | TR10.15.0103 | Pisoár + modul | 0103
12879628 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1170 | Fáze 1 | TR10.15.0106 | Pisoár + modul | 0106
12879640 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1170 | Fáze 1 | TR10.15.0109 | Pisoár + modul | 0109
12880187 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0112 | Toaleta + modul | 0112
12880673 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0115 | Toaleta + modul | 0115
12880677 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0118 | Toaleta + modul | 0118
12880681 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0121 | Toaleta + modul | 0121
12880685 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0124 | Toaleta + modul | 0124
12880689 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0127 | Toaleta + modul | 0127
12880777 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1170 | Fáze 1 | TR10.15.0150 | Pisoár + modul | 0150
12880782 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1170 | Fáze 1 | TR10.15.0153 | Pisoár + modul | 0153
12880787 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1170 | Fáze 1 | TR10.15.0156 | Pisoár + modul | 0156
12880843 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0159 | Toaleta + modul | 0159
12880847 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0162 | Toaleta + modul | 0162
12880851 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0165 | Toaleta + modul | 0165
12880855 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0168 | Toaleta + modul | 0168
12880859 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0171 | Toaleta + modul | 0171
12880947 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1170 | Fáze 1 | TR10.15.0194 | Pisoár + modul | 0194
12880952 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1170 | Fáze 1 | TR10.15.0197 | Pisoár + modul | 0197
12880957 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1170 | Fáze 1 | TR10.15.0200 | Pisoár + modul | 0200
12881013 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0203 | Toaleta + modul | 0203
12881017 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0206 | Toaleta + modul | 0206
12881021 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0209 | Toaleta + modul | 0209
12881025 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0212 | Toaleta + modul | 0212
12881029 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0215 | Toaleta + modul | 0215
12881117 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 1170 | Fáze 1 | TR10.15.0238 | Pisoár + modul | 0238
12881122 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 1170 | Fáze 1 | TR10.15.0241 | Pisoár + modul | 0241
12881127 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 1170 | Fáze 1 | TR10.15.0244 | Pisoár + modul | 0244
12881914 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0247 | Toaleta + modul | 0247
12889908 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0286 | Toaleta + modul | 0286
12889916 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0289 | Toaleta + modul | 0289
12889927 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0292 | Toaleta + modul | 0292
12889949 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0295 | Toaleta + modul | 0295
12890551 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1170 | Fáze 1 | TR10.15.0310 | Pisoár + modul | 0310
12890560 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1170 | Fáze 1 | TR10.15.0313 | Pisoár + modul | 0313
12890572 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1170 | Fáze 1 | TR10.15.0316 | Pisoár + modul | 0316
12892701 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0375 | Toaleta + modul | 0375
12894601 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1045 | Fáze 2 | TR10.15.0429 | Toaleta + modul | 0429
12894891 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1045 | Fáze 2 | TR10.15.0440 | Toaleta + modul | 0440
12894935 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1170 | Fáze 2 | TR10.15.0443 | Pisoár + modul | 0443
12894984 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1045 | Fáze 2 | TR10.15.0446 | Toaleta + modul | 0446
12894992 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1045 | Fáze 2 | TR10.15.0449 | Toaleta + modul | 0449
12895865 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1170 | Fáze 2 | TR10.15.0475 | Pisoár + modul | 0475
12895979 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1045 | Fáze 2 | TR10.15.0478 | Toaleta + modul | 0478
12896034 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1045 | Fáze 2 | TR10.15.0481 | Toaleta + modul | 0481
12896042 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1045 | Fáze 2 | TR10.15.0484 | Toaleta + modul | 0484
12897021 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1170 | Fáze 2 | TR10.15.0518 | Pisoár + modul | 0518
12897076 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1045 | Fáze 2 | TR10.15.0521 | Toaleta + modul | 0521
12897084 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1045 | Fáze 2 | TR10.15.0524 | Toaleta + modul | 0524
12897095 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1045 | Fáze 2 | TR10.15.0527 | Toaleta + modul | 0527
12897904 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 1170 | Fáze 2 | TR10.15.0557 | Pisoár + modul | 0557
12897991 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 1045 | Fáze 2 | TR10.15.0560 | Toaleta + modul | 0560
12897999 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 1045 | Fáze 2 | TR10.15.0563 | Toaleta + modul | 0563
12898010 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 1045 | Fáze 2 | TR10.15.0566 | Toaleta + modul | 0566
12899420 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1045 | Fáze 2 | TR10.15.0595 | Toaleta + modul | 0595
12899602 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1045 | Fáze 2 | TR10.15.0605 | Toaleta + modul | 0605
12992049 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0632 | Toaleta + modul | 0632
12992053 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0635 | Toaleta + modul | 0635
13154275 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1170 | Fáze 2 | TR10.15.0690 | Pisoár + modul | 0690
13154284 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1045 | Fáze 2 | TR10.15.0693 | Toaleta + modul | 0693
13691415 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0813 | Toaleta + modul | 0813
13725115 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0821 | Toaleta + modul (madla, lehká kce)_invalida | 0821
13728394 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0823 | Výlevka nástěnnï | 0823
13728475 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0826 | Výlevka nástěnnð | 0826
13733496 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1045 | Fáze 1 | TR10.15.0842 | Toaleta + modul (madla, lehká kce)_invalida | 0842
14005369 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1045 | Fáze 1 | TR10.15.0845 | Toaleta + modul | 0845
14005661 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1045 | Fáze 1 | TR10.15.0860 | Výlevka nástěnnó | 0860
14006030 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1045 | Fáze 1 | TR10.15.0867 | Výlevka nástěnnõ | 0867
14007103 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 1045 | Fáze 2 | TR10.15.0872 | Toaleta + modul (madla, lehká kce)_invalida | 0872
14007268 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 1045 | Fáze 2 | TR10.15.0879 | Toaleta + modul (madla, lehká kce)_invalida | 0879
14007299 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 1045 | Fáze 2 | TR10.15.0886 | Toaleta + modul (madla, lehká kce)_invalida | 0886
14007328 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1045 | Fáze 2 | TR10.15.0893 | Toaleta + modul (madla, lehká kce)_invalida | 0893

# IfcFlowTerminal: Sedimentační nádrž:Sedimentační nádrž, Sedimentační nádrž:Sedimentační nádrž:13505309
In: -1.PP_SO-102
Type - Classification: RT00 SNIM (SNIM); Material: <Unnamed>
Type - Identifikační data - Kód sestavy: RT00; Komentáře k typům: SEDIMENTAČNÍ NÁDRŽ PRO SBĚR KALU Z PROVOZU BRUSIČSKÉ DÍLNY; Název typu: Sedimentační nádrž; Označení typu: 41; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Sedimentační nádrž
Classification: RT00 SNIM (SNIM); RT00 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: CMA; CCI Technický systém: JB
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 2
Kóty - Objem: 11.1191 m3; Plocha: 3.17687 m2
Identifikační data - Kód prvku: RT00.41.0743; Označení: 0743
Jiné - Páteřní trasa: yes; Id typu: 13505307; Rodina: Sedimentační nádrž; Rodina a typ: Sedimentační nádrž: Sedimentační nádrž; Typ: Sedimentační nádrž

# IfcFlowTerminal: Sprchová hlavice:Sprchová hlavice (6)
In: -2.PP_SO-102
Type - Classification: ZT00 SNIM (SNIM); Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka hlavice: 250 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZT00; Komentáře k typům: Komentáře k typům; Model: Model; Název typu: Sprchová hlavice; Označení typu: 12; Popis: Popis; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Sprchová hlavice
Classification: ZT00 SNIM (SNIM); ZT00 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABE; CCI Technický systém: JB
Vazby - Podlaží: -1.PP_SO-102; Hostitel: Podlaží : -1.PP_SO-102; Odsazení od hostitele: 2043.7 mm; Výška od podlaží: 2043.7 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Teplá voda v domácnosti
Kóty - Objem: 0.000326978 m3; Plocha: 0.0418796 m2
Identifikační data - Název sestavy: Sprchový kout + modul (podomítková baterie)
Jiné - Id typu: 12832414; Rodina: Sprchová hlavice; Rodina a typ: Sprchová hlavice: Sprchová hlavice; Typ: Sprchová hlavice
Name (Sprchová hlavice:Sprchová hlavice:...) | Kód prvku | Označení
12833265 | ZT00.12.0017 | 0017
12833330 | ZT00.12.0020 | 0020
12886122 | ZT00.12.0263 | 0263
14005435 | ZT00.12.0848 | 0848
14005465 | ZT00.12.0851 | 0851
14005517 | ZT00.12.0854 | 0854

# IfcFlowTerminal: Sprchová stěna 900x900mm:Sprchová stěna 900x900mm (8)
Type - Classification: ZT00 SNIM (SNIM); Material: Sprcha
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Stěny: Sprcha
Type - Kóty - DÉLKA: 900 mm; Délka dveří: 452 mm; ŠÍŘKA: 900 mm; VÝŠKA: 1900 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZT00; Komentáře k typům: pevná Lyra plus 90cm, výplň transparent; Model: H297382; Název typu: Sprchová stěna 900x900mm; Označení typu: 03; Popis: Sprchová stěna; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Jika
Type - Jiné - Kategorie: Instalační zařizovací předměty; B1: 428 mm; B2: 428 mm; Název rodiny: Sprchová stěna 900x900mm
Classification: ZT00 SNIM (SNIM); ZT00 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABE; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 0 mm; Pracovní rovina: Sprchová vanička 900x900mm : Sprchová vanička 900x900mm; Výška od podlaží: 163 mm
Grafika - Dveře otevřené: no
Kóty - Objem: 0.006688 m3
Identifikační data - Název sestavy: Sprchový kout - vanička (nástěnná baterie)
Jiné - Id typu: 12798064; OTD: 875 mm; OTS: 875 mm; Rodina: Sprchová stěna 900x900mm; Rodina a typ: Sprchová stěna 900x900mm: Sprchová stěna 900x900mm; Typ: Sprchová stěna 900x900mm
Name (Sprchová stěna 900x900mm:Sprchová stěna 900x900mm:...) | In | Podlaží = Vztažné podlaží | Fáze vytvoření | Kód prvku | Označení
12797923 | -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | ZT00.03.0003 | 0003
12805483 | -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | ZT00.03.0008 | 0008
12833683 | -2.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | ZT00.03.0029 | 0029
12833747 | -2.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | ZT00.03.0034 | 0034
12893442 | 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | ZT00.03.0394 | 0394
12893487 | 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | ZT00.03.0399 | 0399
12893966 | 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | ZT00.03.0404 | 0404
13325305 | -1.PP_SO-102 | -1.PP_SO-102 | Fáze 2 | ZT00.03.0717 | 0717

# IfcFlowTerminal: Sprchová vanička 900x900mm:Sprchová vanička 900x900mm (8)
Type - Classification: ZT08 SNIM (SNIM); Material: PLAST_BÍLÝ
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Vanička: PLAST_BÍLÝ
Type - Kóty - DÉLKA: 900 mm; JMENOVITÝ PRŮMĚR: 50 mm; ŠÍŘKA: 900 mm; VÝŠKA: 63 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: SP.01; Kód sestavy: ZT08; Komentáře k typům: Jika Olymp sprchová vanička čtvercová, vestavená, 900x900 mm, bílá; Model: 2.1183.2.000.000.1; Název typu: Sprchová vanička 900x900mm; Označení typu: 01; Popis: Sprchová vanička; Popis sestavy: Sprchový kout; URL: www.cadconsulting.cz; Výrobce: Jika
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Sprchová vanička 900x900mm; V1: 33 mm
Classification: ZT08 SNIM (SNIM); ZT08 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABE; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 100 mm; Výška od podlaží: 100 mm
Mechanické - Klasifikace systému: Sanitární; PRŮTOK_VODA: 0 m3/s
Kóty - Objem: 0.0105296 m3
Identifikační data - ID pozice: 01; ID systému: 001; Název sestavy: Sprchový kout - vanička (nástěnná baterie)
Jiné - Id typu: 12798062; Rodina: Sprchová vanička 900x900mm; Rodina a typ: Sprchová vanička 900x900mm: Sprchová vanička 900x900mm; Typ: Sprchová vanička 900x900mm
Name (Sprchová vanička 900x900mm:Sprchová vanička 900x900mm:...) | In | Hostitel | Podlaží | Fáze vytvoření | Kód prvku | Označení
12797919 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | ZT08.01.0001 | 0001
12805479 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | ZT08.01.0006 | 0006 | Identifikační data - ID instance: 001
12833679 | -2.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | ZT08.01.0027 | 0027 | Identifikační data - ID instance: 001
12833743 | -2.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | ZT08.01.0032 | 0032 | Identifikační data - ID instance: 001
12893438 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | ZT08.01.0392 | 0392
12893483 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | ZT08.01.0397 | 0397
12893962 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | ZT08.01.0402 | 0402
13325301 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 2 | ZT08.01.0715 | 0715

# IfcFlowTerminal: Sprchový set k vanové baterii:Sprchový set k vanové baterii, Sprchový set k vanové baterii:Sprchový set k vanové baterii:12864818
In: 1.NP_SO-102
Type - Classification: ZT00 SNIM (SNIM); Material: CHROM
Type - Vazby - Výchozí výška: 750 mm
Type - Materiály a povrchové úpravy - Materiál: CHROM
Type - Identifikační data - Kód sestavy: ZT00; Komentáře k typům: k vanové baterii, Jet 1, set = ruční sprcha + nástěnný držák + hadice (set s max. průtokem 10l/min); Model: HansaBasicJet 1; Název typu: Sprchový set k vanové baterii; Označení typu: 19; Popis: sprchový set; Popis sestavy: Obecný prvek; Výrobce: HANSA
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Sprchový set k vanové baterii
Classification: ZT00 SNIM (SNIM); ZT00 Uniformat (Uniformat); Group: WS_Studená vnitřní 24
Text - CCI Funkční systém: F; CCI Komponenta: ABE; CCI Technický systém: JB
Vazby - Podlaží: 1.NP_SO-102; Vztažné podlaží: 1.NP_SO-102; Odsazení od hostitele: 20 mm; Pracovní rovina: <nepřiřazeno>; Výška od podlaží: 775.032 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_Studená vnitřní; Klasifikace systému: Studená voda v domácnosti; Název systému: WS_Studená vnitřní 24
Kóty - Objem: 0.0003307 m3; Rozteč: 150 mm
Identifikační data - Kód prvku: ZT00.19.0040; Název sestavy: Vana (nástěnná baterie); Označení: 0040
Jiné - Id typu: 12859105; Rodina: Sprchový set k vanové baterii; Rodina a typ: Sprchový set k vanové baterii: Sprchový set k vanové baterii; Typ: Sprchový set k vanové baterii

# IfcFlowTerminal: Sprchový set ke sprchové baterii:Sprchový set ke sprchové baterii (8)
Type - Classification: ZT00 SNIM (SNIM); Material: CHROM
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Materiál: CHROM
Type - Kóty - JMENOVITÝ PRŮMĚR: 15 mm
Type - Identifikační data - Kód sestavy: ZT00; Komentáře k typům: ke sprchové baterii; Model: HansaBasicJet 44670130; Název typu: Sprchový set ke sprchové baterii; Označení typu: 04; Popis: Sprchový set; Popis sestavy: Obecný prvek; Výrobce: HANSA
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Sprchový set ke sprchové baterii
Classification: ZT00 SNIM (SNIM); ZT00 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABE; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 1180 mm; Výška od podlaží: 1180 mm
Mechanické - Klasifikace systému: Teplá voda v domácnosti; PRŮTOK_VODA: 0 m3/s; Typ systému: WS_Teplá vnitřní
Kóty - Objem: 0.00116093 m3; Rozteč: 150 mm
Identifikační data - Název sestavy: Sprchový kout - vanička (nástěnná baterie)
Jiné - Id typu: 12798060; Rodina: Sprchový set ke sprchové baterii; Rodina a typ: Sprchový set ke sprchové baterii: Sprchový set ke sprchové baterii; Typ: Sprchový set ke sprchové baterii
Name (Sprchový set ke sprchové baterii:Sprchový set ke sprchové baterii:...) | In | Podlaží | Hostitel | Fáze vytvoření | Název systému = Group | Kód prvku | Označení
12797925 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | WS_Teplá vnitřní 1 | ZT00.04.0004 | 0004
12805485 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | WS_Teplá vnitřní 3 | ZT00.04.0009 | 0009
12833685 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | WS_Teplá vnitřní 6 | ZT00.04.0030 | 0030
12833749 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | WS_Teplá vnitřní 2 | ZT00.04.0035 | 0035
12893444 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní 20 | ZT00.04.0395 | 0395
12893489 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní 95 | ZT00.04.0400 | 0400
12893968 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní 66 | ZT00.04.0405 | 0405
13325307 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | WS_Teplá vnitřní 16 | ZT00.04.0718 | 0718

# IfcFlowTerminal: Střešní vpust 125 S:TW 125 BIT S svislé provedení, manžeta z asfaltového pásu (6)
Type - Classification: VP01 SNIM (SNIM); Material: Plast - hnědý, Plast - černý
Type - Mechanické – tok - PRŮTOK: 0.009 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Límec_Materiál: Plast - černý
Type - Kóty - Délka: 330 mm; Jmenovitá velikost výstupu: 125 mm; JMENOVITÝ PRŮMĚR: 125 mm; Šířka: 330 mm; Výška: 210 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.70.50.21.24; COPYRIGHT: ©TOPWET; Indexovaná poznámka: TW 125 BIT S; Kód sestavy: VP01; Komentáře k typům: STŘEŠNÍ VPUST; Model: viz OBJEDNACÍ KÓD; Nadpis OmniClass: Waste Water Drains; Název typu: TW 125 BIT S svislé provedení, manžeta z asfaltového pásu; Označení typu: 32; Popis: Vpusť; Popis sestavy: Střešní; Typ obrázku: TW 75 BIT S.jpg; URL: http://www.topwet.cz/produkty/10-svisla-stresni-vpust-s-integrovanou-bitumenovou-manzetou; Výrobce: TOPWET
Type - Jiné - Kategorie: Instalační zařizovací předměty; Elektrické vyhřívání_Vpusť: no; Název rodiny: Střešní vpust 125 S; T: 1
Classification: VP01 SNIM (SNIM); VP01 Uniformat (Uniformat); Group: SW_Deště vnitřní podtlak 4
Text - CCI Funkční systém: F; CCI Komponenta: XKE; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: SW_Deště vnitřní podtlak; Klasifikace systému: Sanitární; Název systému: SW_Deště vnitřní podtlak 4
Grafika - Mechanická zápachová uzávěrka: yes; Nástavec střešní vpusti TWN: no; Perforovaný ochranný koš TWOK: no; Perforovaný terasový nástavec TW TER P: no; Plochý ochranný koš TW PLK: yes; Šachta pro zelené střechy 300x300: no; Šachta pro zelené střechy 400x400: no; Terasový nástavec TW TER: no; Typ nástavce střešní vpusti TWN: Nástavec střešní vpusti TWN : TWNE BIT vyhřívaný; Vodní zápachová uzávěrka: no
Kóty - Nástavec střešní vpusti TWN_výška: 300 mm; Objem: 0.00192185 m3; Odvodňovací kroužek TW ODK_k nástavci TW TER P: 1; Perforovaný ochranný koš TWOK_počet nástavců: 3; Perforovaný terasový nástavec TW TER P_výška: 220 mm; Šachta pro zelené střechy_výška: 500 mm; Terasový nástavec TW TER_výška: 150 mm
Identifikační data - OBJEDNACÍ KÓD: TW 125 BIT S
Jiné - Páteřní trasa: yes; Id typu: 13221469; MZK: 39 mm; NOK: 0 mm; Ochranný koš: no; OKB: no; Perforovaný terasový nástavec TW TER P_Odvodňovací kroužky: no; POK: 0 mm; Rodina: Střešní vpust 125 S; Rodina a typ: Střešní vpust 125 S: TW 125 BIT S svislé provedení, manžeta z asfaltového pásu; SZS: 3 mm; TER: 2; TERC: no; TNP: 107 mm; Typ: TW 125 BIT S svislé provedení, manžeta z asfaltového pásu; VK: 0 mm; VN: 368.7 mm; VOK: 47.7 mm; VPK: 8.5 mm; VS: 113 mm; VTN: 62.7 mm; VZ: 110 mm; VZU: 101 mm; ZUM: 29.2 mm
Name (Střešní vpust 125 S:TW 125 BIT S svislé provedení, manžeta z asfaltového pásu:...) | In | Podlaží = Vztažné podlaží | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Pracovní rovina | Kód prvku | Označení
13238105 | 3.NP_SO-102 | 3.NP_SO-102 | 220 | Podlaží : 3.NP_SO-102 | VP01.32.0698 | 0698
13238236 | 3.NP_SO-102 | 3.NP_SO-102 | 0 | Podlaží : 3.NP_SO-102 | VP01.32.0699 | 0699
13238237 | 3.NP_SO-102 | 3.NP_SO-102 | 0 | Podlaží : 3.NP_SO-102 | VP01.32.0700 | 0700
13238383 | 4.NP_SO-102 | 4.NP_SO-102 | -0.99995 | Podlaží : 4.NP_SO-102 | VP01.32.0701 | 0701
13238390 | 4.NP_SO-102 | 4.NP_SO-102 | -0.299985 | Podlaží : 4.NP_SO-102 | VP01.32.0702 | 0702
13706111 | 3.NP_SO-102 | 3.NP_SO-102 | 220.001 | Podlaží : 3.NP_SO-102 | VP01.32.0814 | 0814

# IfcFlowTerminal: Uliční vpusť:DN160, Uliční vpusť:DN160:14014592
In: 1.NP_SO-102
Type - Material: Plactic - Black, Plactic - White, Cast iron, Plactic - Gray
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - JMENOVITÝ PRŮMĚR: 160 mm
Type - Identifikační data - Číslo OmniClass: 23.70.50.21.24.14; DIMENZE: DN160; EAN: 9003076970612; HMOTNOST: 11,885 kg; HYDRAULICKÁ KAPACITA: 4,3 l/s; Indexovaná poznámka: HL606.1/5; Komentáře k typům: ULIČNÍ VPUST - UV1; MATERIÁL: PP; Model: HL606.1/5; Nadpis OmniClass: Deck Waste Water Drains; NÁSTAVEC: 260 x 260 mm Guss; Název typu: DN160; Označení typu: 48; Popis: Perfekt dvorní vtok DN160 se svislým odtokem; PRÁVNÍ OZNÁMENÍ: "Copyright (©), autorská a jiná práva spojená s duševním vlastnictvím, jsou výhradním vlastnictvím společnosti HL Hutterer & Lechner GmbH. Úpravy nejsou dovoleny. Rodina je opatřená vodoznakem."; STAVEBNÍ VÝŠKA: 213 mm; TŘÍDA ZATÍŽENÍ: B - 12,5 t (außen); URL: http://www.hutterer-lechner.com/cs/products/catalog/roof-drains/HL606.1/5.aspx; VTOKOVÁ MŘÍŽKA: Gusseisen 226 x 226 mm; Výrobce: HL Hutterer & Lechner GmbH
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Uliční vpusť
Classification: Uniformat (Uniformat); Group: SW_Deště vnitřní gravitační 5
Text - CCI Funkční systém: F; CCI Komponenta: WPA; CCI Technický systém: JD
Vazby - Podlaží: 1.NP_SO-102; Hostitel: Podlaží : 1.NP_SO-102; Odsazení od hostitele: -3880 mm; Výška od podlaží: -3880 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: SW_Deště vnitřní gravitační; Klasifikace systému: Sanitární; Název systému: SW_Deště vnitřní gravitační 5; PRŮTOK: 0 m3/s
Kóty - Objem: 0.00431103 m3; Stavební výška 1: 0 mm; Stavební výška 2: 0 mm
Identifikační data - Kód prvku: .48.0900; Komentáře: OPATŘENO ZPĚTNOU KLAPKOU; Označení: 0900
Jiné - Páteřní trasa: yes; A: 15 mm; B: 100 mm; C: 0 mm; D: 190 mm; G: 180 deg; Id typu: 14014574; IH: 0 mm; Rodina: Uliční vpusť; Rodina a typ: Uliční vpusť: DN160; Typ: DN160

# IfcFlowTerminal: Umyvadlo:Umyvadlo (112)
Type - Classification: ZT05 SNIM (SNIM); Material: <Unnamed>, PLAST_BÍLÝ
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s
Type - Materiály a povrchové úpravy - Materiál: PLAST_BÍLÝ
Type - Kóty - JMENOVITÝ PRŮMĚR: 40 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZT05; Komentáře k typům: Umyvadlo; Název typu: Umyvadlo; Označení typu: 07; Popis: U; Popis sestavy: Umyvadlo; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Umyvadlo
Classification: ZT05 SNIM (SNIM); ZT05 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Mechanické - Klasifikace systému: Sanitární
Kóty - Objem: 0.0234229 m3
Jiné - Typ: Umyvadlo; Id typu: 12812717; Rodina: Umyvadlo; Rodina a typ: Umyvadlo: Umyvadlo
Name (Umyvadlo:Umyvadlo:...) | In | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Název sestavy | Označení
12825620 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZT05.07.0012 | Umyvadlo | 0012
12865978 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT05.07.0042 | Umyvadlo + modul | 0042
12871082 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZT05.07.0050 | Umyvadlo + modul | 0050
12871110 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZT05.07.0054 | Umyvadlo + modul | 0054
12871171 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZT05.07.0058 | Umyvadlo + modul | 0058
12879372 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT05.07.0078 | Umyvadlo + modul | 0078
12879413 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT05.07.0082 | Umyvadlo + modul | 0082
12879442 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT05.07.0086 | Umyvadlo + modul | 0086
12879473 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT05.07.0090 | Umyvadlo + modul | 0090
12879500 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT05.07.0094 | Umyvadlo + modul | 0094
12879529 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT05.07.0098 | Umyvadlo + modul | 0098
12880691 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0129 | Umyvadlo + modul | 0129
12880705 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0133 | Umyvadlo + modul | 0133
12880733 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0137 | Umyvadlo + modul | 0137
12880747 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0141 | Umyvadlo + modul | 0141
12880761 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0145 | Umyvadlo + modul | 0145
12880861 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT05.07.0173 | Umyvadlo + modul | 0173
12880875 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT05.07.0177 | Umyvadlo + modul | 0177
12880903 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT05.07.0181 | Umyvadlo + modul | 0181
12880917 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT05.07.0185 | Umyvadlo + modul | 0185
12880931 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT05.07.0189 | Umyvadlo + modul | 0189
12881031 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT05.07.0217 | Umyvadlo + modul | 0217
12881045 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT05.07.0221 | Umyvadlo + modul | 0221
12881073 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT05.07.0225 | Umyvadlo + modul | 0225
12881087 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT05.07.0229 | Umyvadlo + modul | 0229
12881101 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT05.07.0233 | Umyvadlo + modul | 0233
12881932 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0249 | Umyvadlo + modul | 0249
12884681 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0255 | Umyvadlo | 0255
12884791 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0258 | Umyvadlo | 0258
12886217 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZT05.07.0265 | Umyvadlo + modul | 0265
12888132 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT05.07.0269 | Umyvadlo + modul | 0269
12888839 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0273 | Umyvadlo + modul | 0273
12888863 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0277 | Umyvadlo + modul | 0277
12889673 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0281 | Umyvadlo + modul | 0281
12890305 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0297 | Umyvadlo + modul | 0297
12890332 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0301 | Umyvadlo + modul | 0301
12890443 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0305 | Umyvadlo + modul | 0305
12890828 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0318 | Umyvadlo + modul | 0318
12890852 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0322 | Umyvadlo + modul | 0322
12891273 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT05.07.0326 | Umyvadlo + modul | 0326
12891684 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0330 | Umyvadlo + modul | 0330
12891775 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0334 | Umyvadlo + modul | 0334
12891848 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0338 | Umyvadlo + modul | 0338
12891920 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0342 | Umyvadlo + modul | 0342
12891995 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0346 | Umyvadlo + modul | 0346
12892061 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0350 | Umyvadlo + modul | 0350
12892278 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT05.07.0354 | Umyvadlo + modul | 0354
12892345 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT05.07.0358 | Umyvadlo + modul | 0358
12892411 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT05.07.0362 | Umyvadlo + modul | 0362
12892477 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT05.07.0366 | Umyvadlo + modul | 0366
12892542 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT05.07.0370 | Umyvadlo + modul | 0370
12892795 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT05.07.0377 | Umyvadlo + modul | 0377
12892898 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT05.07.0381 | Umyvadlo + modul | 0381
12893029 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT05.07.0385 | Umyvadlo + modul | 0385
12893154 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT05.07.0389 | Umyvadlo + modul | 0389
12894055 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT05.07.0408 | Umyvadlo + modul | 0408
12894121 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT05.07.0412 | Umyvadlo + modul | 0412
12894200 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT05.07.0416 | Umyvadlo + modul | 0416
12894264 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT05.07.0420 | Umyvadlo + modul | 0420
12894325 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT05.07.0424 | Umyvadlo + modul | 0424
12894670 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | ZT05.07.0431 | Umyvadlo + modul | 0431
12894784 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZT05.07.0435 | Umyvadlo + modul | 0435
12895094 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZT05.07.0451 | Umyvadlo + modul | 0451
12895277 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZT05.07.0458 | Umyvadlo + modul | 0458
12895301 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZT05.07.0462 | Umyvadlo + modul | 0462
12895432 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZT05.07.0466 | Umyvadlo + modul | 0466
12895778 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZT05.07.0470 | Umyvadlo + modul | 0470
12896132 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZT05.07.0486 | Umyvadlo + modul | 0486
12896332 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZT05.07.0493 | Umyvadlo + modul | 0493
12896400 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZT05.07.0497 | Umyvadlo + modul | 0497
12896713 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZT05.07.0501 | Umyvadlo + modul | 0501
12896773 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZT05.07.0505 | Umyvadlo + modul | 0505
12896889 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZT05.07.0509 | Umyvadlo + modul | 0509
12896913 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZT05.07.0513 | Umyvadlo + modul | 0513
12897286 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZT05.07.0532 | Umyvadlo + modul | 0532
12897359 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZT05.07.0536 | Umyvadlo + modul | 0536
12897410 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZT05.07.0540 | Umyvadlo + modul | 0540
12897441 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZT05.07.0544 | Umyvadlo + modul | 0544
12897748 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZT05.07.0548 | Umyvadlo + modul | 0548
12897772 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZT05.07.0552 | Umyvadlo + modul | 0552
12898196 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZT05.07.0571 | Umyvadlo + modul | 0571
12898220 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZT05.07.0575 | Umyvadlo + modul | 0575
12898542 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZT05.07.0579 | Umyvadlo + modul | 0579
12898593 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZT05.07.0583 | Umyvadlo + modul | 0583
12899098 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT05.07.0587 | Umyvadlo + modul | 0587
12899469 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZT05.07.0597 | Umyvadlo + modul | 0597
12899619 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZT05.07.0607 | Umyvadlo + modul | 0607
12992011 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0623 | Umyvadlo + modul | 0623
12992029 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0627 | Umyvadlo + modul | 0627
13068775 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT05.07.0644 | Umyvadlo + modul | 0644
13068913 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT05.07.0648 | Umyvadlo + modul | 0648
13071944 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT05.07.0652 | Umyvadlo + modul | 0652
13102564 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT05.07.0656 | Umyvadlo + modul | 0656
13102679 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT05.07.0660 | Umyvadlo + modul | 0660
13105034 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0664 | Umyvadlo + modul | 0664
13154250 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZT05.07.0685 | Umyvadlo + modul | 0685
13401871 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0736 | Umyvadlo | 0736
13505811 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZT05.07.0745 | Umyvadlo + modul | 0745
13505919 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZT05.07.0749 | Umyvadlo + modul | 0749
13506561 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZT05.07.0753 | Umyvadlo + modul | 0753
13506634 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT05.07.0757 | Umyvadlo + modul | 0757
13506744 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT05.07.0761 | Umyvadlo + modul | 0761
13506812 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT05.07.0765 | Umyvadlo + modul | 0765
13525883 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZT05.07.0770 | Umyvadlo + modul | 0770
13526116 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZT05.07.0774 | Umyvadlo + modul | 0774
13526367 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZT05.07.0778 | Umyvadlo + modul | 0778
13526784 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZT05.07.0782 | Umyvadlo + modul | 0782
13544044 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZT05.07.0786 | Umyvadlo + modul | 0786
13544813 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT05.07.0789 | Umyvadlo | 0789
13545420 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT05.07.0799 | Umyvadlo + modul | 0799
13546117 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT05.07.0802 | Umyvadlo | 0802
14030744 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | ZT05.07.0901 | Umyvadlo | 0901

# IfcFlowTerminal: Umyvadlo_invalida:Umyvadlo_invalida (6)
Type - Classification: ZT05 SNIM (SNIM); Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Type - Materiály a povrchové úpravy - Materiál: ZDRAVOTNÍ KERAMIKA
Type - Kóty - JMENOVITÝ PRŮMĚR: 40 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: UMi; Kód sestavy: ZT05; Komentáře k typům: Invalida umyvadlo; Název typu: Umyvadlo_invalida; Označení typu: 43; Popis: Umyvadlo invalida; Popis sestavy: Umyvadlo; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Umyvadlo_invalida
Classification: ZT05 SNIM (SNIM); ZT05 Uniformat (Uniformat); Material: <Unnamed>, ZDRAVOTNÍ KERAMIKA
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Mechanické - Klasifikace systému: Sanitární
Kóty - Objem: 0.0364769 m3
Jiné - Id typu: 13720222; Rodina: Umyvadlo_invalida; Rodina a typ: Umyvadlo_invalida: Umyvadlo_invalida; Typ: Umyvadlo_invalida
Name (Umyvadlo_invalida:Umyvadlo_invalida:...) | In | Podlaží = Vztažné podlaží | Pracovní rovina | Fáze vytvoření | Kód prvku | Název sestavy | Označení
14005580 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZT05.43.0858 | Výlevka nástěnnò | 0858
14005961 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZT05.43.0865 | Výlevka nástěnnô | 0865
14007222 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZT05.43.0876 | Výlevka nástěnnö | 0876
14007283 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZT05.43.0883 | Výlevka nástěnnö | 0883
14007314 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZT05.43.0890 | Výlevka nástěnnö | 0890
14007343 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZT05.43.0897 | Výlevka nástěnnö | 0897

# IfcFlowTerminal: Umyvadlo_invalida:Umyvadlo_invalida (4)
Type - Classification: ZT05 SNIM (SNIM); Material: <Unnamed>, ZDRAVOTNÍ KERAMIKA
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Type - Materiály a povrchové úpravy - Materiál: ZDRAVOTNÍ KERAMIKA
Type - Kóty - JMENOVITÝ PRŮMĚR: 40 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: UMi; Kód sestavy: ZT05; Komentáře k typům: Invalida umyvadlo; Název typu: Umyvadlo_invalida; Označení typu: 43; Popis: Umyvadlo invalida; Popis sestavy: Umyvadlo; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Umyvadlo_invalida
Classification: ZT05 SNIM (SNIM); ZT05 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární
Kóty - Objem: 0.0364769 m3
Jiné - Id typu: 13720222; Rodina: Umyvadlo_invalida; Rodina a typ: Umyvadlo_invalida: Umyvadlo_invalida; Typ: Umyvadlo_invalida
Name (Umyvadlo_invalida:Umyvadlo_invalida:...) | In | Podlaží = Vztažné podlaží | Pracovní rovina | Kód prvku | Název sestavy | Označení
13725013 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | ZT05.43.0817 | Výlevka nástěnnî | 0817
13728621 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | ZT05.43.0831 | Výlevka nástěnnñ | 0831
13728678 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | ZT05.43.0835 | Výlevka nástěnnñ | 0835
13733490 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | ZT05.43.0838 | Výlevka nástěnnî | 0838

# IfcFlowTerminal: Vana:Vana, Vana:Vana:12864814
In: 1.NP_SO-102
Type - Classification: ZT07 SNIM (SNIM); Material: Ocel-Bílá
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s
Type - Materiály a povrchové úpravy - Materiál: Ocel-Bílá
Type - Kóty - JMENOVITÝ PRŮMĚR: 40 mm
Type - Identifikační data - Kód sestavy: ZT07; Komentáře k typům: Eurowa 312, odpad u nohou, bílá, 1700/700mm, max 180/80 cm (do max. užitného objemu 200l); Model: Kaldewei EUROWA 312; Název typu: Vana; Označení typu: 16; Popis: Vana obdélníková; Popis sestavy: Vana; Výrobce: Kaldewei
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Vana
Classification: ZT07 SNIM (SNIM); ZT07 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Hostitel: Podlaží : 1.NP_SO-102; Odsazení od hostitele: 137.4 mm; Podlaží: 1.NP_SO-102; Výška od podlaží: 137.4 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární
Kóty - Objem: 0.0538937 m3
Identifikační data - Kód prvku: ZT07.16.0037; Název sestavy: Vana (nástěnná baterie); Označení: 0037
Jiné - Id typu: 12859103; Rodina: Vana; Rodina a typ: Vana: Vana; Typ: Vana

# IfcFlowTerminal: Výlevka nástěnná_malá:Výlevka nástěnná_malá (3)
In: 3.NP_SO-102
Type - Classification: ZT04 SNIM (SNIM); Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - JMENOVITÝ PRŮMĚR: 40 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZT04; Komentáře k typům: zavěšená nerezová výlevka SLVN 01, DN40; Model: SLVN 01; Název typu: Výlevka nástěnná_malá; Označení typu: 28; Popis: Výlevka; Popis sestavy: Výlevka; URL: www.cadconsulting.cz; Výrobce: Sanela
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Výlevka nástěnná_malá
Classification: ZT04 SNIM (SNIM); ZT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Podlaží: 4.NP_SO-102; Hostitel: Podlaží : 4.NP_SO-102; Odsazení od hostitele: 307.517 mm; Výška od podlaží: 307.517 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární; PRŮTOK_VODA: 0 m3/s
Kóty - Objem: 0.00626936 m3
Identifikační data - Název sestavy: Výlevka DN50_modul+nástěnná baterie
Jiné - Id typu: 12873588; Rodina: Výlevka nástěnná_malá; Rodina a typ: Výlevka nástěnná_malá: Výlevka nástěnná_malá; Typ: Výlevka nástěnná_malá
Name (Výlevka nástěnná_malá:Výlevka nástěnná_malá:...) | Kód prvku | Označení
12932540 | ZT04.28.0610 | 0610
12937667 | ZT04.28.0614 | 0614
12937710 | ZT04.28.0618 | 0618

# IfcFlowTerminal: Výlevka nástěnná_velká:Výlevka nástěnná_velká (7)
Type - Classification: ZT04 SNIM (SNIM); Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - JMENOVITÝ PRŮMĚR: 100 mm; JMENOVITÝ PRŮMĚR 2: 55 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZT04; Komentáře k typům: Výlevka keramická Jika Mira závěsná s plast. mřížkou bílá; Model: H8510490000001 234015540500000003; Název typu: Výlevka nástěnná_velká; Označení typu: 10; Popis: Výlevka; Popis sestavy: Výlevka; URL: www.cadconsulting.cz; Výrobce: JIKA
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Výlevka nástěnná_velká
Classification: ZT04 SNIM (SNIM); ZT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Mechanické - Klasifikace systému: Sanitární; PRŮTOK_VODA: 0 m3/s
Kóty - Objem: 0.050226 m3
Identifikační data - Název sestavy: Výlevka + modul
Jiné - Id typu: 12825702; Rodina: Výlevka nástěnná_velká; Rodina a typ: Výlevka nástěnná_velká: Výlevka nástěnná_velká; Typ: Výlevka nástěnná_velká
Name (Výlevka nástěnná_velká:Výlevka nástěnná_velká:...) | In | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
12828508 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZT04.10.0015 | 0015
12895160 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZT04.10.0455 | 0455
12896221 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZT04.10.0490 | 0490
12897198 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZT04.10.0529 | 0529
12898141 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZT04.10.0568 | 0568
12992060 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT04.10.0637 | 0637
13691385 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT04.10.0809 | 0809

# IfcFlowTerminal: Výpusť umyvadlová:Výpusť dřezová (6)
Type - Classification: ZT00 SNIM (SNIM); Material: CHROM
Type - Vazby - Výchozí výška: 850 mm
Type - Materiály a povrchové úpravy - Materiál: CHROM
Type - Identifikační data - Kód sestavy: ZT00; Komentáře k typům: click clack; Název typu: Výpusť dřezová; Označení typu: 40; Popis: Dřezová výpusť; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Výpusť umyvadlová
Classification: ZT00 SNIM (SNIM); ZT00 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 0 mm; Pracovní rovina: Dřez_centrovaný.CC : Dřez_centrovaný.CC; Výška od podlaží: 664.572 mm
Kóty - Objem: 0.00000865422 m3
Jiné - Rodina: Výpusť umyvadlová; Id typu: 13399816; Rodina a typ: Výpusť umyvadlová: Výpusť dřezová; Typ: Výpusť dřezová
Name (Výpusť umyvadlová:Výpusť dřezová:...) | In | Podlaží = Vztažné podlaží | Fáze vytvoření | Kód prvku | Název sestavy | Označení
13401581 | -1.PP_SO-102 | -1.PP_SO-102 | Fáze 2 | ZT00.40.0729 | Výlevka nástěnné | 0729
13401608 | 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | ZT00.40.0732 | Výlevka nástěnné | 0732
13401729 | 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | ZT00.40.0735 | Výlevka nástěnnê | 0735
13545099 | 3.NP_SO-102 | 3.NP_SO-102 | Fáze 2 | ZT00.40.0793 | Výlevka nástěnnë | 0793
13545321 | -2.PP_SO-102 | 4.NP_SO-102 | Fáze 1 | ZT00.40.0796 | Výlevka nástěnnë | 0796
13550216 | 3.NP_SO-102 | 3.NP_SO-102 | Fáze 1 | ZT00.40.0807 | Výlevka nástěnnê | 0807

# IfcFlowTerminal: Výpusť umyvadlová:Výpusť umyvadlová (123)
Type - Classification: ZT00 SNIM (SNIM); Material: CHROM
Type - Vazby - Výchozí výška: 850 mm
Type - Materiály a povrchové úpravy - Materiál: CHROM
Type - Identifikační data - Kód sestavy: ZT00; Komentáře k typům: click clack; Název typu: Výpusť umyvadlová; Označení typu: 21; Popis: Dřezová výpusť; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Výpusť umyvadlová
Classification: ZT00 SNIM (SNIM); ZT00 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 0 mm
Kóty - Objem: 0.00000865422 m3
Jiné - Id typu: 12866106; Rodina: Výpusť umyvadlová; Rodina a typ: Výpusť umyvadlová: Výpusť umyvadlová; Typ: Výpusť umyvadlová
Name (Výpusť umyvadlová:Výpusť umyvadlová:...) | In | Podlaží = Vztažné podlaží | Pracovní rovina | Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Název sestavy | Označení
12866071 | -1.PP_SO-102 | 1.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0047 | Umyvadlo + modul | 0047
12869694 | -2.PP_SO-102 | -1.PP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0048 | Umyvadlo | 0048
12871093 | -2.PP_SO-102 | -1.PP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0052 | Umyvadlo + modul | 0052
12871121 | -2.PP_SO-102 | -1.PP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0056 | Umyvadlo + modul | 0056
12871182 | -2.PP_SO-102 | -1.PP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0060 | Umyvadlo + modul | 0060
12879383 | -1.PP_SO-102 | 1.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0080 | Umyvadlo + modul | 0080
12879424 | -1.PP_SO-102 | 1.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0084 | Umyvadlo + modul | 0084
12879453 | -1.PP_SO-102 | 1.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0088 | Umyvadlo + modul | 0088
12879484 | -1.PP_SO-102 | 1.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0092 | Umyvadlo + modul | 0092
12879511 | -1.PP_SO-102 | 1.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0096 | Umyvadlo + modul | 0096
12879540 | -1.PP_SO-102 | 1.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0100 | Umyvadlo + modul | 0100
12880702 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0131 | Umyvadlo + modul | 0131
12880716 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0135 | Umyvadlo + modul | 0135
12880744 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0139 | Umyvadlo + modul | 0139
12880758 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0143 | Umyvadlo + modul | 0143
12880772 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0147 | Umyvadlo + modul | 0147
12880872 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0175 | Umyvadlo + modul | 0175
12880886 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0179 | Umyvadlo + modul | 0179
12880914 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0183 | Umyvadlo + modul | 0183
12880928 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0187 | Umyvadlo + modul | 0187
12880942 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0191 | Umyvadlo + modul | 0191
12881042 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0219 | Umyvadlo + modul | 0219
12881056 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0223 | Umyvadlo + modul | 0223
12881084 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0227 | Umyvadlo + modul | 0227
12881098 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0231 | Umyvadlo + modul | 0231
