Properties of the parts of a building model (IFC4), part 39 of 60

# IfcPipeFitting: M_Přechod, obecný:Standardní (184)
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Délka (mm) | Jmenovitý poloměr 1 (mm) | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Max. vnější průměr tvarovky 12 (mm) | Šířkové odsazení (mm) | Viditelnost 2 | Viditelnost 3 | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm) | Výškové odsazení (mm) | Group
13473922 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.1256 | 1256 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 134
13473996 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 2373.58 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1264 | 1264 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Studená vnitřní 134
13474034 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 2403.61 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1266 | 1266 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Studená vnitřní 134
13474047 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 15.8675 | 0.00129727 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1269 | 1269 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3047.87 | WS_Teplá vnitřní 83
13474112 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 15.8675 | 0.00129727 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1274 | 1274 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3047.87 | WS_Teplá vnitřní 83
13486231 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1292 | 1292 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Studená vnitřní 134
13486240 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1293 | 1293 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Studená vnitřní 134
13519807 | 1.NP_SO-102 | ø40 mm-ø25 mm | 1.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10.3188 | 20 | 12.5 | 40 | 25 | 40 | 25 | 0.00000994592 | 20 | 20 | 0.00193705 | ø40-ø25 | 16.51 | 11.43 | 41.275 | 28.575 | TT00.05.1332 | 1332 | no | 41.275 | 3048 | yes | no | 14.2875 | 20.6375 | 3048 | WS_"Jiný typ" studená vnitřní 1
13522757 | 2.NP_SO-102 | ø40 mm-ø32 mm | 2.NP_SO-102 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT00.05.1336 | 1336 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | 3048 | WS_Teplá vnitřní 83
13524053 | 1.NP_SO-102 | ø40 mm-ø32 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT00.05.1340 | 1340 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | 3048 | WS_Studená vnitřní 134
13524089 | 1.NP_SO-102 | ø40 mm-ø25 mm | 1.NP_SO-102 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10.3188 | 20 | 12.5 | 40 | 25 | 40 | 25 | 0.00000994592 | 20 | 20 | 0.00193705 | ø40-ø25 | 16.51 | 11.43 | 41.275 | 28.575 | TT00.05.1342 | 1342 | no | 41.275 | 3048 | yes | no | 14.2875 | 20.6375 | 3048 | WS_Studená vnitřní 134
13524345 | 2.NP_SO-102 | ø40 mm-ø32 mm | 2.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT00.05.1346 | 1346 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | 3048 | WS_Studená vnitřní 134
13524382 | 2.NP_SO-102 | ø40 mm-ø25 mm | 2.NP_SO-102 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10.3188 | 20 | 12.5 | 40 | 25 | 40 | 25 | 0.00000994592 | 20 | 20 | 0.00193705 | ø40-ø25 | 16.51 | 11.43 | 41.275 | 28.575 | TT00.05.1349 | 1349 | no | 41.275 | 3048 | yes | no | 14.2875 | 20.6375 | 3048 | WS_Studená vnitřní 134
13524423 | 2.NP_SO-102 | ø40 mm-ø25 mm | 2.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10.3188 | 20 | 12.5 | 40 | 25 | 40 | 25 | 0.00000994592 | 20.2306 | 20 | 0.00193628 | ø40-ø25 | 16.51 | 11.43 | 41.275 | 28.575 | TT00.05.1352 | 1352 | no | 41.275 | 3048.23 | yes | no | 14.2875 | 20.6375 | 3048 | WS_Teplá vnitřní 83
13525002 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.1356 | 1356 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 134
13525246 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.1359 | 1359 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 134
13525753 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.1368 | 1368 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 8
13525783 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.1370 | 1370 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 6
13526003 | 3.NP_SO-102 | ø32 mm-ø25 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.1374 | 1374 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 8
13526049 | 3.NP_SO-102 | ø32 mm-ø25 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.1377 | 1377 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 6
13526453 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.1379 | 1379 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 8
13526497 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.1381 | 1381 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 6
13532767 | 2.NP_SO-102 | ø40 mm-ø25 mm | 2.NP_SO-102 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10.3188 | 20 | 12.5 | 40 | 25 | 40 | 25 | 0.00000994592 | 20 | 20 | 0.00193705 | ø40-ø25 | 16.51 | 11.43 | 41.275 | 28.575 | TT00.05.1398 | 1398 | yes | 41.275 | 3048 | yes | no | 14.2875 | 20.6375 | 3048 | WS_Teplá vnitřní 83
13532897 | 3.NP_SO-102 | ø40 mm-ø32 mm | 3.NP_SO-102 | 3383.34 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT00.05.1399 | 1399 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | 3048 | WS_Studená vnitřní 134
13533233 | 2.NP_SO-102 | ø40 mm-ø25 mm | 2.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10.3188 | 20 | 12.5 | 40 | 25 | 40 | 25 | 0.00000994592 | 20 | 20 | 0.00193705 | ø40-ø25 | 16.51 | 11.43 | 41.275 | 28.575 | TT00.05.1401 | 1401 | no | 41.275 | 3048 | yes | no | 14.2875 | 20.6375 | 3048 | WS_"Jiný typ" studená vnitřní 1
13534556 | 3.NP_SO-102 | ø40 mm-ø25 mm | 3.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10.3188 | 20 | 12.5 | 40 | 25 | 40 | 25 | 0.00000994592 | 20 | 20 | 0.00193705 | ø40-ø25 | 16.51 | 11.43 | 41.275 | 28.575 | TT00.05.1425 | 1425 | no | 41.275 | 3048 | yes | no | 14.2875 | 20.6375 | 3048 | WS_"Jiný typ" studená vnitřní 1
13536227 | -1.PP_SO-102 | ø63 mm-ø50 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16.5437 | 25 | 31.5 | 50 | 63 | 63 | 50 | 0.0000470007 | 25 | 25 | 0.00542487 | ø63-ø50 | 21.59 | 26.47 | 53.975 | 66.175 | TT00.05.1429 | 1429 | yes | 66.175 | 3048 | no | yes | 33.0875 | 26.9875 | 3048 | WS_"Jiný typ" studená vnitřní 1
13544142 | 4.NP_SO-102 | ø50 mm-ø25 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 13.4938 | 12.5 | 25 | 25 | 50 | 50 | 25 | 0.0000185945 | 12.5 | 12.5 | 0.00290744 | ø50-ø25 | 11.43 | 21.59 | 28.575 | 53.975 | TT00.05.1434 | 1434 | yes | 53.975 | 3048 | no | yes | 26.9875 | 14.2875 | 3048 | WS_Teplá vnitřní 8
13544163 | 4.NP_SO-102 | ø50 mm-ø25 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 13.4938 | 12.5 | 25 | 25 | 50 | 50 | 25 | 0.0000185945 | 12.5 | 12.5 | 0.00290744 | ø50-ø25 | 11.43 | 21.59 | 28.575 | 53.975 | TT00.05.1437 | 1437 | yes | 53.975 | 3048 | no | yes | 26.9875 | 14.2875 | 3048 | WS_Studená vnitřní 6
13573408 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 2369.84 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1458 | 1458 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13641425 | -1.PP_SO-102 | ø40 mm-ø20 mm | -1.PP_SO-102 | 3300.33 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT00.05.1487 | 1487 | yes | 41.275 | 3048 | yes | no | 11.1125 | 20.6375 | 3048 | WS_Teplá vnitřní 83 | Mechanické – tok - Tlaková ztráta: 0 Pa
13641669 | -1.PP_SO-102 | ø32 mm-ø20 mm | -1.PP_SO-102 | 3300.3 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1491 | 1491 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Cirkulace vnitřní 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13641880 | -1.PP_SO-102 | ø32 mm-ø20 mm | -1.PP_SO-102 | 3300.3 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1493 | 1493 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Cirkulace vnitřní 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13641983 | -1.PP_SO-102 | ø40 mm-ø20 mm | -1.PP_SO-102 | 3300.33 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT00.05.1497 | 1497 | yes | 41.275 | 3048 | yes | no | 11.1125 | 20.6375 | 3048 | WS_"Jiný typ" studená vnitřní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13642194 | -1.PP_SO-102 | ø40 mm-ø20 mm | -1.PP_SO-102 | 3100.33 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT00.05.1499 | 1499 | yes | 41.275 | 3048 | yes | no | 11.1125 | 20.6375 | 3048 | WS_Studená vnitřní 134 | Mechanické – tok - Tlaková ztráta: 0 Pa
13642227 | -1.PP_SO-102 | ø32 mm-ø20 mm | -1.PP_SO-102 | 3100.3 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1501 | 1501 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Cirkulace vnitřní 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13642273 | -1.PP_SO-102 | ø40 mm-ø20 mm | -1.PP_SO-102 | 3100.33 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT00.05.1503 | 1503 | yes | 41.275 | 3048 | yes | no | 11.1125 | 20.6375 | 3048 | WS_Teplá vnitřní 83 | Mechanické – tok - Tlaková ztráta: 0 Pa
13642505 | -1.PP_SO-102 | ø40 mm-ø20 mm | -1.PP_SO-102 | 2650.53 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT00.05.1507 | 1507 | yes | 41.275 | 3048 | yes | no | 11.1125 | 20.6375 | 3048 | WS_"ŠEDÁ" studená vnitřní 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13642571 | -1.PP_SO-102 | ø32 mm-ø20 mm | -1.PP_SO-102 | 2650.3 | Fáze 2 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 3 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1511 | 1511 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Cirkulace vnitřní 3 | Mechanické – tok - Tlaková ztráta: 0 Pa
13646057 | 2.NP_SO-102 | ø40 mm-ø32 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT00.05.1538 | 1538 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | 3048 | WS_Studená vnitřní 134
13646341 | 3.NP_SO-102 | ø32 mm-ø20 mm | 3.NP_SO-102 | 3360.03 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1541 | 1541 | no | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13646496 | 3.NP_SO-102 | ø40 mm-ø25 mm | 3.NP_SO-102 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10.3188 | 20 | 12.5 | 40 | 25 | 40 | 25 | 0.00000994592 | 20 | 20 | 0.00193705 | ø40-ø25 | 16.51 | 11.43 | 41.275 | 28.575 | TT00.05.1546 | 1546 | yes | 41.275 | 3048 | yes | no | 14.2875 | 20.6375 | 3048 | WS_Teplá vnitřní 83
13646515 | 3.NP_SO-102 | ø32 mm-ø25 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.1548 | 1548 | yes | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Studená vnitřní 134
13646856 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 12.5 | 32 | 25 | 32 | 25 | 0.00000690657 | 16 | 16 | 0.00146184 | ø32-ø25 | 13.97 | 11.43 | 34.925 | 28.575 | TT00.05.1552 | 1552 | no | 34.925 | 3048 | yes | no | 14.2875 | 17.4625 | 3048 | WS_Teplá vnitřní 83
13704889 | 2.NP_SO-102 | ø40 mm-ø25 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 10.3188 | 20 | 12.5 | 40 | 25 | 40 | 25 | 0.00000994592 | 20 | 20 | 0.00193705 | ø40-ø25 | 16.51 | 11.43 | 41.275 | 28.575 | TT00.05.1726 | 1726 | no | 41.275 | 3048 | yes | no | 14.2875 | 20.6375 | 3048 | WS_Cirkulace vnitřní 9
13704891 | 2.NP_SO-102 | ø40 mm-ø25 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 10.3188 | 20 | 12.5 | 40 | 25 | 40 | 25 | 0.00000994592 | 20 | 20 | 0.00193705 | ø40-ø25 | 16.51 | 11.43 | 41.275 | 28.575 | TT00.05.1727 | 1727 | no | 41.275 | 3048 | yes | no | 14.2875 | 20.6375 | 3048 | WS_Cirkulace vnitřní 9
13705810 | -1.PP_SO-102 | ø50 mm-ø25 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 25 | 25 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.05.1736 | 1736 | yes | 53.975 | 3048 | yes | no | 14.2875 | 26.9875 | 3048 | WS_Teplá vnitřní 83
13705818 | -1.PP_SO-102 | ø63 mm-ø50 mm | -1.PP_SO-102 | 2410 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16.5437 | 31.5 | 25 | 63 | 50 | 63 | 50 | 0.000047016 | 31.5 | 31.5 | 0.00542487 | ø63-ø50 | 26.47 | 21.59 | 66.175 | 53.975 | TT00.05.1737 | 1737 | yes | 66.175 | 3048 | yes | no | 26.9875 | 33.0875 | 3048 | WS_Teplá vnitřní 83
13823439 | -1.PP_SO-102 | ø50 mm-ø25 mm | -1.PP_SO-102 | 2760.31 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 25 | 25 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.05.1829 | 1829 | no | 53.975 | 3048 | yes | no | 14.2875 | 26.9875 | 3048 | WS_Teplá vnitřní 83
13823659 | -1.PP_SO-102 | ø63 mm-ø20 mm | -1.PP_SO-102 | 2545.79 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16.5437 | 31.5 | 10 | 63 | 20 | 63 | 20 | 0.0000274375 | 31.5 | 31.5 | 0.00400175 | ø63-ø20 | 26.47 | 8.89 | 66.175 | 22.225 | TT00.05.1834 | 1834 | no | 66.175 | 3048 | yes | no | 11.1125 | 33.0875 | 3048 | WS_"Jiný typ" studená vnitřní 1
13825620 | -1.PP_SO-102 | ø63 mm-ø40 mm | -1.PP_SO-102 | 3254.21 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16.5437 | 31.5 | 20 | 63 | 40 | 63 | 40 | 0.0000381367 | 31.5 | 31.5 | 0.00479601 | ø63-ø40 | 26.47 | 16.51 | 66.175 | 41.275 | TT00.05.1849 | 1849 | yes | 66.175 | 3048 | yes | no | 20.6375 | 33.0875 | 3048 | WS_Teplá vnitřní 83
13825678 | -1.PP_SO-102 | ø63 mm-ø40 mm | -1.PP_SO-102 | 3180.65 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16.5437 | 31.5 | 20 | 63 | 40 | 63 | 40 | 0.0000381367 | 31.5 | 31.5 | 0.00479601 | ø63-ø40 | 26.47 | 16.51 | 66.175 | 41.275 | TT00.05.1852 | 1852 | yes | 66.175 | 3048 | yes | no | 20.6375 | 33.0875 | 3048 | WS_Studená vnitřní 134
13828824 | -1.PP_SO-102 | ø40 mm-ø32 mm | -1.PP_SO-102 | 3366.66 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT00.05.1881 | 1881 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | 3048 | WS_Cirkulace vnitřní 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13828955 | -1.PP_SO-102 | ø63 mm-ø40 mm | -1.PP_SO-102 | 3354.21 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16.5437 | 31.5 | 20 | 63 | 40 | 63 | 40 | 0.0000381367 | 31.5 | 31.5 | 0.00479601 | ø63-ø40 | 26.47 | 16.51 | 66.175 | 41.275 | TT00.05.1884 | 1884 | yes | 66.175 | 3048 | yes | no | 20.6375 | 33.0875 | 3048 | WS_Teplá vnitřní 83
13829345 | -1.PP_SO-102 | ø63 mm-ø40 mm | -1.PP_SO-102 | 3354.21 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16.5437 | 31.5 | 20 | 63 | 40 | 63 | 40 | 0.0000381367 | 31.5 | 31.5 | 0.00479601 | ø63-ø40 | 26.47 | 16.51 | 66.175 | 41.275 | TT00.05.1891 | 1891 | yes | 66.175 | 3048 | yes | no | 20.6375 | 33.0875 | 3048 | WS_Studená vnitřní 134
13839898 | -1.PP_SO-102 | ø40 mm-ø32 mm | -1.PP_SO-102 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT00.05.1959 | 1959 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | 3048 | WS_Cirkulace vnitřní 9
13839900 | -1.PP_SO-102 | ø40 mm-ø32 mm | -1.PP_SO-102 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT00.05.1960 | 1960 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | 3048 | WS_Cirkulace vnitřní 9

# IfcPipeFitting: M_Přechod, obecný:Standardní (3)
In: -1.PP_SO-102
Type - Classification: TT00 SNIM (SNIM); Material: 255-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 05; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat); Group: SW_Odvětrání kanalizace 16
Izolace - Tloušťka izolace: 0 mm
Text - CCI Komponenta: QMA; CCI Technický systém: JB
Vazby - Podlaží: -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: SW_Odvětrání kanalizace; Klasifikace systému: Průduch; Název systému: SW_Odvětrání kanalizace 16
Grafika - Použít měřítko poznámky: no
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Šířkové odsazení: 3048 mm; Viditelnost 1: no; Výškové odsazení: 3048 mm; Viditelnost 2: no; Viditelnost 3: yes
Name (M_Přechod, obecný:Standardní:...) | Celková velikost | Tlaková ztráta (Pa) | CCI Funkční systém | Výška od podlaží (mm) | Délka (mm) | Jmenovitý poloměr 1 (mm) = Odskok – šířka = Odskok – výška | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = Minimální velikost (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = Maximální velikost (mm) = DN tvarovky 2 (sdílený) (mm) | Objem (m3) | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) = Max. vnější průměr tvarovky 12 (mm) | Kód prvku | Označení | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm)
13156692 | ø110 mm-ø75 mm | 0 | G | -3441.56 | 28.2938 | 37.5 | 55 | 75 | 110 | 0.000205589 | 0.0148314 | ø110-ø75 | 31.27 | 45.27 | 78.175 | 113.175 | TT00.05.0868 | 0868 | 56.5875 | 39.0875
13704458 | ø135 mm-ø110 mm |  | G | 2872.94 | 34.5438 | 55 | 67.5 | 110 | 135 | 0.000429795 | 0.0243449 | ø135-ø110 | 45.27 | 55.27 | 113.175 | 138.175 | TT00.05.1719 | 1719 | 69.0875 | 56.5875
13981225 | ø110 mm-ø75 mm | 0 | F | -2661.56 | 28.2938 | 37.5 | 55 | 75 | 110 | 0.000205589 | 0.0148314 | ø110-ø75 | 31.27 | 45.27 | 78.175 | 113.175 | TT00.05.2003 | 2003 | 56.5875 | 39.0875

# IfcPipeFitting: M_Spoj T, obecný:Standardní (161)
Type - Classification: TT00 SNIM (SNIM); Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: WMB; CCI Technický systém: JB
Grafika - Použít měřítko poznámky: no
Kóty - Úhel: 90 deg
Jiné - Typ: Standardní; Úhel tvarovky 1 (sdílený): 90 deg; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní; Úhel 1: 90 deg
Name (M_Spoj T, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) = Štítek, od středu ke konci (mm) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Vnější poloměr tvarovky (mm)
12948053 | 4.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0021 | 0021 | yes | 14.2875
12948580 | 4.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0024 | 0024 | yes | 14.2875
12950258 | 4.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0036 | 0036 | no | 11.1125
12954281 | 4.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 4.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0049 | 0049 | no | 11.1125
12956206 | 3.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0063 | 0063 | yes | 14.2875
12956226 | 3.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0065 | 0065 | yes | 14.2875
12956258 | 3.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 3.NP_SO-102 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.0069 | 0069 | yes | 20.6375
12956466 | 1.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0073 | 0073 | yes | 14.2875
12965154 | 4.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 4.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0080 | 0080 | yes | 14.2875
12966228 | 3.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0089 | 0089 | yes | 14.2875
12967615 | 3.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0104 | 0104 | yes | 14.2875
12968117 | 3.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 3.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.0115 | 0115 | yes | 20.6375
12968202 | 1.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 1.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.0117 | 0117 | yes | 20.6375
12971222 | 2.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0133 | 0133 | yes | 14.2875
12971230 | 2.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0135 | 0135 | yes | 14.2875
12971308 | 2.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0148 | 0148 | yes | 14.2875
12971356 | 2.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0161 | 0161 | yes | 14.2875
12995597 | 2.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0189 | 0189 | no | 11.1125
12995644 | 2.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0190 | 0190 | no | 11.1125
12995763 | 2.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0191 | 0191 | no | 11.1125
12995875 | 2.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-102 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0194 | 0194 | no | 11.1125
12995962 | 2.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-102 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0195 | 0195 | no | 11.1125
12996025 | 2.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-102 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0196 | 0196 | no | 11.1125
12996640 | 2.NP_SO-102 | ø50 mm-ø50 mm-ø50 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0202 | 0202 | no | 26.9875
12996671 | 2.NP_SO-102 | ø50 mm-ø50 mm-ø50 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0204 | 0204 | no | 26.9875
12996754 | 2.NP_SO-102 | ø50 mm-ø50 mm-ø50 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0206 | 0206 | no | 26.9875
12996787 | 2.NP_SO-102 | ø50 mm-ø50 mm-ø50 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0209 | 0209 | no | 26.9875
12997443 | 2.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0213 | 0213 | no | 11.1125
12997447 | 2.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-102 | 1250 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0214 | 0214 | no | 11.1125
12997767 | 2.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0216 | 0216 | no | 11.1125
12997969 | 2.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0217 | 0217 | no | 11.1125
12998071 | 2.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0220 | 0220 | no | 11.1125
12999059 | 2.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0227 | 0227 | no | 14.2875
12999183 | 2.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-102 | 2401.41 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0228 | 0228 | no | 14.2875
13000002 | 2.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0244 | 0244 | no | 11.1125
13000074 | 2.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0246 | 0246 | no | 11.1125
13001612 | 4.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 4.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0271 | 0271 | no | 14.2875
13003379 | 3.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0276 | 0276 | no | 14.2875
13003447 | 3.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 3.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0278 | 0278 | yes | 14.2875
13003637 | 2.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 2.NP_SO-102 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.0284 | 0284 | yes | 20.6375
13003821 | 1.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0294 | 0294 | yes | 14.2875
13003859 | 1.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 1.NP_SO-102 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.0295 | 0295 | yes | 20.6375
13003889 | 1.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 1.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0299 | 0299 | yes | 14.2875
13004673 | 3.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 3.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0305 | 0305 | no | 11.1125
13004701 | 3.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0307 | 0307 | no | 11.1125
13004836 | 3.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0309 | 0309 | no | 11.1125
13004951 | 3.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 3.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0311 | 0311 | no | 11.1125
13005651 | 3.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 3.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0321 | 0321 | no | 14.2875
13005686 | 2.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0325 | 0325 | no | 14.2875
13005719 | 1.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 1.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0328 | 0328 | no | 14.2875
13008163 | 2.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0337 | 0337 | yes | 14.2875
13008276 | 2.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0339 | 0339 | yes | 14.2875
13008360 | 2.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0343 | 0343 | yes | 14.2875
13008387 | 2.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0345 | 0345 | yes | 14.2875
13009591 | 1.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 1.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0352 | 0352 | no | 14.2875
13010259 | 1.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 1.NP_SO-102 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0363 | 0363 | no | 11.1125
13011777 | 3.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 3.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0373 | 0373 | yes | 14.2875
13011799 | 3.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0374 | 0374 | yes | 14.2875
13012640 | 1.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 1.NP_SO-102 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.0380 | 0380 | yes | 20.6375
13014546 | 2.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-102 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0397 | 0397 | yes | 14.2875
13014587 | 3.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 3.NP_SO-102 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0399 | 0399 | yes | 11.1125
13015239 | 3.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 3.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.0407 | 0407 | yes | 20.6375
13015482 | 2.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.0411 | 0411 | yes | 20.6375
13015528 | 1.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 1.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.0414 | 0414 | yes | 20.6375
13022552 | -1.PP_SO-102 | ø50 mm-ø50 mm-ø50 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0429 | 0429 | yes | 26.9875
13022610 | -1.PP_SO-102 | ø50 mm-ø50 mm-ø50 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0431 | 0431 | yes | 26.9875
13023109 | -1.PP_SO-102 | ø50 mm-ø50 mm-ø50 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0436 | 0436 | yes | 26.9875
13025089 | 4.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0443 | 0443 | yes | 14.2875
13025505 | 4.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0451 | 0451 | no | 14.2875
13025530 | 4.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0453 | 0453 | no | 14.2875
13026289 | 4.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 4.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0460 | 0460 | no | 11.1125
13027008 | 4.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 4.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0467 | 0467 | yes | 11.1125
13027473 | 4.NP_SO-102 | ø50 mm-ø50 mm-ø50 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0471 | 0471 | yes | 26.9875
13027512 | 4.NP_SO-102 | ø50 mm-ø50 mm-ø50 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0476 | 0476 | yes | 26.9875
13027951 | 4.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0480 | 0480 | yes | 14.2875
13030412 | 3.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0502 | 0502 | no | 14.2875
13030420 | 3.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0504 | 0504 | no | 14.2875
13030454 | 3.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 3.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0510 | 0510 | no | 11.1125
13030564 | 3.NP_SO-102 | ø50 mm-ø50 mm-ø50 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0520 | 0520 | yes | 26.9875
13030576 | 3.NP_SO-102 | ø50 mm-ø50 mm-ø50 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0525 | 0525 | yes | 26.9875
13030819 | 2.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0546 | 0546 | no | 14.2875
13030827 | 2.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0548 | 0548 | no | 14.2875
13030861 | 2.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0554 | 0554 | no | 11.1125
13030971 | 2.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0566 | 0566 | yes | 14.2875
13030983 | 2.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0571 | 0571 | yes | 14.2875
13031228 | 1.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0592 | 0592 | no | 14.2875
13031236 | 1.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0594 | 0594 | no | 14.2875
13031270 | 1.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 1.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0600 | 0600 | no | 11.1125
13031639 | 3.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 3.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0617 | 0617 | yes | 11.1125
13031643 | 3.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 3.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0618 | 0618 | yes | 11.1125
13031683 | 2.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0619 | 0619 | yes | 11.1125
13031687 | 2.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0620 | 0620 | yes | 14.2875
13031753 | 2.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.0621 | 0621 | yes | 20.6375
13031791 | 2.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.0622 | 0622 | yes | 20.6375
13031831 | 1.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 1.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0623 | 0623 | yes | 11.1125
13031835 | 1.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 1.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.0624 | 0624 | yes | 20.6375
13031879 | 1.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.0625 | 0625 | yes | 20.6375
13031906 | 1.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 1.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.0626 | 0626 | yes | 20.6375
13033521 | 3.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0645 | 0645 | yes | 14.2875
13033825 | 3.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0648 | 0648 | yes | 14.2875
13034114 | 3.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0652 | 0652 | yes | 14.2875
13034184 | 3.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0655 | 0655 | yes | 14.2875
13034397 | 2.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0663 | 0663 | yes | 14.2875
13034722 | 2.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0666 | 0666 | yes | 14.2875
13035287 | 1.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 1.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0673 | 0673 | yes | 14.2875
13035562 | 1.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0674 | 0674 | yes | 14.2875
13035975 | -1.PP_SO-102 | ø50 mm-ø50 mm-ø50 mm | -1.PP_SO-102 | 2649.95 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0684 | 0684 | yes | 26.9875
13036031 | -1.PP_SO-102 | ø50 mm-ø50 mm-ø50 mm | -1.PP_SO-102 | 2649.8 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0686 | 0686 | yes | 26.9875
13080210 | 2.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.0774 | 0774 | no | 11.1125
13080846 | -1.PP_SO-102 | ø50 mm-ø50 mm-ø50 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.0775 | 0775 | yes | 26.9875
13154317 | 1.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0854 | 0854 | yes | 14.2875
13154325 | 1.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 1.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0856 | 0856 | yes | 14.2875
13154410 | 1.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 1.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0859 | 0859 | yes | 14.2875
13168936 | -1.PP_SO-102 | ø25 mm-ø25 mm-ø25 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0891 | 0891 | yes | 14.2875
13169241 | -1.PP_SO-102 | ø25 mm-ø25 mm-ø25 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0894 | 0894 | yes | 14.2875
13169712 | 3.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 3.NP_SO-102 | 3366.44 | Fáze 2 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0902 | 0902 | yes | 14.2875
13170052 | 1.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 1.NP_SO-102 | 3200 | Fáze 2 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.0910 | 0910 | yes | 14.2875
13335586 | 4.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 4.NP_SO-102 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.1067 | 1067 | no | 14.2875
13361423 | 3.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.1130 | 1130 | no | 14.2875
13361477 | 3.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 3.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.1133 | 1133 | no | 14.2875
13519799 | 1.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 1.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.1331 | 1331 | yes | 20.6375
13522749 | 2.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 2.NP_SO-102 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.1335 | 1335 | yes | 20.6375
13524045 | 1.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.1339 | 1339 | yes | 20.6375
13524081 | 1.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 1.NP_SO-102 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.1341 | 1341 | yes | 20.6375
13524337 | 2.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 2.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.1345 | 1345 | yes | 20.6375
13524374 | 2.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 2.NP_SO-102 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.1348 | 1348 | yes | 20.6375
13524415 | 2.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 2.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.1351 | 1351 | yes | 20.6375
13533225 | 2.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 2.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.1400 | 1400 | yes | 20.6375
13534548 | 3.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 3.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.1424 | 1424 | yes | 20.6375
13641417 | -1.PP_SO-102 | ø40 mm-ø40 mm-ø40 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.1486 | 1486 | yes | 20.6375
