Properties of the parts of a building model (IFC4), part 32 of 60

# IfcPipeFitting: M_Koleno, obecné:Standardní (1248)
Name (M_Koleno, obecné:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm) | Group
13359014 | 3.NP_SO-102 | ø89 mm-ø89 mm | 3.NP_SO-102 | 3366.44 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1111 | 1111 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13359146 | 3.NP_SO-102 | ø50 mm-ø50 mm | 3.NP_SO-102 | 1300 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1112 | 1112 | yes | 33.3375 | 26.9875 | WS_Požární nezavodněný 1
13359972 | 4.NP_SO-102 | ø89 mm-ø89 mm | 4.NP_SO-102 | 838.788 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1124 | 1124 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13361196 | 3.NP_SO-102 | ø32 mm-ø32 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1127 | 1127 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13361317 | 3.NP_SO-102 | ø32 mm-ø32 mm | 3.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1128 | 1128 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 83
13361394 | 3.NP_SO-102 | ø32 mm-ø32 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1129 | 1129 | no | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13361450 | 3.NP_SO-102 | ø32 mm-ø32 mm | 3.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1132 | 1132 | no | 23.8125 | 17.4625 | WS_Teplá vnitřní 83
13362698 | 4.NP_SO-102 | ø160 mm-ø160 mm | 4.NP_SO-102 | 2589.71 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 80 | 160 | 0.00288854 | 87.9375 | 90 | ø160-ø160 | 65.27 | 163.175 | TT01.02.1135 | 1135 | yes | 87.9375 | 81.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13362702 | 4.NP_SO-102 | ø160 mm-ø160 mm | 4.NP_SO-102 | 2589.71 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 1 | 80 | 160 | 0.00288854 | 87.9375 | 90 | ø160-ø160 | 65.27 | 163.175 | TT01.02.1136 | 1136 | yes | 87.9375 | 81.5875 | SW_Odvětrání kanalizace 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13363037 | 3.NP_SO-102 | ø110 mm-ø110 mm | 3.NP_SO-102 | 2969.11 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.1137 | 1137 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13363554 | 3.NP_SO-102 | ø78 mm-ø78 mm | 3.NP_SO-102 | 3362.4 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 20 | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.1138 | 1138 | yes | 46.9375 | 40.5875 | SW_Odvětrání kanalizace 20 | Mechanické – tok - Tlaková ztráta: 0 Pa
13370521 | -1.PP_SO-102 | ø20 mm-ø20 mm | -1.PP_SO-102 | 3225.94 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1141 | 1141 | no | 17.4625 | 11.1125 | WS_"ŠEDÁ" studená vnitřní 2
13370533 | -1.PP_SO-102 | ø20 mm-ø20 mm | -1.PP_SO-102 | 3225.94 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1142 | 1142 | no | 17.4625 | 11.1125 | WS_"ŠEDÁ" studená vnitřní 2
13370576 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3225.94 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1143 | 1143 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13370586 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3225.94 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1144 | 1144 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13370627 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3225.59 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1145 | 1145 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13370639 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3225.59 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1146 | 1146 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13399296 | -1.PP_SO-102 | ø135 mm-ø135 mm | -1.PP_SO-102 | 983.951 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 1 | 67.5 | 135 | 0.000888398 | 31.2472 | 45 | ø135-ø135 | 22.8936 | 138.175 | TT01.02.1147 | 1147 | yes | 75.4375 | 69.0875 | SW_Deště vnitřní gravitační 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13399426 | -1.PP_SO-102 | ø135 mm-ø135 mm | -1.PP_SO-102 | 726.218 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 1 | 67.5 | 135 | 0.000877087 | 30.8063 | 44.4271 | ø135-ø135 | 22.5705 | 138.175 | TT01.02.1148 | 1148 | yes | 75.4375 | 69.0875 | SW_Deště vnitřní gravitační 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13402008 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 1300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1152 | 1152 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13402078 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 1300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1155 | 1155 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13402674 | 3.NP_SO-102 | ø78 mm-ø78 mm | 3.NP_SO-102 | 3362.4 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 20 | 39 | 78 | 0.000381559 | 46.9375 | 90 | ø78-ø78 | 32.47 | 81.175 | TT01.02.1157 | 1157 | yes | 46.9375 | 40.5875 | SW_Odvětrání kanalizace 20 | Mechanické – tok - Tlaková ztráta: 0 Pa
13403175 | 2.NP_SO-102 | ø110 mm-ø110 mm | 2.NP_SO-102 | 1539.34 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.1158 | 1158 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13403209 | 2.NP_SO-102 | ø110 mm-ø110 mm | 2.NP_SO-102 | 1516.22 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.1159 | 1159 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13403836 | 3.NP_SO-102 | ø110 mm-ø110 mm | 3.NP_SO-102 | 2951.29 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 14 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.1161 | 1161 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 14 | Mechanické – tok - Tlaková ztráta: 0 Pa
13412935 | 4.NP_SO-102 | ø78 mm-ø78 mm | 4.NP_SO-102 | 3358.83 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 9 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.1164 | 1164 | yes | 46.9375 | 40.5875 | SW_Odvětrání kanalizace 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13412962 | 4.NP_SO-102 | ø78 mm-ø78 mm | 4.NP_SO-102 | 3300.29 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 8 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.1165 | 1165 | yes | 46.9375 | 40.5875 | SW_Odvětrání kanalizace 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13425926 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1166 | 1166 | yes | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13426715 | -1.PP_SO-102 | ø78 mm-ø78 mm | -1.PP_SO-102 | 3176.61 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.1167 | 1167 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13427018 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2779.49 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.1169 | 1169 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13427238 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 3314.34 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.0009945 | 62.937 | 89.9995 | ø110-ø110 | 45.2696 | 113.175 | TT01.02.1170 | 1170 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13427242 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 3314.34 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.0009945 | 62.937 | 89.9995 | ø110-ø110 | 45.2696 | 113.175 | TT01.02.1171 | 1171 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13428709 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 3787.21 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.1172 | 1172 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13428747 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 3619.12 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497246 | 26.0695 | 44.9999 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.1173 | 1173 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13428913 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 3420.07 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497247 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.1174 | 1174 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13428991 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 2096.09 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.1175 | 1175 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13429314 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 3026.69 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.1176 | 1176 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13429326 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2745.86 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.1177 | 1177 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13429330 | -1.PP_SO-102 | ø200 mm-ø200 mm | -1.PP_SO-102 | 2541.26 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.00287705 | 45.3613 | 44.9905 | ø200-ø200 | 34.1853 | 206.375 | TT01.02.1178 | 1178 | yes | 109.538 | 103.188 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13432713 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | -1557.99 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 62.5 | 125 | 0.000746536 | 29.5835 | 44.9905 | ø125-ø125 | 21.563 | 130.175 | TT01.02.1182 | 1182 | yes | 71.4375 | 65.0875 | SW_Splašky vnitřní gravitační 3
13432732 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | -1503.99 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 62.5 | 125 | 0.000746536 | 29.5835 | 44.9905 | ø125-ø125 | 21.563 | 130.175 | TT01.02.1183 | 1183 | yes | 71.4375 | 65.0875 | SW_Splašky vnitřní gravitační 3
13432742 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | -1486.5 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 62.5 | 125 | 0.000746536 | 29.5835 | 44.9905 | ø125-ø125 | 21.563 | 130.175 | TT01.02.1184 | 1184 | yes | 71.4375 | 65.0875 | SW_Splašky vnitřní gravitační 3
13432886 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | -1175.1 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 62.5 | 125 | 0.000746694 | 29.5904 | 45 | ø125-ø125 | 21.5681 | 130.175 | TT01.02.1186 | 1186 | yes | 71.4375 | 65.0875 | SW_Splašky vnitřní gravitační 3
13432891 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | -1406.69 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 62.5 | 125 | 0.000727682 | 28.757 | 43.8542 | ø125-ø125 | 20.9606 | 130.175 | TT01.02.1187 | 1187 | yes | 71.4375 | 65.0875 | SW_Splašky vnitřní gravitační 3
13434092 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 3386.84 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.1188 | 1188 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Identifikační data - Komentáře: S17
13434227 | 3.NP_SO-102 | ø78 mm-ø78 mm | 3.NP_SO-102 | 3245.62 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.1189 | 1189 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13434231 | 3.NP_SO-102 | ø78 mm-ø78 mm | 3.NP_SO-102 | 3290 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.1190 | 1190 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13434331 | -1.PP_SO-102 | ø78 mm-ø78 mm | -1.PP_SO-102 | 2964.3 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.1191 | 1191 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S16
13434341 | -1.PP_SO-102 | ø78 mm-ø78 mm | -1.PP_SO-102 | 2968.72 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.1192 | 1192 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S16
13434362 | -1.PP_SO-102 | ø78 mm-ø78 mm | -1.PP_SO-102 | 3116.47 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.1193 | 1193 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S16
13434366 | -1.PP_SO-102 | ø78 mm-ø78 mm | -1.PP_SO-102 | 2970.96 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000185919 | 18.8946 | 43.8542 | ø78-ø78 | 13.0707 | 81.175 | TT01.02.1194 | 1194 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S16
13434505 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 3205.23 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.1195 | 1195 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S18
13436524 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | 2447.2 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 80 | 160 | 0.00144417 | 36.4228 | 44.9976 | ø160-ø160 | 27.0341 | 163.175 | TT01.02.1196 | 1196 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13437431 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2844.3 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.00049722 | 26.068 | 44.9976 | ø110-ø110 | 18.7503 | 113.175 | TT01.02.1197 | 1197 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S18
13437491 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2941.04 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000490915 | 25.7017 | 44.4271 | ø110-ø110 | 18.4868 | 113.175 | TT01.02.1198 | 1198 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S18
13437496 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2933.66 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.00049722 | 26.068 | 44.9976 | ø110-ø110 | 18.7503 | 113.175 | TT01.02.1199 | 1199 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S18
13438309 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 3153.09 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.1200 | 1200 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13438323 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2683.35 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.1201 | 1201 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13438665 | -1.PP_SO-102 | ø200 mm-ø200 mm | -1.PP_SO-102 | 2500.82 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.00287704 | 45.3613 | 44.9905 | ø200-ø200 | 34.1853 | 206.375 | TT01.02.1203 | 1203 | yes | 109.538 | 103.188 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13439200 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2782.88 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497247 | 26.0696 | 45 | ø110-ø110 | 18.7515 | 113.175 | TT01.02.1204 | 1204 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13439490 | -1.PP_SO-102 | ø200 mm-ø200 mm | -1.PP_SO-102 | 2202.06 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.00284101 | 44.7316 | 44.4271 | ø200-ø200 | 33.7108 | 206.375 | TT01.02.1206 | 1206 | yes | 109.538 | 103.188 | SW_Splašky vnitřní gravitační 35 (1)
13456548 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 3173.02 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000496928 | 26.051 | 44.9712 | ø110-ø110 | 18.7381 | 113.175 | TT01.02.1209 | 1209 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13456562 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2895.14 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.1210 | 1210 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13461518 | 3.NP_SO-102 | ø78 mm-ø78 mm | 3.NP_SO-102 | 3362.4 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 18 | 39 | 78 | 0.000190778 | 19.4422 | 45.0002 | ø78-ø78 | 13.4496 | 81.175 | TT01.02.1211 | 1211 | yes | 46.9375 | 40.5875 | SW_Odvětrání kanalizace 18 | Mechanické – tok - Tlaková ztráta: 0 Pa
13461899 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 3805.55 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.1214 | 1214 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13461910 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2817.39 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.1215 | 1215 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13462185 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2816.14 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.1216 | 1216 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13462267 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 3331.16 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.1217 | 1217 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13462326 | 3.NP_SO-102 | ø78 mm-ø78 mm | 3.NP_SO-102 | 3331.88 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.1219 | 1219 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13462330 | 3.NP_SO-102 | ø78 mm-ø78 mm | 3.NP_SO-102 | 3290.98 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.1220 | 1220 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13463864 | 2.NP_SO-102 | ø110 mm-ø110 mm | 2.NP_SO-102 | 3357.63 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.1222 | 1222 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13463882 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 3130.51 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.1223 | 1223 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13463920 | 3.NP_SO-102 | ø110 mm-ø110 mm | 3.NP_SO-102 | 3347.65 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.1224 | 1224 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13467065 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -2198.25 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00164389 | 42.1518 | 51.2204 | ø160-ø160 | 31.2864 | 163.175 | TT01.02.1225 | 1225 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3
13467115 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -2304.86 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00192509 | 50.7521 | 59.9818 | ø160-ø160 | 37.6698 | 163.175 | TT01.02.1226 | 1226 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3
13472691 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | -1372.87 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 2 | 62.5 | 125 | 0.000746697 | 29.5905 | 45.0002 | ø125-ø125 | 21.5682 | 130.175 | TT01.02.1228 | 1228 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní gravitační 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13472702 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | -1390.57 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 2 | 62.5 | 125 | 0.000746655 | 29.5886 | 44.9976 | ø125-ø125 | 21.5668 | 130.175 | TT01.02.1229 | 1229 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní gravitační 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13473520 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | -981.675 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 2 | 62.5 | 125 | 0.000746694 | 29.5904 | 45 | ø125-ø125 | 21.5681 | 130.175 | TT01.02.1230 | 1230 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní gravitační 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13473524 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | -1235.9 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 2 | 62.5 | 125 | 0.000737187 | 29.1728 | 44.4271 | ø125-ø125 | 21.2637 | 130.175 | TT01.02.1232 | 1232 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní gravitační 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13473705 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | -2780.55 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 2 | 62.5 | 125 | 0.000746655 | 29.5886 | 44.9976 | ø125-ø125 | 21.5668 | 130.175 | TT01.02.1233 | 1233 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní gravitační 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13473715 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | -2790.15 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 2 | 62.5 | 125 | 0.000746655 | 29.5886 | 44.9976 | ø125-ø125 | 21.5668 | 130.175 | TT01.02.1234 | 1234 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní gravitační 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13473728 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | -2825.35 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 2 | 62.5 | 125 | 0.000746655 | 29.5886 | 44.9976 | ø125-ø125 | 21.5668 | 130.175 | TT01.02.1235 | 1235 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní gravitační 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13473738 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | -2830.95 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 2 | 62.5 | 125 | 0.000746655 | 29.5886 | 44.9976 | ø125-ø125 | 21.5668 | 130.175 | TT01.02.1236 | 1236 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní gravitační 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13473810 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2058.79 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1240 | 1240 | no | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13473825 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2058.79 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1244 | 1244 | no | 23.8125 | 17.4625 | WS_Teplá vnitřní 83
13473903 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2002.33 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1250 | 1250 | no | 23.8125 | 17.4625 | WS_Teplá vnitřní 83
13473924 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2002.33 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1257 | 1257 | no | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13473963 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2404.89 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000176878 | 9.72428 | 44.4271 | ø32-ø32 | 5.70491 | 34.925 | TT01.02.1259 | 1259 | no | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13473966 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2439.82 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000176878 | 9.72428 | 44.4271 | ø32-ø32 | 5.70491 | 34.925 | TT01.02.1260 | 1260 | no | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13473982 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1261 | 1261 | no | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13473990 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 1168.22 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1262 | 1262 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
13474038 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 2399.86 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1267 | 1267 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
13474053 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 2399.87 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1270 | 1270 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83 | Identifikační data - Komentáře: Umyvadlo
13483688 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1278 | 1278 | no | 23.8125 | 17.4625 | WS_Teplá vnitřní 83
13483695 | -1.PP_SO-102 | ø200 mm-ø200 mm | -1.PP_SO-102 | 2008.77 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.00287765 | 45.3719 | 45 | ø200-ø200 | 34.1933 | 206.375 | TT01.02.1280 | 1280 | yes | 109.538 | 103.188 | SW_Splašky vnitřní gravitační 35 (1)
13483697 | -1.PP_SO-102 | ø250 mm-ø250 mm | -1.PP_SO-102 | -1138.65 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 125 | 250 | 0.0109399 | 133.595 | 89.4271 | ø250-ø250 | 101.846 | 257.175 | TT01.02.1281 | 1281 | yes | 134.938 | 128.588 | SW_Splašky vnitřní gravitační 35 (1)
13484938 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -1100 | Fáze 1 | SW_Splašky čerpání | Sanitární | SW_Splašky čerpání 2 | 55 | 110 | 0.00099451 | 62.938 | 90.0004 | ø110-ø110 | 45.2703 | 113.175 | TT01.02.1282 | 1282 | yes | 62.9375 | 56.5875 | SW_Splašky čerpání 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13485196 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 2909.04 | Fáze 1 | SW_Splašky čerpání | Sanitární | SW_Splašky čerpání 2 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.1283 | 1283 | yes | 62.9375 | 56.5875 | SW_Splašky čerpání 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13485439 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1284 | 1284 | no | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13485443 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1285 | 1285 | no | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13485447 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1286 | 1286 | no | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13485486 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1287 | 1287 | no | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13485488 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1288 | 1288 | no | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13485526 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1289 | 1289 | no | 23.8125 | 17.4625 | WS_Teplá vnitřní 83
13485764 | 4.NP_SO-102 | ø32 mm-ø32 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1290 | 1290 | no | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13486144 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 999.923 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.000010648 | 17.4802 | 90.0581 | ø20-ø20 | 8.89901 | 22.225 | TT01.02.1291 | 1291 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13489255 | 3.NP_SO-102 | ø78 mm-ø78 mm | 3.NP_SO-102 | 3082.12 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.1294 | 1294 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13489281 | 3.NP_SO-102 | ø78 mm-ø78 mm | 3.NP_SO-102 | 3392.65 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.1295 | 1295 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13491031 | -1.PP_SO-102 | ø135 mm-ø135 mm | -1.PP_SO-102 | 6461.36 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.000888611 | 31.2556 | 45.0108 | ø135-ø135 | 22.8997 | 138.175 | TT01.02.1296 | 1296 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1)
13494013 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 3354.52 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.1297 | 1297 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13494017 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 3136.37 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.1298 | 1298 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13494406 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 3095.13 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497141 | 26.0634 | 44.9905 | ø110-ø110 | 18.747 | 113.175 | TT01.02.1299 | 1299 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13496698 | 1.NP_SO-102 | ø135 mm-ø135 mm | 1.NP_SO-102 | 2732.36 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.000888406 | 31.2476 | 45.0004 | ø135-ø135 | 22.8938 | 138.175 | TT01.02.1301 | 1301 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13496782 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 3129.99 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190736 | 19.4375 | 44.9903 | ø78-ø78 | 13.4463 | 81.175 | TT01.02.1302 | 1302 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13497049 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 3359.14 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.1303 | 1303 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13504005 | -1.PP_SO-102 | ø315 mm-ø315 mm | -1.PP_SO-102 | -3724.08 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 157.5 | 315 | 0.0206615 | 165.437 | 90 | ø315-ø315 | 127.27 | 318.175 | TT01.02.1305 | 1305 | yes | 165.438 | 159.088 | SW_Deště vnitřní podtlak 4
13506145 | 3.NP_SO-102 | ø78 mm-ø78 mm | 3.NP_SO-102 | 2943.16 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.1308 | 1308 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S21
13506976 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1309 | 1309 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13507018 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1310 | 1310 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13507140 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1311 | 1311 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13507142 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000103942 | 8.54833 | 45 | ø25-ø25 | 4.73446 | 28.575 | TT01.02.1312 | 1312 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13507146 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000103942 | 8.54833 | 45 | ø25-ø25 | 4.73446 | 28.575 | TT01.02.1313 | 1313 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13507194 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1314 | 1314 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13509253 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1315 | 1315 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13509257 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1316 | 1316 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13513878 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2896.63 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1317 | 1317 | yes | 39.4375 | 33.0875 | WS_"Jiný typ" studená vnitřní 1
13514859 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | -2606.42 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 2 | 62.5 | 125 | 0.000746655 | 29.5886 | 44.9976 | ø125-ø125 | 21.5668 | 130.175 | TT01.02.1319 | 1319 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní gravitační 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13516238 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -2543.01 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.1320 | 1320 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 3
13516524 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -2569.01 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.1321 | 1321 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 3
13517199 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 3271.19 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 11 | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.1324 | 1324 | no | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 11
13517231 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2006.7 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 11 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.1325 | 1325 | no | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 11
13517755 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 1859.26 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 11 | 55 | 110 | 0.000994252 | 62.9123 | 89.9771 | ø110-ø110 | 45.2519 | 113.175 | TT01.02.1326 | 1326 | no | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 11
13517811 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 1843.67 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 11 | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.1327 | 1327 | no | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 11
13518310 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 646.898 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 11 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.1328 | 1328 | no | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 11
13518314 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 646.898 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 11 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.1329 | 1329 | no | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 11
13519796 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000208139 | 20.6769 | 90.1092 | ø25-ø25 | 11.4518 | 28.575 | TT01.02.1330 | 1330 | no | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13522745 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1334 | 1334 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 83
13524043 | 1.NP_SO-102 | ø32 mm-ø32 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1338 | 1338 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13524091 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1343 | 1343 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13524335 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1344 | 1344 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13524372 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1347 | 1347 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13524413 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.000020636 | 20.4009 | 89.3393 | ø25-ø25 | 11.2989 | 28.575 | TT01.02.1350 | 1350 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13524449 | 3.NP_SO-102 | ø32 mm-ø32 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1353 | 1353 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13525000 | 4.NP_SO-102 | ø32 mm-ø32 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1355 | 1355 | no | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13525236 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1357 | 1357 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13525279 | 4.NP_SO-102 | ø32 mm-ø32 mm | 4.NP_SO-102 | 3340.16 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1362 | 1362 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13525468 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1363 | 1363 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13525470 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1364 | 1364 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13525530 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1365 | 1365 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13525532 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1366 | 1366 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13525755 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1369 | 1369 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13525801 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1372 | 1372 | yes | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13526005 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1375 | 1375 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13526051 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1378 | 1378 | yes | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13526455 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1380 | 1380 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13526499 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1382 | 1382 | yes | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13526550 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1383 | 1383 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13526552 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1384 | 1384 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13526596 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1385 | 1385 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13526598 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1386 | 1386 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13527507 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -3041.7 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 55 | 110 | 0.000497144 | 26.0636 | 44.9908 | ø110-ø110 | 18.7472 | 113.175 | TT01.02.1388 | 1388 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 3
13527635 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -2452.95 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.1390 | 1390 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 3 | Mechanické – tok - Tlaková ztráta: 0 Pa
13528010 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -3019.82 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.1393 | 1393 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 3
13528844 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -1399.54 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.1394 | 1394 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 3
13531479 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2679.47 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.1395 | 1395 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13531555 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2666.1 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.1396 | 1396 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13532202 | 3.NP_SO-102 | ø32 mm-ø32 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1397 | 1397 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13533256 | 1.NP_SO-102 | ø32 mm-ø32 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1402 | 1402 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13533277 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1404 | 1404 | yes | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13533359 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1407 | 1407 | yes | 26.9875 | 20.6375 | WS_"Jiný typ" studená vnitřní 1
13533363 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1408 | 1408 | yes | 26.9875 | 20.6375 | WS_"Jiný typ" studená vnitřní 1
13533414 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1410 | 1410 | yes | 33.3375 | 26.9875 | WS_Studená vnitřní 134
13533436 | 4.NP_SO-102 | ø32 mm-ø32 mm | 4.NP_SO-102 | 3290.78 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1411 | 1411 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 83
13533497 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1412 | 1412 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13533499 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1413 | 1413 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13533540 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1415 | 1415 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 83
13533542 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1416 | 1416 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 83
13533619 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1418 | 1418 | yes | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13533801 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1422 | 1422 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
13533806 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1423 | 1423 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
13536225 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1428 | 1428 | yes | 33.3375 | 26.9875 | WS_"Jiný typ" studená vnitřní 1
13543651 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 2909.04 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000994554 | 62.9424 | 90.0044 | ø110-ø110 | 45.2735 | 113.175 | TT01.02.1432 | 1432 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1); SW_Splašky čerpání 2
13544140 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1433 | 1433 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13544159 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1435 | 1435 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13544832 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1438 | 1438 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13544863 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1439 | 1439 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13545678 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 3085 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.1440 | 1440 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13545760 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 3003.05 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.1441 | 1441 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
