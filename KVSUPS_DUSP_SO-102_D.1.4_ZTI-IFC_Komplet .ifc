Properties of the parts of a building model (IFC4), part 37 of 60

# IfcPipeFitting: M_Přechod, obecný:Standardní (211)
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Délka (mm) | Jmenovitý poloměr 1 (mm) = Odskok – šířka | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Odskok – výška | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Viditelnost 1 | Výškové odsazení (mm) | Max. vnější průměr tvarovky 12 (mm) | Viditelnost 2 | Viditelnost 3 | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm)
13544161 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.1436 | 1436 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13641528 | -1.PP_SO-102 | ø40 mm-ø16 mm | -1.PP_SO-102 | 3300.33 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10.3188 | 20 | 8 | 40 | 16 | 40 | 16 | 0.00000768525 | 20 | 0.0016814 | ø40-ø16 | 16.51 | 7.67 | 41.275 | 19.175 | TT00.05.1489 | 1489 | yes | no | 3048 | 41.275 | yes | no | 9.5875 | 20.6375 | Mechanické – tok - Tlaková ztráta: 0 Pa
13641949 | -1.PP_SO-102 | ø50 mm-ø20 mm | -1.PP_SO-102 | 3300.4 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT00.05.1495 | 1495 | yes | no | 3048 | 53.975 | yes | no | 11.1125 | 26.9875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13642311 | -1.PP_SO-102 | ø25 mm-ø20 mm | -1.PP_SO-102 | 3100.27 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.1505 | 1505 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13642537 | -1.PP_SO-102 | ø50 mm-ø20 mm | -1.PP_SO-102 | 2650.4 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT00.05.1509 | 1509 | yes | no | 3048 | 53.975 | yes | no | 11.1125 | 26.9875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13642603 | -1.PP_SO-102 | ø50 mm-ø20 mm | -1.PP_SO-102 | 2650.4 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT00.05.1513 | 1513 | yes | no | 3048 | 53.975 | yes | no | 11.1125 | 26.9875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13643207 | 1.NP_SO-102 | ø32 mm-ø25 mm | 1.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 12.5 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.05.1514 | 1514 | yes | no | 3048 | 34.925 | no | yes | 17.4625 | 14.2875
13646433 | 3.NP_SO-102 | ø40 mm-ø32 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT00.05.1543 | 1543 | yes | no | 3048 | 41.275 | no | yes | 20.6375 | 17.4625
13646888 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 12.5 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.05.1554 | 1554 | no | no | 3048 | 34.925 | no | yes | 17.4625 | 14.2875
13648000 | -1.PP_SO-102 | ø25 mm-ø20 mm | -1.PP_SO-102 | 3374.42 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.1562 | 1562 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13705587 | -1.PP_SO-102 | ø75 mm-ø63 mm | -1.PP_SO-102 | 3226.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 19.5438 | 31.5 | 37.5 | 63 | 75 | 75 | 63 | 0.0000800984 | 31.5 | 0.00783294 | ø75-ø63 | 26.47 | 31.27 | 66.175 | 78.175 | TT00.05.1731 | 1731 | yes | no | 3048 | 78.175 | no | yes | 39.0875 | 33.0875
13805874 | -1.PP_SO-102 | ø63 mm-ø25 mm | -1.PP_SO-102 | 2900 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16.5437 | 31.5 | 12.5 | 63 | 25 | 63 | 25 | 0.0000306546 | 31.5 | 0.00420842 | ø63-ø25 | 26.47 | 11.43 | 66.175 | 28.575 | TT00.05.1767 | 1767 | no | no | 3048 | 66.175 | yes | no | 14.2875 | 33.0875
13805880 | -1.PP_SO-102 | ø63 mm-ø25 mm | -1.PP_SO-102 | 2900 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16.5437 | 31.5 | 12.5 | 63 | 25 | 63 | 25 | 0.0000306546 | 31.5 | 0.00420842 | ø63-ø25 | 26.47 | 11.43 | 66.175 | 28.575 | TT00.05.1768 | 1768 | no | no | 3048 | 66.175 | yes | no | 14.2875 | 33.0875
13823519 | -1.PP_SO-102 | ø63 mm-ø25 mm | -1.PP_SO-102 | 2754.21 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16.5437 | 31.5 | 12.5 | 63 | 25 | 63 | 25 | 0.0000306546 | 31.5 | 0.00420842 | ø63-ø25 | 26.47 | 11.43 | 66.175 | 28.575 | TT00.05.1832 | 1832 | no | no | 3048 | 66.175 | yes | no | 14.2875 | 33.0875
13828704 | -1.PP_SO-102 | ø50 mm-ø32 mm | -1.PP_SO-102 | 3360.31 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.05.1878 | 1878 | yes | no | 3048 | 53.975 | yes | no | 17.4625 | 26.9875
13830461 | -1.PP_SO-102 | ø63 mm-ø25 mm | -1.PP_SO-102 | 3354.21 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16.5437 | 31.5 | 12.5 | 63 | 25 | 63 | 25 | 0.0000306546 | 31.5 | 0.00420842 | ø63-ø25 | 26.47 | 11.43 | 66.175 | 28.575 | TT00.05.1894 | 1894 | no | no | 3048 | 66.175 | yes | no | 14.2875 | 33.0875
13830512 | -1.PP_SO-102 | ø63 mm-ø25 mm | -1.PP_SO-102 | 3354.21 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16.5437 | 31.5 | 12.5 | 63 | 25 | 63 | 25 | 0.0000306546 | 31.5 | 0.00420842 | ø63-ø25 | 26.47 | 11.43 | 66.175 | 28.575 | TT00.05.1897 | 1897 | no | no | 3048 | 66.175 | yes | no | 14.2875 | 33.0875
13835360 | 1.NP_SO-102 | ø32 mm-ø25 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 12.5 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.05.1922 | 1922 | yes | no | 3048 | 34.925 | no | yes | 17.4625 | 14.2875
13835833 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 482.538 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.1926 | 1926 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13835902 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 482.538 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.1928 | 1928 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13836087 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 482.538 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.1930 | 1930 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13836118 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 482.538 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.1932 | 1932 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13957992 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.1986 | 1986 |  | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13976075 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.1987 | 1987 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13976116 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.1989 | 1989 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
14025072 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.2198 | 2198 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125

# IfcPipeFitting: M_Přechod, obecný:Standardní (13)
Type - Classification: TT00 SNIM (SNIM); Material: 0-128-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 05; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Komponenta: QMA; CCI Technický systém: JB
Mechanické - Klasifikace systému: Sanitární
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Viditelnost 1: no
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | Tlaková ztráta (Pa) | CCI Funkční systém | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Název systému = Group | Délka (mm) | Jmenovitý poloměr 1 (mm) | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Šířkové odsazení (mm) | Viditelnost 2 | Viditelnost 3 | Výškové odsazení (mm) | Max. vnější průměr tvarovky 12 (mm) | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm)
13236995 | 4.NP_SO-102 | ø110 mm-ø56 mm | 0 | G | 4.NP_SO-102 | 3250 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 28.2938 | 55 | 28 | 110 | 56 | 110 | 56 | 0.000170321 | 55 | 55 | 0.0132861 | ø110-ø56 | 45.27 | 23.67 | 113.175 | 59.175 | TT00.05.0947 | 0947 | no | 3048 | yes | no | 3048 | 113.175 | 29.5875 | 56.5875
13236997 | 4.NP_SO-102 | ø110 mm-ø56 mm | 0 | G | 4.NP_SO-102 | 3250 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 28.2938 | 55 | 28 | 110 | 56 | 110 | 56 | 0.000170321 | 55 | 55 | 0.0132861 | ø110-ø56 | 45.27 | 23.67 | 113.175 | 59.175 | TT00.05.0948 | 0948 | no | 3048 | yes | no | 3048 | 113.175 | 29.5875 | 56.5875
13237323 | 4.NP_SO-102 | ø110 mm-ø56 mm | 0 | G | 4.NP_SO-102 | 3250 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 28.2938 | 55 | 28 | 110 | 56 | 110 | 56 | 0.000170321 | 55 | 55 | 0.0132861 | ø110-ø56 | 45.27 | 23.67 | 113.175 | 59.175 | TT00.05.0956 | 0956 | no | 3048 | yes | no | 3048 | 113.175 | 29.5875 | 56.5875
13237331 | 4.NP_SO-102 | ø110 mm-ø56 mm | 0 | G | 4.NP_SO-102 | 3250 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 28.2938 | 55 | 28 | 110 | 56 | 110 | 56 | 0.000170321 | 55 | 55 | 0.0132861 | ø110-ø56 | 45.27 | 23.67 | 113.175 | 59.175 | TT00.05.0958 | 0958 | no | 3048 | yes | no | 3048 | 113.175 | 29.5875 | 56.5875
13239704 | 4.NP_SO-102 | ø110 mm-ø56 mm | 0 | G | 4.NP_SO-102 | 3006.44 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 28.2938 | 28 | 55 | 56 | 110 | 110 | 56 | 0.000170312 | 28 | 28 | 0.0132861 | ø110-ø56 | 23.67 | 45.27 | 59.175 | 113.175 | TT00.05.0978 | 0978 | no | 3048 | no | yes | 3048 | 113.175 | 56.5875 | 29.5875
13241694 | 1.NP_SO-102 | ø125 mm-ø110 mm | 1452.35 | G | 1.NP_SO-102 | 2642.98 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 32.5438 | 62.5 | 55 | 125 | 110 | 125 | 110 | 0.000378931 | 62.5 | 62.5 | 0.0222459 | ø125-ø110 | 52.07 | 45.27 | 130.175 | 113.175 | TT00.05.0981 | 0981 | yes | 3048 | yes | no | 3048 | 130.175 | 56.5875 | 65.0875
13242086 | 1.NP_SO-102 | ø125 mm-ø110 mm | 0 | G | 1.NP_SO-102 | 2956.69 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 32.5438 | 55 | 62.5 | 110 | 125 | 125 | 110 | 0.000378906 | 57.1659 | 55.0027 | 0.0222644 | ø125-ø110 | 45.27 | 52.07 | 113.175 | 130.175 | TT00.05.0984 | 0984 | yes | 3050.17 | no | yes | 3048 | 130.175 | 65.0875 | 56.5875
13243046 | 1.NP_SO-102 | ø125 mm-ø110 mm | 0 | G | 1.NP_SO-102 | 3089.57 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 32.5438 | 55 | 62.5 | 110 | 125 | 125 | 110 | 0.000378906 | 55 | 55 | 0.0222459 | ø125-ø110 | 45.27 | 52.07 | 113.175 | 130.175 | TT00.05.0997 | 0997 | yes | 3048 | no | yes | 3048 | 130.175 | 65.0875 | 56.5875
13243048 | 4.NP_SO-102 | ø125 mm-ø56 mm | 0 | G | 4.NP_SO-102 | 3249 | Fáze 2 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 32.5438 | 28 | 62.5 | 56 | 125 | 125 | 56 | 0.000239712 | 28 | 28 | 0.0167314 | ø125-ø56 | 23.67 | 52.07 | 59.175 | 130.175 | TT00.05.0998 | 0998 | no | 3048 | no | yes | 3048 | 130.175 | 65.0875 | 29.5875
13399581 | -1.PP_SO-102 | ø135 mm-ø125 mm | 0 | G | -1.PP_SO-102 | 1614.5 | Fáze 1 | SW_Deště vnitřní gravitační | SW_Deště vnitřní gravitační 1 | 34.5438 | 62.5 | 67.5 | 125 | 135 | 135 | 125 | 0.000488477 | 62.5 | 62.5 | 0.0266168 | ø135-ø125 | 52.07 | 55.27 | 130.175 | 138.175 | TT00.05.1149 | 1149 | yes | 3048 | no | yes | 3048 | 138.175 | 69.0875 | 65.0875
13472605 | -1.PP_SO-102 | ø160 mm-ø135 mm | 0 | G | -1.PP_SO-102 | -249 | Fáze 1 | SW_Deště vnitřní gravitační | SW_Deště vnitřní gravitační 2 | 40.7937 | 67.5 | 80 | 135 | 160 | 160 | 135 | 0.000728926 | 67.5 | 67.5 | 0.0347694 | ø160-ø135 | 55.27 | 65.27 | 138.175 | 163.175 | TT00.05.1227 | 1227 | yes | 3048 | no | yes | 3048 | 163.175 | 81.5875 | 69.0875
13982055 | -1.PP_SO-102 | ø125 mm-ø110 mm | 0 | F | -1.PP_SO-102 | -2851.56 | Fáze 1 | SW_Deště vnitřní gravitační | SW_Deště vnitřní gravitační 2 | 32.5438 | 55 | 62.5 | 110 | 125 | 125 | 110 | 0.000378906 | 55 | 56.4021 | 0.0222272 | ø125-ø110 | 45.27 | 52.07 | 113.175 | 130.175 | TT00.05.2008 | 2008 |  | 3048 | no | yes | 3049.4 | 130.175 | 65.0875 | 56.5875
13982915 | -1.PP_SO-102 | ø315 mm-ø110 mm |  | F | -1.PP_SO-102 | 2683.13 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 79.5438 | 55 | 157.5 | 110 | 315 | 315 | 110 | 0.0031245 | 55 | 55 | 0.0968507 | ø315-ø110 | 45.27 | 127.27 | 113.175 | 318.175 | TT00.05.2015 | 2015 | yes | 3048 | no | yes | 3048 | 318.175 | 159.088 | 56.5875

# IfcPipeFitting: M_Přechod, obecný:Standardní (37)
Type - Classification: TT00 SNIM (SNIM); Material: 032-175-175
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 05; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Mechanické - Typ systému: WS_Požární zavodněný; Klasifikace systému: Požární ochrana – vodní prostředky
Grafika - Použít měřítko poznámky: no
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Šířkové odsazení: 3048 mm; Viditelnost 1: no
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Délka (mm) | Jmenovitý poloměr 1 (mm) = Odskok – šířka | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Odskok – výška | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Výškové odsazení (mm) | Viditelnost 2 | Viditelnost 3 | Max. vnější průměr tvarovky 12 (mm) | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm)
13175643 | -1.PP_SO-102 | ø35 mm-ø32 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Požární zavodněný 1 | 9.54375 | 16 | 17.5 | 32 | 35 | 35 | 32 | 0.00000998805 | 16 | 0.00190288 | ø35-ø32 | 13.97 | 15.27 | 34.925 | 38.175 | TT00.05.0917 | 0917 | 3048 | no | yes | 38.175 | 19.0875 | 17.4625
13175645 | -1.PP_SO-102 | ø35 mm-ø32 mm | -1.PP_SO-102 | 3323.81 | Fáze 1 | WS_Požární zavodněný 1 | 9.54375 | 16 | 17.5 | 32 | 35 | 35 | 32 | 0.00000998805 | 16 | 0.00190288 | ø35-ø32 | 13.97 | 15.27 | 34.925 | 38.175 | TT00.05.0918 | 0918 | 3048 | no | yes | 38.175 | 19.0875 | 17.4625
13175652 | -1.PP_SO-102 | ø28 mm-ø25 mm | -1.PP_SO-102 | 1860 | Fáze 1 | WS_Požární zavodněný 1 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 12.5 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.05.0919 | 0919 | 3048 | no | yes | 31.175 | 15.5875 | 14.2875
13175658 | -1.PP_SO-102 | ø28 mm-ø25 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Požární zavodněný 1 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 12.5 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.05.0920 | 0920 | 3048 | no | yes | 31.175 | 15.5875 | 14.2875
13175684 | -1.PP_SO-102 | ø42 mm-ø28 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární zavodněný 1 | 11.2937 | 21 | 14 | 42 | 28 | 42 | 28 | 0.0000130458 | 21 | 0.00227055 | ø42-ø28 | 18.07 | 12.47 | 45.175 | 31.175 | TT00.05.0921 | 0921 | 3048 | yes | no | 45.175 | 15.5875 | 22.5875
13175688 | 4.NP_SO-102 | ø28 mm-ø25 mm | 4.NP_SO-102 | 710 | Fáze 2 | WS_Požární zavodněný 3 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 12.5 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.05.0922 | 0922 | 3048 | no | yes | 31.175 | 15.5875 | 14.2875
13175702 | 3.NP_SO-102 | ø28 mm-ø25 mm | 3.NP_SO-102 | 3393.43 | Fáze 2 | WS_Požární zavodněný 3 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 12.5 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.05.0923 | 0923 | 3048 | no | yes | 31.175 | 15.5875 | 14.2875
13175704 | 3.NP_SO-102 | ø28 mm-ø25 mm | 3.NP_SO-102 | 710 | Fáze 2 | WS_Požární zavodněný 3 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 12.5 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.05.0924 | 0924 | 3048 | no | yes | 31.175 | 15.5875 | 14.2875
13175706 | 3.NP_SO-102 | ø28 mm-ø25 mm | 3.NP_SO-102 | 3366.44 | Fáze 2 | WS_Požární zavodněný 3 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 12.5 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.05.0925 | 0925 | 3048 | no | yes | 31.175 | 15.5875 | 14.2875
13175716 | 2.NP_SO-102 | ø28 mm-ø25 mm | 2.NP_SO-102 | 1860 | Fáze 2 | WS_Požární zavodněný 3 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 12.5 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.05.0926 | 0926 | 3048 | no | yes | 31.175 | 15.5875 | 14.2875
13175729 | 1.NP_SO-102 | ø28 mm-ø25 mm | 1.NP_SO-102 | 1859 | Fáze 2 | WS_Požární zavodněný 3 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 12.5 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.05.0927 | 0927 | 3048 | no | yes | 31.175 | 15.5875 | 14.2875
13175737 | 1.NP_SO-102 | ø28 mm-ø25 mm | 1.NP_SO-102 | 1860 | Fáze 2 | WS_Požární zavodněný 3 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 12.5 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.05.0928 | 0928 | 3048 | no | yes | 31.175 | 15.5875 | 14.2875
13175739 | 1.NP_SO-102 | ø28 mm-ø25 mm | 1.NP_SO-102 | 3173.01 | Fáze 2 | WS_Požární zavodněný 3 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 12.5 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.05.0929 | 0929 | 3048 | no | yes | 31.175 | 15.5875 | 14.2875
13175745 | -1.PP_SO-102 | ø35 mm-ø25 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_Požární zavodněný 3 | 9.54375 | 12.5 | 17.5 | 25 | 35 | 35 | 25 | 0.00000838548 | 12.5 | 0.00166421 | ø35-ø25 | 11.43 | 15.27 | 28.575 | 38.175 | TT00.05.0930 | 0930 | 3048 | no | yes | 38.175 | 19.0875 | 14.2875
13175763 | 3.NP_SO-102 | ø28 mm-ø25 mm | 3.NP_SO-102 | 3339.46 | Fáze 2 | WS_Požární zavodněný 3 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 12.5 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.05.0931 | 0931 | 3048 | no | yes | 31.175 | 15.5875 | 14.2875
13175769 | 2.NP_SO-102 | ø35 mm-ø28 mm | 2.NP_SO-102 | 3209.2 | Fáze 2 | WS_Požární zavodněný 3 | 9.54375 | 17.5 | 14 | 35 | 28 | 35 | 28 | 0.00000900481 | 17.5 | 0.00175717 | ø35-ø28 | 15.27 | 12.47 | 38.175 | 31.175 | TT00.05.0932 | 0932 | 3048 | yes | no | 38.175 | 15.5875 | 19.0875
13175771 | 2.NP_SO-102 | ø35 mm-ø28 mm | 2.NP_SO-102 | 3177.41 | Fáze 2 | WS_Požární zavodněný 3 | 9.54375 | 17.5 | 14 | 35 | 28 | 35 | 28 | 0.00000900481 | 17.5 | 0.00175717 | ø35-ø28 | 15.27 | 12.47 | 38.175 | 31.175 | TT00.05.0933 | 0933 | 3048 | yes | no | 38.175 | 15.5875 | 19.0875
13175775 | 1.NP_SO-102 | ø35 mm-ø28 mm | 1.NP_SO-102 | 3200 | Fáze 2 | WS_Požární zavodněný 3 | 9.54375 | 17.5 | 14 | 35 | 28 | 35 | 28 | 0.00000900481 | 17.5 | 0.00175717 | ø35-ø28 | 15.27 | 12.47 | 38.175 | 31.175 | TT00.05.0934 | 0934 | 3048 | yes | no | 38.175 | 15.5875 | 19.0875
13175780 | 1.NP_SO-102 | ø28 mm-ø25 mm | 1.NP_SO-102 | 3200 | Fáze 2 | WS_Požární zavodněný 3 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 12.5 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.05.0935 | 0935 | 3048 | no | yes | 31.175 | 15.5875 | 14.2875
13175782 | 1.NP_SO-102 | ø28 mm-ø25 mm | 1.NP_SO-102 | 3200 | Fáze 2 | WS_Požární zavodněný 3 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 12.5 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.05.0936 | 0936 | 3048 | no | yes | 31.175 | 15.5875 | 14.2875
13175784 | -1.PP_SO-102 | ø35 mm-ø25 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_Požární zavodněný 3 | 9.54375 | 12.5 | 17.5 | 25 | 35 | 35 | 25 | 0.00000838548 | 12.5 | 0.00166421 | ø35-ø25 | 11.43 | 15.27 | 28.575 | 38.175 | TT00.05.0937 | 0937 | 3048 | no | yes | 38.175 | 19.0875 | 14.2875
13175789 | 3.NP_SO-102 | ø35 mm-ø28 mm | 3.NP_SO-102 | 3338.16 | Fáze 1 | WS_Požární zavodněný 1 | 9.54375 | 14 | 17.5 | 28 | 35 | 35 | 28 | 0.00000901755 | 14 | 0.00175717 | ø35-ø28 | 12.47 | 15.27 | 31.175 | 38.175 | TT00.05.0938 | 0938 | 3048 | no | yes | 38.175 | 19.0875 | 15.5875
13323052 | -1.PP_SO-102 | ø28 mm-ø25 mm | -1.PP_SO-102 | 1859 | Fáze 1 | WS_Požární zavodněný 1 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 12.5 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.05.1035 | 1035 | 3048 | no | yes | 31.175 | 15.5875 | 14.2875
13323171 | 1.NP_SO-102 | ø28 mm-ø25 mm | 1.NP_SO-102 | 1770 | Fáze 1 | WS_Požární zavodněný 1 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 12.5 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.05.1037 | 1037 | 3048 | no | yes | 31.175 | 15.5875 | 14.2875
13323501 | 2.NP_SO-102 | ø28 mm-ø25 mm | 2.NP_SO-102 | 1420 | Fáze 1 | WS_Požární zavodněný 1 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 12.5 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.05.1043 | 1043 | 3048 | no | yes | 31.175 | 15.5875 | 14.2875
13324291 | 4.NP_SO-102 | ø28 mm-ø25 mm | 4.NP_SO-102 | 1420 | Fáze 1 | WS_Požární zavodněný 1 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 12.5 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.05.1046 | 1046 | 3048 | no | yes | 31.175 | 15.5875 | 14.2875
13324362 | 3.NP_SO-102 | ø28 mm-ø25 mm | 3.NP_SO-102 | 1420 | Fáze 1 | WS_Požární zavodněný 1 | 7.79375 | 12.5 | 14 | 25 | 28 | 28 | 25 | 0.00000544922 | 12.5 | 0.00124003 | ø28-ø25 | 11.43 | 12.47 | 28.575 | 31.175 | TT00.05.1052 | 1052 | 3048 | no | yes | 31.175 | 15.5875 | 14.2875
13349047 | -1.PP_SO-102 | ø35 mm-ø28 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární zavodněný 1 | 9.54375 | 14 | 17.5 | 28 | 35 | 35 | 28 | 0.00000901755 | 14 | 0.00175717 | ø35-ø28 | 12.47 | 15.27 | 31.175 | 38.175 | TT00.05.1083 | 1083 | 3048 | no | yes | 38.175 | 19.0875 | 15.5875
13537043 | -1.PP_SO-102 | ø42 mm-ø25 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Požární zavodněný 1 | 11.2937 | 12.5 | 21 | 25 | 42 | 42 | 25 | 0.0000122396 | 12.5 | 0.00217651 | ø42-ø25 | 11.43 | 18.07 | 28.575 | 45.175 | TT00.05.1430 | 1430 | 3048 | no | yes | 45.175 | 22.5875 | 14.2875
13537079 | -1.PP_SO-102 | ø54 mm-ø42 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární zavodněný 1 | 14.2937 | 21 | 27 | 42 | 54 | 54 | 42 | 0.0000295024 | 21 | 0.003963 | ø54-ø42 | 18.07 | 22.87 | 45.175 | 57.175 | TT00.05.1431 | 1431 | 3048 | no | yes | 57.175 | 28.5875 | 22.5875
13647437 | 4.NP_SO-102 | ø28 mm-ø25 mm | 4.NP_SO-102 | 1765.24 | Fáze 1 | WS_Požární zavodněný 1 | 7.79375 | 14 | 12.5 | 28 | 25 | 28 | 25 | 0.0000054459 | 18.7619 | 0.00130098 | ø28-ø25 | 12.47 | 11.43 | 31.175 | 28.575 | TT00.05.1556 | 1556 | 3052.76 | yes | no | 31.175 | 14.2875 | 15.5875
13651663 | -1.PP_SO-102 | ø54 mm-ø42 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární zavodněný 1 | 14.2937 | 21 | 27 | 42 | 54 | 54 | 42 | 0.0000295024 | 21 | 0.003963 | ø54-ø42 | 18.07 | 22.87 | 45.175 | 57.175 | TT00.05.1568 | 1568 | 3048 | no | yes | 57.175 | 28.5875 | 22.5875
13651702 | -1.PP_SO-102 | ø54 mm-ø42 mm | -1.PP_SO-102 | 3183.95 | Fáze 1 | WS_Požární zavodněný 1 | 14.2937 | 27 | 21 | 54 | 42 | 54 | 42 | 0.0000294828 | 27 | 0.003963 | ø54-ø42 | 22.87 | 18.07 | 57.175 | 45.175 | TT00.05.1571 | 1571 | 3048 | yes | no | 57.175 | 22.5875 | 28.5875
13651744 | -1.PP_SO-102 | ø54 mm-ø28 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární zavodněný 1 | 14.2937 | 14 | 27 | 28 | 54 | 54 | 28 | 0.0000225016 | 14 | 0.0033485 | ø54-ø28 | 12.47 | 22.87 | 31.175 | 57.175 | TT00.05.1573 | 1573 | 3048 | no | yes | 57.175 | 28.5875 | 15.5875
13807776 | -1.PP_SO-102 | ø42 mm-ø25 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Požární zavodněný 1 | 11.2937 | 12.5 | 21 | 25 | 42 | 42 | 25 | 0.0000122396 | 12.5 | 0.00217651 | ø42-ø25 | 11.43 | 18.07 | 28.575 | 45.175 | TT00.05.1788 | 1788 | 3048 | no | yes | 45.175 | 22.5875 | 14.2875
13829037 | -1.PP_SO-102 | ø42 mm-ø35 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Požární zavodněný 1 | 11.2937 | 21 | 17.5 | 42 | 35 | 42 | 35 | 0.0000154161 | 21 | 0.0025446 | ø42-ø35 | 18.07 | 15.27 | 45.175 | 38.175 | TT00.05.1886 | 1886 | 3048 | yes | no | 45.175 | 19.0875 | 22.5875
13829231 | -1.PP_SO-102 | ø42 mm-ø35 mm | -1.PP_SO-102 | 3364.71 | Fáze 1 | WS_Požární zavodněný 1 | 11.2937 | 21 | 17.5 | 42 | 35 | 42 | 35 | 0.0000154161 | 21 | 0.0025446 | ø42-ø35 | 18.07 | 15.27 | 45.175 | 38.175 | TT00.05.1889 | 1889 | 3048 | yes | no | 45.175 | 19.0875 | 22.5875

# IfcPipeFitting: M_Přechod, obecný:Standardní (64)
Type - Classification: TT00 SNIM (SNIM); Material: 128-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 05; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Komponenta: QMA; CCI Technický systém: JB
Mechanické - Klasifikace systému: Sanitární
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | CCI Funkční systém | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Název systému = Group | Délka (mm) | Jmenovitý poloměr 1 (mm) | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Šířkové odsazení (mm) | Viditelnost 1 | Výškové odsazení (mm) | Viditelnost 2 | Viditelnost 3 | Max. vnější průměr tvarovky 12 (mm) | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm)
13150613 | -1.PP_SO-102 | ø160 mm-ø110 mm | G | -1.PP_SO-102 | -3629.24 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 40.7937 | 55 | 80 | 110 | 160 | 160 | 110 | 0.000618234 | 55 | 55 | 0.0311347 | ø160-ø110 | 45.27 | 65.27 | 113.175 | 163.175 | TT00.05.0822 | 0822 | yes | 3048 | no | 3048 | no | yes | 163.175 | 81.5875 | 56.5875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13156404 | -1.PP_SO-102 | ø160 mm-ø110 mm | G | -1.PP_SO-102 | -2641.41 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 40.7937 | 80 | 55 | 160 | 110 | 160 | 110 | 0.000618199 | 80 | 80 | 0.0311347 | ø160-ø110 | 65.27 | 45.27 | 163.175 | 113.175 | TT00.05.0865 | 0865 | yes | 3048 | no | 3048 | yes | no | 163.175 | 56.5875 | 81.5875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13363566 | 3.NP_SO-102 | ø110 mm-ø78 mm | G | 3.NP_SO-102 | 3316.4 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 28.2938 | 55 | 39 | 110 | 78 | 110 | 78 | 0.000211635 | 55 | 55 | 0.015107 | ø110-ø78 | 45.27 | 32.47 | 113.175 | 81.175 | TT00.05.1140 | 1140 | yes | 3048 | no | 3048 | yes | no | 113.175 | 40.5875 | 56.5875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13426717 | -1.PP_SO-102 | ø110 mm-ø78 mm | G | -1.PP_SO-102 | 3162.86 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 28.2938 | 39 | 55 | 78 | 110 | 110 | 78 | 0.000211638 | 39 | 39 | 0.015107 | ø110-ø78 | 32.47 | 45.27 | 81.175 | 113.175 | TT00.05.1168 | 1168 | yes | 3048 | no | 3048 | no | yes | 113.175 | 56.5875 | 40.5875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13432691 | -1.PP_SO-102 | ø160 mm-ø125 mm | G | -1.PP_SO-102 | -1828.2 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 40.7937 | 80 | 62.5 | 160 | 125 | 160 | 125 | 0.000692006 | 80 | 80 | 0.0333883 | ø160-ø125 | 65.27 | 52.07 | 163.175 | 130.175 | TT00.05.1181 | 1181 | yes | 3048 | no | 3048 | yes | no | 163.175 | 65.0875 | 81.5875
13462271 | 1.NP_SO-102 | ø110 mm-ø78 mm | G | 1.NP_SO-102 | 3420 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 28.2938 | 39 | 55 | 78 | 110 | 110 | 78 | 0.000211638 | 39 | 39 | 0.015107 | ø110-ø78 | 32.47 | 45.27 | 81.175 | 113.175 | TT00.05.1218 | 1218 | yes | 3048 | no | 3048 | no | yes | 113.175 | 56.5875 | 40.5875
13473522 | -1.PP_SO-102 | ø160 mm-ø125 mm | G | -1.PP_SO-102 | -911.291 | Fáze 1 | SW_Deště vnitřní gravitační | SW_Deště vnitřní gravitační 2 | 40.7937 | 80 | 62.5 | 160 | 125 | 160 | 125 | 0.000692006 | 80 | 80 | 0.0333883 | ø160-ø125 | 65.27 | 52.07 | 163.175 | 130.175 | TT00.05.1231 | 1231 | yes | 3048 | no | 3048 | yes | no | 163.175 | 65.0875 | 81.5875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13497447 | 1.NP_SO-102 | ø78 mm-ø58 mm | G | 1.NP_SO-102 | 3378.58 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 20.2938 | 39 | 29 | 78 | 58 | 78 | 58 | 0.0000812036 | 39 | 39 | 0.00789529 | ø78-ø58 | 32.47 | 24.47 | 81.175 | 61.175 | TT00.05.1304 | 1304 | yes | 3048 | no | 3048 | yes | no | 81.175 | 30.5875 | 40.5875
13520459 | 1.NP_SO-102 | ø110 mm-ø58 mm | G | 1.NP_SO-102 | 3380.59 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 28.2938 | 55 | 29 | 110 | 58 | 110 | 58 | 0.00017378 | 55 | 55 | 0.0134339 | ø110-ø58 | 45.27 | 24.47 | 113.175 | 61.175 | TT00.05.1333 | 1333 | yes | 3048 | no | 3048 | yes | no | 113.175 | 30.5875 | 56.5875
13527388 | -1.PP_SO-102 | ø160 mm-ø110 mm | G | -1.PP_SO-102 | -3050.16 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 40.7937 | 80 | 55 | 160 | 110 | 160 | 110 | 0.000618199 | 80 | 80 | 0.0311347 | ø160-ø110 | 65.27 | 45.27 | 163.175 | 113.175 | TT00.05.1387 | 1387 | yes | 3048 | no | 3048 | yes | no | 163.175 | 56.5875 | 81.5875
13528007 | -1.PP_SO-102 | ø110 mm-ø110 mm | G | -1.PP_SO-102 | -3027.52 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 28.2938 | 55 | 55 | 110 | 110 | 110 | 110 | 0.000284529 | 55.078 | 45.5856 | 0.0189477 | ø110-ø110 | 45.27 | 45.27 | 113.175 | 113.175 | TT00.05.1392 | 1392 | yes | 3048.08 | yes | 3038.59 | no | no | 113.175 | 56.5875 | 56.5875
13546053 | 2.NP_SO-102 | ø78 mm-ø78 mm | G | 2.NP_SO-102 | 2992.37 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 20.2938 | 39 | 39 | 78 | 78 | 78 | 78 | 0.000104955 | 38.9541 | 44.3706 | 0.00962195 | ø78-ø78 | 32.47 | 32.47 | 81.175 | 81.175 | TT00.05.1445 | 1445 | yes | 3047.95 | yes | 3053.37 | no | no | 81.175 | 40.5875 | 40.5875
13546843 | 2.NP_SO-102 | ø110 mm-ø78 mm | G | 2.NP_SO-102 | 1462.62 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 28.2938 | 39 | 55 | 78 | 110 | 110 | 78 | 0.000211638 | 39 | 39 | 0.015107 | ø110-ø78 | 32.47 | 45.27 | 81.175 | 113.175 | TT00.05.1447 | 1447 | yes | 3048 | no | 3048 | no | yes | 113.175 | 56.5875 | 40.5875
13546853 | 2.NP_SO-102 | ø135 mm-ø110 mm | G | 2.NP_SO-102 | 1365.56 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 34.5438 | 67.5 | 55 | 135 | 110 | 135 | 110 | 0.000429809 | 67.5 | 67.5 | 0.0243449 | ø135-ø110 | 55.27 | 45.27 | 138.175 | 113.175 | TT00.05.1449 | 1449 | yes | 3048 | no | 3048 | yes | no | 138.175 | 56.5875 | 69.0875
13550595 | 2.NP_SO-102 | ø78 mm-ø58 mm | G | 2.NP_SO-102 | 3377.8 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 20.2938 | 39 | 29 | 78 | 58 | 78 | 58 | 0.0000812036 | 39 | 39 | 0.00789529 | ø78-ø58 | 32.47 | 24.47 | 81.175 | 61.175 | TT00.05.1453 | 1453 | yes | 3048 | no | 3048 | yes | no | 81.175 | 30.5875 | 40.5875
13621412 | -1.PP_SO-102 | ø125 mm-ø78 mm | G | -1.PP_SO-102 | -400.39 | Fáze 2 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 32.5438 | 62.5 | 39 | 125 | 78 | 125 | 78 | 0.000290454 | 62.5 | 62.5 | 0.0186288 | ø125-ø78 | 52.07 | 32.47 | 130.175 | 81.175 | TT00.05.1466 | 1466 | yes | 3048 | no | 3048 | yes | no | 130.175 | 40.5875 | 65.0875
13624579 | -1.PP_SO-102 | ø250 mm-ø200 mm | G | -1.PP_SO-102 | -1005.06 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 64.2938 | 125 | 100 | 250 | 200 | 250 | 200 | 0.00272323 | 125 | 125 | 0.0830327 | ø250-ø200 | 102.87 | 82.55 | 257.175 | 206.375 | TT00.05.1473 | 1473 | yes | 3048 | no | 3048 | yes | no | 257.175 | 103.188 | 128.588
13645843 | 1.NP_SO-102 | ø110 mm-ø78 mm | G | 1.NP_SO-102 | 3123.03 | Fáze 2 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 28.2938 | 55 | 39 | 110 | 78 | 110 | 78 | 0.000211635 | 55 | 55 | 0.015107 | ø110-ø78 | 45.27 | 32.47 | 113.175 | 81.175 | TT00.05.1535 | 1535 | yes | 3048 | no | 3048 | yes | no | 113.175 | 40.5875 | 56.5875 | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S18
13658928 | -1.PP_SO-102 | ø160 mm-ø110 mm | G | -1.PP_SO-102 | -2578.99 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 40.7937 | 80 | 55 | 160 | 110 | 160 | 110 | 0.000618199 | 80.0049 | 80.5203 | 0.0311576 | ø160-ø110 | 65.27 | 45.27 | 163.175 | 113.175 | TT00.05.1600 | 1600 | yes | 3048 | no | 3048.52 | yes | no | 163.175 | 56.5875 | 81.5875
13659887 | -1.PP_SO-102 | ø160 mm-ø110 mm | G | -1.PP_SO-102 | -2535.38 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 40.7937 | 80 | 55 | 160 | 110 | 160 | 110 | 0.000618199 | 79.9797 | 77.5464 | 0.0310387 | ø160-ø110 | 65.27 | 45.27 | 163.175 | 113.175 | TT00.05.1604 | 1604 | yes | 3047.98 | no | 3045.55 | yes | no | 163.175 | 56.5875 | 81.5875
13671373 | -1.PP_SO-102 | ø110 mm-ø78 mm | G | -1.PP_SO-102 | 3179.16 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 28.2938 | 55 | 39 | 110 | 78 | 110 | 78 | 0.000211635 | 55 | 55 | 0.015107 | ø110-ø78 | 45.27 | 32.47 | 113.175 | 81.175 | TT00.05.1612 | 1612 | yes | 3048 | no | 3048 | yes | no | 113.175 | 40.5875 | 56.5875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13672005 | -1.PP_SO-102 | ø200 mm-ø110 mm | G | -1.PP_SO-102 | 2630.96 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 51.5938 | 100 | 55 | 200 | 110 | 200 | 110 | 0.00106356 | 100 | 100 | 0.044956 | ø200-ø110 | 82.55 | 45.27 | 206.375 | 113.175 | TT00.05.1615 | 1615 | yes | 3048 | no | 3048 | yes | no | 206.375 | 56.5875 | 103.188 | Mechanické – tok - Tlaková ztráta: 4.92361 Pa
13672558 | -1.PP_SO-102 | ø200 mm-ø110 mm | G | -1.PP_SO-102 | 2683.85 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 51.5938 | 100 | 55 | 200 | 110 | 200 | 110 | 0.00106356 | 100 | 100 | 0.044956 | ø200-ø110 | 82.55 | 45.27 | 206.375 | 113.175 | TT00.05.1617 | 1617 | yes | 3048 | no | 3048 | yes | no | 206.375 | 56.5875 | 103.188
13672729 | -1.PP_SO-102 | ø200 mm-ø110 mm | G | -1.PP_SO-102 | 2703.54 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 51.5938 | 100 | 55 | 200 | 110 | 200 | 110 | 0.00106356 | 100 | 100 | 0.044956 | ø200-ø110 | 82.55 | 45.27 | 206.375 | 113.175 | TT00.05.1621 | 1621 | yes | 3048 | no | 3048 | yes | no | 206.375 | 56.5875 | 103.188 | Mechanické – tok - Tlaková ztráta: 0 Pa
13672748 | -1.PP_SO-102 | ø110 mm-ø110 mm | G | -1.PP_SO-102 | 2767.18 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 28.2938 | 55 | 55 | 110 | 110 | 110 | 110 | 0.000284529 | 54.9999 | 37.447 | 0.01942 | ø110-ø110 | 45.27 | 45.27 | 113.175 | 113.175 | TT00.05.1624 | 1624 | yes | 3048 | yes | 3030.45 | no | no | 113.175 | 56.5875 | 56.5875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13672997 | -1.PP_SO-102 | ø200 mm-ø110 mm | G | -1.PP_SO-102 | 2674.24 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 51.5938 | 100 | 55 | 200 | 110 | 200 | 110 | 0.00106356 | 100 | 100 | 0.044956 | ø200-ø110 | 82.55 | 45.27 | 206.375 | 113.175 | TT00.05.1626 | 1626 | yes | 3048 | no | 3048 | yes | no | 206.375 | 56.5875 | 103.188
13673041 | -1.PP_SO-102 | ø200 mm-ø110 mm | G | -1.PP_SO-102 | 2828.78 | Fáze 2 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 51.5938 | 100 | 55 | 200 | 110 | 200 | 110 | 0.00106356 | 100 | 100 | 0.044956 | ø200-ø110 | 82.55 | 45.27 | 206.375 | 113.175 | TT00.05.1627 | 1627 | yes | 3048 | no | 3048 | yes | no | 206.375 | 56.5875 | 103.188 | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S19
13673500 | -1.PP_SO-102 | ø200 mm-ø110 mm | G | -1.PP_SO-102 | 2829.29 | Fáze 2 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 51.5938 | 100 | 55 | 200 | 110 | 200 | 110 | 0.00106356 | 100 | 100 | 0.044956 | ø200-ø110 | 82.55 | 45.27 | 206.375 | 113.175 | TT00.05.1632 | 1632 | yes | 3048 | no | 3048 | yes | no | 206.375 | 56.5875 | 103.188
13675041 | -1.PP_SO-102 | ø110 mm-ø78 mm | G | -1.PP_SO-102 | 2945.05 | Fáze 2 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 28.2938 | 55 | 39 | 110 | 78 | 110 | 78 | 0.000211635 | 55 | 55 | 0.015107 | ø110-ø78 | 45.27 | 32.47 | 113.175 | 81.175 | TT00.05.1635 | 1635 | yes | 3048 | no | 3048 | yes | no | 113.175 | 40.5875 | 56.5875 | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S16
13675043 | -1.PP_SO-102 | ø110 mm-ø78 mm | G | -1.PP_SO-102 | 2945.05 | Fáze 2 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 28.2938 | 55 | 39 | 110 | 78 | 110 | 78 | 0.000211635 | 55 | 55 | 0.015107 | ø110-ø78 | 45.27 | 32.47 | 113.175 | 81.175 | TT00.05.1636 | 1636 | yes | 3048 | no | 3048 | yes | no | 113.175 | 40.5875 | 56.5875 | Identifikační data - Komentáře: S17
13675124 | -1.PP_SO-102 | ø200 mm-ø110 mm | G | -1.PP_SO-102 | 2637.6 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 51.5938 | 100 | 55 | 200 | 110 | 200 | 110 | 0.00106356 | 100 | 100 | 0.044956 | ø200-ø110 | 82.55 | 45.27 | 206.375 | 113.175 | TT00.05.1639 | 1639 | yes | 3048 | no | 3048 | yes | no | 206.375 | 56.5875 | 103.188 | Mechanické – tok - Tlaková ztráta: 0 Pa
13675660 | -1.PP_SO-102 | ø200 mm-ø160 mm | G | -1.PP_SO-102 | 2993.51 | Fáze 2 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 51.5938 | 100 | 80 | 200 | 160 | 200 | 160 | 0.00138957 | 100 | 99.9396 | 0.0530864 | ø200-ø160 | 82.55 | 65.27 | 206.375 | 163.175 | TT00.05.1645 | 1645 | yes | 3048 | no | 3047.94 | yes | no | 206.375 | 81.5875 | 103.188 | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S20
13675747 | -1.PP_SO-102 | ø200 mm-ø110 mm | G | -1.PP_SO-102 | 2755.62 | Fáze 2 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 51.5938 | 100 | 55 | 200 | 110 | 200 | 110 | 0.00106356 | 100 | 100 | 0.044956 | ø200-ø110 | 82.55 | 45.27 | 206.375 | 113.175 | TT00.05.1647 | 1647 | yes | 3048 | no | 3048 | yes | no | 206.375 | 56.5875 | 103.188
13680402 | -1.PP_SO-102 | ø110 mm-ø78 mm | G | -1.PP_SO-102 | -1513.57 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 28.2938 | 55 | 39 | 110 | 78 | 110 | 78 | 0.000211635 | 55 | 55 | 0.015107 | ø110-ø78 | 45.27 | 32.47 | 113.175 | 81.175 | TT00.05.1653 | 1653 | yes | 3048 | no | 3048 | yes | no | 113.175 | 40.5875 | 56.5875
13680750 | 3.NP_SO-102 | ø160 mm-ø110 mm | G | 3.NP_SO-102 | 3289.77 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 40.7937 | 80 | 55 | 160 | 110 | 160 | 110 | 0.000618199 | 80 | 80 | 0.0311347 | ø160-ø110 | 65.27 | 45.27 | 163.175 | 113.175 | TT00.05.1656 | 1656 | yes | 3048 | no | 3048 | yes | no | 163.175 | 56.5875 | 81.5875 | Mechanické – tok - Tlaková ztráta: 5.87893 Pa
13680824 | 2.NP_SO-102 | ø160 mm-ø110 mm | G | 2.NP_SO-102 | 3299.74 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 40.7937 | 80 | 55 | 160 | 110 | 160 | 110 | 0.000618199 | 80 | 80 | 0.0311347 | ø160-ø110 | 65.27 | 45.27 | 163.175 | 113.175 | TT00.05.1659 | 1659 | yes | 3048 | no | 3048 | yes | no | 163.175 | 56.5875 | 81.5875 | Mechanické – tok - Tlaková ztráta: 5.87893 Pa
13680879 | 1.NP_SO-102 | ø160 mm-ø110 mm | G | 1.NP_SO-102 | 3066.15 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 40.7937 | 80 | 55 | 160 | 110 | 160 | 110 | 0.000618199 | 80 | 80 | 0.0311347 | ø160-ø110 | 65.27 | 45.27 | 163.175 | 113.175 | TT00.05.1662 | 1662 | yes | 3048 | no | 3048 | yes | no | 163.175 | 56.5875 | 81.5875 | Mechanické – tok - Tlaková ztráta: 5.87893 Pa
13688930 | -1.PP_SO-102 | ø200 mm-ø160 mm | G | -1.PP_SO-102 | 2795.84 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 51.5938 | 100 | 80 | 200 | 160 | 200 | 160 | 0.00138957 | 100 | 100 | 0.0530888 | ø200-ø160 | 82.55 | 65.27 | 206.375 | 163.175 | TT00.05.1690 | 1690 | yes | 3048 | no | 3048 | yes | no | 206.375 | 81.5875 | 103.188 | Mechanické – tok - Tlaková ztráta: 8.75897 Pa
13689217 | -1.PP_SO-102 | ø200 mm-ø110 mm | G | -1.PP_SO-102 | 2595.78 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 51.5938 | 55 | 100 | 110 | 200 | 200 | 110 | 0.00106358 | 55 | 55 | 0.044956 | ø200-ø110 | 45.27 | 82.55 | 113.175 | 206.375 | TT00.05.1691 | 1691 | yes | 3048 | no | 3048 | no | yes | 206.375 | 103.188 | 56.5875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13689399 | -1.PP_SO-102 | ø200 mm-ø160 mm | G | -1.PP_SO-102 | 2442.11 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 51.5938 | 100 | 80 | 200 | 160 | 200 | 160 | 0.00138957 | 100 | 100 | 0.0530888 | ø200-ø160 | 82.55 | 65.27 | 206.375 | 163.175 | TT00.05.1696 | 1696 | yes | 3048 | no | 3048 | yes | no | 206.375 | 81.5875 | 103.188 | Mechanické – tok - Tlaková ztráta: 0 Pa
13689701 | -1.PP_SO-102 | ø200 mm-ø110 mm | G | -1.PP_SO-102 | 2544.84 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 51.5938 | 100 | 55 | 200 | 110 | 200 | 110 | 0.00106356 | 100 | 100 | 0.044956 | ø200-ø110 | 82.55 | 45.27 | 206.375 | 113.175 | TT00.05.1698 | 1698 | yes | 3048 | no | 3048 | yes | no | 206.375 | 56.5875 | 103.188 | Mechanické – tok - Tlaková ztráta: 0 Pa
13689730 | 1.NP_SO-102 | ø110 mm-ø78 mm | G | 1.NP_SO-102 | 3262.77 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 28.2938 | 39 | 55 | 78 | 110 | 110 | 78 | 0.000211638 | 39 | 39 | 0.015107 | ø110-ø78 | 32.47 | 45.27 | 81.175 | 113.175 | TT00.05.1699 | 1699 | yes | 3048 | no | 3048 | no | yes | 113.175 | 56.5875 | 40.5875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13689925 | -1.PP_SO-102 | ø200 mm-ø110 mm | G | -1.PP_SO-102 | 2517.46 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 51.5938 | 100 | 55 | 200 | 110 | 200 | 110 | 0.00106356 | 100 | 100 | 0.044956 | ø200-ø110 | 82.55 | 45.27 | 206.375 | 113.175 | TT00.05.1704 | 1704 | yes | 3048 | no | 3048 | yes | no | 206.375 | 56.5875 | 103.188 | Mechanické – tok - Tlaková ztráta: 0 Pa
13690097 | -1.PP_SO-102 | ø110 mm-ø78 mm | G | -1.PP_SO-102 | 2886.43 | Fáze 2 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 28.2938 | 55 | 39 | 110 | 78 | 110 | 78 | 0.000211635 | 55 | 55 | 0.015107 | ø110-ø78 | 45.27 | 32.47 | 113.175 | 81.175 | TT00.05.1711 | 1711 | yes | 3048 | no | 3048 | yes | no | 113.175 | 40.5875 | 56.5875 | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S19
13818872 | 1.NP_SO-102 | ø78 mm-ø58 mm | F | 1.NP_SO-102 | 3064.97 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 20.2938 | 39 | 29 | 78 | 58 | 78 | 58 | 0.0000812036 | 39 | 39 | 0.00789529 | ø78-ø58 | 32.47 | 24.47 | 81.175 | 61.175 | TT00.05.1807 | 1807 | yes | 3048 | no | 3048 | yes | no | 81.175 | 30.5875 | 40.5875
13993478 | 2.NP_SO-102 | ø135 mm-ø78 mm | F | 2.NP_SO-102 | -846.454 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 34.5438 | 67.5 | 39 | 135 | 78 | 135 | 78 | 0.000333579 | 67.5 | 67.5 | 0.0207326 | ø135-ø78 | 55.27 | 32.47 | 138.175 | 81.175 | TT00.05.2030 | 2030 | yes | 3048 | no | 3048 | yes | no | 138.175 | 40.5875 | 69.0875
13993606 | 1.NP_SO-102 | ø135 mm-ø110 mm | F | 1.NP_SO-102 | 3020.39 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 34.5438 | 67.5 | 55 | 135 | 110 | 135 | 110 | 0.000429809 | 67.5 | 67.5 | 0.0243449 | ø135-ø110 | 55.27 | 45.27 | 138.175 | 113.175 | TT00.05.2033 | 2033 | yes | 3048 | no | 3048 | yes | no | 138.175 | 56.5875 | 69.0875 | Mechanické – tok - Tlaková ztráta: 4.75191 Pa
13993947 | 2.NP_SO-102 | ø135 mm-ø78 mm | F | 2.NP_SO-102 | -903.03 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 34.5438 | 67.5 | 39 | 135 | 78 | 135 | 78 | 0.000333579 | 67.5 | 44.5482 | 0.0205439 | ø135-ø78 | 55.27 | 32.47 | 138.175 | 81.175 | TT00.05.2039 | 2039 | yes | 3048 | no | 3025.05 | yes | no | 138.175 | 40.5875 | 69.0875
13995030 | 1.NP_SO-102 | ø135 mm-ø78 mm | F | 1.NP_SO-102 | 2922.85 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 34.5438 | 67.5 | 39 | 135 | 78 | 135 | 78 | 0.000333579 | 67.5 | 67.5 | 0.0207326 | ø135-ø78 | 55.27 | 32.47 | 138.175 | 81.175 | TT00.05.2047 | 2047 | yes | 3048 | no | 3048 | yes | no | 138.175 | 40.5875 | 69.0875
13995736 | 1.NP_SO-102 | ø135 mm-ø110 mm | F | 1.NP_SO-102 | 2839.02 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 34.5438 | 67.5 | 55 | 135 | 110 | 135 | 110 | 0.000429809 | 67.5 | 67.5 | 0.0243449 | ø135-ø110 | 55.27 | 45.27 | 138.175 | 113.175 | TT00.05.2050 | 2050 | yes | 3048 | no | 3048 | yes | no | 138.175 | 56.5875 | 69.0875 | Mechanické – tok - Tlaková ztráta: 4.75191 Pa
13996576 | 1.NP_SO-102 | ø135 mm-ø110 mm | F | 1.NP_SO-102 | 2845.79 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 34.5438 | 67.5 | 55 | 135 | 110 | 135 | 110 | 0.000429809 | 67.5 | 67.5 | 0.0243449 | ø135-ø110 | 55.27 | 45.27 | 138.175 | 113.175 | TT00.05.2060 | 2060 | yes | 3048 | no | 3048 | yes | no | 138.175 | 56.5875 | 69.0875
13996700 | 2.NP_SO-102 | ø110 mm-ø78 mm | F | 2.NP_SO-102 | -925.057 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 28.2938 | 55 | 39 | 110 | 78 | 110 | 78 | 0.000211635 | 55 | 55 | 0.015107 | ø110-ø78 | 45.27 | 32.47 | 113.175 | 81.175 | TT00.05.2063 | 2063 | yes | 3048 | no | 3048 | yes | no | 113.175 | 40.5875 | 56.5875
13996840 | 1.NP_SO-102 | ø110 mm-ø58 mm | F | 1.NP_SO-102 | 3079.94 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 28.2938 | 55 | 29 | 110 | 58 | 110 | 58 | 0.00017378 | 55 | 55 | 0.0134339 | ø110-ø58 | 45.27 | 24.47 | 113.175 | 61.175 | TT00.05.2068 | 2068 | yes | 3048 | no | 3048 | yes | no | 113.175 | 30.5875 | 56.5875
13998583 | 2.NP_SO-102 | ø135 mm-ø135 mm | F | 2.NP_SO-102 | -863.269 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 34.5438 | 67.5 | 67.5 | 135 | 135 | 135 | 135 | 0.000517876 | 67.4995 | 56.9804 | 0.0283102 | ø135-ø135 | 55.27 | 55.27 | 138.175 | 138.175 | TT00.05.2076 | 2076 | yes | 3048 | yes | 3037.48 | no | no | 138.175 | 69.0875 | 69.0875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13999288 | 1.NP_SO-102 | ø135 mm-ø110 mm | F | 1.NP_SO-102 | 2995.64 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 34.5438 | 67.5 | 55 | 135 | 110 | 135 | 110 | 0.000429809 | 67.5 | 67.5 | 0.0243449 | ø135-ø110 | 55.27 | 45.27 | 138.175 | 113.175 | TT00.05.2084 | 2084 | yes | 3048 | no | 3048 | yes | no | 138.175 | 56.5875 | 69.0875 | Mechanické – tok - Tlaková ztráta: 4.75191 Pa
13999349 | 1.NP_SO-102 | ø110 mm-ø110 mm | F | 1.NP_SO-102 | 3025.51 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 28.2938 | 55 | 55 | 110 | 110 | 110 | 110 | 0.000284529 | 54.9999 | 37.447 | 0.01942 | ø110-ø110 | 45.27 | 45.27 | 113.175 | 113.175 | TT00.05.2087 | 2087 | yes | 3048 | yes | 3030.45 | no | no | 113.175 | 56.5875 | 56.5875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13999677 | 1.NP_SO-102 | ø135 mm-ø78 mm | F | 1.NP_SO-102 | 2698.94 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 34.5438 | 67.5 | 39 | 135 | 78 | 135 | 78 | 0.000333579 | 67.5 | 67.5 | 0.0207326 | ø135-ø78 | 55.27 | 32.47 | 138.175 | 81.175 | TT00.05.2093 | 2093 | yes | 3048 | no | 3048 | yes | no | 138.175 | 40.5875 | 69.0875
14000688 | 1.NP_SO-102 | ø160 mm-ø110 mm | F | 1.NP_SO-102 | 2757.03 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 40.7937 | 55 | 80 | 110 | 160 | 160 | 110 | 0.000618234 | 55 | 55 | 0.0311347 | ø160-ø110 | 45.27 | 65.27 | 113.175 | 163.175 | TT00.05.2098 | 2098 | yes | 3048 | no | 3048 | no | yes | 163.175 | 81.5875 | 56.5875 | Mechanické – tok - Tlaková ztráta: 0 Pa
14000912 | 1.NP_SO-102 | ø160 mm-ø135 mm | F | 1.NP_SO-102 | 2253.4 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 40.7937 | 80 | 67.5 | 160 | 135 | 160 | 135 | 0.000728875 | 79.9468 | 80 | 0.0347699 | ø160-ø135 | 65.27 | 55.27 | 163.175 | 138.175 | TT00.05.2102 | 2102 | yes | 3047.95 | no | 3048 | yes | no | 163.175 | 69.0875 | 81.5875
14004646 | 1.NP_SO-102 | ø135 mm-ø110 mm | F | 1.NP_SO-102 | 2930.77 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 34.5438 | 67.5 | 55 | 135 | 110 | 135 | 110 | 0.000429809 | 67.5 | 67.5 | 0.0243449 | ø135-ø110 | 55.27 | 45.27 | 138.175 | 113.175 | TT00.05.2131 | 2131 | yes | 3048 | no | 3048 | yes | no | 138.175 | 56.5875 | 69.0875 | Mechanické – tok - Tlaková ztráta: 4.75191 Pa
14004676 | 2.NP_SO-102 | ø110 mm-ø110 mm | F | 2.NP_SO-102 | -966.933 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 28.2938 | 55 | 55 | 110 | 110 | 110 | 110 | 0.000284529 | 54.9983 | 44.5402 | 0.0189948 | ø110-ø110 | 45.27 | 45.27 | 113.175 | 113.175 | TT00.05.2133 | 2133 | yes | 3048 | yes | 3037.54 | no | no | 113.175 | 56.5875 | 56.5875 | Mechanické – tok - Tlaková ztráta: 0 Pa
14027583 | -1.PP_SO-102 | ø250 mm-ø160 mm | F | -1.PP_SO-102 | -1259.94 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 64.2938 | 125 | 80 | 250 | 160 | 250 | 160 | 0.00226751 | 125 | 125 | 0.0740619 | ø250-ø160 | 102.87 | 65.27 | 257.175 | 163.175 | TT00.05.2210 | 2210 | yes | 3048 | no | 3048 | yes | no | 257.175 | 81.5875 | 128.588
14036854 | -1.PP_SO-102 | ø110 mm-ø78 mm | F | -1.PP_SO-102 | 103.205 | Fáze 2 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 28.2938 | 55 | 39 | 110 | 78 | 110 | 78 | 0.000211635 | 55 | 55 | 0.015107 | ø110-ø78 | 45.27 | 32.47 | 113.175 | 81.175 | TT00.05.2225 | 2225 |  | 3048 | no | 3048 | yes | no | 113.175 | 40.5875 | 56.5875
14036856 | -1.PP_SO-102 | ø160 mm-ø110 mm | F | -1.PP_SO-102 | -2262.59 | Fáze 2 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 40.7937 | 80 | 55 | 160 | 110 | 160 | 110 | 0.000618199 | 80 | 80 | 0.0311347 | ø160-ø110 | 65.27 | 45.27 | 163.175 | 113.175 | TT00.05.2226 | 2226 |  | 3048 | no | 3048 | yes | no | 163.175 | 56.5875 | 81.5875

# IfcPipeFitting: M_Přechod, obecný:Standardní (15)
Type - Classification: TT00 SNIM (SNIM); Material: 128-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 05; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Mechanické - Klasifikace systému: Studená voda v domácnosti
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Šířkové odsazení: 3048 mm; Viditelnost 1: no
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Název systému = Group | Odskok – šířka | Odskok – výška | Délka (mm) | Jmenovitý poloměr 1 (mm) | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Výškové odsazení (mm) | Viditelnost 2 | Viditelnost 3 | Max. vnější průměr tvarovky 12 (mm) | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm)
13068038 | 4.NP_SO-102 | ø32 mm-ø20 mm | 4.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 10 | 8.73125 | 10 | 16 | 20 | 32 | 32 | 20 | 0.00000565444 | 0.00129853 | ø32-ø20 | 8.89 | 13.97 | 22.225 | 34.925 | TT00.05.0721 | 0721 | yes | 3048 | no | yes | 34.925 | 17.4625 | 11.1125
13068047 | 4.NP_SO-102 | ø32 mm-ø20 mm | 4.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 10 | 8.73125 | 10 | 16 | 20 | 32 | 32 | 20 | 0.00000565444 | 0.00129853 | ø32-ø20 | 8.89 | 13.97 | 22.225 | 34.925 | TT00.05.0722 | 0722 | yes | 3048 | no | yes | 34.925 | 17.4625 | 11.1125
13068073 | 4.NP_SO-102 | ø32 mm-ø20 mm | 4.NP_SO-102 | 3227.46 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 10 | 8.73125 | 10 | 16 | 20 | 32 | 32 | 20 | 0.00000565444 | 0.00129853 | ø32-ø20 | 8.89 | 13.97 | 22.225 | 34.925 | TT00.05.0723 | 0723 | yes | 3048 | no | yes | 34.925 | 17.4625 | 11.1125
13068075 | 3.NP_SO-102 | ø32 mm-ø20 mm | 3.NP_SO-102 | 3268.74 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 10 | 8.73125 | 10 | 16 | 20 | 32 | 32 | 20 | 0.00000565444 | 0.00129853 | ø32-ø20 | 8.89 | 13.97 | 22.225 | 34.925 | TT00.05.0724 | 0724 | yes | 3048 | no | yes | 34.925 | 17.4625 | 11.1125
13068143 | 3.NP_SO-102 | ø32 mm-ø20 mm | 3.NP_SO-102 | 3221.11 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 10 | 8.73125 | 10 | 16 | 20 | 32 | 32 | 20 | 0.00000565444 | 0.00129853 | ø32-ø20 | 8.89 | 13.97 | 22.225 | 34.925 | TT00.05.0727 | 0727 | yes | 3048 | no | yes | 34.925 | 17.4625 | 11.1125
13068154 | 2.NP_SO-102 | ø40 mm-ø25 mm | 2.NP_SO-102 | 3217.94 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | WS_"ŠEDÁ" studená vnitřní 2 | 12.5 | 12.5 | 10.3188 | 12.5 | 20 | 25 | 40 | 40 | 25 | 0.00000997107 | 0.00193705 | ø40-ø25 | 11.43 | 16.51 | 28.575 | 41.275 | TT00.05.0729 | 0729 | yes | 3048 | no | yes | 41.275 | 20.6375 | 14.2875
13068373 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 10 | 8.73125 | 10 | 16 | 20 | 32 | 32 | 20 | 0.00000565444 | 0.00129853 | ø32-ø20 | 8.89 | 13.97 | 22.225 | 34.925 | TT00.05.0742 | 0742 | yes | 3048 | no | yes | 34.925 | 17.4625 | 11.1125
