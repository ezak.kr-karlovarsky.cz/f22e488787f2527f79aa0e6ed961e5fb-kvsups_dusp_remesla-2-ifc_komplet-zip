Properties of the parts of a building model (IFC4), part 24 of 60

# IfcDistributionPort (11856)
Name | FlowDirection | PredefinedType | SystemType | Group
OutPort_13805464_1 | SOURCE | PIPE | DOMESTICHOTWATER
InPort_13805464_2 | SINK | PIPE | HEATING
InPort_13805464_3 | SINK | PIPE | DOMESTICHOTWATER
OutPort_13805464_4 | SOURCE | PIPE | HEATING
InPort_13805464_5 | SINK | PIPE | DOMESTICCOLDWATER
Port_13805465_2 | SOURCEANDSINK | PIPE
OutPort_13805466_1 | SOURCE | PIPE | DOMESTICHOTWATER
InPort_13805466_2 | SINK | PIPE | HEATING
InPort_13805466_3 | SINK | PIPE | DOMESTICHOTWATER
OutPort_13805466_4 | SOURCE | PIPE | HEATING
InPort_13805466_5 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_13805467_1 | SOURCE | PIPE | DOMESTICHOTWATER
InPort_13805467_2 | SINK | PIPE | HEATING
InPort_13805467_3 | SINK | PIPE | DOMESTICHOTWATER
OutPort_13805467_4 | SOURCE | PIPE | HEATING
InPort_13805467_5 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_13805468_1 | SOURCE | PIPE | DOMESTICHOTWATER
InPort_13805468_2 | SINK | PIPE | HEATING
InPort_13805468_3 | SINK | PIPE | DOMESTICHOTWATER
OutPort_13805468_4 | SOURCE | PIPE | HEATING
InPort_13805468_5 | SINK | PIPE | DOMESTICCOLDWATER
Port_13805725_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13831947_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13805725_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13805880_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13805860_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13805874_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13805860_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13805861_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13805861_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13832221_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13805874_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836790_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13805880_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836769_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13807023_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13807358_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13807054_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13807701_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13807054_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13807705_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13807062_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13807661_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13807062_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13807665_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13807208_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13807766_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13807239_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13807738_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13807239_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13807742_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13807255_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13807693_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13807274_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13807653_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13807302_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13807622_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13807302_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13807626_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13807356_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13807358_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13807356_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13807374_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13807399_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13807401_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13807399_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13807738_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13807434_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13807436_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13807434_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13807701_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13807436_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13828817_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13807473_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13807475_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13807473_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13807661_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13807475_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13829338_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13807509_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13807511_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13807509_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13807622_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13807612_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13807614_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13807612_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13807626_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13807651_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13807653_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13807651_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13807665_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13807691_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13807693_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13807691_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13807705_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13807728_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13807730_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13807728_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13807742_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13807764_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13807766_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13807764_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13807778_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13807976_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808076_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13807976_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808151_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808029_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808076_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808029_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808043_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808043_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13825256_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808149_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808151_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808149_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808159_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808159_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808263_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808263_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808271_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808271_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808272_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808272_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808367_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808317_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808375_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808317_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808377_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808365_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808367_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808365_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808377_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808375_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808523_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808516_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808522_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808516_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808526_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808522_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13808523_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13817615_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13817623_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13817615_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13817648_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13818869_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13818872_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13822531_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13823025_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13822531_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13823029_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13822562_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13823062_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13822562_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13823066_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13822578_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13823099_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13822578_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13823103_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13822590_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13823135_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13822590_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13823139_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13822603_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13823208_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13822603_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13823212_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13822812_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13840327_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13822812_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13822818_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13822813_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13822818_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13822813_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13823208_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13822858_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13840288_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13822858_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13822868_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13822900_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13822902_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13822900_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13823135_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13822931_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13840219_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13822931_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13823099_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13822961_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13822963_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13822961_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13823062_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13822992_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13840145_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13822992_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13823025_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13823015_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13823017_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13823015_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13823029_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13823052_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13823054_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13823052_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13823066_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13823089_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13823091_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13823089_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13823103_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13823125_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13823127_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13823125_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13823139_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13823160_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13916173_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13823160_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13823172_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13823172_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13823652_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13823196_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13823200_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13823197_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13823200_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13823197_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13823212_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13823412_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13823439_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13823412_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13823422_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13823414_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13823422_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13823414_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13823498_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13823519_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13823498_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13823511_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13823507_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13823508_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13823507_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13823519_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13823508_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13840258_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13823649_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13823659_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13823649_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13823667_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13823651_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13823652_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13823651_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13823659_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13824395_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13824405_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13824395_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13824860_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13824425_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13824588_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13824425_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13824938_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13824491_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13824507_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13824491_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13824900_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13824844_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13824864_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13824844_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13839803_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13824858_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13824860_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13824858_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13824864_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13824898_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13824900_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13824898_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13825057_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13824936_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13824938_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13824936_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13824942_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13824942_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13825020_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13825010_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13840007_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13825020_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13840007_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13825049_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13839892_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13825049_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13839894_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13825051_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13839892_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13825051_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13825057_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13825069_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13839803_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13825069_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13839805_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13825256_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13825289_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13825264_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13825285_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13825264_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13825289_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13825587_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13825620_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13825587_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13825604_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13825591_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13825604_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13825635_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13825643_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13825639_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13825643_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13825656_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13825678_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13825656_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13825665_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13825658_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13825665_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13825690_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13825720_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13825690_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13825705_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13825692_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13825705_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13826482_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13826849_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13826531_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13826907_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13826550_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13826954_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13826560_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13827011_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13826647_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13827192_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13826653_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13827159_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13826663_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13827085_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13826670_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13827122_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13826706_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13827229_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13826847_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13826849_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13826847_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13826859_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13826905_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13826907_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13826905_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13826917_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13826952_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13826954_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13826952_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13826964_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13827009_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13827011_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13827009_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13827021_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13827083_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13827085_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13827083_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13827095_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13827120_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13827122_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13827120_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13827132_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13827157_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13827159_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13827157_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13827169_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13827190_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13827192_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13827190_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13827202_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13827227_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13827229_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13827227_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13827239_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13827931_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13830520_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13827940_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13830469_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13827974_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13830504_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13827974_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13828947_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13828006_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13830453_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13828006_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13829337_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13828694_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13828704_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13828694_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13828715_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13828696_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13828697_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13828696_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13828704_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13828814_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
OutPort_13828824_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
InPort_13828832_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
OutPort_13828814_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13828816_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13828817_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
InPort_13828824_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
OutPort_13828816_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13828945_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13828955_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13828945_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13828963_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13828947_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13828955_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13829134_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13829231_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13829134_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13829217_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13829335_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13829345_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13829335_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13829353_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13829337_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13829338_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13829337_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13829345_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13830451_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13830461_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13830451_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13830469_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13830453_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13830454_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13830453_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13830461_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13830502_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13830512_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13830502_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13830520_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13830504_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13830505_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13830504_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13830512_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13830841_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13830849_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_13831116_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
OutPort_13831106_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
InPort_13831110_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
OutPort_13831116_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13831131_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13831139_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13831133_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13831139_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13831154_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13831183_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13831154_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13831168_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13831156_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13831168_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13831927_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13832231_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13831940_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13832192_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13831940_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13832196_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13831947_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13832146_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13832144_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13832146_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13832144_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13832156_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13832182_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13832184_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13832182_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13832196_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13832219_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13832221_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13832219_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13832231_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13832787_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13833173_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13832801_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13833236_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13833035_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13833145_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13833035_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13833036_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13833054_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13833118_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13833054_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13833055_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13833109_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13833117_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13833109_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13833117_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13833118_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13833138_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13833144_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13833138_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13833144_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13833145_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13833171_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13833173_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13833171_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13833183_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13833234_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13833236_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13833234_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13833246_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13835358_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13835360_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13835653_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13835660_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13835660_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13837047_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13835692_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13835699_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13835699_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13837026_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13835831_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13835833_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13835833_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13837035_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13835900_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13835902_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13835902_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13837014_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13835959_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836648_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13835959_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13835982_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836674_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13835982_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836076_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836441_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836076_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836462_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836083_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836087_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836083_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836441_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836085_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836087_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836109_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836400_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836109_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836793_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836114_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836118_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836114_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836400_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836116_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836118_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836301_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836748_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836311_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836727_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836339_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836676_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836349_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836650_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836405_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836789_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836405_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836793_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836454_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836462_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836454_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836772_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836464_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836768_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836464_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836772_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836648_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836650_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836674_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836676_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836727_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836789_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836748_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836768_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836768_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836769_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13836789_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13836790_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13837014_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13837024_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13837016_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13837024_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13837016_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13837026_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13837035_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13837045_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13837037_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13837045_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13837037_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13837047_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13837801_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13837944_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13837801_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13838149_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13837852_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13838581_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13837852_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13838019_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13838147_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13838149_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13838147_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13838256_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13838256_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13838572_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13838567_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13838581_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13838567_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13838585_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13838572_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13838585_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13839297_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13840319_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13839350_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13840280_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13839369_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13840176_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13839483_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13840137_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13839798_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13839805_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13839798_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13840248_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13839805_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13839806_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13839885_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13839898_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13839885_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13840211_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13839894_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13839898_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13839894_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13839900_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13839895_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13839900_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13840135_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13840137_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13840135_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13840149_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13840174_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13840176_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13840174_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13840186_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13840209_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13840211_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13840209_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13840223_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13840246_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13840248_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13840246_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13840258_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13840278_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13840280_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13840278_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13840292_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13840317_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13840319_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13840317_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13840329_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13840854_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13840882_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13840858_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13840882_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13840858_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13840887_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13840867_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13840869_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13840867_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13840887_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13916163_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13916165_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13916163_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13916177_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13916165_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13916166_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13975766_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13976075_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13975766_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13976077_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13975813_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13976116_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13975813_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13976118_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13975847_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13976153_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13975847_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13976155_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13976059_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13976204_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13976059_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13976077_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13976104_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13976257_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13976104_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13976118_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13976143_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13976145_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13976143_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13976155_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13976196_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13976198_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13976196_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13976208_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13976249_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13976251_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13976249_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13976261_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13976302_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13976304_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13976302_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13976312_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13980315_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 4
Port_13980315_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 4
InPort_13981069_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13981225_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13981227_3 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13981069_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13981216_0 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13981227_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13981227_2 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13981228_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13981921_2 | SINK | PIPE | SEWAGE | SW_Deště čerpání 1
OutPort_13981843_0 | SOURCE | PIPE | SEWAGE | SW_Deště čerpání 1
InPort_13981843_1 | SINK | PIPE | SEWAGE | SW_Deště čerpání 1
OutPort_13981953_1 | SOURCE | PIPE | SEWAGE | SW_Deště čerpání 1
InPort_13736833_1 | SINK | PIPE | SEWAGE | SW_Deště čerpání 1
OutPort_13981857_0 | SOURCE | PIPE | SEWAGE | SW_Deště čerpání 1
InPort_13981857_1 | SINK | PIPE | SEWAGE | SW_Deště čerpání 1
