Properties of the parts of a building model (IFC4), part 43 of 60

# IfcPipeSegment: Typy trubek:HDPE 100+_odvodnění střech (126)
Name (Typy trubek:HDPE 100+_odvodnění střech:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Relativní drsnost | CCI Funkční systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) | Spodní výška (mm) | Střední výška (mm) | Fáze vytvoření | Řez | Název systému = Group | Obrátit výšku (mm) | Průměr (mm) = Vnější průměr (mm) | Typ systému | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Sklon
13982628 | 2.NP_SO-102 | 152.425 | 0.00950189 | 0.0526745 | ø110 mm | 0.0000984252 | G | 2.NP_SO-102 | -5089.29 | -5241.71 | -5089.29 | -5241.71 | -5089.29 | Fáze 1 | 39 | SW_Deště vnitřní podtlak 4 | -1241.71 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.2046 | 2046 | yes | Identifikační data - Komentáře: D1
13982639 | 2.NP_SO-102 | 8134.22 | 0.00950189 | 2.81098 | ø110 mm | 0.0000984252 | G | 2.NP_SO-102 | 3183.51 | -4950.71 | 3183.51 | -4950.71 | 3183.51 | Fáze 1 | 38 | SW_Deště vnitřní podtlak 4 | -950.712 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.2047 | 2047 | yes | Identifikační data - Komentáře: D1
14002289 | 1.NP_SO-102 | 507.892 | 0.00950189 | 0.175515 | ø110 mm | 0.0000984252 | F | 1.NP_SO-102 | 2687.63 | 2627.55 | 2632.63 | 2572.55 | 2632.63 | Fáze 1 | 45 | SW_Deště vnitřní podtlak 4 | 2576.75 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.2135 | 2135 | yes | 1
14002394 | 1.NP_SO-102 | 4128.07 | 0.00950189 | 1.42656 | ø110 mm | 0.0000984252 | F | 1.NP_SO-102 | 2682.03 | 2585.75 | 2627.03 | 2530.75 | 2627.03 | Fáze 1 | 45 | SW_Deště vnitřní podtlak 4 | 2534.95 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.2136 | 2136 | yes | 1
14002402 | 1.NP_SO-102 | 264.353 | 0.00950189 | 0.0913538 | ø110 mm | 0.0000984252 | F | 1.NP_SO-102 | 2640.23 | 2582.59 | 2585.23 | 2527.59 | 2585.23 | Fáze 1 | 45 | SW_Deště vnitřní podtlak 4 | 2531.79 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.2137 | 2137 | yes | 1
14002412 | 1.NP_SO-102 | 390.474 | 0.00950189 | 0.134938 | ø110 mm | 0.0000984252 | F | 1.NP_SO-102 | 2637.06 | 2578.16 | 2582.06 | 2523.16 | 2582.06 | Fáze 1 | 45 | SW_Deště vnitřní podtlak 4 | 2527.36 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.2138 | 2138 | yes | 1
14002505 | 2.NP_SO-102 | 218.497 | 0.01227 | 0.0858036 | ø125 mm | 0.0000866551 | F | 2.NP_SO-102 | -867.59 | -1066.29 | -911.785 | -1110.48 | -911.785 | Fáze 1 | 44 | SW_Deště vnitřní podtlak 4 | 2892.91 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2139 | 2139 | yes | 100
14002520 | 2.NP_SO-102 | 4105.66 | 0.01227 | 1.61229 | ø125 mm | 0.0000866551 | F | 2.NP_SO-102 | -1024.71 | -1128.26 | -1087.21 | -1190.76 | -1087.21 | Fáze 1 | 44 | SW_Deště vnitřní podtlak 4 | 2814.04 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2140 | 2140 | yes | 1
14002534 | 2.NP_SO-102 | 434.982 | 0.01227 | 0.170817 | ø125 mm | 0.0000866551 | F | 2.NP_SO-102 | -1066.35 | -1133.2 | -1128.85 | -1195.7 | -1128.85 | Fáze 1 | 44 | SW_Deště vnitřní podtlak 4 | 2809.1 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2141 | 2141 | yes | 1
14002680 | 1.NP_SO-102 | 7228.31 | 0.01227 | 2.83855 | ø125 mm | 0.0000866551 | G | 1.NP_SO-102 | 3003.82 | 2866.85 | 2941.32 | 2804.35 | 2941.32 | Fáze 1 | 46 | SW_Deště vnitřní podtlak 4 | 2809.15 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2142 | 2142 | yes | 1.03034
14003704 | 2.NP_SO-102 | 6716.42 | 0.0122696 | 2.63753 | ø125 mm | 0.0000866551 | F | 2.NP_SO-102 | 3140.75 | 3011.09 | 3078.25 | 2948.59 | 3078.25 | Fáze 1 | 54 | SW_Deště vnitřní podtlak 4 | 6953.39 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2143 | 2143 | yes | 1
14004123 | 2.NP_SO-102 | 672.676 | 0.01227 | 0.264159 | ø125 mm | 0.0000866551 | F | 2.NP_SO-102 | -1006.27 | -1075.49 | -1068.76 | -1137.99 | -1068.76 | Fáze 1 | 48 | SW_Deště vnitřní podtlak 4 | 2866.81 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2144 | 2144 | yes | 1
14004135 | 2.NP_SO-102 | 140.425 | 0.01227 | 0.0551448 | ø125 mm | 0.0000866551 | F | 2.NP_SO-102 | -1013.59 | -1077.49 | -1076.08 | -1139.98 | -1076.08 | Fáze 1 | 48 | SW_Deště vnitřní podtlak 4 | 2864.82 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2145 | 2145 | yes | 1
14004145 | 2.NP_SO-102 | 130.004 | 0.01227 | 0.0510525 | ø125 mm | 0.0000866551 | F | 2.NP_SO-102 | -1062.59 | -1198.71 | -1106.79 | -1242.91 | -1106.79 | Fáze 1 | 48 | SW_Deště vnitřní podtlak 4 | 2760.49 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2146 | 2146 | yes | 100
14004206 | 1.NP_SO-102 | 4294.06 | 0.01227 | 1.68627 | ø125 mm | 0.0000866551 | G | 1.NP_SO-102 | 2749.41 | 2642.98 | 2686.92 | 2580.49 | 2686.92 | Fáze 1 | 53 | SW_Deště vnitřní podtlak 4 | 2585.29 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2147 | 2147 | yes | 1.02317
14004215 | 1.NP_SO-102 | 16951.1 | 0.01227 | 6.65667 | ø125 mm | 0.0000866551 | G | 1.NP_SO-102 | 2926.11 | 2690.18 | 2863.61 | 2627.68 | 2863.61 | Fáze 1 | 5 | SW_Deště vnitřní podtlak 4 | 2632.48 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2148 | 2148 | yes | 1.02317
14015955 | 2.NP_SO-102 | 521.985 | 0.01227 | 0.204983 | ø125 mm | 0.0000866551 | F | 2.NP_SO-102 | 3034.36 | 2621.07 | 2990.17 | 2576.88 | 2990.17 | Fáze 1 | 54 | SW_Deště vnitřní podtlak 4 | 6580.27 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2158 | 2158 |  | 100
14016042 | 2.NP_SO-102 | 234.905 | 0.01227 | 0.0922469 | ø125 mm | 0.0000866551 | F | 2.NP_SO-102 | 3061.49 | 2996.65 | 2999 | 2934.15 | 2999 | Fáze 1 | 57 | SW_Deště vnitřní podtlak 4 | 6938.95 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2159 | 2159 |  | 1
14016060 | 2.NP_SO-102 | 240.329 | 0.01227 | 0.094377 | ø125 mm | 0.0000866551 | F | 2.NP_SO-102 | 3058.55 | 2993.65 | 2996.06 | 2931.16 | 2996.06 | Fáze 1 | 57 | SW_Deště vnitřní podtlak 4 | 6935.95 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2160 | 2160 |  | 1
14016072 | 2.NP_SO-102 | 274.611 | 0.01227 | 0.10784 | ø125 mm | 0.0000866551 | F | 2.NP_SO-102 | 3016.93 | 2778.55 | 2972.73 | 2734.36 | 2972.73 | Fáze 1 | 57 | SW_Deště vnitřní podtlak 4 | 6737.75 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2161 | 2161 |  | 100
14016134 | 2.NP_SO-102 | 60.9442 | 0.01227 | 0.0239327 | ø125 mm | 0.0000866551 | F | 2.NP_SO-102 | 2728.04 | 2667.09 | 2728.04 | 2667.09 | 2728.04 | Fáze 1 | 57 | SW_Deště vnitřní podtlak 4 | 6667.09 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2162 | 2162
14016364 | 2.NP_SO-102 | 92.3502 | 0.01227 | 0.0362658 | ø125 mm | 0.0000866551 | F | 2.NP_SO-102 | 2592.36 | 2528.94 | 2529.86 | 2466.44 | 2529.86 | Fáze 1 | 21 | SW_Deště vnitřní podtlak 4 | 6471.24 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2163 | 2163 |  | 1
14016382 | 2.NP_SO-102 | 106.247 | 0.01227 | 0.041723 | ø125 mm | 0.0000866551 | F | 2.NP_SO-102 | 2590.84 | 2527.28 | 2528.35 | 2464.79 | 2528.35 | Fáze 1 | 21 | SW_Deště vnitřní podtlak 4 | 6469.59 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2164 | 2164 |  | 1
14016408 | 2.NP_SO-102 | 479.131 | 0.01227 | 0.188154 | ø125 mm | 0.0000866551 | F | 2.NP_SO-102 | 2550.56 | 2167.57 | 2506.36 | 2123.37 | 2506.36 | Fáze 1 | 21 | SW_Deště vnitřní podtlak 4 | 6126.77 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2165 | 2165 |  | 100
14016443 | 2.NP_SO-102 | 2316.07 | 0.01227 | 0.909519 | ø125 mm | 0.0000866551 | F | 2.NP_SO-102 | 1899.32 | -416.751 | 1899.32 | -416.751 | 1899.32 | Fáze 1 | 48 | SW_Deště vnitřní podtlak 4 | 3583.25 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2166 | 2166 | yes
14016451 | 2.NP_SO-102 | 139.235 | 0.01227 | 0.0546773 | ø125 mm | 0.0000866551 | F | 2.NP_SO-102 | 2352.82 | 2213.59 | 2352.82 | 2213.59 | 2352.82 | Fáze 1 | 56 | SW_Deště vnitřní podtlak 4 | 6213.59 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2167 | 2167 | yes
14016470 | 2.NP_SO-102 | 348.758 | 0.01227 | 0.136957 | ø125 mm | 0.0000866551 | F | 2.NP_SO-102 | -425.688 | -491.672 | -488.185 | -554.169 | -488.185 | Fáze 1 | 48 | SW_Deště vnitřní podtlak 4 | 3450.63 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2168 | 2168 |  | 1
14016583 | 2.NP_SO-102 | 442.714 | 0.01227 | 0.173853 | ø125 mm | 0.0000866551 | F | 2.NP_SO-102 | -800.839 | -863.336 | -867.763 | -930.26 | -867.763 | Fáze 1 | 48 | SW_Deště vnitřní podtlak 4 | 3074.54 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2169 | 2169 |  | 1
14016593 | 2.NP_SO-102 | 228.796 | 0.01227 | 0.0898481 | ø125 mm | 0.0000866551 | F | 2.NP_SO-102 | -563.106 | -791.902 | -563.106 | -791.902 | -563.106 | Fáze 1 | 48 | SW_Deště vnitřní podtlak 4 | 3208.1 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2170 | 2170
14016651 | 2.NP_SO-102 | 182.736 | 0.01227 | 0.0717602 | ø125 mm | 0.0000866551 | F | 2.NP_SO-102 | -844.489 | -888.683 | -1017.9 | -1062.09 | -1017.9 | Fáze 1 | 48 | SW_Deště vnitřní podtlak 4 | 2941.3 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2171 | 2171 |  | 100
14016855 | 1.NP_SO-102 | 1225.74 | 0.01227 | 0.481349 | ø125 mm | 0.0000866551 | G | 1.NP_SO-102 | 3300.42 | 3237.92 | 3225.66 | 3163.17 | 3225.66 | Fáze 2 | 33 | SW_Deště vnitřní podtlak 4 | 3167.97 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.2172 | 2172 | yes | 1

# IfcPipeSegment: Typy trubek:Ocel_pozink (uvnitř / vně pozinkovaná) (155)
Type - Material: 175-0-255
Type - Požární ochrana - Požární odolnost: –
Type - Identifikační data - ID kategorie: TR; Kód sestavy: TR03; Model: IVAR.IVCCT; Název typu: Ocel_pozink (uvnitř / vně pozinkovaná); Označení typu: 04; Popis: POZINK; Popis sestavy: Ocel pozinková; Výrobce: IVAR CS
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR03 SNIM (SNIM); TR03 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: WPA
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Mechanické - Typ přípoje: Obecné
Jiné - Páteřní trasa: yes; Rodina: Typy trubek; Id typu: 12484472; Rodina a typ: Typy trubek: Ocel_pozink (uvnitř / vně pozinkovaná); Typ: Ocel_pozink (uvnitř / vně pozinkovaná)
Name (Typy trubek:Ocel_pozink (uvnitř / vně pozinkovaná):...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Celková velikost | Relativní drsnost | CCI Technický systém | Referenční podlaží | Sklon | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Typ systému | Drsnost (mm) | Klasifikace systému | Materiál | Název systému = Group | Obrátit výšku (mm) | Plocha (m2) | Popis úseku | Průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení
13103598 | -1.PP_SO-102 | 20294.2 | 0.00620623 | 5.66793 | ø89 mm | 0.000171821 | JB | -1.PP_SO-102 | 0 | 2644.45 | 2600 | 2600 | 2555.55 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1442.45 | 5.67431 | Zn | 89 | 406 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.0961 | 0961
13103613 | -1.PP_SO-102 | 286.687 | 0.00620623 | 0.0800681 | ø89 mm | 0.000171821 | JB | -1.PP_SO-102 | 0 | 2444.45 | 2400 | 2400 | 2355.55 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1642.45 | 0.0801581 | Zn | 89 | 406 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.0962 | 0962
13103947 | 4.NP_SO-102 | 3427.56 | 0.00620623 | 0.957276 | ø89 mm | 0.000171821 | JB | 4.NP_SO-102 |  | 786.35 | 786.35 | -2641.21 | -2641.21 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | 9358.79 | 0.958352 | Zn | 89 | 345 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.0963 | 0963 | Identifikační data - Komentáře: SCH2
13157471 | -1.PP_SO-102 | 2533.04 | 0.00138523 | 0.334226 | ø42 mm | 0.000515464 | JB | -1.PP_SO-102 | 0 | 2621 | 2600 | 2600 | 2579 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -1419.5 | 0.334226 | Zn | 42 | 148 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø42 | 42 | 39 | TR03.04.1037 | 1037
13157475 | -1.PP_SO-102 | 19735.4 | 0.00138523 | 2.60402 | ø42 mm | 0.000515464 | JB | -1.PP_SO-102 | 0 | 2921 | 2900 | 2900 | 2879 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -1119.5 | 2.60402 | Zn | 42 | 148 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø42 | 42 | 39 | TR03.04.1038 | 1038
13157479 | -1.PP_SO-102 | 738.04 | 0.00138523 | 0.097382 | ø42 mm | 0.000515464 | JB | -1.PP_SO-102 | 0 | 2431 | 2410 | 2410 | 2389 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -1609.5 | 0.097382 | Zn | 42 | 148 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø42 | 42 | 39 | TR03.04.1039 | 1039
13157483 | -1.PP_SO-102 | 2011.74 | 0.000961968 | 0.221202 | ø35 mm | 0.000515464 | JB | -1.PP_SO-102 | 0 | 3417.5 | 3400 | 3400 | 3382.5 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -616 | 0.221202 | Zn | 35 | 144 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 35 | 32 | TR03.04.1040 | 1040
13157487 | -1.PP_SO-102 | 2125.79 | 0.000961968 | 0.233743 | ø35 mm | 0.000515464 | JB | -1.PP_SO-102 | 0 | 2617.5 | 2600 | 2600 | 2582.5 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -1416 | 0.233743 | Zn | 35 | 144 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 35 | 32 | TR03.04.1041 | 1041
13157491 | -1.PP_SO-102 | 714.466 | 0.000961968 | 0.0785596 | ø35 mm | 0.000515464 | JB | -1.PP_SO-102 | 0 | 3317.5 | 3300 | 3300 | 3282.5 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -716 | 0.0785596 | Zn | 35 | 145 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 35 | 32 | TR03.04.1042 | 1042
13157499 | -1.PP_SO-102 | 116.206 | 0.000961968 | 0.0127775 | ø35 mm | 0.000515464 | JB | -1.PP_SO-102 | 0 | 3317.5 | 3300 | 3300 | 3282.5 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -716 | 0.0127775 | Zn | 35 | 145 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 35 | 32 | TR03.04.1043 | 1043
13157503 | 4.NP_SO-102 | 2348.57 | 0.00061566 | 0.206591 | ø28 mm | 0.000403226 | JB | 4.NP_SO-102 |  | 1743.3 | 1743.3 | -605.268 | -605.268 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 11394.7 | 0.206591 | Zn | 28 | 16 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1044 | 1044 | Identifikační data - Komentáře: P2
13157509 | 4.NP_SO-102 | 269.013 | 0.00061566 | 0.0236636 | ø28 mm | 0.000515464 | JB | 4.NP_SO-102 | 0 | 1779.24 | 1765.24 | 1765.24 | 1751.24 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 13752.7 | 0.0236636 | Zn | 28 | 16 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1045 | 1045 | Identifikační data - Komentáře: P2
13157516 | 3.NP_SO-102 | 11995.3 | 0.000961968 | 1.31895 | ø35 mm | 0.000515464 | JB | 3.NP_SO-102 |  | 3328.61 | 3328.61 | -8666.64 | -8666.64 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -666.644 | 1.31895 | Zn | 35 | 22 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 35 | 32 | TR03.04.1047 | 1047 | Identifikační data - Komentáře: P2
13168906 | -1.PP_SO-102 | 1751.66 | 0.00061566 | 0.154084 | ø28 mm | 0.000515464 | JB | -1.PP_SO-102 | 0 | 2814 | 2800 | 2800 | 2786 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -1212.5 | 0.154084 | Zn | 28 | 24 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1060 | 1060
13168923 | -1.PP_SO-102 | 1958.34 | 0.00138523 | 0.258397 | ø42 mm | 0.000515464 | JB | -1.PP_SO-102 | 0 | 3421 | 3400 | 3400 | 3379 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -619.5 | 0.258397 | Zn | 42 | 121 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø42 | 42 | 39 | TR03.04.1061 | 1061
13168928 | -1.PP_SO-102 | 910.269 | 0.00061566 | 0.0800714 | ø28 mm | 0 | JB | -1.PP_SO-102 |  | 2778.06 | 2778.06 | 1867.79 | 1867.79 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -2132.21 | 0.0800714 | Zn | 28 | 24 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1062 | 1062
13168937 | -1.PP_SO-102 | 2335.81 | 0.00138523 | 0.308203 | ø42 mm | 0.000515464 | JB | -1.PP_SO-102 | 0 | 2821 | 2800 | 2800 | 2779 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -1219.5 | 0.308203 | Zn | 42 | 148 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø42 | 42 | 39 | TR03.04.1063 | 1063
13168952 | -1.PP_SO-102 | 2385.78 | 0.00228988 | 0.404738 | ø54 mm | 0.000515464 | JB | -1.PP_SO-102 | 0 | 2835.31 | 2808.31 | 2808.31 | 2781.31 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -1217.19 | 0.404738 | Zn | 54 | 130 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø54 | 54 | 51 | TR03.04.1064 | 1064
13168957 | -1.PP_SO-102 | 1330.16 | 0.00061566 | 0.117007 | ø28 mm | 0 | JB | -1.PP_SO-102 |  | 3196.95 | 3196.95 | 1866.79 | 1866.79 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -2133.21 | 0.117007 | Zn | 28 | 94 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1065 | 1065
13169152 | -1.PP_SO-102 | 4194.56 | 0.000961968 | 0.461216 | ø35 mm | 0.000515464 | JB | -1.PP_SO-102 | 0 | 2667.5 | 2650 | 2650 | 2632.5 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | -1366 | 0.461216 | Zn | 35 | 54 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 35 | 32 | TR03.04.1066 | 1066
13169176 | -1.PP_SO-102 | 1078.03 | 0.000961968 | 0.118536 | ø35 mm | 0.000515464 | JB | -1.PP_SO-102 | 0 | 2667.5 | 2650 | 2650 | 2632.5 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | -1366 | 0.118536 | Zn | 35 | 57 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 35 | 32 | TR03.04.1067 | 1067
13169184 | -1.PP_SO-102 | 105.007 | 0.000961968 | 0.0115461 | ø35 mm | 0.000515464 | JB | -1.PP_SO-102 | 0 | 2667.5 | 2650 | 2650 | 2632.5 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | -1366 | 0.0115461 | Zn | 35 | 57 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 35 | 32 | TR03.04.1068 | 1068
13169236 | -1.PP_SO-102 | 589.22 | 0.0004908 | 0.0462772 | ø25 mm | 0.000515464 | JB | -1.PP_SO-102 | 0 | 3237.74 | 3225.24 | 3225.24 | 3212.74 | Fáze 2 | WS_Požární zavodněný | 0.01 | Požární ochrana – vodní prostředky | Trubka Evo, S4 | WS_Požární zavodněný 3 | -784.462 | 0.0462772 | PP–RCT S4 | 25 | 58 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | ø25 | 25 | 19.4 | TR03.04.1069 | 1069
13169242 | -1.PP_SO-102 | 2038.03 | 0.000961968 | 0.224093 | ø35 mm | 0.000515464 | JB | -1.PP_SO-102 | 0 | 2667.5 | 2650 | 2650 | 2632.5 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | -1366 | 0.224093 | Zn | 35 | 54 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 35 | 32 | TR03.04.1070 | 1070
13169332 | -1.PP_SO-102 | 2550.45 | 0.0004908 | 0.200312 | ø25 mm | 0.000515464 | JB | -1.PP_SO-102 | 0 | 3237.74 | 3225.24 | 3225.24 | 3212.74 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | -787.262 | 0.200312 | Zn | 25 | 58 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø25 | 25 | 25 | TR03.04.1071 | 1071
13169346 | -1.PP_SO-102 | 1344.6 | 0.0004908 | 0.105605 | ø25 mm | 0 | JB | -1.PP_SO-102 |  | 3204.6 | 3204.6 | 1860 | 1860 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | -2140 | 0.105605 | Zn | 25 | 58 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø25 | 25 | 25 | TR03.04.1072 | 1072
13169493 | 4.NP_SO-102 | 1843.87 | 0.00061566 | 0.162196 | ø28 mm | 0.000515464 | JB | 4.NP_SO-102 |  | 1245.1 | 1245.1 | -598.775 | -598.775 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | 11401.2 | 0.162196 | Zn | 28 | 27 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1073 | 1073 | Identifikační data - Komentáře: P3
13169527 | 1.NP_SO-102 | 1297.43 | 0.00061566 | 0.114127 | ø28 mm | 0 | JB | 1.NP_SO-102 |  | 3165.22 | 3165.22 | 1867.79 | 1867.79 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | 1867.79 | 0.114127 | Zn | 28 | 45 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1074 | 1074
13169641 | 4.NP_SO-102 | 399.588 | 0.00061566 | 0.0351496 | ø28 mm | 0.000515464 | JB | 4.NP_SO-102 | 0 | 1281.04 | 1267.04 | 1267.04 | 1253.04 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | 13254.5 | 0.0351496 | Zn | 28 | 27 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1075 | 1075
13169653 | 4.NP_SO-102 | 461.299 | 0.00061566 | 0.040578 | ø28 mm | 0.000515464 | JB | 4.NP_SO-102 | 0 | 1281.04 | 1267.04 | 1267.04 | 1253.04 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | 13254.5 | 0.040578 | Zn | 28 | 27 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1076 | 1076
13169663 | 4.NP_SO-102 | 527.304 | 0.00061566 | 0.0463841 | ø28 mm | 0 | JB | 4.NP_SO-102 |  | 1245.1 | 1245.1 | 717.794 | 717.794 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | 12717.8 | 0.0463841 | Zn | 28 | 27 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1077 | 1077
13169704 | 3.NP_SO-102 | 386.744 | 0.00061566 | 0.0340198 | ø28 mm | 0.000515464 | JB | 3.NP_SO-102 | 0 | 3380.44 | 3366.44 | 3366.44 | 3352.44 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | 11353.9 | 0.0340198 | Zn | 28 | 33 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1078 | 1078
13169713 | 3.NP_SO-102 | 4112.92 | 0.00061566 | 0.361791 | ø28 mm | 0.000515464 | JB | 3.NP_SO-102 |  | 3331.66 | 3331.66 | -781.257 | -781.257 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | 7218.74 | 0.361791 | Zn | 28 | 56 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1079 | 1079 | Identifikační data - Komentáře: P3
13169718 | 3.NP_SO-102 | 569.737 | 0.00061566 | 0.0501167 | ø28 mm | 0.000515464 | JB | 3.NP_SO-102 | 0 | 3380.44 | 3366.44 | 3366.44 | 3352.44 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | 11353.9 | 0.0501167 | Zn | 28 | 33 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1080 | 1080
13169728 | 3.NP_SO-102 | 2626.71 | 0.00061566 | 0.231058 | ø28 mm | 0 | JB | 3.NP_SO-102 |  | 3344.51 | 3344.51 | 717.794 | 717.794 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | 8717.79 | 0.231058 | Zn | 28 | 33 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1081 | 1081
13169764 | 2.NP_SO-102 | 569.737 | 0.00061566 | 0.0501167 | ø28 mm | 0.000515464 | JB | 2.NP_SO-102 | 0 | 3191.41 | 3177.41 | 3177.41 | 3163.41 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | 7164.91 | 0.0501167 | Zn | 28 | 35 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1082 | 1082
13169774 | 2.NP_SO-102 | 1287.68 | 0.00061566 | 0.11327 | ø28 mm | 0 | JB | 2.NP_SO-102 |  | 3155.47 | 3155.47 | 1867.79 | 1867.79 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | 5867.79 | 0.11327 | Zn | 28 | 35 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1083 | 1083
13169840 | 2.NP_SO-102 | 380.194 | 0.00061566 | 0.0334436 | ø28 mm | 0 | JB | 2.NP_SO-102 | 0 | 3191.41 | 3177.41 | 3177.41 | 3163.41 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | 7164.91 | 0.0334436 | Zn | 28 | 35 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1084 | 1084
13169843 | 2.NP_SO-102 | 3913.84 | 0.000961968 | 0.430349 | ø35 mm | 0.000515464 | JB | 2.NP_SO-102 |  | 3145.62 | 3145.62 | -768.212 | -768.212 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | 3231.79 | 0.430349 | Zn | 35 | 9 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 35 | 32 | TR03.04.1085 | 1085 | Identifikační data - Komentáře: P3
13169922 | 1.NP_SO-102 | 380.194 | 0.00061566 | 0.0334436 | ø28 mm | 0.000515464 | JB | 1.NP_SO-102 | 0 | 3214 | 3200 | 3200 | 3186 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | 3187.5 | 0.0334436 | Zn | 28 | 46 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1086 | 1086
13169978 | 1.NP_SO-102 | 4492.78 | 0.000961968 | 0.494006 | ø35 mm | 0.000515464 | JB | 1.NP_SO-102 |  | 3168.21 | 3168.21 | -1324.56 | -1324.56 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | -1324.56 | 0.494006 | Zn | 35 | 57 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 35 | 32 | TR03.04.1087 | 1087 | Identifikační data - Komentáře: P3
13170053 | 1.NP_SO-102 | 558.194 | 0.00061566 | 0.0491013 | ø28 mm | 0.000515464 | JB | 1.NP_SO-102 | 0 | 3214 | 3200 | 3200 | 3186 | Fáze 2 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 3 | 3187.5 | 0.0491013 | Zn | 28 | 46 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1089 | 1089
13175822 | -1.PP_SO-102 | 13014.6 | 0.000961968 | 1.43103 | ø35 mm | 0.000515464 | JB | -1.PP_SO-102 | 0 | 3242.74 | 3225.24 | 3225.24 | 3207.74 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -790.762 | 1.43103 | Zn | 35 | 120 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 35 | 32 | TR03.04.1100 | 1100
13175839 | -1.PP_SO-102 | 1724.79 | 0.00061566 | 0.151721 | ø28 mm | 0.004 | JB | -1.PP_SO-102 | 0 | 3239.24 | 3225.24 | 3225.24 | 3211.24 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -787.262 | 0.151721 | Zn | 28 | 47 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1101 | 1101
13271951 | -1.PP_SO-102 | 4869.13 | 0.000961968 | 0.535388 | ø35 mm | 0.003125 | JB | -1.PP_SO-102 | 0 | 3242.74 | 3225.24 | 3225.24 | 3207.74 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -790.762 | 0.535388 | Zn | 35 | 120 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 35 | 32 | TR03.04.1194 | 1194
13271961 | -1.PP_SO-102 | 3994.56 | 0.000961968 | 0.439225 | ø35 mm | 0.003125 | JB | -1.PP_SO-102 | 0 | 3242.74 | 3225.24 | 3225.24 | 3207.74 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -790.762 | 0.439225 | Zn | 35 | 120 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 35 | 32 | TR03.04.1195 | 1195
13322434 | 1.NP_SO-102 | 4088.82 | 0.00061566 | 0.359672 | ø28 mm | 0.003125 | JB | 1.NP_SO-102 |  | 3336 | -752.824 | 3336 | -752.824 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -752.824 | 0.359672 | Zn | 28 | 96 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1198 | 1198 | Identifikační data - Komentáře: P1
13322464 | 3.NP_SO-102 | 3838.41 | 0.00061566 | 0.337644 | ø28 mm | 0.004 | JB | 3.NP_SO-102 |  | 3170.64 | -667.773 | 3170.64 | -667.773 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 7332.23 | 0.337644 | Zn | 28 | 117 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1199 | 1199 | Identifikační data - Komentáře: P2
13322791 | -1.PP_SO-102 | 64.001 | 0.00061566 | 0.00562982 | ø28 mm | 0.004 | JB | -1.PP_SO-102 | 0 | 3239.24 | 3225.24 | 3225.24 | 3211.24 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -787.262 | 0.00562982 | Zn | 28 | 96 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1200 | 1200
13322803 | -1.PP_SO-102 | 81.7483 | 0.00061566 | 0.00719095 | ø28 mm | 0.004 | JB | -1.PP_SO-102 | 0 | 3239.24 | 3225.24 | 3225.24 | 3211.24 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -787.262 | 0.00719095 | Zn | 28 | 96 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1201 | 1201
13323040 | -1.PP_SO-102 | 2856.13 | 0.00061566 | 0.251238 | ø28 mm | 0.004 | JB | -1.PP_SO-102 | 0 | 3239.24 | 3225.24 | 3225.24 | 3211.24 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -787.262 | 0.251238 | Zn | 28 | 96 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1202 | 1202
13323079 | 1.NP_SO-102 | 18.0625 | 0.00061566 | 0.00158886 | ø28 mm | 0.004 | JB | 1.NP_SO-102 | 0 | 1784 | 1770 | 1770 | 1756 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 1757.5 | 0.00158886 | Zn | 28 | 97 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1203 | 1203
13323178 | 1.NP_SO-102 | 189.775 | 0.00061566 | 0.0166935 | ø28 mm | 0.004 | JB | 1.NP_SO-102 | 0 | 3378.28 | 3364.28 | 3364.28 | 3350.28 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 3351.78 | 0.0166935 | Zn | 28 | 97 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1204 | 1204
13323185 | 2.NP_SO-102 | 3895.78 | 0.00061566 | 0.34269 | ø28 mm | 0.004 | JB | 2.NP_SO-102 |  | 3288.35 | 3288.35 | -607.428 | -607.428 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 3392.57 | 0.34269 | Zn | 28 | 116 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1205 | 1205 | Identifikační data - Komentáře: P1
13323188 | 1.NP_SO-102 | 478.926 | 0.00061566 | 0.0421285 | ø28 mm | 0.004 | JB | 1.NP_SO-102 | 0 | 3378.28 | 3364.28 | 3364.28 | 3350.28 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 3351.78 | 0.0421285 | Zn | 28 | 97 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1206 | 1206
13323247 | 1.NP_SO-102 | 300.944 | 0.00061566 | 0.0264725 | ø28 mm | 0.004 | JB | 1.NP_SO-102 | 0 | 3378.28 | 3364.28 | 3364.28 | 3350.28 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 3351.78 | 0.0264725 | Zn | 28 | 97 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1207 | 1207
13323351 | 1.NP_SO-102 | 1550.41 | 0.00061566 | 0.136381 | ø28 mm | 0.004 | JB | 1.NP_SO-102 |  | 3342.35 | 3342.35 | 1791.94 | 1791.94 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 1791.94 | 0.136381 | Zn | 28 | 97 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1208 | 1208
13323392 | 2.NP_SO-102 | 46.1514 | 0.00061566 | 0.00405969 | ø28 mm | 0.004 | JB | 2.NP_SO-102 | 0 | 1434 | 1420 | 1420 | 1406 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 5407.5 | 0.00405969 | Zn | 28 | 111 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1209 | 1209
13323968 | 4.NP_SO-102 | 38.0625 | 0.00061566 | 0.00334815 | ø28 mm | 0.004 | JB | 4.NP_SO-102 | 0 | 1434 | 1420 | 1420 | 1406 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 13407.5 | 0.00334815 | Zn | 28 | 108 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1210 | 1210
13324033 | 3.NP_SO-102 | 58.0625 | 0.00061566 | 0.00510744 | ø28 mm | 0.004 | JB | 3.NP_SO-102 | 0 | 1434 | 1420 | 1420 | 1406 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 9407.5 | 0.00510744 | Zn | 28 | 4 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1211 | 1211
13324078 | 2.NP_SO-102 | 96.125 | 0.00061566 | 0.0084556 | ø28 mm | 0.004 | JB | 2.NP_SO-102 | 0 | 3324.29 | 3310.29 | 3310.29 | 3296.29 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 7297.79 | 0.0084556 | Zn | 28 | 117 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1212 | 1212
13324094 | 2.NP_SO-102 | 1221.19 | 0.00061566 | 0.107422 | ø28 mm | 0.004 | JB | 2.NP_SO-102 | 0 | 3324.29 | 3310.29 | 3310.29 | 3296.29 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 7297.79 | 0.107422 | Zn | 28 | 117 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1213 | 1213
13324298 | 4.NP_SO-102 | 276.125 | 0.00061566 | 0.0242892 | ø28 mm | 0.004 | JB | 4.NP_SO-102 | 0 | 3322.35 | 3308.35 | 3308.35 | 3294.35 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 15295.8 | 0.0242892 | Zn | 28 | 108 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1214 | 1214
13324312 | 4.NP_SO-102 | 234.708 | 0.00061566 | 0.020646 | ø28 mm | 0.004 | JB | 4.NP_SO-102 | 0 | 3322.35 | 3308.35 | 3308.35 | 3294.35 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 15295.8 | 0.020646 | Zn | 28 | 108 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1215 | 1215
13324322 | 4.NP_SO-102 | 415.469 | 0.00061566 | 0.0365465 | ø28 mm | 0.004 | JB | 4.NP_SO-102 | 0 | 3322.35 | 3308.35 | 3308.35 | 3294.35 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 15295.8 | 0.0365465 | Zn | 28 | 108 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1216 | 1216
13324331 | 4.NP_SO-102 | 1844.47 | 0.00061566 | 0.162248 | ø28 mm | 0 | JB | 4.NP_SO-102 |  | 3286.41 | 3286.41 | 1441.94 | 1441.94 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 13441.9 | 0.162248 | Zn | 28 | 108 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1217 | 1217
13324377 | 3.NP_SO-102 | 269.775 | 0.00061566 | 0.0237306 | ø28 mm | 0.004 | JB | 3.NP_SO-102 | 0 | 3212.93 | 3198.93 | 3198.93 | 3184.93 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 11186.4 | 0.0237306 | Zn | 28 | 4 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1218 | 1218
13324386 | 4.NP_SO-102 | 4059.19 | 0.00061566 | 0.357065 | ø28 mm | 0.004 | JB | 4.NP_SO-102 |  | 3286.41 | -772.785 | 3286.41 | -772.785 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 11227.2 | 0.357065 | Zn | 28 | 108 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1219 | 1219 | Identifikační data - Komentáře: P1
13324389 | 3.NP_SO-102 | 226.773 | 0.00061566 | 0.019948 | ø28 mm | 0.004 | JB | 3.NP_SO-102 | 0 | 3212.93 | 3198.93 | 3198.93 | 3184.93 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 11186.4 | 0.019948 | Zn | 28 | 4 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1220 | 1220
13324422 | 3.NP_SO-102 | 435.469 | 0.00061566 | 0.0383058 | ø28 mm | 0.004 | JB | 3.NP_SO-102 | 0 | 3212.93 | 3198.93 | 3198.93 | 3184.93 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 11186.4 | 0.0383058 | Zn | 28 | 4 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1221 | 1221
13324475 | 3.NP_SO-102 | 1735.05 | 0.00061566 | 0.152623 | ø28 mm | 0 | JB | 3.NP_SO-102 |  | 3176.99 | 3176.99 | 1441.94 | 1441.94 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 9441.94 | 0.152623 | Zn | 28 | 4 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1222 | 1222
13324796 | 2.NP_SO-102 | 318.114 | 0.00061566 | 0.0279828 | ø28 mm | 0.004 | JB | 2.NP_SO-102 | 0 | 3324.29 | 3310.29 | 3310.29 | 3296.29 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 7297.79 | 0.0279828 | Zn | 28 | 111 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1223 | 1223
13324825 | 2.NP_SO-102 | 391.56 | 0.00061566 | 0.0344434 | ø28 mm | 0.004 | JB | 2.NP_SO-102 | 0 | 3324.29 | 3310.29 | 3310.29 | 3296.29 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 7297.79 | 0.0344434 | Zn | 28 | 111 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1224 | 1224
13324940 | 2.NP_SO-102 | 1846.41 | 0.00061566 | 0.162419 | ø28 mm | 0 | JB | 2.NP_SO-102 |  | 3288.35 | 3288.35 | 1441.94 | 1441.94 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 5441.94 | 0.162419 | Zn | 28 | 111 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1225 | 1225
13324998 | 2.NP_SO-102 | 2476.83 | 0.00061566 | 0.217873 | ø28 mm | 0.004 | JB | 2.NP_SO-102 | 0 | 3324.29 | 3310.29 | 3310.29 | 3296.29 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 7297.79 | 0.217873 | Zn | 28 | 117 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1226 | 1226
13325004 | 2.NP_SO-102 | 252.301 | 0.00061566 | 0.0221936 | ø28 mm | 0.004 | JB | 2.NP_SO-102 | 0 | 3324.29 | 3310.29 | 3310.29 | 3296.29 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | 7297.79 | 0.0221936 | Zn | 28 | 116 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1227 | 1227
13348471 | -1.PP_SO-102 | 9355.52 | 0.00620623 | 2.61288 | ø89 mm | 0.00117786 | JB | -1.PP_SO-102 | 0 | 849.5 | 805.05 | 805.05 | 760.6 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -3237.4 | 2.61582 | Zn | 89 | 390 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1246 | 1246 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13348578 | -1.PP_SO-102 | 13395.1 | 0.00620623 | 3.74109 | ø89 mm | 0.00117786 | JB | -1.PP_SO-102 | 0 | 3269.69 | 3225.24 | 3225.24 | 3180.79 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -817.212 | 3.7453 | Zn | 89 | 390 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1247 | 1247 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13348623 | -1.PP_SO-102 | 5558.51 | 0.00620623 | 1.55242 | ø89 mm | 0.00117786 | JB | -1.PP_SO-102 | 0 | 3269.69 | 3225.24 | 3225.24 | 3180.79 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -817.212 | 1.55417 | Zn | 89 | 390 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1248 | 1248 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13348631 | -1.PP_SO-102 | 4915.13 | 0.00620623 | 1.37273 | ø89 mm | 0.00117786 | JB | -1.PP_SO-102 | 0 | 3269.69 | 3225.24 | 3225.24 | 3180.79 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -817.212 | 1.37428 | Zn | 89 | 390 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1249 | 1249 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13348639 | -1.PP_SO-102 | 1536.39 | 0.00620623 | 0.429096 | ø89 mm | 0.00117786 | JB | -1.PP_SO-102 | 0 | 3269.69 | 3225.24 | 3225.24 | 3180.79 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -817.212 | 0.429578 | Zn | 89 | 390 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1250 | 1250 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13349032 | -1.PP_SO-102 | 1520.29 | 0.00061566 | 0.133732 | ø28 mm | 0.004 | JB | -1.PP_SO-102 | 0 | 3239.24 | 3225.24 | 3225.24 | 3211.24 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -787.262 | 0.133732 | Zn | 28 | 136 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1251 | 1251
13349034 | -1.PP_SO-102 | 321.759 | 0.00061566 | 0.0283034 | ø28 mm | 0.004 | JB | -1.PP_SO-102 | 0 | 3239.24 | 3225.24 | 3225.24 | 3211.24 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -787.262 | 0.0283034 | Zn | 28 | 136 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø28 | 28 | 25 | TR03.04.1252 | 1252
13349067 | 2.NP_SO-102 | 88.775 | 0.00620623 | 0.0247938 | ø89 mm | 0.00117786 | JB | 2.NP_SO-102 | 0 | 2044.45 | 2000 | 2000 | 1955.55 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | 5957.55 | 0.0248216 | Zn | 89 | 323 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1253 | 1253 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13356233 | -1.PP_SO-102 | 567.563 | 0.00620623 | 0.158513 | ø89 mm | 0.00117786 | JB | -1.PP_SO-102 | 0 | 3269.69 | 3225.24 | 3225.24 | 3180.79 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -817.212 | 0.158691 | Zn | 89 | 299 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1256 | 1256 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13356243 | -1.PP_SO-102 | 248.775 | 0.00620623 | 0.0694798 | ø89 mm | 0.00117786 | JB | -1.PP_SO-102 | 0 | 3269.69 | 3225.24 | 3225.24 | 3180.79 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -817.212 | 0.0695579 | Zn | 89 | 390 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1257 | 1257 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13356522 | -1.PP_SO-102 | 1835.47 | 0.00620623 | 0.512624 | ø89 mm | 0.00117786 | JB | -1.PP_SO-102 |  | 3172.8 | 3172.8 | 1337.33 | 1337.33 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -2662.67 | 0.5132 | Zn | 89 | 299 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1258 | 1258 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13356678 | -1.PP_SO-102 | 64.2772 | 0.000176688 | 0.00302899 | ø15 mm | 0.00793651 | JB | -1.PP_SO-102 | 0 | 1307.5 | 1300 | 1300 | 1292.5 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -2706.3 | 0.00302899 | Zn | 15 | 307 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø15 | 15 | 12.6 | TR03.04.1259 | 1259 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13356905 | -1.PP_SO-102 | 35.3035 | 0.000176688 | 0.00166364 | ø15 mm | 0.00793651 | JB | -1.PP_SO-102 | 0 | 1307.5 | 1300 | 1300 | 1292.5 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -2706.3 | 0.00166364 | Zn | 15 | 308 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø15 | 15 | 12.6 | TR03.04.1260 | 1260 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13356914 | -1.PP_SO-102 | 65.1603 | 0.000176688 | 0.00307061 | ø15 mm | 0.00793651 | JB | -1.PP_SO-102 | 0 | 1307.5 | 1300 | 1300 | 1292.5 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -2706.3 | 0.00307061 | Zn | 15 | 304 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø15 | 15 | 12.6 | TR03.04.1261 | 1261 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13356917 | -1.PP_SO-102 | 36.1338 | 0.000176688 | 0.00170276 | ø15 mm | 0.00793651 | JB | -1.PP_SO-102 | 0 | 1307.5 | 1300 | 1300 | 1292.5 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -2706.3 | 0.00170276 | Zn | 15 | 308 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø15 | 15 | 12.6 | TR03.04.1262 | 1262 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13358368 | -1.PP_SO-102 | 1957.19 | 0.00620623 | 0.546618 | ø89 mm | 0.00117786 | JB | -1.PP_SO-102 |  | 5241.21 | 3284.03 | 5241.21 | 3284.03 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -715.974 | 0.547233 | Zn | 89 | 311 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1268 | 1268 | Identifikační data - Komentáře: SCH1; Mechanické – tok - Doplňkový průtok: 0 m3/s
13358426 | 2.NP_SO-102 | 4588.77 | 0.00620623 | 1.28159 | ø89 mm | 0.00117786 | JB | 2.NP_SO-102 |  | 1947.56 | -2641.21 | 1947.56 | -2641.21 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | 1358.79 | 1.28303 | Zn | 89 | 297 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1269 | 1269 | Identifikační data - Komentáře: SCH1; Mechanické – tok - Doplňkový průtok: 0 m3/s
13358514 | 2.NP_SO-102 | 1580.27 | 0.00620623 | 0.44135 | ø89 mm | 0.00117786 | JB | 2.NP_SO-102 | 0 | 2044.45 | 2000 | 2000 | 1955.55 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | 5957.55 | 0.441847 | Zn | 89 | 297 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1274 | 1274 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13358770 | 3.NP_SO-102 | 5261.57 | 0.00620623 | 1.46949 | ø89 mm | 0.00117786 | JB | 3.NP_SO-102 |  | 3314.01 | 3314.01 | -1947.56 | -1947.56 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | 6052.44 | 1.47114 | Zn | 89 | 323 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1281 | 1281 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13359427 | 1.NP_SO-102 | 2388.78 | 0.00620623 | 0.667155 | ø89 mm | 0.00117786 | JB | 1.NP_SO-102 |  | 1241.21 | -1147.56 | 1241.21 | -1147.56 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1147.56 | 0.667906 | Zn | 89 | 287 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1287 | 1287 | Identifikační data - Komentáře: SCH2
13359542 | 2.NP_SO-102 | 3882.43 | 0.00620623 | 1.08431 | ø89 mm | 0.00117786 | JB | 2.NP_SO-102 |  | 1241.21 | 1241.21 | -2641.21 | -2641.21 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | 1358.79 | 1.08553 | Zn | 89 | 330 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1289 | 1289 | Identifikační data - Komentáře: SCH2
13359800 | 3.NP_SO-102 | 3882.42 | 0.00620623 | 1.08431 | ø89 mm | 0.00117786 | JB | 3.NP_SO-102 |  | 1241.21 | 1241.21 | -2641.21 | -2641.21 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | 5358.79 | 1.08553 | Zn | 89 | 339 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1291 | 1291 | Identifikační data - Komentáře: SCH2
13359953 | 4.NP_SO-102 | 112.091 | 0.00620623 | 0.0313055 | ø89 mm | 0.00117786 | JB | 4.NP_SO-102 | 0 | 883.238 | 838.788 | 838.788 | 794.338 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | 12796.3 | 0.0313407 | Zn | 89 | 345 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1292 | 1292
13359967 | 4.NP_SO-102 | 73.8437 | 0.0019632 | 0.0115993 | ø50 mm | 0 | JB | 4.NP_SO-102 | 0 | 825 | 800 | 800 | 775 | Fáze 1 | WS_Požární nezavodněný | 0 | Požární ochrana – suché prostředky |  | WS_Požární nezavodněný 1 | 12775 | 0.0115993 |  | 50 | 351 |  |  | ø50 | 50 | 50 | TR03.04.1293 | 1293
13360366 | -1.PP_SO-102 | 1814.01 | 0.00620623 | 0.506631 | ø89 mm | 0 | JB | -1.PP_SO-102 |  | 3166.45 | 3166.45 | 1352.44 | 1352.44 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -2647.56 | 0.507201 | Zn | 89 | 362 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1294 | 1294
13360448 | -1.PP_SO-102 | 52.5625 | 0.00620623 | 0.0146801 | ø89 mm | 0.00117786 | JB | -1.PP_SO-102 | 0 | 1344.45 | 1300 | 1300 | 1255.55 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -2742.45 | 0.0146966 | Zn | 89 | 362 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1295 | 1295
13361079 | -1.PP_SO-102 | 53.472 | 0.00228988 | 0.0090713 | ø54 mm | 0.00196078 | JB | -1.PP_SO-102 | 0 | 1327 | 1300 | 1300 | 1273 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -2725.5 | 0.0090713 | Zn | 54 | 364 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø54 | 54 | 51 | TR03.04.1296 | 1296
13404201 | -1.PP_SO-102 | 52.2228 | 0.000176688 | 0.00246094 | ø15 mm | 0.00793651 | JB | -1.PP_SO-102 | 0 | 2807.5 | 2800 | 2800 | 2792.5 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1206.3 | 0.00246094 | Zn | 15 | 367 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø15 | 15 | 12.6 | TR03.04.1346 | 1346
13404222 | -1.PP_SO-102 | 6.73346 | 0.00620623 | 0.00188057 | ø89 mm | 0 | JB | -1.PP_SO-102 | 0 | 2844.45 | 2800 | 2800 | 2755.55 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1242.45 | 0.00188269 | Zn | 89 | 366 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1347 | 1347
13647428 | 4.NP_SO-102 | 58.5936 | 0.0004908 | 0.00460193 | ø25 mm | 0 | JB | 4.NP_SO-102 | 0 | 1782.5 | 1770 | 1770 | 1757.5 | Fáze 1 | WS_Požární zavodněný | 0 | Požární ochrana – vodní prostředky |  | WS_Požární zavodněný 1 | 13757.5 | 0.00460193 |  | 25 | 131 |  |  | ø25 | 25 | 25 | TR03.04.1689 | 1689
13651129 | -1.PP_SO-102 | 540.719 | 0.00138523 | 0.0713462 | ø42 mm | 0 | JB | -1.PP_SO-102 |  | 3169.66 | 3169.66 | 2628.94 | 2628.94 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -1371.06 | 0.0713462 | Zn | 42 | 148 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø42 | 42 | 39 | TR03.04.1695 | 1695
13651695 | -1.PP_SO-102 | 3611.32 | 0.00228988 | 0.612646 | ø54 mm | 0.00196078 | JB | -1.PP_SO-102 | 0 | 3252.24 | 3225.24 | 3225.24 | 3198.24 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -800.262 | 0.612646 | Zn | 54 | 137 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø54 | 54 | 51 | TR03.04.1697 | 1697
13651883 | -1.PP_SO-102 | 520.363 | 0.00620623 | 0.145331 | ø89 mm | 0 | JB | -1.PP_SO-102 |  | 3172.8 | 2652.44 | 3172.8 | 2652.44 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1347.56 | 0.145494 | Zn | 89 | 406 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1700 | 1700
13654065 | -1.PP_SO-102 | 757.363 | 0.00138523 | 0.0999317 | ø42 mm | 0 | JB | -1.PP_SO-102 |  | 3196.3 | 3196.3 | 2438.94 | 2438.94 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -1561.06 | 0.0999317 | Zn | 42 | 148 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø42 | 42 | 39 | TR03.04.1711 | 1711
13654123 | -1.PP_SO-102 | 720.363 | 0.00620623 | 0.201188 | ø89 mm | 0 | JB | -1.PP_SO-102 |  | 3172.8 | 3172.8 | 2452.44 | 2452.44 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1547.56 | 0.201415 | Zn | 89 | 406 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1716 | 1716
13763913 | -1.PP_SO-102 | 1479.36 | 0.00620623 | 0.413168 | ø89 mm | 0.00117786 | JB | -1.PP_SO-102 | 0 | 849.5 | 805.05 | 805.05 | 760.6 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -3237.4 | 0.413633 | Zn | 89 | 390 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1833 | 1833 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13764057 | -1.PP_SO-102 | 11516.6 | 0.00620623 | 3.21645 | ø89 mm | 0.00117786 | JD | -1.PP_SO-102 | 0 | 3269.69 | 3225.24 | 3225.24 | 3180.79 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -817.212 | 3.22007 | Zn | 89 | 390 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1834 | 1834 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13764065 | -1.PP_SO-102 | 4350.89 | 0.00620623 | 1.21515 | ø89 mm | 0.00117786 | JD | -1.PP_SO-102 | 0 | 3269.69 | 3225.24 | 3225.24 | 3180.79 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -817.212 | 1.21652 | Zn | 89 | 390 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1835 | 1835 | Mechanické – tok - Doplňkový průtok: 0 m3/s
