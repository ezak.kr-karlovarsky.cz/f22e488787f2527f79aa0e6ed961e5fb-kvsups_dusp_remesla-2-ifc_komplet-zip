Properties of the parts of a building model (IFC4), part 52 of 60

# IfcPipeSegment: Typy trubek:PP-RCT (1338)
Name (Typy trubek:PP-RCT:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Instalační jednotky = Reynoldsovo číslo = Třecí faktor = Tření = Průtok (m3/s) = Rychlost (m/s) = Tlaková ztráta (Pa) | Stav průtoku | Doplňkový průtok (m3/s) | Relativní drsnost | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) | Spodní výška (mm) | Střední výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Délka (mm) | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
13533210 | 2.NP_SO-102 | 3933.32 | 0.00125645 | 0.494276 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 2.NP_SO-102 | 1393.32 | -2540 | 1393.32 | -2540 | 1393.32 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 1460 | PP–RCT S4 | 40 | 328 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3933.32 | ø40 | 31 | TR10.03.1568 | 1568 | yes | WS_"Jiný typ" studená vnitřní 1
13533390 | 1.NP_SO-102 | 38.8937 | 0.00125645 | 0.00488753 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 1.NP_SO-102 | 3316.66 | 3277.77 | 3316.66 | 3277.77 | 3316.66 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3277.77 | PP–RCT S4 | 40 | 81 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 38.8937 | ø40 | 31 | TR10.03.1569 | 1569 | yes | WS_Studená vnitřní 134
13533522 | 1.NP_SO-102 | 38.8937 | 0.00125645 | 0.00488753 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 1.NP_SO-102 | 3166.66 | 3127.77 | 3166.66 | 3127.77 | 3166.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3127.77 | PP–RCT S4 | 40 | 97 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 38.8937 | ø40 | 31 | TR10.03.1570 | 1570 | yes | WS_Teplá vnitřní 83
13533894 | -1.PP_SO-102 | 224.009 | 0.00125645 | 0.0281498 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 3320 | 3300 | 3300 | 3280 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -715.5 | PP–RCT S4 | 40 | 325 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 224.009 | ø40 | 31 | TR10.03.1571 | 1571 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13534537 | 3.NP_SO-102 | 3933.33 | 0.00125645 | 0.494276 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 3.NP_SO-102 | 1393.32 | -2540 | 1393.32 | -2540 | 1393.32 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5460 | PP–RCT S4 | 40 | 59 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3933.33 | ø40 | 31 | TR10.03.1572 | 1572 | yes | WS_"Jiný typ" studená vnitřní 1
13534549 | 4.NP_SO-102 | 3935.71 | 0.00125645 | 0.494575 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 4.NP_SO-102 | 1395.71 | -2540 | 1395.71 | -2540 | 1395.71 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 9460 | PP–RCT S4 | 40 | 45 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3935.71 | ø40 | 31 | TR10.03.1573 | 1573 | yes | WS_"Jiný typ" studená vnitřní 1
13536480 | -1.PP_SO-102 | 970.56 | 0.0019632 | 0.152455 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3325 | 3300 | 3300 | 3275 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -719.4 | PP–RCT S4 | 50 | 353 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 970.56 | ø50 | 38.8 | TR10.03.1574 | 1574 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13536603 | -1.PP_SO-102 | 1773.95 | 0.0019632 | 0.278652 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3425 | 3400 | 3400 | 3375 | 3400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -619.4 | PP–RCT S4 | 50 | 353 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1773.95 | ø50 | 38.8 | TR10.03.1575 | 1575 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13536652 | -1.PP_SO-102 | 592.417 | 0.000804127 | 0.0595562 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3316.52 | 3300.52 | 3300.06 | 3284.06 | 3300.52 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -712.344 | PP–RCT S4 | 32 | 320 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 592.417 | ø32 | 24.8 | TR10.03.1576 | 1576 | yes | WS_"Jiný typ" studená vnitřní 1 | 0.0789119
13544830 | 3.NP_SO-102 | 1119.36 | 0.0004908 | 0.0879145 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3402.69 | 3390.19 | 3390.19 | 3377.69 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11380.5 | PP–RCT S4 | 25 | 316 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1119.36 | ø25 | 19.4 | TR10.03.1579 | 1579 | no | WS_Teplá vnitřní 83 | 0
13544855 | 3.NP_SO-102 | 1319.36 | 0.0004908 | 0.103622 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11340.3 | PP–RCT S4 | 25 | 113 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1319.36 | ø25 | 19.4 | TR10.03.1580 | 1580 | no | WS_Studená vnitřní 134 | 0
13573387 | 2.NP_SO-102 | 987.974 | 0.000804127 | 0.099322 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2416 | 2400 | 2400 | 2384 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6387.6 | PP–RCT S4 | 32 | 208 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 987.974 | ø32 | 24.8 | TR10.03.1594 | 1594 | no | WS_Teplá vnitřní 83 | 0
13573401 | 2.NP_SO-102 | 3388.37 | 0.000804127 | 0.340636 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2416 | 2400 | 2400 | 2384 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6387.6 | PP–RCT S4 | 32 | 26 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3388.37 | ø32 | 24.8 | TR10.03.1595 | 1595 | no | WS_Teplá vnitřní 83 | 0
13640896 | -1.PP_SO-102 | 50.0156 | 0.000314112 | 0.00314258 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3309.95 | 3299.91 | 3299.95 | 3289.91 | 3299.95 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -707.791 | PP–RCT S4 | 20 | 324 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 50.0156 | ø20 | 15.4 | TR10.03.1620 | 1620 | yes | WS_"Jiný typ" studená vnitřní 1 | 0.0789119
13640915 | -1.PP_SO-102 | 156.943 | 0.000804127 | 0.0157777 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3315.85 | 3299.73 | 3299.85 | 3283.73 | 3299.85 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -712.675 | PP–RCT S4 | 32 | 202 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 156.943 | ø32 | 24.8 | TR10.03.1621 | 1621 | yes | WS_"Jiný typ" studená vnitřní 1 | 0.0789119
13640939 | -1.PP_SO-102 | 45.3438 | 0.000201032 | 0.00227923 | ø16 mm | 0 | Laminární | 0 | 0.000862069 | JB | -1.PP_SO-102 | 3308.89 | 3300.89 | 3300.44 | 3292.44 | 3300.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S3.2 | WS_Studená vnitřní 134 | -705.363 | PP–RCT S3,2 | 16 | 397 | Trubka Evo, S3.2 - ø16 | ø16 | 45.3438 | ø16 | 11.6 | TR10.03.1622 | 1622 | yes | WS_Studená vnitřní 134 | 1
13641014 | -1.PP_SO-102 | 42.4682 | 0.000314112 | 0.00266835 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3310.86 | 3300.86 | 3300.44 | 3290.44 | 3300.44 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -707.263 | PP–RCT S4 | 20 | 356 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 42.4682 | ø20 | 15.4 | TR10.03.1623 | 1623 | yes | WS_Teplá vnitřní 83 | 1
13641029 | -1.PP_SO-102 | 115.163 | 0.00125645 | 0.0144718 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 3320 | 3300 | 3300 | 3280 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -715.5 | PP–RCT S4 | 40 | 352 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 115.163 | ø40 | 31 | TR10.03.1624 | 1624 | yes | WS_Teplá vnitřní 83 | 0
13641180 | -1.PP_SO-102 | 130.618 | 0.000804127 | 0.0131311 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3316 | 3299.9 | 3300 | 3283.9 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -712.503 | PP–RCT S4 | 32 | 320 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 130.618 | ø32 | 24.8 | TR10.03.1625 | 1625 | yes | WS_"Jiný typ" studená vnitřní 1 | 0.0789119
13641311 | -1.PP_SO-102 | 81.7017 | 0.00125645 | 0.0102669 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 3320 | 3300 | 3300 | 3280 | 3300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -715.5 | PP–RCT S4 | 40 | 131 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 81.7017 | ø40 | 31 | TR10.03.1626 | 1626 | yes | WS_Studená vnitřní 134 | 0
13641418 | -1.PP_SO-102 | 230.639 | 0.00125645 | 0.0289829 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 3320 | 3300 | 3300 | 3280 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -715.5 | PP–RCT S4 | 40 | 423 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 230.639 | ø40 | 31 | TR10.03.1627 | 1627 | yes | WS_Teplá vnitřní 83 | 0
13641521 | -1.PP_SO-102 | 204.594 | 0.00125645 | 0.02571 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 3320 | 3300 | 3300 | 3280 | 3300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -715.5 | PP–RCT S4 | 40 | 484 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 204.594 | ø40 | 31 | TR10.03.1628 | 1628 | yes | WS_Studená vnitřní 134 | 0
13641588 | -1.PP_SO-102 | 180.014 | 0.000804127 | 0.018097 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3316 | 3300 | 3300 | 3284 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -712.4 | PP–RCT S4 | 32 | 228 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 180.014 | ø32 | 24.8 | TR10.03.1629 | 1629 | yes | WS_Cirkulace vnitřní 9 | 0
13641662 | -1.PP_SO-102 | 180.014 | 0.000804127 | 0.018097 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3316 | 3300 | 3300 | 3284 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -712.4 | PP–RCT S4 | 32 | 258 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 180.014 | ø32 | 24.8 | TR10.03.1630 | 1630 | yes | WS_Cirkulace vnitřní 9 | 0
13641754 | -1.PP_SO-102 | 76.2889 | 0.000314112 | 0.00479337 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3311.15 | 3301.15 | 3300.39 | 3290.39 | 3300.39 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -707.311 | PP–RCT S4 | 20 | 236 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 76.2889 | ø20 | 15.4 | TR10.03.1631 | 1631 | yes | WS_Cirkulace vnitřní 9 | 1
13641864 | -1.PP_SO-102 | 113.115 | 0.000314112 | 0.00710724 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3311.52 | 3301.52 | 3300.39 | 3290.39 | 3300.39 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -707.311 | PP–RCT S4 | 20 | 240 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 113.115 | ø20 | 15.4 | TR10.03.1632 | 1632 | yes | WS_Cirkulace vnitřní 9 | 1
13641933 | -1.PP_SO-102 | 53.0899 | 0.000314112 | 0.00333574 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3311.06 | 3301.06 | 3300.53 | 3290.53 | 3300.53 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -707.168 | PP–RCT S4 | 20 | 402 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 53.0899 | ø20 | 15.4 | TR10.03.1633 | 1633 | yes | WS_Studená vnitřní 134 | 1
13641967 | -1.PP_SO-102 | 43.3495 | 0.000314112 | 0.00272373 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3310.87 | 3300.87 | 3300.44 | 3290.44 | 3300.44 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -707.263 | PP–RCT S4 | 20 | 327 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 43.3495 | ø20 | 15.4 | TR10.03.1634 | 1634 | yes | WS_"Jiný typ" studená vnitřní 1 | 1
13642178 | -1.PP_SO-102 | 24.6008 | 0.000314112 | 0.00154571 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3110.68 | 3100.68 | 3100.44 | 3090.44 | 3100.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -907.263 | PP–RCT S4 | 20 | 381 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 24.6008 | ø20 | 15.4 | TR10.03.1635 | 1635 | yes | WS_Studená vnitřní 134 | 1
13642187 | -1.PP_SO-102 | 320.865 | 0.00125645 | 0.0403211 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 3120 | 3100 | 3100 | 3080 | 3100 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -915.5 | PP–RCT S4 | 40 | 514 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 320.865 | ø40 | 31 | TR10.03.1636 | 1636 | yes | WS_Studená vnitřní 134 | 0
13642211 | -1.PP_SO-102 | 128.022 | 0.000314112 | 0.00804386 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3111.67 | 3101.67 | 3100.39 | 3090.39 | 3100.39 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -907.311 | PP–RCT S4 | 20 | 12 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 128.022 | ø20 | 15.4 | TR10.03.1637 | 1637 | yes | WS_Cirkulace vnitřní 9 | 1
13642220 | -1.PP_SO-102 | 238.675 | 0.000804127 | 0.0239942 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3116 | 3100 | 3100 | 3084 | 3100 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -912.4 | PP–RCT S4 | 32 | 267 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 238.675 | ø32 | 24.8 | TR10.03.1638 | 1638 | yes | WS_Cirkulace vnitřní 9 | 0
13642246 | -1.PP_SO-102 | 165.355 | 0.000314112 | 0.0103896 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3112.09 | 3102.09 | 3100.44 | 3090.44 | 3100.44 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -907.263 | PP–RCT S4 | 20 | 348 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 165.355 | ø20 | 15.4 | TR10.03.1639 | 1639 | yes | WS_Teplá vnitřní 83 | 1
13642257 | -1.PP_SO-102 | 233.965 | 0.00125645 | 0.0294009 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 3120 | 3100 | 3100 | 3080 | 3100 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -915.5 | PP–RCT S4 | 40 | 346 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 233.965 | ø40 | 31 | TR10.03.1640 | 1640 | yes | WS_Teplá vnitřní 83 | 0
13642289 | -1.PP_SO-102 | 74.8754 | 0.000314112 | 0.00470456 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3111.09 | 3101.09 | 3100.34 | 3090.34 | 3100.34 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -907.358 | PP–RCT S4 | 20 | 194 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 74.8754 | ø20 | 15.4 | TR10.03.1641 | 1641 | yes | WS_"Jiný typ" studená vnitřní 1 | 1
13642304 | -1.PP_SO-102 | 354.564 | 0.0004908 | 0.0278474 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3112.5 | 3100 | 3100 | 3087.5 | 3100 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -909.7 | PP–RCT S4 | 25 | 192 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 354.564 | ø25 | 19.4 | TR10.03.1642 | 1642 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13642489 | -1.PP_SO-102 | 84.1193 | 0.000314112 | 0.00528537 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 2661.48 | 2651.48 | 2650.64 | 2640.64 | 2650.64 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | -1357.06 | PP–RCT S4 | 20 | 90 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 84.1193 | ø20 | 15.4 | TR10.03.1643 | 1643 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 1
13642498 | -1.PP_SO-102 | 82.4005 | 0.00125645 | 0.0103548 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 2670 | 2650 | 2650 | 2630 | 2650 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | -1365.5 | PP–RCT S4 | 40 | 63 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 82.4005 | ø40 | 31 | TR10.03.1644 | 1644 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 0
13642521 | -1.PP_SO-102 | 174.601 | 0.000314112 | 0.0109705 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 2662.28 | 2652.28 | 2650.53 | 2640.53 | 2650.53 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | -1357.17 | PP–RCT S4 | 20 | 201 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 174.601 | ø20 | 15.4 | TR10.03.1645 | 1645 | yes | WS_Studená vnitřní 6 | 1
13642530 | -1.PP_SO-102 | 197.841 | 0.0019632 | 0.0310768 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 2674.8 | 2649.8 | 2649.8 | 2624.8 | 2649.8 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | -1369.6 | PP–RCT S4 | 50 | 183 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 197.841 | ø50 | 38.8 | TR10.03.1646 | 1646 | yes | WS_Studená vnitřní 6 | 0
13642553 | -1.PP_SO-102 | 138.94 | 0.000314112 | 0.00872988 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 2661.78 | 2651.78 | 2650.39 | 2640.39 | 2650.39 | Fáze 2 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 3 | -1357.31 | PP–RCT S4 | 20 | 10 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 138.94 | ø20 | 15.4 | TR10.03.1647 | 1647 | yes | WS_Cirkulace vnitřní 3 | 1
13642564 | -1.PP_SO-102 | 69.8574 | 0.000804127 | 0.00702283 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 2666 | 2650 | 2650 | 2634 | 2650 | Fáze 2 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 3 | -1362.4 | PP–RCT S4 | 32 | 2 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 69.8574 | ø32 | 24.8 | TR10.03.1648 | 1648 | yes | WS_Cirkulace vnitřní 3 | 0
13642587 | -1.PP_SO-102 | 64.5858 | 0.000314112 | 0.00405805 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 2661.18 | 2651.18 | 2650.53 | 2640.53 | 2650.53 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | -1357.17 | PP–RCT S4 | 20 | 201 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 64.5858 | ø20 | 15.4 | TR10.03.1649 | 1649 | yes | WS_Teplá vnitřní 8 | 1
13642596 | -1.PP_SO-102 | 69.7005 | 0.0019632 | 0.0109485 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 2674.95 | 2649.95 | 2649.95 | 2624.95 | 2649.95 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | -1369.45 | PP–RCT S4 | 50 | 183 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 69.7005 | ø50 | 38.8 | TR10.03.1650 | 1650 | yes | WS_Teplá vnitřní 8 | 0
13642650 | -1.PP_SO-102 | 131.643 | 0.00125645 | 0.0165427 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 2670 | 2650 | 2650 | 2630 | 2650 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | -1365.5 | PP–RCT S4 | 40 | 88 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 131.643 | ø40 | 31 | TR10.03.1651 | 1651 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 0
13642671 | -1.PP_SO-102 | 71.0477 | 0.0019632 | 0.0111601 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 2674.8 | 2649.8 | 2649.8 | 2624.8 | 2649.8 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | -1369.6 | PP–RCT S4 | 50 | 199 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 71.0477 | ø50 | 38.8 | TR10.03.1652 | 1652 | yes | WS_Studená vnitřní 6 | 0
13642690 | -1.PP_SO-102 | 239.638 | 0.000804127 | 0.024091 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 2666 | 2650 | 2650 | 2634 | 2650 | Fáze 2 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 3 | -1362.4 | PP–RCT S4 | 32 | 2 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 239.638 | ø32 | 24.8 | TR10.03.1653 | 1653 | yes | WS_Cirkulace vnitřní 3 | 0
13642706 | -1.PP_SO-102 | 199.188 | 0.0019632 | 0.0312884 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 2674.95 | 2649.95 | 2649.95 | 2624.95 | 2649.95 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | -1369.45 | PP–RCT S4 | 50 | 199 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 199.188 | ø50 | 38.8 | TR10.03.1654 | 1654 | yes | WS_Teplá vnitřní 8 | 0
13644782 | 1.NP_SO-102 | 111.093 | 0.0004908 | 0.00872521 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3340.3 | PP–RCT S4 | 25 | 441 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 111.093 | ø25 | 19.4 | TR10.03.1655 | 1655 | no | WS_Studená vnitřní 134 | 0
13644857 | 1.NP_SO-102 | 65.0032 | 0.0004908 | 0.00510534 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3363.15 | 3350.65 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3340.3 | PP–RCT S4 | 25 | 441 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 65.0032 | ø25 | 19.4 | TR10.03.1656 | 1656 | no | WS_Studená vnitřní 134 | 1
13644956 | 1.NP_SO-102 | 96.0928 | 0.0004908 | 0.00754711 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3340.3 | PP–RCT S4 | 25 | 441 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 96.0928 | ø25 | 19.4 | TR10.03.1657 | 1657 | no | WS_Studená vnitřní 134 | 0
13645138 | 2.NP_SO-102 | 1712.37 | 0.0004908 | 0.13449 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3352.5 | 3340 | 3340 | 3327.5 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7330.3 | PP–RCT S4 | 25 | 449 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1712.37 | ø25 | 19.4 | TR10.03.1658 | 1658 | no | WS_Studená vnitřní 134 | 0
13645149 | 2.NP_SO-102 | 614.284 | 0.0004908 | 0.0482457 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3352.5 | 3340 | 3340 | 3327.5 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7330.3 | PP–RCT S4 | 25 | 513 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 614.284 | ø25 | 19.4 | TR10.03.1659 | 1659 | no | WS_Studená vnitřní 134 | 0
13645153 | 2.NP_SO-102 | 160.092 | 0.0004908 | 0.0125736 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3352.5 | 3340 | 3340 | 3327.5 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7330.3 | PP–RCT S4 | 25 | 449 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 160.092 | ø25 | 19.4 | TR10.03.1660 | 1660 | no | WS_Studená vnitřní 134 | 0
13645192 | 2.NP_SO-102 | 210.179 | 0.0004908 | 0.0165074 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3352.5 | 3340 | 3340 | 3327.5 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7330.3 | PP–RCT S4 | 25 | 449 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 210.179 | ø25 | 19.4 | TR10.03.1661 | 1661 | no | WS_Studená vnitřní 134 | 0
13645223 | 2.NP_SO-102 | 160.092 | 0.0004908 | 0.0125736 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3352.5 | 3340 | 3340 | 3327.5 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7330.3 | PP–RCT S4 | 25 | 449 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 160.092 | ø25 | 19.4 | TR10.03.1662 | 1662 | no | WS_Studená vnitřní 134 | 0
13645307 | 3.NP_SO-102 | 2552.38 | 0.0004908 | 0.200463 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11340.3 | PP–RCT S4 | 25 | 227 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2552.38 | ø25 | 19.4 | TR10.03.1663 | 1663 | no | WS_Studená vnitřní 134 | 0
13645316 | 3.NP_SO-102 | 3723 | 0.0004908 | 0.292403 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11340.3 | PP–RCT S4 | 25 | 454 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3723 | ø25 | 19.4 | TR10.03.1664 | 1664 | no | WS_Studená vnitřní 134 | 0
13645320 | 3.NP_SO-102 | 69.1239 | 0.0004908 | 0.00542898 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11340.3 | PP–RCT S4 | 25 | 227 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 69.1239 | ø25 | 19.4 | TR10.03.1665 | 1665 | no | WS_Studená vnitřní 134 | 0
13645361 | 3.NP_SO-102 | 84.4319 | 0.0004908 | 0.00663126 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11340.3 | PP–RCT S4 | 25 | 227 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 84.4319 | ø25 | 19.4 | TR10.03.1666 | 1666 | no | WS_Studená vnitřní 134 | 0
13645388 | 3.NP_SO-102 | 216.807 | 0.0004908 | 0.017028 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11340.3 | PP–RCT S4 | 25 | 227 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 216.807 | ø25 | 19.4 | TR10.03.1667 | 1667 | no | WS_Studená vnitřní 134 | 0
13645507 | 4.NP_SO-102 | 1712.38 | 0.0004908 | 0.13449 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15340.3 | PP–RCT S4 | 25 | 443 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1712.38 | ø25 | 19.4 | TR10.03.1668 | 1668 | no | WS_Studená vnitřní 134 | 0
13645509 | 4.NP_SO-102 | 160.092 | 0.0004908 | 0.0125736 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15340.3 | PP–RCT S4 | 25 | 443 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 160.092 | ø25 | 19.4 | TR10.03.1669 | 1669 | no | WS_Studená vnitřní 134 | 0
13645514 | 4.NP_SO-102 | 210.179 | 0.0004908 | 0.0165074 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15340.3 | PP–RCT S4 | 25 | 443 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 210.179 | ø25 | 19.4 | TR10.03.1670 | 1670 | no | WS_Studená vnitřní 134 | 0
13645517 | 4.NP_SO-102 | 160.092 | 0.0004908 | 0.0125736 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15340.3 | PP–RCT S4 | 25 | 443 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 160.092 | ø25 | 19.4 | TR10.03.1671 | 1671 | no | WS_Studená vnitřní 134 | 0
13645534 | 4.NP_SO-102 | 415.72 | 0.0004908 | 0.0326505 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15340.3 | PP–RCT S4 | 25 | 183 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 415.72 | ø25 | 19.4 | TR10.03.1672 | 1672 | no | WS_Studená vnitřní 134 | 0
13645540 | 4.NP_SO-102 | 5021.72 | 0.0004908 | 0.394405 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15340.3 | PP–RCT S4 | 25 | 442 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5021.72 | ø25 | 19.4 | TR10.03.1673 | 1673 | yes | WS_Studená vnitřní 134 | 0
13645695 | 3.NP_SO-102 | 2078.72 | 0.000314112 | 0.13061 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3302.54 | 3302.54 | 1223.81 | 1223.81 | 1223.81 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 9223.81 | PP–RCT S4 | 20 | 9 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2078.72 | ø20 | 15.4 | TR10.03.1674 | 1674 | no | WS_"Jiný typ" studená vnitřní 1
13645706 | 3.NP_SO-102 | 2700.66 | 0.000314112 | 0.169688 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1210 | 1200 | 1200 | 1190 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 9192.3 | PP–RCT S4 | 20 | 333 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2700.66 | ø20 | 15.4 | TR10.03.1675 | 1675 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13645710 | 3.NP_SO-102 | 1359.99 | 0.000314112 | 0.0854506 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1210 | 1200 | 1200 | 1190 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 9192.3 | PP–RCT S4 | 20 | 338 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1359.99 | ø20 | 15.4 | TR10.03.1676 | 1676 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13645713 | 3.NP_SO-102 | 11665.1 | 0.000314112 | 0.732938 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3330 | 3320 | 3320 | 3310 | 3320 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11312.3 | PP–RCT S4 | 20 | 9 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 11665.1 | ø20 | 15.4 | TR10.03.1677 | 1677 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13645717 | 3.NP_SO-102 | 265.075 | 0.000314112 | 0.0166552 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3330 | 3320 | 3320 | 3310 | 3320 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 11312.3 | PP–RCT S4 | 20 | 9 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 265.075 | ø20 | 15.4 | TR10.03.1678 | 1678 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13645742 | 3.NP_SO-102 | 2285.07 | 0.000314112 | 0.143575 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3302.54 | 1017.46 | 3302.54 | 1017.46 | 3302.54 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 9017.46 | PP–RCT S4 | 20 | 9 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2285.07 | ø20 | 15.4 | TR10.03.1679 | 1679 | no | WS_"Jiný typ" studená vnitřní 1
13645752 | 3.NP_SO-102 | 442.037 | 0.000314112 | 0.027774 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1010 | 1000 | 1000 | 990 | 1000 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 8992.3 | PP–RCT S4 | 20 | 9 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 442.037 | ø20 | 15.4 | TR10.03.1680 | 1680 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13646007 | 2.NP_SO-102 | 85.8867 | 0.000804127 | 0.00863427 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3356 | 3340 | 3340 | 3324 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7327.6 | PP–RCT S4 | 32 | 446 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 85.8867 | ø32 | 24.8 | TR10.03.1681 | 1681 | yes | WS_Studená vnitřní 134 | 0
13646320 | 3.NP_SO-102 | 2506.03 | 0.000804127 | 0.251933 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3406.19 | 3390.19 | 3390.19 | 3374.19 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11377.8 | PP–RCT S4 | 32 | 137 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2506.03 | ø32 | 24.8 | TR10.03.1682 | 1682 | yes | WS_Teplá vnitřní 83 | 0
13646334 | 3.NP_SO-102 | 109.376 | 0.000804127 | 0.0109957 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3406.19 | 3390.19 | 3390.19 | 3374.19 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11377.8 | PP–RCT S4 | 32 | 136 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 109.376 | ø32 | 24.8 | TR10.03.1683 | 1683 | yes | WS_Teplá vnitřní 83 | 0
13646475 | 3.NP_SO-102 | 3793.32 | 0.00125645 | 0.476683 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 3.NP_SO-102 | 3166.66 | -626.662 | 3166.66 | -626.662 | 3166.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7373.34 | PP–RCT S4 | 40 | 384 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3793.32 | ø40 | 31 | TR10.03.1684 | 1684 | yes | WS_Teplá vnitřní 83
13646489 | 3.NP_SO-102 | 123.516 | 0.00125645 | 0.0155214 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 3.NP_SO-102 | 3356.85 | 3233.34 | 3356.85 | 3233.34 | 3356.85 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11233.3 | PP–RCT S4 | 40 | 128 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 123.516 | ø40 | 31 | TR10.03.1685 | 1685 | yes | WS_Teplá vnitřní 83
13646833 | 2.NP_SO-102 | 1214.32 | 0.0004908 | 0.0953726 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2412.5 | 2400 | 2400 | 2387.5 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6390.3 | PP–RCT S4 | 25 | 55 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1214.32 | ø25 | 19.4 | TR10.03.1688 | 1688 | no | WS_Teplá vnitřní 83 | 0
13647647 | 3.NP_SO-102 | 453.154 | 0.0004908 | 0.0355906 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 1439.16 | 1426.66 | 1426.66 | 1414.16 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 9416.96 | PP–RCT S4 | 25 | 346 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 453.154 | ø25 | 19.4 | TR10.03.1690 | 1690 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13647986 | 1.NP_SO-102 | 1834.31 | 0.000314112 | 0.115253 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 1226.19 | -608.118 | 1226.19 | -608.118 | 1226.19 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -608.118 | PP–RCT S4 | 20 | 350 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1834.31 | ø20 | 15.4 | TR10.03.1691 | 1691 | no | WS_"Jiný typ" studená vnitřní 1
13647988 | -1.PP_SO-102 | 3714.76 | 0.000314112 | 0.233405 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3384.42 | 3374.42 | 3374.42 | 3364.42 | 3374.42 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -633.281 | PP–RCT S4 | 20 | 350 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3714.76 | ø20 | 15.4 | TR10.03.1692 | 1692 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13650926 | -1.PP_SO-102 | 1483.93 | 0.00311678 | 0.2937 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2831.5 | 2800 | 2800 | 2768.5 | 2800 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1224.4 | PP–RCT S4 | 63 | 344 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1483.93 | ø63 | 48.8 | TR10.03.1693 | 1693 | yes | WS_Studená vnitřní 134 | 0
13650970 | -1.PP_SO-102 | 1366.44 | 0.0019632 | 0.214641 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 2825 | 2800 | 2800 | 2775 | 2800 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1219.4 | PP–RCT S4 | 50 | 392 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1366.44 | ø50 | 38.8 | TR10.03.1694 | 1694 | yes | WS_Teplá vnitřní 83 | 0
13651242 | -1.PP_SO-102 | 626.975 | 0.0019632 | 0.098485 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3260.31 | 3260.31 | 2633.34 | 2633.34 | 2633.34 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1366.66 | PP–RCT S4 | 50 | 392 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 626.975 | ø50 | 38.8 | TR10.03.1696 | 1696 | yes | WS_Teplá vnitřní 83
13651761 | -1.PP_SO-102 | 652.375 | 0.000804127 | 0.0655839 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3276.19 | 2623.81 | 3276.19 | 2623.81 | 3276.19 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1376.19 | PP–RCT S4 | 32 | 261 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 652.375 | ø32 | 24.8 | TR10.03.1698 | 1698 | yes | WS_Cirkulace vnitřní 9
13651789 | -1.PP_SO-102 | 541.212 | 0.00311678 | 0.107117 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3180.65 | 3180.65 | 2639.44 | 2639.44 | 2639.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1360.56 | PP–RCT S4 | 63 | 344 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 541.212 | ø63 | 48.8 | TR10.03.1699 | 1699 | yes | WS_Studená vnitřní 134
13654079 | -1.PP_SO-102 | 811.125 | 0.00311678 | 0.160538 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3260.56 | 2449.44 | 3260.56 | 2449.44 | 3260.56 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1550.56 | PP–RCT S4 | 63 | 395 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 811.125 | ø63 | 48.8 | TR10.03.1712 | 1712 | yes | WS_Teplá vnitřní 83
13654090 | -1.PP_SO-102 | 852.375 | 0.000804127 | 0.0856901 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3276.19 | 2423.81 | 3276.19 | 2423.81 | 3276.19 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1576.19 | PP–RCT S4 | 32 | 247 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 852.375 | ø32 | 24.8 | TR10.03.1713 | 1713 | yes | WS_Cirkulace vnitřní 9
13654101 | -1.PP_SO-102 | 747.562 | 0.00311678 | 0.147958 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3187 | 2439.44 | 3187 | 2439.44 | 3187 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1560.56 | PP–RCT S4 | 63 | 468 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 747.562 | ø63 | 48.8 | TR10.03.1714 | 1714 | yes | WS_Studená vnitřní 134
13654112 | -1.PP_SO-102 | 821.125 | 0.00311678 | 0.162517 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3260.56 | 2439.44 | 3260.56 | 2439.44 | 3260.56 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1560.56 | PP–RCT S4 | 63 | 366 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 821.125 | ø63 | 48.8 | TR10.03.1715 | 1715 | yes | WS_"Jiný typ" studená vnitřní 1
13704838 | -1.PP_SO-102 | 271.125 | 0.00311678 | 0.0536612 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3310.56 | 3039.44 | 3310.56 | 3039.44 | 3310.56 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -960.562 | PP–RCT S4 | 63 | 507 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 271.125 | ø63 | 48.8 | TR10.03.1818 | 1818 | yes | WS_Studená vnitřní 134
13704886 | 2.NP_SO-102 | 5011.43 | 0.0004908 | 0.393597 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2412.5 | 2400 | 2400 | 2387.5 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | 6390.3 | PP–RCT S4 | 25 | 5 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5011.43 | ø25 | 19.4 | TR10.03.1819 | 1819 | no | WS_Cirkulace vnitřní 9 | 0
13705062 | -1.PP_SO-102 | 271.125 | 0.00311678 | 0.0536612 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3310.56 | 3039.44 | 3310.56 | 3039.44 | 3310.56 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -960.562 | PP–RCT S4 | 63 | 445 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 271.125 | ø63 | 48.8 | TR10.03.1820 | 1820 | yes | WS_Teplá vnitřní 83
13705065 | -1.PP_SO-102 | 1357.63 | 0.00311678 | 0.268702 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2441.5 | 2410 | 2410 | 2378.5 | 2410 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1614.4 | PP–RCT S4 | 63 | 395 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1357.63 | ø63 | 48.8 | TR10.03.1821 | 1821 | yes | WS_Teplá vnitřní 83 | 0
13705183 | -1.PP_SO-102 | 296.025 | 0.00125645 | 0.0371996 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 3323.01 | 3026.99 | 3323.01 | 3026.99 | 3323.01 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -973.012 | PP–RCT S4 | 40 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 296.025 | ø40 | 31 | TR10.03.1822 | 1822 | yes | WS_Cirkulace vnitřní 9
13705186 | -1.PP_SO-102 | 20003.2 | 0.000804127 | 2.01094 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 2816 | 2800 | 2800 | 2784 | 2800 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1212.4 | PP–RCT S4 | 32 | 261 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 20003.2 | ø32 | 24.8 | TR10.03.1823 | 1823 | yes | WS_Cirkulace vnitřní 9 | 0
13705730 | -1.PP_SO-102 | 1520.11 | 0.0019632 | 0.238779 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3325 | 3300 | 3300 | 3275 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -719.4 | PP–RCT S4 | 50 | 402 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1520.11 | ø50 | 38.8 | TR10.03.1824 | 1824 | yes | WS_Teplá vnitřní 83 | 0
13705738 | -1.PP_SO-102 | 4326.18 | 0.0004908 | 0.339777 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3312.5 | 3300 | 3300 | 3287.5 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -709.7 | PP–RCT S4 | 25 | 401 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4326.18 | ø25 | 19.4 | TR10.03.1825 | 1825 | yes | WS_Teplá vnitřní 83 | 0
13705969 | -1.PP_SO-102 | 13255.5 | 0.000804127 | 1.33259 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3316 | 3300 | 3300 | 3284 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 4 | -712.4 | PP–RCT S4 | 32 | 52 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 13255.5 | ø32 | 24.8 | TR10.03.1826 | 1826 | yes | WS_Cirkulace vnitřní 4 | 0
13706071 | -1.PP_SO-102 | 1420.57 | 0.0019632 | 0.223143 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3251.44 | 3226.44 | 3226.44 | 3201.44 | 3226.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -792.963 | PP–RCT S4 | 50 | 357 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1420.57 | ø50 | 38.8 | TR10.03.1827 | 1827 | yes | WS_Studená vnitřní 134 | 0
13706079 | -1.PP_SO-102 | 4311.86 | 0.00311678 | 0.853404 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3257.94 | 3226.44 | 3226.44 | 3194.94 | 3226.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -797.963 | PP–RCT S4 | 63 | 472 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4311.86 | ø63 | 48.8 | TR10.03.1828 | 1828 | yes | WS_Studená vnitřní 134 | 0
13763906 | -1.PP_SO-102 | 1309.13 | 0.0044172 | 0.308455 | ø75 mm |  |  |  | 0.000171821 | JB | -1.PP_SO-102 | 842.55 | 805.05 | 805.05 | 767.55 | 805.05 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | Trubka Evo, S4 | WS_Požární nezavodněný 1 | -3224.05 | PP–RCT S4 | 75 | 388 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1309.13 | ø75 | 58.2 | TR10.03.1832 | 1832 | yes | WS_Požární nezavodněný 1 | 0
13764220 | -1.PP_SO-102 | 10464.1 | 0.0044172 | 2.46555 | ø75 mm |  |  |  | 0.000171821 | JD | -1.PP_SO-102 | 842.55 | 805.05 | 805.05 | 767.55 | 805.05 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | Trubka Evo, S4 | WS_Požární nezavodněný 1 | -3224.05 | PP–RCT S4 | 75 | 388 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 10464.1 | ø75 | 58.2 | TR10.03.1840 | 1840 | yes | WS_Požární nezavodněný 1 | 0
13764361 | -1.PP_SO-102 | 2018.79 | 0.0044172 | 0.475667 | ø75 mm |  |  |  | 0 | JD | -1.PP_SO-102 | 2869.28 | 2869.28 | 850.488 | 850.488 | 850.488 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | Trubka Evo, S4 | WS_Požární nezavodněný 1 | -3149.51 | PP–RCT S4 | 75 | 388 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2018.79 | ø75 | 58.2 | TR10.03.1842 | 1842 | yes | WS_Požární nezavodněný 1
13764517 | -1.PP_SO-102 | 306.844 | 0.0044172 | 0.0722983 | ø75 mm |  |  |  | 0.000171821 | JD | -1.PP_SO-102 | 2952.22 | 2914.72 | 2914.72 | 2877.22 | 2914.72 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | Trubka Evo, S4 | WS_Požární nezavodněný 1 | -1114.38 | PP–RCT S4 | 75 | 388 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 306.844 | ø75 | 58.2 | TR10.03.1844 | 1844 | yes | WS_Požární nezavodněný 1 | 0
13805861 | -1.PP_SO-102 | 6499.6 | 0.00311678 | 1.2864 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2931.5 | 2900 | 2900 | 2868.5 | 2900 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1124.4 | PP–RCT S4 | 63 | 355 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6499.6 | ø63 | 48.8 | TR10.03.1846 | 1846 | yes | WS_Studená vnitřní 134 | 0
13807054 | -1.PP_SO-102 | 3655.15 | 0.00125645 | 0.45932 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 2820 | 2800 | 2800 | 2780 | 2800 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1215.5 | PP–RCT S4 | 40 | 251 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3655.15 | ø40 | 31 | TR10.03.1848 | 1848 | yes | WS_Cirkulace vnitřní 9 | 0
13807062 | -1.PP_SO-102 | 3630.25 | 0.00311678 | 0.718501 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2831.5 | 2800 | 2800 | 2768.5 | 2800 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1224.4 | PP–RCT S4 | 63 | 475 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3630.25 | ø63 | 48.8 | TR10.03.1849 | 1849 | yes | WS_Studená vnitřní 134 | 0
13807239 | -1.PP_SO-102 | 3630.25 | 0.00311678 | 0.718501 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2831.5 | 2800 | 2800 | 2768.5 | 2800 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1224.4 | PP–RCT S4 | 63 | 411 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3630.25 | ø63 | 48.8 | TR10.03.1851 | 1851 | yes | WS_Teplá vnitřní 83 | 0
13807255 | -1.PP_SO-102 | 896.91 | 0.00125645 | 0.112709 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 3320 | 3300 | 3300 | 3280 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -715.5 | PP–RCT S4 | 40 | 251 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 896.91 | ø40 | 31 | TR10.03.1852 | 1852 | yes | WS_Cirkulace vnitřní 9 | 0
13807274 | -1.PP_SO-102 | 1436.6 | 0.00311678 | 0.284332 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3257.94 | 3226.44 | 3226.44 | 3194.94 | 3226.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -797.963 | PP–RCT S4 | 63 | 475 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1436.6 | ø63 | 48.8 | TR10.03.1853 | 1853 | yes | WS_Studená vnitřní 134 | 0
13807302 | -1.PP_SO-102 | 3642.45 | 0.0019632 | 0.572155 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 2825 | 2800 | 2800 | 2775 | 2800 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1219.4 | PP–RCT S4 | 50 | 353 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3642.45 | ø50 | 38.8 | TR10.03.1854 | 1854 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13807399 | -1.PP_SO-102 | 521.125 | 0.00311678 | 0.103141 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 3360.56 | 2839.44 | 3360.56 | 2839.44 | 3360.56 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1160.56 | PP–RCT S4 | 63 | 411 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 521.125 | ø63 | 48.8 | TR10.03.1856 | 1856 | yes | WS_Teplá vnitřní 83
13807434 | -1.PP_SO-102 | 546.025 | 0.00125645 | 0.0686155 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JD | -1.PP_SO-102 | 3373.01 | 2826.99 | 3373.01 | 2826.99 | 3373.01 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1173.01 | PP–RCT S4 | 40 | 251 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 546.025 | ø40 | 31 | TR10.03.1857 | 1857 | yes | WS_Cirkulace vnitřní 9
13807473 | -1.PP_SO-102 | 521.125 | 0.00311678 | 0.103141 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 3360.56 | 2839.44 | 3360.56 | 2839.44 | 3360.56 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1160.56 | PP–RCT S4 | 63 | 475 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 521.125 | ø63 | 48.8 | TR10.03.1858 | 1858 | yes | WS_Studená vnitřní 134
13807509 | -1.PP_SO-102 | 533.325 | 0.0019632 | 0.0837745 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JD | -1.PP_SO-102 | 3366.66 | 2833.34 | 3366.66 | 2833.34 | 3366.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1166.66 | PP–RCT S4 | 50 | 353 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 533.325 | ø50 | 38.8 | TR10.03.1859 | 1859 | yes | WS_"Jiný typ" studená vnitřní 1
13807612 | -1.PP_SO-102 | 433.325 | 0.0019632 | 0.0680665 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JD | -1.PP_SO-102 | 3266.66 | 2833.34 | 3266.66 | 2833.34 | 3266.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1166.66 | PP–RCT S4 | 50 | 353 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 433.325 | ø50 | 38.8 | TR10.03.1860 | 1860 | yes | WS_"Jiný typ" studená vnitřní 1
13807651 | -1.PP_SO-102 | 347.562 | 0.00311678 | 0.0687896 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 3187 | 2839.44 | 3187 | 2839.44 | 3187 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1160.56 | PP–RCT S4 | 63 | 475 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 347.562 | ø63 | 48.8 | TR10.03.1861 | 1861 | yes | WS_Studená vnitřní 134
13807691 | -1.PP_SO-102 | 446.025 | 0.00125645 | 0.0560492 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JD | -1.PP_SO-102 | 3273.01 | 2826.99 | 3273.01 | 2826.99 | 3273.01 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1173.01 | PP–RCT S4 | 40 | 251 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 446.025 | ø40 | 31 | TR10.03.1862 | 1862 | yes | WS_Cirkulace vnitřní 9
13807728 | -1.PP_SO-102 | 421.125 | 0.00311678 | 0.0833492 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 3260.56 | 2839.44 | 3260.56 | 2839.44 | 3260.56 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1160.56 | PP–RCT S4 | 63 | 411 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 421.125 | ø63 | 48.8 | TR10.03.1863 | 1863 | yes | WS_Teplá vnitřní 83
13822562 | -1.PP_SO-102 | 896.499 | 0.0019632 | 0.140822 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 2525 | 2500 | 2500 | 2475 | 2500 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1519.4 | PP–RCT S4 | 50 | 392 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 896.499 | ø50 | 38.8 | TR10.03.1876 | 1876 | yes | WS_Teplá vnitřní 83 | 0
13822578 | -1.PP_SO-102 | 1065.55 | 0.000804127 | 0.107121 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 2516 | 2500 | 2500 | 2484 | 2500 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1512.4 | PP–RCT S4 | 32 | 261 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1065.55 | ø32 | 24.8 | TR10.03.1877 | 1877 | yes | WS_Cirkulace vnitřní 9 | 0
13822590 | -1.PP_SO-102 | 1184.3 | 0.00311678 | 0.234397 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2531.5 | 2500 | 2500 | 2468.5 | 2500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1524.4 | PP–RCT S4 | 63 | 344 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1184.3 | ø63 | 48.8 | TR10.03.1878 | 1878 | yes | WS_Studená vnitřní 134 | 0
13822858 | -1.PP_SO-102 | 21.125 | 0.00311678 | 0.00418107 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 2560.56 | 2539.44 | 2560.56 | 2539.44 | 2560.56 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1460.56 | PP–RCT S4 | 63 | 366 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 21.125 | ø63 | 48.8 | TR10.03.1882 | 1882 | yes | WS_"Jiný typ" studená vnitřní 1
13822900 | -1.PP_SO-102 | 221.125 | 0.00311678 | 0.0437651 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 2760.56 | 2539.44 | 2760.56 | 2539.44 | 2760.56 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1460.56 | PP–RCT S4 | 63 | 344 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 221.125 | ø63 | 48.8 | TR10.03.1883 | 1883 | yes | WS_Studená vnitřní 134
13822931 | -1.PP_SO-102 | 252.375 | 0.000804127 | 0.0253715 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JD | -1.PP_SO-102 | 2776.19 | 2523.81 | 2776.19 | 2523.81 | 2776.19 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1476.19 | PP–RCT S4 | 32 | 261 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 252.375 | ø32 | 24.8 | TR10.03.1884 | 1884 | yes | WS_Cirkulace vnitřní 9
13822961 | -1.PP_SO-102 | 233.325 | 0.0019632 | 0.0366506 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JD | -1.PP_SO-102 | 2766.66 | 2533.34 | 2766.66 | 2533.34 | 2766.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1466.66 | PP–RCT S4 | 50 | 392 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 233.325 | ø50 | 38.8 | TR10.03.1885 | 1885 | yes | WS_Teplá vnitřní 83
13823052 | -1.PP_SO-102 | 33.325 | 0.0019632 | 0.00523468 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JD | -1.PP_SO-102 | 2566.66 | 2533.34 | 2566.66 | 2533.34 | 2566.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1466.66 | PP–RCT S4 | 50 | 392 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 33.325 | ø50 | 38.8 | TR10.03.1888 | 1888 | yes | WS_Teplá vnitřní 83
13823089 | -1.PP_SO-102 | 52.375 | 0.000804127 | 0.00526531 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JD | -1.PP_SO-102 | 2576.19 | 2523.81 | 2576.19 | 2523.81 | 2576.19 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1476.19 | PP–RCT S4 | 32 | 261 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 52.375 | ø32 | 24.8 | TR10.03.1889 | 1889 | yes | WS_Cirkulace vnitřní 9
13823125 | -1.PP_SO-102 | 21.125 | 0.00311678 | 0.00418107 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 2560.56 | 2539.44 | 2560.56 | 2539.44 | 2560.56 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1460.56 | PP–RCT S4 | 63 | 344 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 21.125 | ø63 | 48.8 | TR10.03.1890 | 1890 | yes | WS_Studená vnitřní 134
13823160 | -1.PP_SO-102 | 21.125 | 0.00311678 | 0.00418107 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 2560.56 | 2539.44 | 2560.56 | 2539.44 | 2560.56 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1460.56 | PP–RCT S4 | 63 | 212 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 21.125 | ø63 | 48.8 | TR10.03.1891 | 1891 | yes | WS_"Jiný typ" studená vnitřní 1
13823412 | -1.PP_SO-102 | 226.181 | 0.0004908 | 0.0177642 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 2746.82 | 2520.64 | 2746.82 | 2520.64 | 2746.82 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1479.36 | PP–RCT S4 | 25 | 416 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 226.181 | ø25 | 19.4 | TR10.03.1894 | 1894 | no | WS_Teplá vnitřní 83
13823414 | -1.PP_SO-102 | 1219.87 | 0.0004908 | 0.095808 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 2512.5 | 2500 | 2500 | 2487.5 | 2500 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1509.7 | PP–RCT S4 | 25 | 416 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1219.87 | ø25 | 19.4 | TR10.03.1895 | 1895 | no | WS_Teplá vnitřní 83 | 0
13823498 | -1.PP_SO-102 | 217.031 | 0.0004908 | 0.0170456 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 2737.67 | 2520.64 | 2737.67 | 2520.64 | 2737.67 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1479.36 | PP–RCT S4 | 25 | 479 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 217.031 | ø25 | 19.4 | TR10.03.1896 | 1896 | no | WS_Studená vnitřní 134
13823508 | -1.PP_SO-102 | 18503.4 | 0.00311678 | 3.66219 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2831.5 | 2800 | 2800 | 2768.5 | 2800 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1224.4 | PP–RCT S4 | 63 | 506 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 18503.4 | ø63 | 48.8 | TR10.03.1897 | 1897 | yes | WS_Studená vnitřní 134 | 0
13823649 | -1.PP_SO-102 | 20.2063 | 0.000314112 | 0.0012696 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JD | -1.PP_SO-102 | 2582.54 | 2582.54 | 2562.33 | 2562.33 | 2562.33 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1437.67 | PP–RCT S4 | 20 | 354 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 20.2063 | ø20 | 15.4 | TR10.03.1898 | 1898 | no | WS_"Jiný typ" studená vnitřní 1
13823652 | -1.PP_SO-102 | 638.846 | 0.00311678 | 0.126441 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2531.5 | 2500 | 2500 | 2468.5 | 2500 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1524.4 | PP–RCT S4 | 63 | 212 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 638.846 | ø63 | 48.8 | TR10.03.1899 | 1899 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
