Properties of the parts of a building model (IFC4), part 53 of 60

# IfcPipeSegment: Typy trubek:PP-RCT (1338)
Name (Typy trubek:PP-RCT:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Instalační jednotky = Reynoldsovo číslo = Třecí faktor = Tření = Průtok (m3/s) = Rychlost (m/s) = Tlaková ztráta (Pa) | Stav průtoku | Doplňkový průtok (m3/s) | Relativní drsnost | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) | Spodní výška (mm) | Střední výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Délka (mm) | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
13824395 | -1.PP_SO-102 | 961.125 | 0.00311678 | 0.190226 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 3031.5 | 3000 | 3000 | 2968.5 | 3000 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1024.4 | PP–RCT S4 | 63 | 507 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 961.125 | ø63 | 48.8 | TR10.03.1900 | 1900 | yes | WS_Studená vnitřní 134 | 0
13824425 | -1.PP_SO-102 | 961.125 | 0.00311678 | 0.190226 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 3031.5 | 3000 | 3000 | 2968.5 | 3000 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1024.4 | PP–RCT S4 | 63 | 445 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 961.125 | ø63 | 48.8 | TR10.03.1901 | 1901 | yes | WS_Teplá vnitřní 83 | 0
13824491 | -1.PP_SO-102 | 986.025 | 0.00125645 | 0.123908 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JD | -1.PP_SO-102 | 3020 | 3000 | 3000 | 2980 | 3000 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1015.5 | PP–RCT S4 | 40 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 986.025 | ø40 | 31 | TR10.03.1902 | 1902 | yes | WS_Cirkulace vnitřní 9 | 0
13824844 | -1.PP_SO-102 | 447.311 | 0.00311678 | 0.0885319 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 2551.03 | 2519.53 | 2519.53 | 2488.03 | 2519.53 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1504.87 | PP–RCT S4 | 63 | 507 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 447.311 | ø63 | 48.8 | TR10.03.1903 | 1903 | yes | WS_Studená vnitřní 134 | 0
13824858 | -1.PP_SO-102 | 401.598 | 0.00311678 | 0.0794844 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 2960.56 | 2558.96 | 2960.56 | 2558.96 | 2960.56 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1441.04 | PP–RCT S4 | 63 | 507 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 401.598 | ø63 | 48.8 | TR10.03.1904 | 1904 | yes | WS_Studená vnitřní 134
13824898 | -1.PP_SO-102 | 426.498 | 0.00125645 | 0.0535953 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JD | -1.PP_SO-102 | 2973.01 | 2546.51 | 2973.01 | 2546.51 | 2973.01 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1453.49 | PP–RCT S4 | 40 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 426.498 | ø40 | 31 | TR10.03.1905 | 1905 | yes | WS_Cirkulace vnitřní 9
13824936 | -1.PP_SO-102 | 401.598 | 0.00311678 | 0.0794844 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 2960.56 | 2558.96 | 2960.56 | 2558.96 | 2960.56 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1441.04 | PP–RCT S4 | 63 | 445 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 401.598 | ø63 | 48.8 | TR10.03.1906 | 1906 | yes | WS_Teplá vnitřní 83
13825010 | -1.PP_SO-102 | 24.3022 | 0.00311678 | 0.0048099 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 2480.09 | 2455.79 | 2480.09 | 2455.79 | 2480.09 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1544.21 | PP–RCT S4 | 63 | 445 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 24.3022 | ø63 | 48.8 | TR10.03.1907 | 1907 | yes | WS_Teplá vnitřní 83
13825020 | -1.PP_SO-102 | 147.311 | 0.00311678 | 0.0291558 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 2551.03 | 2519.53 | 2519.53 | 2488.03 | 2519.53 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1504.87 | PP–RCT S4 | 63 | 445 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 147.311 | ø63 | 48.8 | TR10.03.1908 | 1908 | yes | WS_Teplá vnitřní 83 | 0
13825049 | -1.PP_SO-102 | 59.2022 | 0.00125645 | 0.00743957 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JD | -1.PP_SO-102 | 2492.54 | 2433.34 | 2492.54 | 2433.34 | 2492.54 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1566.66 | PP–RCT S4 | 40 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 59.2022 | ø40 | 31 | TR10.03.1909 | 1909 | yes | WS_Cirkulace vnitřní 9
13825051 | -1.PP_SO-102 | 322.211 | 0.00125645 | 0.0404902 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JD | -1.PP_SO-102 | 2539.53 | 2519.53 | 2519.53 | 2499.53 | 2519.53 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1495.97 | PP–RCT S4 | 40 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 322.211 | ø40 | 31 | TR10.03.1910 | 1910 | yes | WS_Cirkulace vnitřní 9 | 0
13825069 | -1.PP_SO-102 | 34.3022 | 0.00311678 | 0.0067891 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 2480.09 | 2445.79 | 2480.09 | 2445.79 | 2480.09 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1554.21 | PP–RCT S4 | 63 | 507 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 34.3022 | ø63 | 48.8 | TR10.03.1911 | 1911 | yes | WS_Studená vnitřní 134
13825587 | -1.PP_SO-102 | 110.681 | 0.00125645 | 0.0139086 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JD | -1.PP_SO-102 | 3237.67 | 3126.99 | 3237.67 | 3126.99 | 3237.67 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -873.012 | PP–RCT S4 | 40 | 418 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 110.681 | ø40 | 31 | TR10.03.1914 | 1914 | yes | WS_Teplá vnitřní 83
13825591 | -1.PP_SO-102 | 712.157 | 0.00125645 | 0.0894922 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JD | -1.PP_SO-102 | 3120 | 3100 | 3100 | 3080 | 3100 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -915.5 | PP–RCT S4 | 40 | 418 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 712.157 | ø40 | 31 | TR10.03.1915 | 1915 | yes | WS_Teplá vnitřní 83 | 0
13825635 | -1.PP_SO-102 | 146.025 | 0.000804127 | 0.01468 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JD | -1.PP_SO-102 | 3269.84 | 3123.81 | 3269.84 | 3123.81 | 3269.84 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -876.188 | PP–RCT S4 | 32 | 9 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 146.025 | ø32 | 24.8 | TR10.03.1916 | 1916 | yes | WS_Cirkulace vnitřní 9
13825639 | -1.PP_SO-102 | 886.41 | 0.000804127 | 0.0891116 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JD | -1.PP_SO-102 | 3116 | 3100 | 3100 | 3084 | 3100 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -912.4 | PP–RCT S4 | 32 | 9 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 886.41 | ø32 | 24.8 | TR10.03.1917 | 1917 | yes | WS_Cirkulace vnitřní 9 | 0
13825656 | -1.PP_SO-102 | 37.1182 | 0.00125645 | 0.00466441 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JD | -1.PP_SO-102 | 3164.11 | 3126.99 | 3164.11 | 3126.99 | 3164.11 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -873.012 | PP–RCT S4 | 40 | 481 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 37.1182 | ø40 | 31 | TR10.03.1918 | 1918 | yes | WS_Studená vnitřní 134
13825658 | -1.PP_SO-102 | 926.297 | 0.00125645 | 0.116402 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JD | -1.PP_SO-102 | 3120 | 3100 | 3100 | 3080 | 3100 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -915.5 | PP–RCT S4 | 40 | 481 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 926.297 | ø40 | 31 | TR10.03.1919 | 1919 | yes | WS_Studená vnitřní 134 | 0
13825690 | -1.PP_SO-102 | 117.031 | 0.0004908 | 0.00919161 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 3237.67 | 3120.64 | 3237.67 | 3120.64 | 3237.67 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -879.362 | PP–RCT S4 | 25 | 359 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 117.031 | ø25 | 19.4 | TR10.03.1920 | 1920 | yes | WS_"Jiný typ" studená vnitřní 1
13825692 | -1.PP_SO-102 | 1109.53 | 0.0004908 | 0.0871419 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 3112.5 | 3100 | 3100 | 3087.5 | 3100 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -909.7 | PP–RCT S4 | 25 | 359 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1109.53 | ø25 | 19.4 | TR10.03.1921 | 1921 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13826531 | -1.PP_SO-102 | 2128.76 | 0.0004908 | 0.167193 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 2662.45 | 2649.95 | 2649.95 | 2637.45 | 2649.95 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | -1359.75 | PP–RCT S4 | 25 | 205 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2128.76 | ø25 | 19.4 | TR10.03.1923 | 1923 | yes | WS_Teplá vnitřní 8 | 0
13826550 | -1.PP_SO-102 | 2328.75 | 0.0004908 | 0.1829 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 2662.3 | 2649.8 | 2649.8 | 2637.3 | 2649.8 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | -1359.9 | PP–RCT S4 | 25 | 205 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2328.75 | ø25 | 19.4 | TR10.03.1924 | 1924 | yes | WS_Studená vnitřní 6 | 0
13826560 | -1.PP_SO-102 | 2446.22 | 0.000314112 | 0.1537 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 2660 | 2650 | 2650 | 2640 | 2650 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | -1357.7 | PP–RCT S4 | 20 | 91 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2446.22 | ø20 | 15.4 | TR10.03.1925 | 1925 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 0
13826647 | -1.PP_SO-102 | 11623.1 | 0.0019632 | 1.82575 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3425 | 3400 | 3400 | 3375 | 3400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -619.4 | PP–RCT S4 | 50 | 264 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 11623.1 | ø50 | 38.8 | TR10.03.1926 | 1926 | yes | WS_Teplá vnitřní 83 | 0
13826653 | -1.PP_SO-102 | 11542.1 | 0.000804127 | 1.16034 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3416 | 3400 | 3400 | 3384 | 3400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -612.4 | PP–RCT S4 | 32 | 204 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 11542.1 | ø32 | 24.8 | TR10.03.1927 | 1927 | yes | WS_Cirkulace vnitřní 9 | 0
13826663 | -1.PP_SO-102 | 11362.9 | 0.00125645 | 1.42791 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 3420 | 3400 | 3400 | 3380 | 3400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -615.5 | PP–RCT S4 | 40 | 151 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 11362.9 | ø40 | 31 | TR10.03.1928 | 1928 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13826670 | -1.PP_SO-102 | 11451.3 | 0.0019632 | 1.79877 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3425 | 3400 | 3400 | 3375 | 3400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -619.4 | PP–RCT S4 | 50 | 237 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 11451.3 | ø50 | 38.8 | TR10.03.1929 | 1929 | yes | WS_Studená vnitřní 134 | 0
13826905 | -1.PP_SO-102 | 534.363 | 0.0004908 | 0.0419688 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 3204.95 | 3204.95 | 2670.59 | 2670.59 | 2670.59 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | -1329.41 | PP–RCT S4 | 25 | 205 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 534.363 | ø25 | 19.4 | TR10.03.1932 | 1932 | yes | WS_Teplá vnitřní 8
13826952 | -1.PP_SO-102 | 534.863 | 0.0004908 | 0.042008 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 3205.3 | 3205.3 | 2670.44 | 2670.44 | 2670.44 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | -1329.56 | PP–RCT S4 | 25 | 205 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 534.863 | ø25 | 19.4 | TR10.03.1933 | 1933 | yes | WS_Studená vnitřní 6
13827009 | -1.PP_SO-102 | 541.013 | 0.000314112 | 0.0339928 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JD | -1.PP_SO-102 | 3208.48 | 3208.48 | 2667.46 | 2667.46 | 2667.46 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | -1332.54 | PP–RCT S4 | 20 | 91 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 541.013 | ø20 | 15.4 | TR10.03.1934 | 1934 | yes | WS_"ŠEDÁ" studená vnitřní 2
13827083 | -1.PP_SO-102 | 746.025 | 0.00125645 | 0.0937483 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JD | -1.PP_SO-102 | 3373.01 | 2626.99 | 3373.01 | 2626.99 | 3373.01 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1373.01 | PP–RCT S4 | 40 | 151 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 746.025 | ø40 | 31 | TR10.03.1935 | 1935 | yes | WS_"Jiný typ" studená vnitřní 1
13827120 | -1.PP_SO-102 | 733.325 | 0.0019632 | 0.11519 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JD | -1.PP_SO-102 | 3366.66 | 2633.34 | 3366.66 | 2633.34 | 3366.66 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1366.66 | PP–RCT S4 | 50 | 237 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 733.325 | ø50 | 38.8 | TR10.03.1936 | 1936 | yes | WS_Studená vnitřní 134
13827157 | -1.PP_SO-102 | 752.375 | 0.000804127 | 0.075637 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JD | -1.PP_SO-102 | 3376.19 | 2623.81 | 3376.19 | 2623.81 | 3376.19 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1376.19 | PP–RCT S4 | 32 | 204 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 752.375 | ø32 | 24.8 | TR10.03.1937 | 1937 | yes | WS_Cirkulace vnitřní 9
13827190 | -1.PP_SO-102 | 733.325 | 0.0019632 | 0.11519 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JD | -1.PP_SO-102 | 3366.66 | 2633.34 | 3366.66 | 2633.34 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1366.66 | PP–RCT S4 | 50 | 264 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 733.325 | ø50 | 38.8 | TR10.03.1938 | 1938 | yes | WS_Teplá vnitřní 83
13827931 | -1.PP_SO-102 | 519.339 | 0.0004908 | 0.0407888 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3312.5 | 3300 | 3300 | 3287.5 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -709.7 | PP–RCT S4 | 25 | 427 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 519.339 | ø25 | 19.4 | TR10.03.1940 | 1940 | no | WS_Teplá vnitřní 83 | 0
13827940 | -1.PP_SO-102 | 275.807 | 0.0004908 | 0.0216618 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3312.5 | 3300 | 3300 | 3287.5 | 3300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -709.7 | PP–RCT S4 | 25 | 487 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 275.807 | ø25 | 19.4 | TR10.03.1941 | 1941 | no | WS_Studená vnitřní 134 | 0
13827974 | -1.PP_SO-102 | 1111.11 | 0.00311678 | 0.219912 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3431.5 | 3400 | 3400 | 3368.5 | 3400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -624.4 | PP–RCT S4 | 63 | 349 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1111.11 | ø63 | 48.8 | TR10.03.1942 | 1942 | yes | WS_Teplá vnitřní 83 | 0
13828006 | -1.PP_SO-102 | 842.787 | 0.00311678 | 0.166805 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3431.5 | 3400 | 3400 | 3368.5 | 3400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -624.4 | PP–RCT S4 | 63 | 370 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 842.787 | ø63 | 48.8 | TR10.03.1943 | 1943 | yes | WS_Studená vnitřní 134 | 0
13828694 | -1.PP_SO-102 | 22.4827 | 0.000804127 | 0.00226021 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JD | -1.PP_SO-102 | 3346.82 | 3324.34 | 3346.82 | 3324.34 | 3346.82 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -675.664 | PP–RCT S4 | 32 | 320 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 22.4827 | ø32 | 24.8 | TR10.03.1944 | 1944 | yes | WS_"Jiný typ" studená vnitřní 1
13828697 | -1.PP_SO-102 | 2546.98 | 0.0019632 | 0.400078 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3425 | 3400 | 3400 | 3375 | 3400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -619.4 | PP–RCT S4 | 50 | 201 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2546.98 | ø50 | 38.8 | TR10.03.1945 | 1945 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13828814 | -1.PP_SO-102 | 32.5312 | 0.000804127 | 0.0032704 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JD | -1.PP_SO-102 | 3356.34 | 3323.81 | 3356.34 | 3323.81 | 3356.34 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -676.187 | PP–RCT S4 | 32 | 258 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 32.5312 | ø32 | 24.8 | TR10.03.1946 | 1946 | yes | WS_Cirkulace vnitřní 9
13828817 | -1.PP_SO-102 | 1611.65 | 0.00125645 | 0.202526 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 3420 | 3400 | 3400 | 3380 | 3400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -615.5 | PP–RCT S4 | 40 | 251 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1611.65 | ø40 | 31 | TR10.03.1947 | 1947 | yes | WS_Cirkulace vnitřní 9 | 0
13828945 | -1.PP_SO-102 | 10.6812 | 0.00125645 | 0.00134225 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JD | -1.PP_SO-102 | 3337.67 | 3326.99 | 3337.67 | 3326.99 | 3337.67 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -673.013 | PP–RCT S4 | 40 | 423 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 10.6812 | ø40 | 31 | TR10.03.1948 | 1948 | yes | WS_Teplá vnitřní 83
13829335 | -1.PP_SO-102 | 10.6812 | 0.00125645 | 0.00134225 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JD | -1.PP_SO-102 | 3337.67 | 3326.99 | 3337.67 | 3326.99 | 3337.67 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -673.013 | PP–RCT S4 | 40 | 484 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 10.6812 | ø40 | 31 | TR10.03.1950 | 1950 | yes | WS_Studená vnitřní 134
13829338 | -1.PP_SO-102 | 1676.84 | 0.00311678 | 0.33188 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3431.5 | 3400 | 3400 | 3368.5 | 3400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -624.4 | PP–RCT S4 | 63 | 475 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1676.84 | ø63 | 48.8 | TR10.03.1951 | 1951 | yes | WS_Studená vnitřní 134 | 0
13830451 | -1.PP_SO-102 | 17.0312 | 0.0004908 | 0.00133763 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 3337.67 | 3320.64 | 3337.67 | 3320.64 | 3337.67 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -679.363 | PP–RCT S4 | 25 | 487 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 17.0312 | ø25 | 19.4 | TR10.03.1952 | 1952 | no | WS_Studená vnitřní 134
13830454 | -1.PP_SO-102 | 1595.81 | 0.00311678 | 0.315844 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3431.5 | 3400 | 3400 | 3368.5 | 3400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -624.4 | PP–RCT S4 | 63 | 337 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1595.81 | ø63 | 48.8 | TR10.03.1953 | 1953 | yes | WS_Studená vnitřní 134 | 0
13830502 | -1.PP_SO-102 | 17.0312 | 0.0004908 | 0.00133763 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 3337.67 | 3320.64 | 3337.67 | 3320.64 | 3337.67 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -679.363 | PP–RCT S4 | 25 | 427 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 17.0312 | ø25 | 19.4 | TR10.03.1954 | 1954 | no | WS_Teplá vnitřní 83
13830505 | -1.PP_SO-102 | 1367.09 | 0.00311678 | 0.270574 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3431.5 | 3400 | 3400 | 3368.5 | 3400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -624.4 | PP–RCT S4 | 63 | 279 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1367.09 | ø63 | 48.8 | TR10.03.1955 | 1955 | yes | WS_Teplá vnitřní 83 | 0
13830841 | -1.PP_SO-102 | 26.975 | 0.0019632 | 0.00423722 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JD | -1.PP_SO-102 | 3360.31 | 3333.34 | 3360.31 | 3333.34 | 3360.31 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -666.662 | PP–RCT S4 | 50 | 425 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 26.975 | ø50 | 38.8 | TR10.03.1956 | 1956 | yes | WS_Teplá vnitřní 83
13831106 | -1.PP_SO-102 | 46.025 | 0.000804127 | 0.00462694 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JD | -1.PP_SO-102 | 3369.84 | 3323.81 | 3369.84 | 3323.81 | 3369.84 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -676.187 | PP–RCT S4 | 32 | 203 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 46.025 | ø32 | 24.8 | TR10.03.1957 | 1957 | yes | WS_Cirkulace vnitřní 9
13831110 | -1.PP_SO-102 | 1855.69 | 0.000804127 | 0.186554 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JD | -1.PP_SO-102 | 3316 | 3300 | 3300 | 3284 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -712.4 | PP–RCT S4 | 32 | 203 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1855.69 | ø32 | 24.8 | TR10.03.1958 | 1958 | yes | WS_Cirkulace vnitřní 9 | 0
13831131 | -1.PP_SO-102 | 26.975 | 0.0019632 | 0.00423722 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JD | -1.PP_SO-102 | 3360.31 | 3333.34 | 3360.31 | 3333.34 | 3360.31 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -666.662 | PP–RCT S4 | 50 | 486 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 26.975 | ø50 | 38.8 | TR10.03.1959 | 1959 | yes | WS_Studená vnitřní 134
13831133 | -1.PP_SO-102 | 2019.48 | 0.0019632 | 0.317219 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JD | -1.PP_SO-102 | 3325 | 3300 | 3300 | 3275 | 3300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -719.4 | PP–RCT S4 | 50 | 486 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2019.48 | ø50 | 38.8 | TR10.03.1960 | 1960 | yes | WS_Studená vnitřní 134 | 0
13831154 | -1.PP_SO-102 | 19.8312 | 0.00125645 | 0.00249207 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JD | -1.PP_SO-102 | 3346.82 | 3326.99 | 3346.82 | 3326.99 | 3346.82 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -673.012 | PP–RCT S4 | 40 | 54 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 19.8312 | ø40 | 31 | TR10.03.1961 | 1961 | yes | WS_"Jiný typ" studená vnitřní 1
13831156 | -1.PP_SO-102 | 2009.34 | 0.00125645 | 0.252501 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JD | -1.PP_SO-102 | 3320 | 3300 | 3300 | 3280 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -715.5 | PP–RCT S4 | 40 | 54 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2009.34 | ø40 | 31 | TR10.03.1962 | 1962 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13831927 | -1.PP_SO-102 | 8059.39 | 0.00311678 | 1.59512 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3381.5 | 3350 | 3350 | 3318.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -674.4 | PP–RCT S4 | 63 | 355 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 8059.39 | ø63 | 48.8 | TR10.03.1963 | 1963 | yes | WS_Studená vnitřní 134 | 0
13831940 | -1.PP_SO-102 | 9100.54 | 0.00125645 | 1.14361 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 3370 | 3350 | 3350 | 3330 | 3350 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -665.5 | PP–RCT S4 | 40 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 9100.54 | ø40 | 31 | TR10.03.1964 | 1964 | yes | WS_Cirkulace vnitřní 9 | 0
13831947 | -1.PP_SO-102 | 6899.6 | 0.00311678 | 1.36557 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2931.5 | 2900 | 2900 | 2868.5 | 2900 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1124.4 | PP–RCT S4 | 63 | 432 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6899.6 | ø63 | 48.8 | TR10.03.1965 | 1965 | yes | WS_Teplá vnitřní 83 | 0
13832144 | -1.PP_SO-102 | 371.125 | 0.00311678 | 0.0734532 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 3310.56 | 3310.56 | 2939.44 | 2939.44 | 2939.44 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1060.56 | PP–RCT S4 | 63 | 432 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 371.125 | ø63 | 48.8 | TR10.03.1966 | 1966 | yes | WS_Teplá vnitřní 83
13832182 | -1.PP_SO-102 | 396.025 | 0.00125645 | 0.049766 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JD | -1.PP_SO-102 | 3323.01 | 3323.01 | 2926.99 | 2926.99 | 2926.99 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1073.01 | PP–RCT S4 | 40 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 396.025 | ø40 | 31 | TR10.03.1967 | 1967 | yes | WS_Cirkulace vnitřní 9
13832219 | -1.PP_SO-102 | 371.125 | 0.00311678 | 0.0734532 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 3310.56 | 3310.56 | 2939.44 | 2939.44 | 2939.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1060.56 | PP–RCT S4 | 63 | 355 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 371.125 | ø63 | 48.8 | TR10.03.1968 | 1968 | yes | WS_Studená vnitřní 134
13832787 | -1.PP_SO-102 | 246.428 | 0.0004908 | 0.0193544 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 1012.5 | 1000 | 1000 | 987.5 | 1000 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -3009.7 | PP–RCT S4 | 25 | 435 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 246.428 | ø25 | 19.4 | TR10.03.1969 | 1969 | no | WS_Teplá vnitřní 83 | 0
13832801 | -1.PP_SO-102 | 122.218 | 0.0004908 | 0.00959898 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 1012.5 | 1000 | 1000 | 987.5 | 1000 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -3009.7 | PP–RCT S4 | 25 | 499 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 122.218 | ø25 | 19.4 | TR10.03.1970 | 1970 | no | WS_Studená vnitřní 134 | 0
13833036 | -1.PP_SO-102 | 439.503 | 0.0004908 | 0.0345185 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 1012.5 | 1000 | 1000 | 987.5 | 1000 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -3009.7 | PP–RCT S4 | 25 | 499 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 439.503 | ø25 | 19.4 | TR10.03.1971 | 1971 | no | WS_Studená vnitřní 134 | 0
13833055 | -1.PP_SO-102 | 386.142 | 0.0004908 | 0.0303275 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 1012.5 | 1000 | 1000 | 987.5 | 1000 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -3009.7 | PP–RCT S4 | 25 | 435 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 386.142 | ø25 | 19.4 | TR10.03.1972 | 1972 | no | WS_Teplá vnitřní 83 | 0
13833109 | -1.PP_SO-102 | 2013.01 | 0.0004908 | 0.158102 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 1012.5 | 1000 | 1000 | 987.5 | 1000 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -3009.7 | PP–RCT S4 | 25 | 437 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2013.01 | ø25 | 19.4 | TR10.03.1973 | 1973 | no | WS_Teplá vnitřní 83 | 0
13833118 | -1.PP_SO-102 | 1140.46 | 0.0004908 | 0.0895717 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 1012.5 | 1000 | 1000 | 987.5 | 1000 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -3009.7 | PP–RCT S4 | 25 | 434 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1140.46 | ø25 | 19.4 | TR10.03.1974 | 1974 | no | WS_Teplá vnitřní 83 | 0
13833138 | -1.PP_SO-102 | 1931.42 | 0.0004908 | 0.151694 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 1012.5 | 1000 | 1000 | 987.5 | 1000 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -3009.7 | PP–RCT S4 | 25 | 498 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1931.42 | ø25 | 19.4 | TR10.03.1975 | 1975 | no | WS_Studená vnitřní 134 | 0
13833145 | -1.PP_SO-102 | 1122.66 | 0.0004908 | 0.0881736 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 1012.5 | 1000 | 1000 | 987.5 | 1000 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -3009.7 | PP–RCT S4 | 25 | 495 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1122.66 | ø25 | 19.4 | TR10.03.1976 | 1976 | no | WS_Studená vnitřní 134 | 0
13833171 | -1.PP_SO-102 | 1858.73 | 0.0004908 | 0.145984 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 2879.36 | 2879.36 | 1020.64 | 1020.64 | 1020.64 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -2979.36 | PP–RCT S4 | 25 | 435 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1858.73 | ø25 | 19.4 | TR10.03.1977 | 1977 | no | WS_Teplá vnitřní 83
13833234 | -1.PP_SO-102 | 1858.73 | 0.0004908 | 0.145984 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 2879.36 | 2879.36 | 1020.64 | 1020.64 | 1020.64 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -2979.36 | PP–RCT S4 | 25 | 499 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1858.73 | ø25 | 19.4 | TR10.03.1978 | 1978 | no | WS_Studená vnitřní 134
13835660 | -1.PP_SO-102 | 1472.02 | 0.0004908 | 0.115612 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 3238.44 | 3225.94 | 3225.94 | 3213.44 | 3225.94 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | -783.762 | PP–RCT S4 | 25 | 208 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1472.02 | ø25 | 19.4 | TR10.03.1979 | 1979 | no | WS_Studená vnitřní 6 | 0
13835699 | -1.PP_SO-102 | 1463 | 0.0004908 | 0.114904 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 3238.09 | 3225.59 | 3225.59 | 3213.09 | 3225.59 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | -784.112 | PP–RCT S4 | 25 | 208 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1463 | ø25 | 19.4 | TR10.03.1980 | 1980 | no | WS_Teplá vnitřní 8 | 0
13835959 | 1.NP_SO-102 | 31589.7 | 0.000314112 | 1.98484 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 510 | 500 | 500 | 490 | 500 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 492.3 | PP–RCT S4 | 20 | 206 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 31589.7 | ø20 | 15.4 | TR10.03.1981 | 1981 | no | WS_Teplá vnitřní 83 | 0 | Identifikační data - Komentáře: Odvodňovací žlábek krytý mřížkou
13835982 | 1.NP_SO-102 | 31529.8 | 0.000314112 | 1.98108 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 510 | 500 | 500 | 490 | 500 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 492.3 | PP–RCT S4 | 20 | 501 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 31529.8 | ø20 | 15.4 | TR10.03.1982 | 1982 | no | WS_Studená vnitřní 134 | 0 | Identifikační data - Komentáře: bruska voda+ odpad
13836076 | -1.PP_SO-102 | 78.725 | 0.0004908 | 0.00618305 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 2912.5 | 2900 | 2900 | 2887.5 | 2900 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1109.7 | PP–RCT S4 | 25 | 441 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 78.725 | ø25 | 19.4 | TR10.03.1983 | 1983 | no | WS_Teplá vnitřní 83 | 0
13836083 | -1.PP_SO-102 | 1554.76 | 0.0004908 | 0.12211 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 4475.39 | 2920.64 | 4475.39 | 2920.64 | 4475.39 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1079.36 | PP–RCT S4 | 25 | 441 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1554.76 | ø25 | 19.4 | TR10.03.1984 | 1984 | no | WS_Teplá vnitřní 83
13836109 | -1.PP_SO-102 | 238.725 | 0.0004908 | 0.0187494 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 2912.5 | 2900 | 2900 | 2887.5 | 2900 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1109.7 | PP–RCT S4 | 25 | 503 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 238.725 | ø25 | 19.4 | TR10.03.1985 | 1985 | no | WS_Studená vnitřní 134 | 0
13836114 | -1.PP_SO-102 | 1554.76 | 0.0004908 | 0.12211 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 4475.39 | 2920.64 | 4475.39 | 2920.64 | 4475.39 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1079.36 | PP–RCT S4 | 25 | 503 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1554.76 | ø25 | 19.4 | TR10.03.1986 | 1986 | no | WS_Studená vnitřní 134
13836405 | -1.PP_SO-102 | 1057.37 | 0.0004908 | 0.0830457 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 2912.5 | 2900 | 2900 | 2887.5 | 2900 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1109.7 | PP–RCT S4 | 25 | 503 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1057.37 | ø25 | 19.4 | TR10.03.1987 | 1987 | no | WS_Studená vnitřní 134 | 0
13836454 | -1.PP_SO-102 | 438.725 | 0.0004908 | 0.0344574 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 2912.5 | 2900 | 2900 | 2887.5 | 2900 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1109.7 | PP–RCT S4 | 25 | 441 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 438.725 | ø25 | 19.4 | TR10.03.1988 | 1988 | no | WS_Teplá vnitřní 83 | 0
13836464 | -1.PP_SO-102 | 986.1 | 0.0004908 | 0.0774481 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 2912.5 | 2900 | 2900 | 2887.5 | 2900 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1109.7 | PP–RCT S4 | 25 | 441 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 986.1 | ø25 | 19.4 | TR10.03.1989 | 1989 | no | WS_Teplá vnitřní 83 | 0
13836650 | 1.NP_SO-102 | 128.253 | 0.000314112 | 0.00805836 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 510 | 500 | 500 | 490 | 500 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 492.3 | PP–RCT S4 | 20 | 206 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 128.253 | ø20 | 15.4 | TR10.03.1990 | 1990 | no | WS_Teplá vnitřní 83 | 0 | Identifikační data - Komentáře: Odvodňovací žlábek krytý mřížkou
13836676 | 1.NP_SO-102 | 90.6936 | 0.000314112 | 0.00569845 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 510 | 500 | 500 | 490 | 500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 492.3 | PP–RCT S4 | 20 | 501 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 90.6936 | ø20 | 15.4 | TR10.03.1991 | 1991 | no | WS_Studená vnitřní 134 | 0 | Identifikační data - Komentáře: bruska voda+ odpad
13836727 | -1.PP_SO-102 | 5128.57 | 0.0004908 | 0.402797 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 2912.5 | 2900 | 2900 | 2887.5 | 2900 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1109.7 | PP–RCT S4 | 25 | 499 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5128.57 | ø25 | 19.4 | TR10.03.1992 | 1992 | no | WS_Studená vnitřní 134 | 0
13836748 | -1.PP_SO-102 | 4944.44 | 0.0004908 | 0.388336 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 2912.5 | 2900 | 2900 | 2887.5 | 2900 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1109.7 | PP–RCT S4 | 25 | 435 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4944.44 | ø25 | 19.4 | TR10.03.1993 | 1993 | no | WS_Teplá vnitřní 83 | 0
13836769 | -1.PP_SO-102 | 1910.33 | 0.0004908 | 0.150037 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 2912.5 | 2900 | 2900 | 2887.5 | 2900 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1109.7 | PP–RCT S4 | 25 | 442 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1910.33 | ø25 | 19.4 | TR10.03.1994 | 1994 | no | WS_Teplá vnitřní 83 | 0
13836790 | -1.PP_SO-102 | 2207.79 | 0.0004908 | 0.173399 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 2912.5 | 2900 | 2900 | 2887.5 | 2900 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1109.7 | PP–RCT S4 | 25 | 504 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2207.79 | ø25 | 19.4 | TR10.03.1995 | 1995 | no | WS_Studená vnitřní 134 | 0
13837014 | 1.NP_SO-102 | 1229.17 | 0.0004908 | 0.0965386 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | 1.NP_SO-102 | 475.394 | -753.774 | 475.394 | -753.774 | 475.394 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | -753.774 | PP–RCT S4 | 25 | 208 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1229.17 | ø25 | 19.4 | TR10.03.1996 | 1996 | no | WS_Teplá vnitřní 8
13837016 | -1.PP_SO-102 | 56.0072 | 0.0004908 | 0.0043988 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 3238.09 | 3225.59 | 3225.59 | 3213.09 | 3225.59 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | -784.112 | PP–RCT S4 | 25 | 208 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 56.0072 | ø25 | 19.4 | TR10.03.1997 | 1997 | no | WS_Teplá vnitřní 8 | 0
13837035 | 1.NP_SO-102 | 1228.82 | 0.0004908 | 0.0965112 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | 1.NP_SO-102 | 475.394 | -753.425 | 475.394 | -753.425 | 475.394 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | -753.425 | PP–RCT S4 | 25 | 208 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1228.82 | ø25 | 19.4 | TR10.03.1998 | 1998 | no | WS_Studená vnitřní 6
13837037 | -1.PP_SO-102 | 246.491 | 0.0004908 | 0.0193594 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | -1.PP_SO-102 | 3238.44 | 3225.94 | 3225.94 | 3213.44 | 3225.94 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | -783.762 | PP–RCT S4 | 25 | 208 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 246.491 | ø25 | 19.4 | TR10.03.1999 | 1999 | no | WS_Studená vnitřní 6 | 0
13839350 | -1.PP_SO-102 | 1649.98 | 0.00311678 | 0.326565 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2431.5 | 2400 | 2400 | 2368.5 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1624.4 | PP–RCT S4 | 63 | 366 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1649.98 | ø63 | 48.8 | TR10.03.2006 | 2006 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13839369 | -1.PP_SO-102 | 507.074 | 0.0019632 | 0.079651 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 2435 | 2410 | 2410 | 2385 | 2410 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1609.4 | PP–RCT S4 | 50 | 444 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 507.074 | ø50 | 38.8 | TR10.03.2007 | 2007 | yes | WS_Teplá vnitřní 83 | 0
13839798 | -1.PP_SO-102 | 319.49 | 0.00311678 | 0.0632336 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2431.5 | 2400 | 2400 | 2368.5 | 2400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1624.4 | PP–RCT S4 | 63 | 506 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 319.49 | ø63 | 48.8 | TR10.03.2009 | 2009 | yes | WS_Studená vnitřní 134 | 0
13839806 | -1.PP_SO-102 | 1348.9 | 0.00311678 | 0.266975 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2431.5 | 2400 | 2400 | 2368.5 | 2400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1624.4 | PP–RCT S4 | 63 | 468 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1348.9 | ø63 | 48.8 | TR10.03.2010 | 2010 | yes | WS_Studená vnitřní 134 | 0
13839885 | -1.PP_SO-102 | 438.627 | 0.000804127 | 0.0440956 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 2416 | 2400 | 2400 | 2384 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1612.4 | PP–RCT S4 | 32 | 261 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 438.627 | ø32 | 24.8 | TR10.03.2011 | 2011 | yes | WS_Cirkulace vnitřní 9 | 0
13839895 | -1.PP_SO-102 | 1379.28 | 0.000804127 | 0.13866 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 2416 | 2400 | 2400 | 2384 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1612.4 | PP–RCT S4 | 32 | 247 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1379.28 | ø32 | 24.8 | TR10.03.2012 | 2012 | yes | WS_Cirkulace vnitřní 9 | 0
13840174 | -1.PP_SO-102 | 323.325 | 0.0019632 | 0.0507878 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JD | -1.PP_SO-102 | 2766.66 | 2766.66 | 2443.34 | 2443.34 | 2443.34 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1556.66 | PP–RCT S4 | 50 | 444 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 323.325 | ø50 | 38.8 | TR10.03.2014 | 2014 | yes | WS_Teplá vnitřní 83
13840209 | -1.PP_SO-102 | 352.375 | 0.000804127 | 0.0354246 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JD | -1.PP_SO-102 | 2776.19 | 2776.19 | 2423.81 | 2423.81 | 2423.81 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1576.19 | PP–RCT S4 | 32 | 261 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 352.375 | ø32 | 24.8 | TR10.03.2015 | 2015 | yes | WS_Cirkulace vnitřní 9
13840246 | -1.PP_SO-102 | 321.125 | 0.00311678 | 0.0635572 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 2760.56 | 2760.56 | 2439.44 | 2439.44 | 2439.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1560.56 | PP–RCT S4 | 63 | 506 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 321.125 | ø63 | 48.8 | TR10.03.2016 | 2016 | yes | WS_Studená vnitřní 134
13840278 | -1.PP_SO-102 | 121.125 | 0.00311678 | 0.0239731 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 2560.56 | 2560.56 | 2439.44 | 2439.44 | 2439.44 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1560.56 | PP–RCT S4 | 63 | 366 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 121.125 | ø63 | 48.8 | TR10.03.2017 | 2017 | yes | WS_"Jiný typ" studená vnitřní 1
13916163 | -1.PP_SO-102 | 614.775 | 0.00311678 | 0.121676 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 3254.21 | 2639.44 | 3254.21 | 2639.44 | 3254.21 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1360.56 | PP–RCT S4 | 63 | 212 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 614.775 | ø63 | 48.8 | TR10.03.2022 | 2022 | yes | WS_"Jiný typ" studená vnitřní 1
13916166 | -1.PP_SO-102 | 4315.65 | 0.00311678 | 0.854155 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3331.5 | 3300 | 3300 | 3268.5 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -724.4 | PP–RCT S4 | 63 | 205 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4315.65 | ø63 | 48.8 | TR10.03.2023 | 2023 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13975766 | 1.NP_SO-102 | 3850.94 | 0.000314112 | 0.241962 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3337.23 | PP–RCT S4 | 20 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3850.94 | ø20 | 15.4 | TR10.03.2024 | 2024 | yes | WS_Teplá vnitřní 8 | 0
13975813 | 1.NP_SO-102 | 3948.41 | 0.000314112 | 0.248086 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3277.23 | PP–RCT S4 | 20 | 209 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3948.41 | ø20 | 15.4 | TR10.03.2025 | 2025 | yes | WS_Studená vnitřní 6 | 0
13975847 | 1.NP_SO-102 | 4038.72 | 0.0004908 | 0.317201 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3257.43 | 3244.93 | 3244.93 | 3232.43 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 3235.23 | PP–RCT S4 | 25 | 86 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4038.72 | ø25 | 19.4 | TR10.03.2026 | 2026 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 0
13976059 | 1.NP_SO-102 | 510.001 | 0.000314112 | 0.0320443 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JD | 1.NP_SO-102 | 3327.46 | 3327.46 | 2817.46 | 2817.46 | 2817.46 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 2817.46 | PP–RCT S4 | 20 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 510.001 | ø20 | 15.4 | TR10.03.2027 | 2027 |  | WS_Teplá vnitřní 8
13976104 | 1.NP_SO-102 | 450.001 | 0.000314112 | 0.0282744 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JD | 1.NP_SO-102 | 3267.46 | 3267.46 | 2817.46 | 2817.46 | 2817.46 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 2817.46 | PP–RCT S4 | 20 | 209 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 450.001 | ø20 | 15.4 | TR10.03.2028 | 2028 |  | WS_Studená vnitřní 6
13976143 | 1.NP_SO-102 | 403.651 | 0.0004908 | 0.0317026 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | 1.NP_SO-102 | 3224.29 | 3224.29 | 2820.64 | 2820.64 | 2820.64 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 2820.64 | PP–RCT S4 | 25 | 86 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 403.651 | ø25 | 19.4 | TR10.03.2029 | 2029 |  | WS_"ŠEDÁ" studená vnitřní 2
13976196 | 1.NP_SO-102 | 510.001 | 0.000314112 | 0.0320443 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JD | 1.NP_SO-102 | 3327.46 | 2817.46 | 3327.46 | 2817.46 | 3327.46 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 2817.46 | PP–RCT S4 | 20 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 510.001 | ø20 | 15.4 | TR10.03.2030 | 2030 |  | WS_Teplá vnitřní 8
13976249 | 1.NP_SO-102 | 450.001 | 0.000314112 | 0.0282744 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JD | 1.NP_SO-102 | 3267.46 | 2817.46 | 3267.46 | 2817.46 | 3267.46 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 2817.46 | PP–RCT S4 | 20 | 209 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 450.001 | ø20 | 15.4 | TR10.03.2031 | 2031 |  | WS_Studená vnitřní 6
13976302 | 1.NP_SO-102 | 403.651 | 0.0004908 | 0.0317026 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | 1.NP_SO-102 | 3224.29 | 3224.29 | 2820.64 | 2820.64 | 2820.64 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 2820.64 | PP–RCT S4 | 25 | 86 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 403.651 | ø25 | 19.4 | TR10.03.2032 | 2032 |  | WS_"ŠEDÁ" studená vnitřní 2
13986287 | -1.PP_SO-102 | 3450.78 | 0.0044172 | 0.81307 | ø75 mm | 0 | Laminární | 0 | 0.000171821 | JB | -1.PP_SO-102 | 3263.94 | 3226.44 | 3226.44 | 3188.94 | 3226.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -802.663 | PP–RCT S4 | 75 | 316 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3450.78 | ø75 | 58.2 | TR10.03.2049 | 2049 | yes | WS_Studená vnitřní 134 | 0
13986344 | -1.PP_SO-102 | 3339.45 | 0.00311678 | 0.660944 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3331.5 | 3300 | 3300 | 3268.5 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -724.4 | PP–RCT S4 | 63 | 368 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3339.45 | ø63 | 48.8 | TR10.03.2050 | 2050 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13986431 | -1.PP_SO-102 | 324.494 | 0.00311678 | 0.064224 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JD | -1.PP_SO-102 | 3260.56 | 3260.56 | 2936.07 | 2936.07 | 2936.07 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1063.93 | PP–RCT S4 | 63 | 368 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 324.494 | ø63 | 48.8 | TR10.03.2051 | 2051 | yes | WS_"Jiný typ" studená vnitřní 1
13986460 | -1.PP_SO-102 | 238.931 | 0.0044172 | 0.0562968 | ø75 mm | 0 | Laminární | 0 | 0.000171821 | JD | -1.PP_SO-102 | 3181 | 2942.07 | 3181 | 2942.07 | 3181 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1057.93 | PP–RCT S4 | 75 | 316 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 238.931 | ø75 | 58.2 | TR10.03.2052 | 2052 | yes | WS_Studená vnitřní 134
13986603 | -1.PP_SO-102 | 79.8248 | 0.0044172 | 0.0188083 | ø75 mm | 0 | Laminární | 0 | 0.000171821 | JD | -1.PP_SO-102 | 537.5 | 500 | 500 | 462.5 | 500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -3529.1 | PP–RCT S4 | 75 | 510 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 79.8248 | ø75 | 58.2 | TR10.03.2054 | 2054 | yes | WS_Studená vnitřní 134 | 0
13987614 | -1.PP_SO-102 | 96.9766 | 0.0044172 | 0.0228496 | ø75 mm | 0 | Laminární | 0 | 0.000171821 | JD | -1.PP_SO-102 | 1559.05 | 1521.55 | 1521.55 | 1484.05 | 1521.55 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -2507.55 | PP–RCT S4 | 75 | 511 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 96.9766 | ø75 | 58.2 | TR10.03.2055 | 2055 | yes | WS_Studená vnitřní 134 | 0
13987623 | -1.PP_SO-102 | 1277.85 | 0.0044172 | 0.301087 | ø75 mm | 0 | Laminární | 0 | 0.000171821 | JB | -1.PP_SO-102 | 2851.19 | 1573.34 | 2851.19 | 1573.34 | 2851.19 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -2426.66 | PP–RCT S4 | 75 | 316 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1277.85 | ø75 | 58.2 | TR10.03.2056 | 2056 | yes | WS_Studená vnitřní 134
13987723 | -1.PP_SO-102 | 98.9531 | 0.0044172 | 0.0233153 | ø75 mm | 0 | Laminární | 0 | 0.000171821 | JD | -1.PP_SO-102 | 1559.05 | 1521.55 | 1521.55 | 1484.05 | 1521.55 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -2507.55 | PP–RCT S4 | 75 | 511 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 98.9531 | ø75 | 58.2 | TR10.03.2057 | 2057 | yes | WS_Studená vnitřní 134 | 0
13991936 | -1.PP_SO-102 | 96.9766 | 0.0044172 | 0.0228496 | ø75 mm | 0 | Laminární | 0 | 0.000171821 | JD | -1.PP_SO-102 | 1559.05 | 1521.55 | 1521.55 | 1484.05 | 1521.55 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -2507.55 | PP–RCT S4 | 75 | 511 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 96.9766 | ø75 | 58.2 | TR10.03.2058 | 2058 | yes | WS_Studená vnitřní 134 | 0
14017273 | 2.NP_SO-102 | 4894.12 | 0.0004908 | 0.384383 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3352.5 | 3340 | 3340 | 3327.5 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7330.3 | PP–RCT S4 | 25 | 513 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4894.12 | ø25 | 19.4 | TR10.03.2173 | 2173 | no | WS_Studená vnitřní 134 | 0
14017337 | 2.NP_SO-102 | 4814.12 | 0.0004908 | 0.3781 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3352.5 | 3340 | 3340 | 3327.5 | 3340 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7330.3 | PP–RCT S4 | 25 | 447 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4814.12 | ø25 | 19.4 | TR10.03.2174 | 2174 | no | WS_Teplá vnitřní 83 | 0
14017383 | 2.NP_SO-102 | 520.156 | 0.0004908 | 0.040853 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3412.5 | 3400 | 3400 | 3387.5 | 3400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7390.3 | PP–RCT S4 | 25 | 447 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 520.156 | ø25 | 19.4 | TR10.03.2175 | 2175 | no | WS_Teplá vnitřní 83 | 0
14017429 | 2.NP_SO-102 | 520.156 | 0.0004908 | 0.040853 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3412.5 | 3400 | 3400 | 3387.5 | 3400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7390.3 | PP–RCT S4 | 25 | 513 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 520.156 | ø25 | 19.4 | TR10.03.2176 | 2176 | no | WS_Studená vnitřní 134 | 0
14017483 | 2.NP_SO-102 | 18.725 | 0.0004908 | 0.00147066 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | 2.NP_SO-102 | 3379.36 | 3379.36 | 3360.64 | 3360.64 | 3360.64 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7360.64 | PP–RCT S4 | 25 | 513 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 18.725 | ø25 | 19.4 | TR10.03.2177 | 2177 |  | WS_Studená vnitřní 134
14017512 | 2.NP_SO-102 | 18.725 | 0.0004908 | 0.00147066 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | 2.NP_SO-102 | 3379.36 | 3379.36 | 3360.64 | 3360.64 | 3360.64 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7360.64 | PP–RCT S4 | 25 | 447 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 18.725 | ø25 | 19.4 | TR10.03.2178 | 2178 |  | WS_Teplá vnitřní 83
14017543 | 2.NP_SO-102 | 18.725 | 0.0004908 | 0.00147066 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | 2.NP_SO-102 | 3379.36 | 3379.36 | 3360.64 | 3360.64 | 3360.64 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7360.64 | PP–RCT S4 | 25 | 447 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 18.725 | ø25 | 19.4 | TR10.03.2179 | 2179 |  | WS_Teplá vnitřní 83
14017578 | 2.NP_SO-102 | 18.725 | 0.0004908 | 0.00147066 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | 2.NP_SO-102 | 3379.36 | 3379.36 | 3360.64 | 3360.64 | 3360.64 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7360.64 | PP–RCT S4 | 25 | 513 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 18.725 | ø25 | 19.4 | TR10.03.2180 | 2180 |  | WS_Studená vnitřní 134
14024838 | 2.NP_SO-102 | 1906.5 | 0.00125645 | 0.239578 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 2.NP_SO-102 | 2423.74 | 2403.74 | 2403.74 | 2383.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6388.24 | PP–RCT S4 | 40 | 514 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1906.5 | ø40 | 31 | TR10.03.2197 | 2197 | no | WS_Studená vnitřní 134 | 0
14024857 | 2.NP_SO-102 | 597.66 | 0.000804127 | 0.0600834 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2016 | 2000 | 2000 | 1984 | 2000 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | 5987.6 | PP–RCT S4 | 32 | 267 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 597.66 | ø32 | 24.8 | TR10.03.2198 | 2198 | no | WS_Cirkulace vnitřní 9 | 0
14024869 | 2.NP_SO-102 | 676.681 | 0.00125645 | 0.0850343 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 2.NP_SO-102 | 2020 | 2000 | 2000 | 1980 | 2000 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5984.5 | PP–RCT S4 | 40 | 346 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 676.681 | ø40 | 31 | TR10.03.2199 | 2199 | no | WS_Teplá vnitřní 83 | 0
14024895 | 2.NP_SO-102 | 781.677 | 0.0004908 | 0.0613928 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2012.5 | 2000 | 2000 | 1987.5 | 2000 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5990.3 | PP–RCT S4 | 25 | 192 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 781.677 | ø25 | 19.4 | TR10.03.2200 | 2200 | no | WS_"Jiný typ" studená vnitřní 1 | 0
14024945 | 2.NP_SO-102 | 346.025 | 0.00125645 | 0.0434828 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JD | 2.NP_SO-102 | 2376.75 | 2030.73 | 2376.75 | 2030.73 | 2376.75 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6030.73 | PP–RCT S4 | 40 | 514 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 346.025 | ø40 | 31 | TR10.03.2201 | 2201 |  | WS_Studená vnitřní 134
14024982 | 2.NP_SO-102 | 352.375 | 0.000804127 | 0.0354246 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JD | 2.NP_SO-102 | 2376.19 | 2023.81 | 2376.19 | 2023.81 | 2376.19 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | 6023.81 | PP–RCT S4 | 32 | 267 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 352.375 | ø32 | 24.8 | TR10.03.2202 | 2202 |  | WS_Cirkulace vnitřní 9
14025018 | 2.NP_SO-102 | 346.025 | 0.00125645 | 0.0434828 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JD | 2.NP_SO-102 | 2373.01 | 2026.99 | 2373.01 | 2026.99 | 2373.01 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6026.99 | PP–RCT S4 | 40 | 346 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 346.025 | ø40 | 31 | TR10.03.2203 | 2203 |  | WS_Teplá vnitřní 83
14025056 | 2.NP_SO-102 | 358.725 | 0.0004908 | 0.0281742 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JD | 2.NP_SO-102 | 2379.36 | 2379.36 | 2020.64 | 2020.64 | 2020.64 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 6020.64 | PP–RCT S4 | 25 | 192 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 358.725 | ø25 | 19.4 | TR10.03.2204 | 2204 |  | WS_"Jiný typ" studená vnitřní 1
14037121 | 3.NP_SO-102 | 262.538 | 0.000314112 | 0.0164957 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JD | 3.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11342.3 | PP–RCT S4 | 20 | 389 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 262.538 | ø20 | 15.4 | TR10.03.2226 | 2226 |  | WS_Studená vnitřní 134 | 0
