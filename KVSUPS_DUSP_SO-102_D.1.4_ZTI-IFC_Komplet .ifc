Properties of the parts of a building model (IFC4), part 31 of 60

# IfcPipeFitting: M_Koleno, obecné:Standardní (1248)
Name (M_Koleno, obecné:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm) | Group
13099765 | 4.NP_SO-102 | ø78 mm-ø78 mm | 4.NP_SO-102 | 3372.59 | Fáze 2 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 17 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0801 | 0801 | yes | 46.9375 | 40.5875 | SW_Odvětrání kanalizace 17 | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S16
13099792 | 4.NP_SO-102 | ø78 mm-ø78 mm | 4.NP_SO-102 | 3358.97 | Fáze 2 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 17 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0802 | 0802 | yes | 46.9375 | 40.5875 | SW_Odvětrání kanalizace 17 | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: S16
13099975 | 3.NP_SO-102 | ø78 mm-ø78 mm | 3.NP_SO-102 | 3278.04 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0803 | 0803 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13100058 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 3368.22 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000381559 | 46.9375 | 90 | ø78-ø78 | 32.47 | 81.175 | TT01.02.0804 | 0804 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Identifikační data - Komentáře: S17
13100062 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 3368.22 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000381559 | 46.9375 | 90 | ø78-ø78 | 32.47 | 81.175 | TT01.02.0805 | 0805 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Identifikační data - Komentáře: S17
13100943 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 3372.06 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0806 | 0806 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13101940 | 4.NP_SO-102 | ø78 mm-ø78 mm | 4.NP_SO-102 | 3342.43 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 9 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0808 | 0808 | yes | 46.9375 | 40.5875 | SW_Odvětrání kanalizace 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13102412 | 4.NP_SO-102 | ø78 mm-ø78 mm | 4.NP_SO-102 | 3285.09 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 8 | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0810 | 0810 | yes | 46.9375 | 40.5875 | SW_Odvětrání kanalizace 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13102970 | -1.PP_SO-102 | ø75 mm-ø75 mm | -1.PP_SO-102 | 805.05 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 37.5 | 75 | 0.000342568 | 45.4375 | 90 | ø75-ø75 | 31.27 | 78.175 | TT01.02.0811 | 0811 | yes | 45.4375 | 39.0875 | WS_Požární nezavodněný 1
13144276 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0812 | 0812 | no | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13144286 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0813 | 0813 | no | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13144624 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -1901.51 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00144425 | 36.4249 | 45 | ø160-ø160 | 27.0357 | 163.175 | TT01.02.0815 | 0815 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3
13144760 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -2334.22 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00144395 | 36.4164 | 44.9905 | ø160-ø160 | 27.0294 | 163.175 | TT01.02.0817 | 0817 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3
13145028 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -3493.21 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00144395 | 36.4164 | 44.9905 | ø160-ø160 | 27.0294 | 163.175 | TT01.02.0818 | 0818 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3 | Mechanické – tok - Tlaková ztráta: 0 Pa
13145069 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -3412.9 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00144395 | 36.4164 | 44.9905 | ø160-ø160 | 27.0294 | 163.175 | TT01.02.0819 | 0819 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3
13150550 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -3696.56 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000167598 | 8.37946 | 15.1675 | ø110-ø110 | 6.02722 | 113.175 | TT01.02.0820 | 0820 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4
13150590 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -3499.5 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00144395 | 36.4164 | 44.9905 | ø160-ø160 | 27.0294 | 163.175 | TT01.02.0821 | 0821 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3 | Mechanické – tok - Tlaková ztráta: 0 Pa
13150694 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -3656.13 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000154938 | 7.73985 | 14.0217 | ø110-ø110 | 5.56716 | 113.175 | TT01.02.0823 | 0823 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4
13152114 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -3107.32 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00144425 | 36.4249 | 45 | ø160-ø160 | 27.0357 | 163.175 | TT01.02.0824 | 0824 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3
13152192 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -3396.67 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00140748 | 35.399 | 43.8542 | ø160-ø160 | 26.2743 | 163.175 | TT01.02.0827 | 0827 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3
13152861 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -3572.83 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.000237017 | 5.67511 | 7.385 | ø160-ø160 | 4.21224 | 163.175 | TT01.02.0830 | 0830 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3 | Mechanické – tok - Tlaková ztráta: 0 Pa
13152865 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -3630.56 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.000273789 | 6.55863 | 8.53077 | ø160-ø160 | 4.86802 | 163.175 | TT01.02.0831 | 0831 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3 | Mechanické – tok - Tlaková ztráta: 0 Pa
13152920 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -3343.32 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0832 | 0832 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4
13152924 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -3596.02 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.0833 | 0833 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4
13153278 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -2151.1 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.0834 | 0834 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4
13153311 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -2141.54 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.0836 | 0836 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4
13153499 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -1916.2 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0838 | 0838 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4
13153503 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -2113.35 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.0839 | 0839 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4
13153529 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -1917.76 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0840 | 0840 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4
13153533 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -2113.48 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.0841 | 0841 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 4
13153771 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -2113.21 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00144425 | 36.4249 | 45 | ø160-ø160 | 27.0357 | 163.175 | TT01.02.0842 | 0842 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3
13154012 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -2253.21 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00144425 | 36.4249 | 45 | ø160-ø160 | 27.0357 | 163.175 | TT01.02.0845 | 0845 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3
13154098 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -2479.16 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00140748 | 35.399 | 43.8542 | ø160-ø160 | 26.2743 | 163.175 | TT01.02.0847 | 0847 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3
13154214 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -1999.16 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00144425 | 36.4249 | 45 | ø160-ø160 | 27.0357 | 163.175 | TT01.02.0848 | 0848 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3
13154295 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0849 | 0849 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13154299 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0850 | 0850 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13154307 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0851 | 0851 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13154311 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0852 | 0852 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13154507 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0860 | 0860 | no | 20.6375 | 14.2875 | WS_"ŠEDÁ" studená vnitřní 2
13155695 | -1.PP_SO-102 | ø78 mm-ø78 mm | -1.PP_SO-102 | 430.064 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 39 | 78 | 0.000374273 | 45.5505 | 88.2816 | ø78-ø78 | 31.5105 | 81.175 | TT01.02.0862 | 0862 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 3
13155834 | -1.PP_SO-102 | ø78 mm-ø78 mm | -1.PP_SO-102 | 351.499 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 39 | 78 | 0.000183492 | 18.6226 | 43.2816 | ø78-ø78 | 12.8826 | 81.175 | TT01.02.0863 | 0863 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 3
13156466 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -1100 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0866 | 0866 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 16
13156498 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -1100 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0867 | 0867 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 16
13156735 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 3000 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0869 | 0869 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
13156750 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 3000 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0870 | 0870 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
13157399 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -2545.26 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00144395 | 36.4164 | 44.9905 | ø160-ø160 | 27.0294 | 163.175 | TT01.02.0873 | 0873 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3
13157459 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -2530.62 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00140748 | 35.399 | 43.8542 | ø160-ø160 | 26.2743 | 163.175 | TT01.02.0874 | 0874 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3
13157463 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -2299.01 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00144425 | 36.4249 | 45 | ø160-ø160 | 27.0357 | 163.175 | TT01.02.0875 | 0875 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3
13157481 | -1.PP_SO-102 | ø42 mm-ø42 mm | -1.PP_SO-102 | 2410 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 21 | 42 | 0.0000728541 | 28.9375 | 90 | ø42-ø42 | 18.07 | 45.175 | TT01.02.0876 | 0876 | yes | 28.9375 | 22.5875 | WS_Požární zavodněný 1
13157489 | -1.PP_SO-102 | ø35 mm-ø35 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 17.5 | 35 | 0.000045733 | 25.4375 | 90 | ø35-ø35 | 15.27 | 38.175 | TT01.02.0877 | 0877 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 1
13157507 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0879 | 0879 | yes | 23.8125 | 17.4625 | WS_Požární zavodněný 1
13161605 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -3137.21 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00285176 | 86.1963 | 88.8542 | ø160-ø160 | 63.9777 | 163.175 | TT01.02.0883 | 0883 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3
13165276 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -1814.34 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00144395 | 36.4164 | 44.9905 | ø160-ø160 | 27.0294 | 163.175 | TT01.02.0887 | 0887 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3 | Mechanické – tok - Tlaková ztráta: 0 Pa
13165347 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -1246.83 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00144425 | 36.4249 | 45 | ø160-ø160 | 27.0357 | 163.175 | TT01.02.0888 | 0888 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3 | Mechanické – tok - Tlaková ztráta: 0 Pa
13165351 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -1757.97 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00140748 | 35.399 | 43.8542 | ø160-ø160 | 26.2743 | 163.175 | TT01.02.0889 | 0889 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3 | Mechanické – tok - Tlaková ztráta: 0 Pa
13168930 | -1.PP_SO-102 | ø28 mm-ø28 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0890 | 0890 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13169174 | -1.PP_SO-102 | ø35 mm-ø35 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 17.5 | 35 | 0.000045733 | 25.4375 | 90 | ø35-ø35 | 15.27 | 38.175 | TT01.02.0893 | 0893 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 3
13169348 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3225.24 | Fáze 2 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0895 | 0895 | yes | 20.6375 | 14.2875 | WS_Požární zavodněný 3
13169582 | -1.PP_SO-102 | ø35 mm-ø35 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 17.5 | 35 | 0.000045733 | 25.4375 | 90 | ø35-ø35 | 15.27 | 38.175 | TT01.02.0896 | 0896 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 3
13169584 | -1.PP_SO-102 | ø35 mm-ø35 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 17.5 | 35 | 0.000045733 | 25.4375 | 90 | ø35-ø35 | 15.27 | 38.175 | TT01.02.0897 | 0897 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 3
13169649 | 4.NP_SO-102 | ø28 mm-ø28 mm | 4.NP_SO-102 | 1267.04 | Fáze 2 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0899 | 0899 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 3
13169665 | 4.NP_SO-102 | ø28 mm-ø28 mm | 4.NP_SO-102 | 1267.04 | Fáze 2 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0900 | 0900 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 3
13169669 | 4.NP_SO-102 | ø28 mm-ø28 mm | 4.NP_SO-102 | 1267.04 | Fáze 2 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0901 | 0901 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 3
13169730 | 3.NP_SO-102 | ø28 mm-ø28 mm | 3.NP_SO-102 | 3366.44 | Fáze 2 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0903 | 0903 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 3
13169734 | 3.NP_SO-102 | ø28 mm-ø28 mm | 3.NP_SO-102 | 3366.44 | Fáze 2 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0904 | 0904 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 3
13169850 | 2.NP_SO-102 | ø28 mm-ø28 mm | 2.NP_SO-102 | 3177.41 | Fáze 2 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0906 | 0906 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 3
13169854 | 2.NP_SO-102 | ø28 mm-ø28 mm | 2.NP_SO-102 | 3177.41 | Fáze 2 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0907 | 0907 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 3
13169998 | 1.NP_SO-102 | ø28 mm-ø28 mm | 1.NP_SO-102 | 3200 | Fáze 2 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0909 | 0909 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 3
13170145 | 1.NP_SO-102 | ø28 mm-ø28 mm | 1.NP_SO-102 | 3200 | Fáze 2 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0911 | 0911 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 3
13170149 | 1.NP_SO-102 | ø28 mm-ø28 mm | 1.NP_SO-102 | 3200 | Fáze 2 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.0912 | 0912 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 3
13170643 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2810 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0914 | 0914 | yes | 62.9375 | 56.5875 | SW_Odvětrání kanalizace 16
13170678 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | 3110 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 67.5 | 135 | 0.00177682 | 75.4375 | 90 | ø135-ø135 | 55.27 | 138.175 | TT01.02.0915 | 0915 | yes | 75.4375 | 69.0875 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
13181847 | 4.NP_SO-102 | ø110 mm-ø110 mm | 4.NP_SO-102 | 3250 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0939 | 0939 | no | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13181859 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3250 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.000155246 | 35.9375 | 90 | ø56-ø56 | 23.67 | 59.175 | TT01.02.0940 | 0940 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13182003 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3250 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.000155246 | 35.9375 | 90 | ø56-ø56 | 23.67 | 59.175 | TT01.02.0941 | 0941 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13182054 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3250 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.0000776221 | 14.8858 | 45 | ø56-ø56 | 9.80444 | 59.175 | TT01.02.0943 | 0943 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13182088 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3250 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.000155246 | 35.9375 | 90 | ø56-ø56 | 23.67 | 59.175 | TT01.02.0944 | 0944 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13237078 | 4.NP_SO-102 | ø110 mm-ø110 mm | 4.NP_SO-102 | 3250 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0951 | 0951 | no | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13237199 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3250 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.000155246 | 35.9375 | 90 | ø56-ø56 | 23.67 | 59.175 | TT01.02.0952 | 0952 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13237283 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3250 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.000155246 | 35.9375 | 90 | ø56-ø56 | 23.67 | 59.175 | TT01.02.0953 | 0953 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13237287 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3250 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.000155246 | 35.9375 | 90 | ø56-ø56 | 23.67 | 59.175 | TT01.02.0954 | 0954 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13237325 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3250 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.0000776221 | 14.8858 | 45 | ø56-ø56 | 9.80444 | 59.175 | TT01.02.0957 | 0957 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13237628 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 3093.64 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.00049722 | 26.068 | 44.9976 | ø110-ø110 | 18.7503 | 113.175 | TT01.02.0959 | 0959 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13237648 | 1.NP_SO-102 | ø125 mm-ø125 mm | 1.NP_SO-102 | 2953.12 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000746655 | 29.5886 | 44.9976 | ø125-ø125 | 21.5668 | 130.175 | TT01.02.0960 | 0960 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13237758 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 2964.18 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.00049722 | 26.068 | 44.9976 | ø110-ø110 | 18.7503 | 113.175 | TT01.02.0962 | 0962 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239165 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3285.94 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.000155246 | 35.9375 | 90 | ø56-ø56 | 23.67 | 59.175 | TT01.02.0965 | 0965 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239233 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3285.94 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.0000776221 | 14.8858 | 45 | ø56-ø56 | 9.80444 | 59.175 | TT01.02.0966 | 0966 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239270 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3285.94 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.000155246 | 35.9375 | 90 | ø56-ø56 | 23.67 | 59.175 | TT01.02.0968 | 0968 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239386 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3285.94 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.0000776221 | 14.8858 | 45 | ø56-ø56 | 9.80444 | 59.175 | TT01.02.0969 | 0969 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239414 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3215.94 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.0000776221 | 14.8858 | 45 | ø56-ø56 | 9.80444 | 59.175 | TT01.02.0970 | 0970 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239501 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3285.94 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.000155246 | 35.9375 | 90 | ø56-ø56 | 23.67 | 59.175 | TT01.02.0971 | 0971 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239505 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3285.94 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.000155246 | 35.9375 | 90 | ø56-ø56 | 23.67 | 59.175 | TT01.02.0972 | 0972 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239508 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3285.94 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.000155246 | 35.9375 | 90 | ø56-ø56 | 23.67 | 59.175 | TT01.02.0973 | 0973 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239512 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3285.94 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.000155246 | 35.9375 | 90 | ø56-ø56 | 23.67 | 59.175 | TT01.02.0974 | 0974 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239610 | 2.NP_SO-102 | ø110 mm-ø110 mm | 2.NP_SO-102 | 3246.44 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0975 | 0975 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239622 | 2.NP_SO-102 | ø110 mm-ø110 mm | 2.NP_SO-102 | 3246.44 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0976 | 0976 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239671 | 2.NP_SO-102 | ø110 mm-ø110 mm | 2.NP_SO-102 | 3246.44 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0977 | 0977 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13239903 | -1.PP_SO-102 | ø315 mm-ø315 mm | -1.PP_SO-102 | -3724.08 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 157.5 | 315 | 0.0206615 | 165.437 | 90 | ø315-ø315 | 127.27 | 318.175 | TT01.02.0979 | 0979 | yes | 165.438 | 159.088 | SW_Deště vnitřní podtlak 4
13241247 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 2885.31 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000746694 | 29.5904 | 45 | ø125-ø125 | 21.5681 | 130.175 | TT01.02.0980 | 0980 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13241887 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2867.07 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.0982 | 0982 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13242007 | 1.NP_SO-102 | ø125 mm-ø125 mm | 1.NP_SO-102 | 2941.63 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000746653 | 29.5886 | 44.9975 | ø125-ø125 | 21.5668 | 130.175 | TT01.02.0983 | 0983 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13242614 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3249 | Fáze 2 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.000155246 | 35.9375 | 90 | ø56-ø56 | 23.67 | 59.175 | TT01.02.0989 | 0989 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13242683 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3249 | Fáze 2 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.0000776221 | 14.8858 | 45 | ø56-ø56 | 9.80444 | 59.175 | TT01.02.0990 | 0990 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13242864 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3249 | Fáze 2 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.0000776221 | 14.8858 | 45 | ø56-ø56 | 9.80444 | 59.175 | TT01.02.0992 | 0992 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13242893 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3249 | Fáze 2 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.000155246 | 35.9375 | 90 | ø56-ø56 | 23.67 | 59.175 | TT01.02.0993 | 0993 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13242897 | 4.NP_SO-102 | ø56 mm-ø56 mm | 4.NP_SO-102 | 3249 | Fáze 2 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.0000776221 | 14.8858 | 45 | ø56-ø56 | 9.80444 | 59.175 | TT01.02.0994 | 0994 | no | 35.9375 | 29.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13242914 | 4.NP_SO-102 | ø125 mm-ø125 mm | 4.NP_SO-102 | 3249 | Fáze 2 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.00149341 | 71.4375 | 90 | ø125-ø125 | 52.07 | 130.175 | TT01.02.0995 | 0995 | no | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13242984 | 1.NP_SO-102 | ø125 mm-ø125 mm | 1.NP_SO-102 | 3288.34 | Fáze 2 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000746655 | 29.5886 | 44.9976 | ø125-ø125 | 21.5668 | 130.175 | TT01.02.0996 | 0996 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13243174 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 3223.22 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0999 | 0999 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13243178 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 3006.66 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.000490915 | 25.7017 | 44.4271 | ø110-ø110 | 18.4868 | 113.175 | TT01.02.1000 | 1000 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13243242 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 3284.76 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.1001 | 1001 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13243246 | 1.NP_SO-102 | ø110 mm-ø110 mm | 1.NP_SO-102 | 3137.3 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.000490915 | 25.7017 | 44.4271 | ø110-ø110 | 18.4868 | 113.175 | TT01.02.1002 | 1002 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13243302 | 1.NP_SO-102 | ø125 mm-ø125 mm | 1.NP_SO-102 | 3295.53 | Fáze 2 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000746655 | 29.5886 | 44.9976 | ø125-ø125 | 21.5668 | 130.175 | TT01.02.1003 | 1003 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13243345 | 1.NP_SO-102 | ø125 mm-ø125 mm | 1.NP_SO-102 | 3501.77 | Fáze 2 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000746694 | 29.5904 | 45 | ø125-ø125 | 21.5681 | 130.175 | TT01.02.1004 | 1004 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13243349 | 1.NP_SO-102 | ø125 mm-ø125 mm | 1.NP_SO-102 | 3336.99 | Fáze 2 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000737187 | 29.1728 | 44.4271 | ø125-ø125 | 21.2637 | 130.175 | TT01.02.1005 | 1005 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13243968 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 3044.69 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.0014839 | 70.7267 | 89.4271 | ø125-ø125 | 51.5519 | 130.175 | TT01.02.1006 | 1006 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13243994 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 3126.08 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.0014839 | 70.7267 | 89.4271 | ø125-ø125 | 51.5519 | 130.175 | TT01.02.1007 | 1007 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13244122 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 3081.13 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000746655 | 29.5886 | 44.9976 | ø125-ø125 | 21.5668 | 130.175 | TT01.02.1008 | 1008 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13244619 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2867.07 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.000497278 | 26.0714 | 45.0029 | ø110-ø110 | 18.7528 | 113.175 | TT01.02.1009 | 1009 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13244629 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2863.46 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.00049722 | 26.068 | 44.9976 | ø110-ø110 | 18.7503 | 113.175 | TT01.02.1010 | 1010 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13244639 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2853.53 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.00049722 | 26.068 | 44.9976 | ø110-ø110 | 18.7503 | 113.175 | TT01.02.1011 | 1011 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13244655 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2850.84 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.00049722 | 26.068 | 44.9976 | ø110-ø110 | 18.7503 | 113.175 | TT01.02.1012 | 1012 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13244665 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2788.95 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.00049722 | 26.068 | 44.9976 | ø110-ø110 | 18.7503 | 113.175 | TT01.02.1013 | 1013 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13244675 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2783.69 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.00049722 | 26.068 | 44.9976 | ø110-ø110 | 18.7503 | 113.175 | TT01.02.1014 | 1014 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13244913 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2690.52 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.00049722 | 26.068 | 44.9976 | ø110-ø110 | 18.7503 | 113.175 | TT01.02.1015 | 1015 | yes | 62.9375 | 56.5875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13244944 | -1.PP_SO-102 | ø315 mm-ø315 mm | -1.PP_SO-102 | 2675.45 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 157.5 | 315 | 0.02053 | 163.791 | 89.4271 | ø315-ø315 | 126.004 | 318.175 | TT01.02.1016 | 1016 | yes | 165.438 | 159.088 | SW_Deště vnitřní podtlak 4
13244948 | -1.PP_SO-102 | ø315 mm-ø315 mm | -1.PP_SO-102 | 2681.41 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 157.5 | 315 | 0.0103301 | 68.5224 | 44.9976 | ø315-ø315 | 52.7139 | 318.175 | TT01.02.1017 | 1017 | yes | 165.438 | 159.088 | SW_Deště vnitřní podtlak 4
13269654 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 3150.31 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000746694 | 29.5904 | 45 | ø125-ø125 | 21.5681 | 130.175 | TT01.02.1019 | 1019 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13269671 | 2.NP_SO-102 | ø125 mm-ø125 mm | 2.NP_SO-102 | 2875.97 | Fáze 1 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.000737187 | 29.1728 | 44.4271 | ø125-ø125 | 21.2637 | 130.175 | TT01.02.1020 | 1020 | yes | 71.4375 | 65.0875 | SW_Deště vnitřní podtlak 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13271054 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 3333.99 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000381559 | 46.9375 | 90 | ø78-ø78 | 32.47 | 81.175 | TT01.02.1021 | 1021 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13271071 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 3333.99 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000381559 | 46.9375 | 90 | ø78-ø78 | 32.47 | 81.175 | TT01.02.1022 | 1022 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13271474 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1023 | 1023 | yes | 33.3375 | 26.9875 | WS_"Jiný typ" studená vnitřní 1
13271671 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 3226.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1024 | 1024 | yes | 33.3375 | 26.9875 | WS_Studená vnitřní 134
13271713 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 4 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1025 | 1025 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 4
13271721 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 4 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1026 | 1026 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 4
13271755 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1027 | 1027 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 83
13271781 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1028 | 1028 | yes | 33.3375 | 26.9875 | WS_"Jiný typ" studená vnitřní 1
13271789 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1029 | 1029 | yes | 33.3375 | 26.9875 | WS_"Jiný typ" studená vnitřní 1
13271959 | -1.PP_SO-102 | ø35 mm-ø35 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 17.5 | 35 | 0.000045733 | 25.4375 | 90 | ø35-ø35 | 15.27 | 38.175 | TT01.02.1030 | 1030 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 1
13271967 | -1.PP_SO-102 | ø35 mm-ø35 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 17.5 | 35 | 0.000045733 | 25.4375 | 90 | ø35-ø35 | 15.27 | 38.175 | TT01.02.1031 | 1031 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 1
13322801 | -1.PP_SO-102 | ø28 mm-ø28 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1032 | 1032 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13322811 | -1.PP_SO-102 | ø28 mm-ø28 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1033 | 1033 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13322815 | -1.PP_SO-102 | ø28 mm-ø28 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1034 | 1034 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13323199 | 1.NP_SO-102 | ø28 mm-ø28 mm | 1.NP_SO-102 | 3364.28 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1039 | 1039 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13323257 | 1.NP_SO-102 | ø28 mm-ø28 mm | 1.NP_SO-102 | 3364.28 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1040 | 1040 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13323372 | 1.NP_SO-102 | ø28 mm-ø28 mm | 1.NP_SO-102 | 1770 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1041 | 1041 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13323374 | 1.NP_SO-102 | ø28 mm-ø28 mm | 1.NP_SO-102 | 3364.28 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1042 | 1042 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13324090 | 2.NP_SO-102 | ø28 mm-ø28 mm | 2.NP_SO-102 | 3310.29 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1044 | 1044 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13324208 | 2.NP_SO-102 | ø28 mm-ø28 mm | 2.NP_SO-102 | 3310.29 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1045 | 1045 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13324308 | 4.NP_SO-102 | ø28 mm-ø28 mm | 4.NP_SO-102 | 3308.35 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1047 | 1047 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13324320 | 4.NP_SO-102 | ø28 mm-ø28 mm | 4.NP_SO-102 | 3308.35 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1048 | 1048 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13324333 | 4.NP_SO-102 | ø28 mm-ø28 mm | 4.NP_SO-102 | 1420 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1049 | 1049 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13324337 | 4.NP_SO-102 | ø28 mm-ø28 mm | 4.NP_SO-102 | 3308.35 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1050 | 1050 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13324341 | 4.NP_SO-102 | ø28 mm-ø28 mm | 4.NP_SO-102 | 3308.35 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1051 | 1051 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13324399 | 3.NP_SO-102 | ø28 mm-ø28 mm | 3.NP_SO-102 | 3198.93 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1054 | 1054 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13324477 | 3.NP_SO-102 | ø28 mm-ø28 mm | 3.NP_SO-102 | 1420 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1055 | 1055 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13324485 | 3.NP_SO-102 | ø28 mm-ø28 mm | 3.NP_SO-102 | 3198.93 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1056 | 1056 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13324487 | 3.NP_SO-102 | ø28 mm-ø28 mm | 3.NP_SO-102 | 3198.93 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1057 | 1057 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13324942 | 2.NP_SO-102 | ø28 mm-ø28 mm | 2.NP_SO-102 | 1420 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1058 | 1058 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13324952 | 2.NP_SO-102 | ø28 mm-ø28 mm | 2.NP_SO-102 | 3310.29 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1059 | 1059 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13324975 | 2.NP_SO-102 | ø28 mm-ø28 mm | 2.NP_SO-102 | 3310.29 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 89.9999 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1060 | 1060 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13324979 | 2.NP_SO-102 | ø28 mm-ø28 mm | 2.NP_SO-102 | 3310.29 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1061 | 1061 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13325001 | 2.NP_SO-102 | ø28 mm-ø28 mm | 2.NP_SO-102 | 3310.29 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1062 | 1062 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13325916 | -1.PP_SO-102 | ø20 mm-ø20 mm | -1.PP_SO-102 | 3225.94 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1064 | 1064 | yes | 17.4625 | 11.1125 | WS_"ŠEDÁ" studená vnitřní 2
13335301 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1065 | 1065 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13335303 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1066 | 1066 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13335753 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3308.35 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1069 | 1069 | yes | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13347267 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1072 | 1072 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
13347271 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3355.2 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106384 | 17.4555 | 89.9771 | ø20-ø20 | 8.88645 | 22.225 | TT01.02.1073 | 1073 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
13347279 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3372.21 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106384 | 17.4555 | 89.9771 | ø20-ø20 | 8.88645 | 22.225 | TT01.02.1074 | 1074 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
13348479 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 805.05 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1079 | 1079 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13348603 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1080 | 1080 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13348637 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1081 | 1081 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13348647 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1082 | 1082 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13349179 | 2.NP_SO-102 | ø89 mm-ø89 mm | 2.NP_SO-102 | 2000 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1084 | 1084 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13356024 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1085 | 1085 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
13356032 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1086 | 1086 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
13356212 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1087 | 1087 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13356238 | 2.NP_SO-102 | ø89 mm-ø89 mm | 2.NP_SO-102 | 2000 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1088 | 1088 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13356708 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1090 | 1090 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13356895 | -1.PP_SO-102 | ø15 mm-ø15 mm | -1.PP_SO-102 | 1300 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.02.1091 | 1091 | yes | 14.2875 | 7.9375 | WS_Požární nezavodněný 1
13356930 | -1.PP_SO-102 | ø15 mm-ø15 mm | -1.PP_SO-102 | 1300 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.02.1094 | 1094 | yes | 14.2875 | 7.9375 | WS_Požární nezavodněný 1
13357714 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3308.35 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1099 | 1099 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13358500 | 2.NP_SO-102 | ø50 mm-ø50 mm | 2.NP_SO-102 | 1300 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1102 | 1102 | yes | 33.3375 | 26.9875 | WS_Požární nezavodněný 1
13358524 | 2.NP_SO-102 | ø50 mm-ø50 mm | 2.NP_SO-102 | 1300 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1105 | 1105 | yes | 33.3375 | 26.9875 | WS_Požární nezavodněný 1
13358528 | 2.NP_SO-102 | ø50 mm-ø50 mm | 2.NP_SO-102 | 1300 | Fáze 1 | WS_Požární nezavodněný | Studená voda v domácnosti | WS_Požární nezavodněný 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1106 | 1106 | yes | 33.3375 | 26.9875 | WS_Požární nezavodněný 1
13358622 | 3.NP_SO-102 | ø28 mm-ø28 mm | 3.NP_SO-102 | 3366.44 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1107 | 1107 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13358632 | 3.NP_SO-102 | ø28 mm-ø28 mm | 3.NP_SO-102 | 3366.44 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1108 | 1108 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13358640 | 3.NP_SO-102 | ø28 mm-ø28 mm | 3.NP_SO-102 | 3366.44 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1109 | 1109 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
13358650 | 3.NP_SO-102 | ø28 mm-ø28 mm | 3.NP_SO-102 | 3366.44 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 14 | 28 | 0.0000263025 | 21.9375 | 90 | ø28-ø28 | 12.47 | 31.175 | TT01.02.1110 | 1110 | yes | 21.9375 | 15.5875 | WS_Požární zavodněný 1
