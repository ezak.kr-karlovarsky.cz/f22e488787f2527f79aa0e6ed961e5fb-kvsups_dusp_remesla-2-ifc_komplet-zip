Properties of the parts of a building model (IFC4), part 47 of 60

# IfcPipeSegment: Typy trubek:PP-RCT (1338)
Name (Typy trubek:PP-RCT:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Instalační jednotky = Reynoldsovo číslo = Třecí faktor = Tření = Průtok (m3/s) = Rychlost (m/s) = Tlaková ztráta (Pa) | Stav průtoku | Doplňkový průtok (m3/s) | Relativní drsnost | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) | Spodní výška (mm) | Střední výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Délka (mm) | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
13004857 | 3.NP_SO-102 | 502.537 | 0.000314112 | 0.0315754 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 9242.3 | PP–RCT S4 | 20 | 143 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 502.537 | ø20 | 15.4 | TR10.03.0414 | 0414 | no | WS_Teplá vnitřní 83 | 0
13004949 | 3.NP_SO-102 | 2098.92 | 0.000314112 | 0.131879 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3366.38 | 1267.46 | 3366.38 | 1267.46 | 3366.38 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 9267.46 | PP–RCT S4 | 20 | 143 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2098.92 | ø20 | 15.4 | TR10.03.0415 | 0415 | no | WS_Teplá vnitřní 83
13004952 | 3.NP_SO-102 | 1988.3 | 0.0004908 | 0.15616 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3402.69 | 3390.19 | 3390.19 | 3377.69 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11380.5 | PP–RCT S4 | 25 | 57 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1988.3 | ø25 | 19.4 | TR10.03.0416 | 0416 | no | WS_Teplá vnitřní 83 | 0
13005057 | 3.NP_SO-102 | 406.656 | 0.000314112 | 0.0255509 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 9242.3 | PP–RCT S4 | 20 | 59 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 406.656 | ø20 | 15.4 | TR10.03.0417 | 0417 | no | WS_Studená vnitřní 134 | 0
13005086 | 3.NP_SO-102 | 2065.07 | 0.000314112 | 0.129752 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3332.54 | 1267.46 | 3332.54 | 1267.46 | 3332.54 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 9267.46 | PP–RCT S4 | 20 | 59 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2065.07 | ø20 | 15.4 | TR10.03.0418 | 0418 | no | WS_Studená vnitřní 134
13005107 | 3.NP_SO-102 | 486.656 | 0.000314112 | 0.0305775 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 9242.3 | PP–RCT S4 | 20 | 142 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 486.656 | ø20 | 15.4 | TR10.03.0419 | 0419 | no | WS_Teplá vnitřní 83 | 0
13005154 | 3.NP_SO-102 | 2105.27 | 0.000314112 | 0.132278 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3372.73 | 1267.46 | 3372.73 | 1267.46 | 3372.73 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 9267.46 | PP–RCT S4 | 20 | 142 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2105.27 | ø20 | 15.4 | TR10.03.0420 | 0420 | no | WS_Teplá vnitřní 83
13005332 | 4.NP_SO-102 | 15943.2 | 0.000804127 | 1.60278 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3266.96 | -12676.2 | 3266.96 | -12676.2 | 3266.96 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -676.187 | PP–RCT S4 | 32 | 238 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 15943.2 | ø32 | 24.8 | TR10.03.0421 | 0421 | yes | WS_Teplá vnitřní 83; WS_Cirkulace vnitřní 9
13005470 | 4.NP_SO-102 | 2033.79 | 0.0004908 | 0.159733 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15340.3 | PP–RCT S4 | 25 | 180 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2033.79 | ø25 | 19.4 | TR10.03.0422 | 0422 | yes | WS_Studená vnitřní 134 | 0
13005497 | 4.NP_SO-102 | 803.072 | 0.0004908 | 0.0630731 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3379.16 | 3366.66 | 3366.66 | 3354.16 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15357 | PP–RCT S4 | 25 | 146 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 803.072 | ø25 | 19.4 | TR10.03.0423 | 0423 | yes | WS_Teplá vnitřní 83 | 0
13005516 | 4.NP_SO-102 | 63.94 | 0.000804127 | 0.00642795 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15337.6 | PP–RCT S4 | 32 | 181 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 63.94 | ø32 | 24.8 | TR10.03.0424 | 0424 | yes | WS_Studená vnitřní 134 | 0
13005540 | 4.NP_SO-102 | 183.691 | 0.000804127 | 0.0184666 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3406.19 | 3390.19 | 3390.19 | 3374.19 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15377.8 | PP–RCT S4 | 32 | 39 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 183.691 | ø32 | 24.8 | TR10.03.0425 | 0425 | yes | WS_Teplá vnitřní 83 | 0
13005641 | 3.NP_SO-102 | 214.839 | 0.0004908 | 0.0168734 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 1439.16 | 1426.66 | 1426.66 | 1414.16 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 9416.96 | PP–RCT S4 | 25 | 346 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 214.839 | ø25 | 19.4 | TR10.03.0426 | 0426 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13005643 | 3.NP_SO-102 | 1812.42 | 0.000314112 | 0.113878 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1436.66 | 1426.66 | 1426.66 | 1416.66 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 3 | 9418.96 | PP–RCT S4 | 20 | 7 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1812.42 | ø20 | 15.4 | TR10.03.0427 | 0427 | no | WS_"ŠEDÁ" studená vnitřní 3 | 0
13005647 | 3.NP_SO-102 | 52.5375 | 0.000314112 | 0.00330103 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1180 | 1170 | 1170 | 1160 | 1170 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 3 | 9162.3 | PP–RCT S4 | 20 | 345 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 52.5375 | ø20 | 15.4 | TR10.03.0428 | 0428 | no | WS_"ŠEDÁ" studená vnitřní 3 | 0
13005649 | 3.NP_SO-102 | 205.069 | 0.000314112 | 0.0128848 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1392.53 | 1187.46 | 1392.53 | 1187.46 | 1392.53 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 3 | 9187.46 | PP–RCT S4 | 20 | 345 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 205.069 | ø20 | 15.4 | TR10.03.0429 | 0429 | no | WS_"ŠEDÁ" studená vnitřní 3
13005676 | 2.NP_SO-102 | 214.68 | 0.0004908 | 0.0168609 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 1439.16 | 1426.66 | 1426.66 | 1414.16 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5416.96 | PP–RCT S4 | 25 | 336 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 214.68 | ø25 | 19.4 | TR10.03.0430 | 0430 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13005678 | 2.NP_SO-102 | 1757.14 | 0.000314112 | 0.110405 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1436.66 | 1426.66 | 1426.66 | 1416.66 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5418.96 | PP–RCT S4 | 20 | 10 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1757.14 | ø20 | 15.4 | TR10.03.0431 | 0431 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13005682 | 2.NP_SO-102 | 52.5375 | 0.000314112 | 0.00330103 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1180 | 1170 | 1170 | 1160 | 1170 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5162.3 | PP–RCT S4 | 20 | 339 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 52.5375 | ø20 | 15.4 | TR10.03.0432 | 0432 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13005684 | 2.NP_SO-102 | 205.069 | 0.000314112 | 0.0128848 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1392.53 | 1187.46 | 1392.53 | 1187.46 | 1392.53 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5187.46 | PP–RCT S4 | 20 | 339 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 205.069 | ø20 | 15.4 | TR10.03.0433 | 0433 | no | WS_"Jiný typ" studená vnitřní 1
13005709 | 1.NP_SO-102 | 220.667 | 0.0004908 | 0.0173311 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 1439.16 | 1426.66 | 1426.66 | 1414.16 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 1416.96 | PP–RCT S4 | 25 | 8 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 220.667 | ø25 | 19.4 | TR10.03.0434 | 0434 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13005715 | 1.NP_SO-102 | 58.4043 | 0.000314112 | 0.00366965 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 1180 | 1170 | 1170 | 1160 | 1170 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 1162.3 | PP–RCT S4 | 20 | 1 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 58.4043 | ø20 | 15.4 | TR10.03.0435 | 0435 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13005717 | 1.NP_SO-102 | 205.069 | 0.000314112 | 0.0128848 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 1392.53 | 1187.46 | 1392.53 | 1187.46 | 1392.53 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 1187.46 | PP–RCT S4 | 20 | 1 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 205.069 | ø20 | 15.4 | TR10.03.0436 | 0436 | no | WS_"Jiný typ" studená vnitřní 1
13005720 | 1.NP_SO-102 | 1042.1 | 0.0004908 | 0.0818465 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 1439.16 | 1426.66 | 1426.66 | 1414.16 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 1416.96 | PP–RCT S4 | 25 | 4 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1042.1 | ø25 | 19.4 | TR10.03.0437 | 0437 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13005953 | 3.NP_SO-102 | 742.337 | 0.0004908 | 0.058303 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3379.16 | 3366.66 | 3366.66 | 3354.16 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11357 | PP–RCT S4 | 25 | 58 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 742.337 | ø25 | 19.4 | TR10.03.0438 | 0438 | yes | WS_Teplá vnitřní 83 | 0
13005982 | 3.NP_SO-102 | 70.1991 | 0.000804127 | 0.00705718 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11337.6 | PP–RCT S4 | 32 | 452 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 70.1991 | ø32 | 24.8 | TR10.03.0439 | 0439 | yes | WS_Studená vnitřní 134 | 0
13006128 | 3.NP_SO-102 | 188.66 | 0.000804127 | 0.0189662 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3406.19 | 3390.19 | 3390.19 | 3374.19 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11377.8 | PP–RCT S4 | 32 | 136 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 188.66 | ø32 | 24.8 | TR10.03.0440 | 0440 | yes | WS_Teplá vnitřní 83 | 0
13006828 | 1.NP_SO-102 | 3930.94 | 0.0019632 | 0.61747 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | 1.NP_SO-102 | 3264.28 | -666.663 | 3264.28 | -666.663 | 3264.28 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -666.662 | PP–RCT S4 | 50 | 400 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3930.94 | ø50 | 38.8 | TR10.03.0441 | 0441 | yes | WS_Studená vnitřní 134 | Identifikační data - Komentáře: V3
13007385 | 2.NP_SO-102 | 381.975 | 0.000804127 | 0.0384003 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3356 | 3340 | 3340 | 3324 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7327.6 | PP–RCT S4 | 32 | 225 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 381.975 | ø32 | 24.8 | TR10.03.0442 | 0442 | yes | WS_Studená vnitřní 134 | 0
13007387 | 4.NP_SO-102 | 3926.18 | 0.000804127 | 0.394703 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3319.84 | 3319.84 | -606.344 | -606.344 | -606.344 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11393.7 | PP–RCT S4 | 32 | 220 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3926.18 | ø32 | 24.8 | TR10.03.0443 | 0443 | yes | WS_Studená vnitřní 134 | Identifikační data - Komentáře: V3
13007445 | 1.NP_SO-102 | 381.975 | 0.000804127 | 0.0384003 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3337.6 | PP–RCT S4 | 32 | 406 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 381.975 | ø32 | 24.8 | TR10.03.0444 | 0444 | yes | WS_Studená vnitřní 134 | 0
13007447 | 2.NP_SO-102 | 3923.32 | 0.00125645 | 0.49302 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 2.NP_SO-102 | 3306.66 | -616.663 | 3306.66 | -616.663 | 3306.66 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3383.34 | PP–RCT S4 | 40 | 172 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3923.32 | ø40 | 31 | TR10.03.0445 | 0445 | yes | WS_Studená vnitřní 134 | Identifikační data - Komentáře: V3
13008027 | 2.NP_SO-102 | 1205.87 | 0.000314112 | 0.075767 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3350 | 3340 | 3340 | 3330 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7332.3 | PP–RCT S4 | 20 | 206 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1205.87 | ø20 | 15.4 | TR10.03.0446 | 0446 | no | WS_Studená vnitřní 134 | 0
13008164 | 2.NP_SO-102 | 6181.15 | 0.0004908 | 0.485467 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3352.5 | 3340 | 3340 | 3327.5 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7330.3 | PP–RCT S4 | 25 | 200 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6181.15 | ø25 | 19.4 | TR10.03.0447 | 0447 | yes | WS_Studená vnitřní 134 | 0
13008215 | 2.NP_SO-102 | 1216.76 | 0.000314112 | 0.0764511 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7342.3 | PP–RCT S4 | 20 | 178 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1216.76 | ø20 | 15.4 | TR10.03.0448 | 0448 | no | WS_Teplá vnitřní 83 | 0
13008272 | 2.NP_SO-102 | 4.90799 | 0.0004908 | 0.000385473 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3379.16 | 3366.66 | 3366.66 | 3354.16 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7356.96 | PP–RCT S4 | 25 | 177 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4.90799 | ø25 | 19.4 | TR10.03.0449 | 0449 | yes | WS_Teplá vnitřní 83 | 0
13008273 | 2.NP_SO-102 | 9.09793 | 0.000314112 | 0.00057164 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3368.62 | 3355.11 | 3361.55 | 3348.04 | 3361.55 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7349.67 | PP–RCT S4 | 20 | 178 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 9.09793 | ø20 | 15.4 | TR10.03.0450 | 0450 | yes | WS_Teplá vnitřní 83 | 100
13008351 | 2.NP_SO-102 | 4976.42 | 0.000314112 | 0.312678 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3350 | 3340 | 3340 | 3330 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7332.3 | PP–RCT S4 | 20 | 198 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4976.42 | ø20 | 15.4 | TR10.03.0451 | 0451 | yes | WS_Studená vnitřní 134 | 0
13008361 | 2.NP_SO-102 | 977.248 | 0.0004908 | 0.0767529 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3352.5 | 3340 | 3340 | 3327.5 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7330.3 | PP–RCT S4 | 25 | 199 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 977.248 | ø25 | 19.4 | TR10.03.0452 | 0452 | yes | WS_Studená vnitřní 134 | 0
13008380 | 2.NP_SO-102 | 5146.92 | 0.000314112 | 0.32339 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3376.66 | 3366.66 | 3366.66 | 3356.66 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7358.96 | PP–RCT S4 | 20 | 169 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5146.92 | ø20 | 15.4 | TR10.03.0453 | 0453 | yes | WS_Teplá vnitřní 83 | 0
13008388 | 2.NP_SO-102 | 974.501 | 0.0004908 | 0.0765371 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3379.16 | 3366.66 | 3366.66 | 3354.16 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7356.96 | PP–RCT S4 | 25 | 170 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 974.501 | ø25 | 19.4 | TR10.03.0454 | 0454 | yes | WS_Teplá vnitřní 83 | 0
13008404 | 2.NP_SO-102 | 1222.54 | 0.000314112 | 0.0768143 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3350 | 3340 | 3340 | 3330 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7332.3 | PP–RCT S4 | 20 | 198 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1222.54 | ø20 | 15.4 | TR10.03.0455 | 0455 | no | WS_Studená vnitřní 134 | 0
13008442 | 2.NP_SO-102 | 1302.54 | 0.000314112 | 0.0818408 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3376.66 | 3366.66 | 3366.66 | 3356.66 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7358.96 | PP–RCT S4 | 20 | 169 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1302.54 | ø20 | 15.4 | TR10.03.0456 | 0456 | no | WS_Teplá vnitřní 83 | 0
13008588 | 2.NP_SO-102 | 657.71 | 0.0004908 | 0.0516564 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3352.5 | 3340 | 3340 | 3327.5 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7330.3 | PP–RCT S4 | 25 | 196 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 657.71 | ø25 | 19.4 | TR10.03.0457 | 0457 | yes | WS_Studená vnitřní 134 | 0
13008608 | 2.NP_SO-102 | 786.238 | 0.0004908 | 0.061751 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3379.16 | 3366.66 | 3366.66 | 3354.16 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7356.96 | PP–RCT S4 | 25 | 167 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 786.238 | ø25 | 19.4 | TR10.03.0458 | 0458 | yes | WS_Teplá vnitřní 83 | 0
13008632 | 2.NP_SO-102 | 19.6642 | 0.000804127 | 0.00197686 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3356 | 3340 | 3340 | 3324 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7327.6 | PP–RCT S4 | 32 | 446 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 19.6642 | ø32 | 24.8 | TR10.03.0459 | 0459 | yes | WS_Studená vnitřní 134 | 0
13008648 | 2.NP_SO-102 | 167.503 | 0.000804127 | 0.0168393 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3356 | 3340 | 3340 | 3324 | 3340 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7327.6 | PP–RCT S4 | 32 | 74 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 167.503 | ø32 | 24.8 | TR10.03.0460 | 0460 | yes | WS_Teplá vnitřní 83 | 0
13008755 | 2.NP_SO-102 | 3185.08 | 0.0004908 | 0.250155 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3352.5 | 3340 | 3340 | 3327.5 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7330.3 | PP–RCT S4 | 25 | 513 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3185.08 | ø25 | 19.4 | TR10.03.0461 | 0461 | no | WS_Studená vnitřní 134 | 0
13009235 | 1.NP_SO-102 | 7585.07 | 0.000314112 | 0.476584 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3376.66 | 3366.66 | 3366.66 | 3356.66 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3358.96 | PP–RCT S4 | 20 | 371 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 7585.07 | ø20 | 15.4 | TR10.03.0462 | 0462 | no | WS_Teplá vnitřní 83 | 0
13009397 | 1.NP_SO-102 | 7425.08 | 0.000314112 | 0.466531 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3342.3 | PP–RCT S4 | 20 | 408 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 7425.08 | ø20 | 15.4 | TR10.03.0463 | 0463 | no | WS_Studená vnitřní 134 | 0
13009543 | 1.NP_SO-102 | 1837.57 | 0.0004908 | 0.144323 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3340.3 | PP–RCT S4 | 25 | 332 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1837.57 | ø25 | 19.4 | TR10.03.0464 | 0464 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13009589 | 1.NP_SO-102 | 1875.71 | 0.0004908 | 0.147318 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3329.36 | 3329.36 | 1453.65 | 1453.65 | 1453.65 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 1453.65 | PP–RCT S4 | 25 | 332 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1875.71 | ø25 | 19.4 | TR10.03.0465 | 0465 | no | WS_"Jiný typ" studená vnitřní 1
13009592 | 1.NP_SO-102 | 573.922 | 0.0004908 | 0.0450758 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 1439.16 | 1426.66 | 1426.66 | 1414.16 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 1416.96 | PP–RCT S4 | 25 | 8 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 573.922 | ø25 | 19.4 | TR10.03.0466 | 0466 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13009637 | 1.NP_SO-102 | 5572.17 | 0.0004908 | 0.437637 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3340.3 | PP–RCT S4 | 25 | 332 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5572.17 | ø25 | 19.4 | TR10.03.0467 | 0467 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13009727 | 1.NP_SO-102 | 1209.64 | 0.0004908 | 0.0950046 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 592.5 | 580 | 580 | 567.5 | 580 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 570.3 | PP–RCT S4 | 25 | 82 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1209.64 | ø25 | 19.4 | TR10.03.0468 | 0468 | no | WS_Teplá vnitřní 83 | 0
13009762 | 1.NP_SO-102 | 2768.92 | 0.0004908 | 0.21747 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3369.55 | 600.637 | 3369.55 | 600.637 | 3369.55 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 600.637 | PP–RCT S4 | 25 | 82 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2768.92 | ø25 | 19.4 | TR10.03.0469 | 0469 | no | WS_Teplá vnitřní 83
13009786 | 1.NP_SO-102 | 1129.64 | 0.0004908 | 0.0887214 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 592.5 | 580 | 580 | 567.5 | 580 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 570.3 | PP–RCT S4 | 25 | 47 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1129.64 | ø25 | 19.4 | TR10.03.0470 | 0470 | no | WS_Studená vnitřní 134 | 0
13009829 | 1.NP_SO-102 | 2728.72 | 0.0004908 | 0.214314 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3329.36 | 600.637 | 3329.36 | 600.637 | 3329.36 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 600.637 | PP–RCT S4 | 25 | 47 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2728.72 | ø25 | 19.4 | TR10.03.0471 | 0471 | no | WS_Studená vnitřní 134
13009964 | 1.NP_SO-102 | 2682.94 | 0.0004908 | 0.210718 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3332.5 | 3320 | 3320 | 3307.5 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3310.3 | PP–RCT S4 | 25 | 70 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2682.94 | ø25 | 19.4 | TR10.03.0472 | 0472 | yes | WS_Teplá vnitřní 83 | 0
13009989 | 1.NP_SO-102 | 2515.17 | 0.0004908 | 0.197541 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3340.3 | PP–RCT S4 | 25 | 86 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2515.17 | ø25 | 19.4 | TR10.03.0473 | 0473 | yes | WS_Studená vnitřní 134 | 0
13010244 | 1.NP_SO-102 | 1869.15 | 0.000314112 | 0.117442 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3342.3 | PP–RCT S4 | 20 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1869.15 | ø20 | 15.4 | TR10.03.0474 | 0474 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13010257 | 1.NP_SO-102 | 2108.72 | 0.000314112 | 0.132495 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3332.54 | 3332.54 | 1223.81 | 1223.81 | 1223.81 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 1223.81 | PP–RCT S4 | 20 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2108.72 | ø20 | 15.4 | TR10.03.0475 | 0475 | no | WS_"Jiný typ" studená vnitřní 1
13010260 | 1.NP_SO-102 | 576.197 | 0.000314112 | 0.0362035 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 1210 | 1200 | 1200 | 1190 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 1192.3 | PP–RCT S4 | 20 | 56 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 576.197 | ø20 | 15.4 | TR10.03.0476 | 0476 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13010307 | 1.NP_SO-102 | 7065.08 | 0.000314112 | 0.443912 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3342.3 | PP–RCT S4 | 20 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 7065.08 | ø20 | 15.4 | TR10.03.0477 | 0477 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13010323 | 1.NP_SO-102 | 2047 | 0.000314112 | 0.128617 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3342.3 | PP–RCT S4 | 20 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2047 | ø20 | 15.4 | TR10.03.0478 | 0478 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13010414 | 1.NP_SO-102 | 321.929 | 0.000314112 | 0.0202274 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3342.3 | PP–RCT S4 | 20 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 321.929 | ø20 | 15.4 | TR10.03.0479 | 0479 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13010562 | 1.NP_SO-102 | 2017.57 | 0.0004908 | 0.15846 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3340.3 | PP–RCT S4 | 25 | 209 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2017.57 | ø25 | 19.4 | TR10.03.0480 | 0480 | yes | WS_Studená vnitřní 134 | 0
13010580 | 1.NP_SO-102 | 819.285 | 0.0004908 | 0.0643465 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3379.16 | 3366.66 | 3366.66 | 3354.16 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3356.96 | PP–RCT S4 | 25 | 180 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 819.285 | ø25 | 19.4 | TR10.03.0481 | 0481 | yes | WS_Teplá vnitřní 83 | 0
13010595 | 1.NP_SO-102 | 353.285 | 0.0004908 | 0.0277469 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3340.3 | PP–RCT S4 | 25 | 332 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 353.285 | ø25 | 19.4 | TR10.03.0482 | 0482 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13010641 | 1.NP_SO-102 | 65.8686 | 0.0004908 | 0.00517331 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 1439.16 | 1426.66 | 1426.66 | 1414.16 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 1416.96 | PP–RCT S4 | 25 | 4 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 65.8686 | ø25 | 19.4 | TR10.03.0483 | 0483 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13010746 | 1.NP_SO-102 | 64.8292 | 0.000804127 | 0.00651734 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3337.6 | PP–RCT S4 | 32 | 3 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 64.8292 | ø32 | 24.8 | TR10.03.0484 | 0484 | yes | WS_Studená vnitřní 134 | 0
13010764 | 1.NP_SO-102 | 258.02 | 0.000804127 | 0.025939 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3406.19 | 3390.19 | 3390.19 | 3374.19 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3377.79 | PP–RCT S4 | 32 | 131 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 258.02 | ø32 | 24.8 | TR10.03.0485 | 0485 | yes | WS_Teplá vnitřní 83 | 0
13010806 | 1.NP_SO-102 | 1919.36 | 0.0004908 | 0.150746 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 1239.92 | 1227.42 | 1227.42 | 1214.92 | 1227.42 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 1217.72 | PP–RCT S4 | 25 | 1 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1919.36 | ø25 | 19.4 | TR10.03.0486 | 0486 | no | WS_Studená vnitřní 134 | 0
13010859 | 1.NP_SO-102 | 2059.36 | 0.0004908 | 0.161742 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 1262.5 | 1250 | 1250 | 1237.5 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 1240.3 | PP–RCT S4 | 25 | 83 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2059.36 | ø25 | 19.4 | TR10.03.0487 | 0487 | no | WS_Teplá vnitřní 83 | 0
13010956 | 1.NP_SO-102 | 2081.3 | 0.0004908 | 0.163465 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3329.36 | 1248.06 | 3329.36 | 1248.06 | 3329.36 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 1248.06 | PP–RCT S4 | 25 | 1 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2081.3 | ø25 | 19.4 | TR10.03.0488 | 0488 | no | WS_Studená vnitřní 134
13011074 | 1.NP_SO-102 | 2028.72 | 0.0004908 | 0.159336 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3299.36 | 1270.64 | 3299.36 | 1270.64 | 3299.36 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 1270.64 | PP–RCT S4 | 25 | 83 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2028.72 | ø25 | 19.4 | TR10.03.0489 | 0489 | no | WS_Teplá vnitřní 83
13011114 | 1.NP_SO-102 | 376.045 | 0.000314112 | 0.0236276 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 1242.3 | PP–RCT S4 | 20 | 349 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 376.045 | ø20 | 15.4 | TR10.03.0490 | 0490 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13011179 | 1.NP_SO-102 | 2058.72 | 0.000314112 | 0.129354 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3332.54 | 1273.81 | 3332.54 | 1273.81 | 3332.54 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 1273.81 | PP–RCT S4 | 20 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2058.72 | ø20 | 15.4 | TR10.03.0491 | 0491 | no | WS_"Jiný typ" studená vnitřní 1
13011257 | 2.NP_SO-102 | 1791.35 | 0.0004908 | 0.140693 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 1439.16 | 1426.66 | 1426.66 | 1414.16 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5416.96 | PP–RCT S4 | 25 | 336 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1791.35 | ø25 | 19.4 | TR10.03.0492 | 0492 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13011308 | 3.NP_SO-102 | 1274.21 | 0.0004908 | 0.100076 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 1439.16 | 1426.66 | 1426.66 | 1414.16 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 9416.96 | PP–RCT S4 | 25 | 346 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1274.21 | ø25 | 19.4 | TR10.03.0493 | 0493 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13011336 | 4.NP_SO-102 | 408.363 | 0.0004908 | 0.0320727 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 1439.16 | 1426.66 | 1426.66 | 1414.16 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 13417 | PP–RCT S4 | 25 | 40 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 408.363 | ø25 | 19.4 | TR10.03.0494 | 0494 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13011666 | 3.NP_SO-102 | 5221.48 | 0.000314112 | 0.328076 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11342.3 | PP–RCT S4 | 20 | 462 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5221.48 | ø20 | 15.4 | TR10.03.0495 | 0495 | yes | WS_Studená vnitřní 134 | 0
13011676 | 3.NP_SO-102 | 742.537 | 0.000314112 | 0.046655 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11342.3 | PP–RCT S4 | 20 | 462 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 742.537 | ø20 | 15.4 | TR10.03.0496 | 0496 | no | WS_Studená vnitřní 134 | 0
13011712 | 3.NP_SO-102 | 822.537 | 0.000314112 | 0.0516816 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3376.66 | 3366.66 | 3366.66 | 3356.66 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11359 | PP–RCT S4 | 20 | 381 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 822.537 | ø20 | 15.4 | TR10.03.0497 | 0497 | no | WS_Teplá vnitřní 83 | 0
13011770 | 3.NP_SO-102 | 5396.04 | 0.000314112 | 0.339043 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3376.66 | 3366.66 | 3366.66 | 3356.66 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11359 | PP–RCT S4 | 20 | 381 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5396.04 | ø20 | 15.4 | TR10.03.0498 | 0498 | yes | WS_Teplá vnitřní 83 | 0
13011778 | 3.NP_SO-102 | 646.025 | 0.0004908 | 0.0507387 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3379.16 | 3366.66 | 3366.66 | 3354.16 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11357 | PP–RCT S4 | 25 | 157 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 646.025 | ø25 | 19.4 | TR10.03.0499 | 0499 | yes | WS_Teplá vnitřní 83 | 0
13011800 | 3.NP_SO-102 | 806.025 | 0.0004908 | 0.0633051 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11340.3 | PP–RCT S4 | 25 | 463 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 806.025 | ø25 | 19.4 | TR10.03.0500 | 0500 | yes | WS_Studená vnitřní 134 | 0
13013248 | 4.NP_SO-102 | 15946.8 | 0.000804127 | 1.60315 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3270.63 | -12676.2 | 3270.63 | -12676.2 | 3270.63 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -676.187 | PP–RCT S4 | 32 | 228 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 15946.8 | ø32 | 24.8 | TR10.03.0501 | 0501 | yes | WS_Cirkulace vnitřní 9
13013903 | 1.NP_SO-102 | 129.937 | 0.000804127 | 0.0130627 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3337.6 | PP–RCT S4 | 32 | 392 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 129.937 | ø32 | 24.8 | TR10.03.0502 | 0502 | yes | WS_Studená vnitřní 134 | 0
13013929 | 1.NP_SO-102 | 327.039 | 0.000804127 | 0.0328776 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3337.6 | PP–RCT S4 | 32 | 111 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 327.039 | ø32 | 24.8 | TR10.03.0503 | 0503 | yes | WS_Studená vnitřní 134 | 0
13013995 | 1.NP_SO-102 | 377.26 | 0.000804127 | 0.0379263 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3336 | 3320 | 3320 | 3304 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3307.6 | PP–RCT S4 | 32 | 110 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 377.26 | ø32 | 24.8 | TR10.03.0504 | 0504 | yes | WS_Teplá vnitřní 83 | 0
13014021 | 1.NP_SO-102 | 255.763 | 0.000804127 | 0.0257121 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3336 | 3320 | 3320 | 3304 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3307.6 | PP–RCT S4 | 32 | 65 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 255.763 | ø32 | 24.8 | TR10.03.0505 | 0505 | yes | WS_Teplá vnitřní 83 | 0
13014506 | 1.NP_SO-102 | 1846.3 | 0.000804127 | 0.18561 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 1169.84 | -676.462 | 1169.84 | -676.462 | 1169.84 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -676.462 | PP–RCT S4 | 32 | 202 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1846.3 | ø32 | 24.8 | TR10.03.0506 | 0506 | yes | WS_"Jiný typ" studená vnitřní 1
13014541 | 2.NP_SO-102 | 3934.12 | 0.0004908 | 0.308985 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 1173.01 | -2761.11 | 1173.01 | -2761.11 | 1173.01 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 1238.89 | PP–RCT S4 | 25 | 27 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3934.12 | ø25 | 19.4 | TR10.03.0507 | 0507 | yes | WS_"Jiný typ" studená vnitřní 1
13014582 | 3.NP_SO-102 | 3942.06 | 0.0004908 | 0.309608 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 1169.04 | -2773.01 | 1169.04 | -2773.01 | 1169.04 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5226.99 | PP–RCT S4 | 25 | 24 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3942.06 | ø25 | 19.4 | TR10.03.0508 | 0508 | yes | WS_"Jiný typ" studená vnitřní 1
13014588 | 4.NP_SO-102 | 3948.41 | 0.0004908 | 0.310107 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 1179.36 | -2769.04 | 1179.36 | -2769.04 | 1179.36 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 9230.96 | PP–RCT S4 | 25 | 22 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3948.41 | ø25 | 19.4 | TR10.03.0509 | 0509 | yes | WS_"Jiný typ" studená vnitřní 1
13015021 | 4.NP_SO-102 | 395.469 | 0.000804127 | 0.0397569 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15337.6 | PP–RCT S4 | 32 | 179 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 395.469 | ø32 | 24.8 | TR10.03.0510 | 0510 | yes | WS_Studená vnitřní 134 | 0
13015039 | 4.NP_SO-102 | 53.5952 | 0.000804127 | 0.00538798 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15337.6 | PP–RCT S4 | 32 | 181 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 53.5952 | ø32 | 24.8 | TR10.03.0511 | 0511 | yes | WS_Studená vnitřní 134 | 0
13015134 | 3.NP_SO-102 | 33.8424 | 0.000804127 | 0.00340221 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11337.6 | PP–RCT S4 | 32 | 452 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 33.8424 | ø32 | 24.8 | TR10.03.0512 | 0512 | yes | WS_Studená vnitřní 134 | 0
13015136 | 3.NP_SO-102 | 3943.32 | 0.00125645 | 0.495533 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 3.NP_SO-102 | 3316.66 | 3316.66 | -626.663 | -626.663 | -626.663 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7373.34 | PP–RCT S4 | 40 | 177 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3943.32 | ø40 | 31 | TR10.03.0513 | 0513 | yes | WS_Studená vnitřní 134 | Identifikační data - Komentáře: V3
13015240 | 4.NP_SO-102 | 3735.99 | 0.000804127 | 0.375583 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3169.84 | -566.153 | 3169.84 | -566.153 | 3169.84 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11433.8 | PP–RCT S4 | 32 | 10 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3735.99 | ø32 | 24.8 | TR10.03.0514 | 0514 | yes | WS_Teplá vnitřní 83
13015529 | 2.NP_SO-102 | 3743.13 | 0.00125645 | 0.470376 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 2.NP_SO-102 | 3166.66 | 3166.66 | -576.472 | -576.472 | -576.472 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3423.53 | PP–RCT S4 | 40 | 165 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3743.13 | ø40 | 31 | TR10.03.0515 | 0515 | yes | WS_Teplá vnitřní 83
13015888 | 3.NP_SO-102 | 2626.03 | 0.000804127 | 0.263997 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11337.6 | PP–RCT S4 | 32 | 190 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2626.03 | ø32 | 24.8 | TR10.03.0516 | 0516 | yes | WS_Studená vnitřní 134 | 0
13015900 | 3.NP_SO-102 | 81.5255 | 0.000804127 | 0.00819584 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11337.6 | PP–RCT S4 | 32 | 452 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 81.5255 | ø32 | 24.8 | TR10.03.0517 | 0517 | yes | WS_Studená vnitřní 134 | 0
13015987 | 4.NP_SO-102 | 76.1063 | 0.000804127 | 0.00765103 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15337.6 | PP–RCT S4 | 32 | 182 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 76.1063 | ø32 | 24.8 | TR10.03.0518 | 0518 | yes | WS_Studená vnitřní 134 | 0
13015999 | 4.NP_SO-102 | 76.5255 | 0.000804127 | 0.00769318 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15337.6 | PP–RCT S4 | 32 | 181 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 76.5255 | ø32 | 24.8 | TR10.03.0519 | 0519 | yes | WS_Studená vnitřní 134 | 0
13016301 | -1.PP_SO-102 | 151.563 | 0.0019632 | 0.0238075 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3325 | 3300 | 3300 | 3275 | 3300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -719.4 | PP–RCT S4 | 50 | 400 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 151.563 | ø50 | 38.8 | TR10.03.0520 | 0520 | yes | WS_Studená vnitřní 134 | 0
13016363 | -1.PP_SO-102 | 247.375 | 0.000804127 | 0.0248688 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3316 | 3300 | 3300 | 3284 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -712.4 | PP–RCT S4 | 32 | 238 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 247.375 | ø32 | 24.8 | TR10.03.0521 | 0521 | yes | WS_Cirkulace vnitřní 9 | 0
13016388 | -1.PP_SO-102 | 331.236 | 0.000804127 | 0.0332995 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3316 | 3300 | 3300 | 3284 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -712.4 | PP–RCT S4 | 32 | 238 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 331.236 | ø32 | 24.8 | TR10.03.0522 | 0522 | yes | WS_Cirkulace vnitřní 9 | 0
13016509 | -1.PP_SO-102 | 5930.13 | 0.000804127 | 0.596162 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3316 | 3300 | 3300 | 3284 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 4 | -712.4 | PP–RCT S4 | 32 | 52 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5930.13 | ø32 | 24.8 | TR10.03.0523 | 0523 | yes | WS_Cirkulace vnitřní 4 | 0
13016547 | -1.PP_SO-102 | 3646.01 | 0.000804127 | 0.366537 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3116 | 3100 | 3100 | 3084 | 3100 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 4 | -912.4 | PP–RCT S4 | 32 | 52 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3646.01 | ø32 | 24.8 | TR10.03.0524 | 0524 | no | WS_Cirkulace vnitřní 4 | 0
13016614 | -1.PP_SO-102 | 5816.62 | 0.00125645 | 0.730938 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 2920 | 2900 | 2900 | 2880 | 2900 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1115.5 | PP–RCT S4 | 40 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5816.62 | ø40 | 31 | TR10.03.0525 | 0525 | yes | WS_Cirkulace vnitřní 9 | 0
13016926 | -1.PP_SO-102 | 6697.08 | 0.00125645 | 0.84158 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 2920 | 2900 | 2900 | 2880 | 2900 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1115.5 | PP–RCT S4 | 40 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6697.08 | ø40 | 31 | TR10.03.0526 | 0526 | yes | WS_Cirkulace vnitřní 9 | 0
13017093 | -1.PP_SO-102 | 328.325 | 0.0019632 | 0.0515732 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3325 | 3300 | 3300 | 3275 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -719.4 | PP–RCT S4 | 50 | 330 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 328.325 | ø50 | 38.8 | TR10.03.0527 | 0527 | yes | WS_Teplá vnitřní 83 | 0
13018303 | 4.NP_SO-102 | 30.4517 | 0.000804127 | 0.00306134 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3260.61 | 3230.16 | 3260.61 | 3230.16 | 3260.61 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15230.2 | PP–RCT S4 | 32 | 126 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 30.4517 | ø32 | 24.8 | TR10.03.0528 | 0528 | yes | WS_Teplá vnitřní 83
13018604 | 4.NP_SO-102 | 45.439 | 0.000804127 | 0.00456802 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3366.38 | 3320.94 | 3366.38 | 3320.94 | 3366.38 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15320.9 | PP–RCT S4 | 32 | 39 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 45.439 | ø32 | 24.8 | TR10.03.0529 | 0529 | yes | WS_Teplá vnitřní 83
13018613 | 4.NP_SO-102 | 39.675 | 0.000804127 | 0.00398857 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3269.84 | 3269.84 | 3230.16 | 3230.16 | 3230.16 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15230.2 | PP–RCT S4 | 32 | 104 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 39.675 | ø32 | 24.8 | TR10.03.0530 | 0530 | yes | WS_Teplá vnitřní 83
13018839 | -1.PP_SO-102 | 3536.35 | 0.0004908 | 0.277744 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3112.5 | 3100 | 3100 | 3087.5 | 3100 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -909.7 | PP–RCT S4 | 25 | 401 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3536.35 | ø25 | 19.4 | TR10.03.0531 | 0531 | no | WS_Teplá vnitřní 83 | 0
13018864 | -1.PP_SO-102 | 341.136 | 0.00125645 | 0.0428684 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 3320 | 3300 | 3300 | 3280 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -715.5 | PP–RCT S4 | 40 | 325 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 341.136 | ø40 | 31 | TR10.03.0532 | 0532 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13018934 | -1.PP_SO-102 | 78.0384 | 0.00125645 | 0.0098066 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 3320 | 3300 | 3300 | 3280 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -715.5 | PP–RCT S4 | 40 | 325 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 78.0384 | ø40 | 31 | TR10.03.0533 | 0533 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13019097 | -1.PP_SO-102 | 4629.62 | 0.000314112 | 0.290888 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3110 | 3100 | 3100 | 3090 | 3100 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -907.7 | PP–RCT S4 | 20 | 64 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4629.62 | ø20 | 15.4 | TR10.03.0534 | 0534 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13019841 | -1.PP_SO-102 | 4352.74 | 0.0004908 | 0.341863 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 2912.5 | 2900 | 2900 | 2887.5 | 2900 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1109.7 | PP–RCT S4 | 25 | 435 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4352.74 | ø25 | 19.4 | TR10.03.0535 | 0535 | no | WS_Teplá vnitřní 83 | 0
13020801 | -1.PP_SO-102 | 2377.73 | 0.000314112 | 0.149397 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -657.7 | PP–RCT S4 | 20 | 261 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2377.73 | ø20 | 15.4 | TR10.03.0536 | 0536 | no | WS_Teplá vnitřní 83 | 0
13020871 | -1.PP_SO-102 | 1030.91 | 0.00311678 | 0.204038 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3381.5 | 3350 | 3350 | 3318.5 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -674.4 | PP–RCT S4 | 63 | 445 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1030.91 | ø63 | 48.8 | TR10.03.0537 | 0537 | yes | WS_Teplá vnitřní 83 | 0
13020887 | -1.PP_SO-102 | 7953.16 | 0.00311678 | 1.57409 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3381.5 | 3350 | 3350 | 3318.5 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -674.4 | PP–RCT S4 | 63 | 432 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 7953.16 | ø63 | 48.8 | TR10.03.0538 | 0538 | yes | WS_Teplá vnitřní 83 | 0
13021066 | -1.PP_SO-102 | 351.734 | 0.0019632 | 0.0552502 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3325 | 3300 | 3300 | 3275 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -719.4 | PP–RCT S4 | 50 | 330 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 351.734 | ø50 | 38.8 | TR10.03.0539 | 0539 | yes | WS_Teplá vnitřní 83 | 0
13021086 | -1.PP_SO-102 | 345.459 | 0.000804127 | 0.0347293 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3316 | 3300 | 3300 | 3284 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -712.4 | PP–RCT S4 | 32 | 238 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 345.459 | ø32 | 24.8 | TR10.03.0540 | 0540 | yes | WS_Cirkulace vnitřní 9 | 0
13022382 | -1.PP_SO-102 | 235.429 | 0.0019632 | 0.036981 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3325 | 3300 | 3300 | 3275 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -719.4 | PP–RCT S4 | 50 | 330 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 235.429 | ø50 | 38.8 | TR10.03.0541 | 0541 | yes | WS_Teplá vnitřní 83 | 0
13022418 | -1.PP_SO-102 | 167.352 | 0.0019632 | 0.0262876 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3325 | 3300 | 3300 | 3275 | 3300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -719.4 | PP–RCT S4 | 50 | 400 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 167.352 | ø50 | 38.8 | TR10.03.0542 | 0542 | yes | WS_Studená vnitřní 134 | 0
13022553 | -1.PP_SO-102 | 13974.4 | 0.00311678 | 2.76582 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3431.5 | 3400 | 3400 | 3368.5 | 3400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -624.4 | PP–RCT S4 | 63 | 337 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 13974.4 | ø63 | 48.8 | TR10.03.0543 | 0543 | yes | WS_Studená vnitřní 134 | 0
13022586 | -1.PP_SO-102 | 13835.9 | 0.00125645 | 1.73868 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 3420 | 3400 | 3400 | 3380 | 3400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -615.5 | PP–RCT S4 | 40 | 224 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 13835.9 | ø40 | 31 | TR10.03.0544 | 0544 | yes | WS_Cirkulace vnitřní 9 | 0
13022611 | -1.PP_SO-102 | 13588.5 | 0.00311678 | 2.68944 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3431.5 | 3400 | 3400 | 3368.5 | 3400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -624.4 | PP–RCT S4 | 63 | 279 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 13588.5 | ø63 | 48.8 | TR10.03.0545 | 0545 | yes | WS_Teplá vnitřní 83 | 0
13022730 | -1.PP_SO-102 | 4566.66 | 0.0019632 | 0.71733 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 2675 | 2650 | 2650 | 2625 | 2650 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | -1369.4 | PP–RCT S4 | 50 | 170 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4566.66 | ø50 | 38.8 | TR10.03.0546 | 0546 | yes | WS_Studená vnitřní 6 | 0
13022759 | -1.PP_SO-102 | 71.0477 | 0.0019632 | 0.0111601 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 2674.8 | 2649.8 | 2649.8 | 2624.8 | 2649.8 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | -1369.6 | PP–RCT S4 | 50 | 199 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 71.0477 | ø50 | 38.8 | TR10.03.0547 | 0547 | yes | WS_Studená vnitřní 6 | 0
13022815 | -1.PP_SO-102 | 4456.19 | 0.000804127 | 0.447985 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 2666 | 2650 | 2650 | 2634 | 2650 | Fáze 2 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 3 | -1362.4 | PP–RCT S4 | 32 | 2 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4456.19 | ø32 | 24.8 | TR10.03.0548 | 0548 | yes | WS_Cirkulace vnitřní 3 | 0
13022836 | -1.PP_SO-102 | 216.891 | 0.000804127 | 0.0218043 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 2666 | 2650 | 2650 | 2634 | 2650 | Fáze 2 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 3 | -1362.4 | PP–RCT S4 | 32 | 8 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 216.891 | ø32 | 24.8 | TR10.03.0549 | 0549 | yes | WS_Cirkulace vnitřní 3 | 0
13022892 | -1.PP_SO-102 | 4339.14 | 0.0019632 | 0.68159 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 2675 | 2650 | 2650 | 2625 | 2650 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | -1369.4 | PP–RCT S4 | 50 | 8 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4339.14 | ø50 | 38.8 | TR10.03.0550 | 0550 | yes | WS_Teplá vnitřní 8 | 0
13022913 | -1.PP_SO-102 | 298.575 | 0.0019632 | 0.0469 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 2674.95 | 2649.95 | 2649.95 | 2624.95 | 2649.95 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | -1369.45 | PP–RCT S4 | 50 | 199 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 298.575 | ø50 | 38.8 | TR10.03.0551 | 0551 | yes | WS_Teplá vnitřní 8 | 0
13022959 | 4.NP_SO-102 | 6.025 | 0.000804127 | 0.000605699 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3321.11 | 3321.11 | 3315.09 | 3315.09 | 3315.09 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15315.1 | PP–RCT S4 | 32 | 139 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6.025 | ø32 | 24.8 | TR10.03.0552 | 0552 | yes | WS_Teplá vnitřní 8
13022987 | 4.NP_SO-102 | 16587.3 | 0.000804127 | 1.66754 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3261.11 | 3261.11 | -13326.2 | -13326.2 | -13326.2 | Fáze 2 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 3 | -1326.19 | PP–RCT S4 | 32 | 8 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 16587.3 | ø32 | 24.8 | TR10.03.0553 | 0553 | yes | WS_Cirkulace vnitřní 3
