Properties of the parts of a building model (IFC4), part 12 of 60

# IfcDistributionPort (11856)
Name | FlowDirection | PredefinedType | SystemType | Group
OutPort_12898542_1 | SOURCE | PIPE | SEWAGE
InPort_12898543_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 135
InPort_12898545_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 135
OutPort_12898543_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 135
InPort_12898544_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 131
InPort_12898547_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 131
OutPort_12898544_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 131
InPort_12898549_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 135
OutPort_12898545_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 135
InPort_12898549_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 131
OutPort_12898547_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 131
Port_12898551_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12898602_1 | SINK | PIPE | SEWAGE
OutPort_12898593_1 | SOURCE | PIPE | SEWAGE
InPort_12898594_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 137
InPort_12898596_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 137
OutPort_12898594_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 137
InPort_12898595_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 133
InPort_12898598_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 133
OutPort_12898595_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 133
InPort_12898600_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 137
OutPort_12898596_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 137
InPort_12898600_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 133
OutPort_12898598_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 133
Port_12898602_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12899107_1 | SINK | PIPE | SEWAGE
OutPort_12899098_1 | SOURCE | PIPE | SEWAGE
InPort_12899099_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 79
InPort_12899101_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 79
OutPort_12899099_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 79
InPort_12899100_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 50
InPort_12899103_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 50
OutPort_12899100_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 50
InPort_12899105_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 79
OutPort_12899101_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 79
InPort_12899105_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 50
OutPort_12899103_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 50
Port_12899107_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_12899363_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12899366_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 46
OutPort_12899369_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 46
InPort_12899366_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 23
OutPort_12899371_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 23
InPort_12899367_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 23
InPort_12899371_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 23
OutPort_12899367_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 23
InPort_12899368_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 46
InPort_12899369_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 46
OutPort_12899368_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 46
Port_12899417_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12899420_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12899478_1 | SINK | PIPE | SEWAGE
OutPort_12899469_1 | SOURCE | PIPE | SEWAGE
InPort_12899470_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 57
InPort_12899472_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 57
OutPort_12899470_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 57
InPort_12899471_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 56
InPort_12899474_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 56
OutPort_12899471_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 56
InPort_12899476_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 57
OutPort_12899472_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 57
InPort_12899476_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 56
OutPort_12899474_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 56
Port_12899478_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_12899554_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12899557_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 51
OutPort_12899560_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 51
InPort_12899557_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 45
OutPort_12899562_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 45
InPort_12899558_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 45
InPort_12899562_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 45
OutPort_12899558_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 45
InPort_12899559_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 51
InPort_12899560_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 51
OutPort_12899559_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 51
Port_12899599_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12899602_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12899628_1 | SINK | PIPE | SEWAGE
OutPort_12899619_1 | SOURCE | PIPE | SEWAGE
InPort_12899620_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 139
InPort_12899622_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 139
OutPort_12899620_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 139
InPort_12899621_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 135
InPort_12899624_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 135
OutPort_12899621_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 135
InPort_12899626_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 139
OutPort_12899622_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 139
InPort_12899626_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 135
OutPort_12899624_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 135
Port_12899628_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12903605_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_12904288_2 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 1
InPort_13362702_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 1
OutPort_12903605_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_13243174_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_12903732_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_12903732_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13181847_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13688672_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12904288_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12904856_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12919424_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13427018_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12904856_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12904871_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13689730_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689885_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12904871_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12904886_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12940880_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13671373_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12904886_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13243242_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_12911809_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_12911809_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237078_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_12912135_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13428991_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13439200_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12912135_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12912181_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13402627_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12939194_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12912181_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13100943_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12912653_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12912653_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13462330_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_12912668_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13681489_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_12912668_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13545760_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12912681_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12912681_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13434227_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12912964_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13267077_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13170678_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_12912964_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_12913030_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13163888_2 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 16
InPort_13682932_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_12913030_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_12913041_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999401_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_12913041_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12913117_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13163384_2 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 16
InPort_13682360_3 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_12913117_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13163910_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12913132_0 | SOURCE | PIPE | VENT | SW_Splašky vnitřní gravitační 35 (1)
InPort_13682747_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_12913132_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_12913493_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13152534_2 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 16
InPort_14019710_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_12913493_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_12913504_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13154012_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_12913504_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_12913515_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13153771_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_12913515_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13152738_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
OutPort_12913552_0 | SOURCE | PIPE | VENT | SW_Splašky vnitřní gravitační 4
InPort_13156735_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_12913552_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_12913565_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153499_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_12913565_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_12913578_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_13153529_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
Port_12913578_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 4
InPort_13165347_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_12913610_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_12913610_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_12919749_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_12913860_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242914_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13243345_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_12913860_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_12913862_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 15
OutPort_13444203_2 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 15
InPort_13444260_1 | SINK | PIPE | SEWAGE | SW_Odvětrání kanalizace 15
OutPort_12913862_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 15
InPort_12913903_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13690091_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13690095_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12913903_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13096422_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 10
OutPort_12913931_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 10
InPort_12913931_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 10
OutPort_13096384_2 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 10
Port_12913944_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13100058_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_12913944_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13690904_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13095098_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12913983_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12913983_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13095242_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13099792_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 17
OutPort_12914032_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 17
InPort_12914032_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 17
OutPort_13099715_2 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 17
InPort_12914082_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13098740_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13099007_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12914082_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_12914171_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13099975_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_12914171_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_12914209_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13533524_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12914209_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13533542_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12915131_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13660548_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_12915131_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_12915142_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13660438_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_12915142_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_12917557_1 | SINK | PIPE | SEWAGE | SW_Odvětrání kanalizace 1
OutPort_13362690_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 1
InPort_12917852_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 2
OutPort_12917856_2 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 2
InPort_12917858_1 | SINK | PIPE | SEWAGE | SW_Odvětrání kanalizace 2
OutPort_12917852_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 2
InPort_12917854_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12917856_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13404007_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12917854_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12917986_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 3
OutPort_12917990_2 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 3
InPort_12917992_1 | SINK | PIPE | SEWAGE | SW_Odvětrání kanalizace 3
OutPort_12917986_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 3
InPort_13363559_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12917990_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12918154_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13404007_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12918188_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12918154_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12918178_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12918188_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12918203_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12918178_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12918193_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12918203_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12918251_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12918193_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13428859_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12918251_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12919424_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12919200_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12919200_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13363037_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12919739_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 6
OutPort_12919749_2 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 6
OutPort_12919739_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 6
InPort_12924274_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 7
OutPort_14020970_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 7
InPort_12924280_1 | SINK | PIPE | SEWAGE | SW_Odvětrání kanalizace 7
OutPort_12924274_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 7
InPort_13680742_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12924278_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14020874_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 7
OutPort_12924278_2 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 7
InPort_12924316_1 | SINK | PIPE | SEWAGE | SW_Odvětrání kanalizace 8
OutPort_13102087_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 8
InPort_12924337_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13101492_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13434231_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12924337_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12924343_1 | SINK | PIPE | SEWAGE | SW_Odvětrání kanalizace 9
OutPort_13101582_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 9
OutPort_12932540_1 | SOURCE | PIPE | SEWAGE
Port_12932541_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_12932541_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12932544_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_12932544_2 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12934796_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13428747_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13429314_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12934796_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12936312_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13403769_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13403175_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12936312_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12937667_1 | SOURCE | PIPE | SEWAGE
Port_12937668_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_12937668_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12937671_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_12937671_2 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12937710_1 | SOURCE | PIPE | SEWAGE
Port_12937711_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_12937711_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12937714_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_12937714_2 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12939102_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12939190_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12939226_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12939102_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12939190_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12939171_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12939171_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12939194_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12939218_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12939226_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12939260_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12939218_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689730_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12939260_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12941174_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12940644_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12940644_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12941178_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12940852_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12941174_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12940880_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12940852_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12941139_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12941147_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12941178_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12941139_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12941147_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13461506_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12941323_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 4
OutPort_12941325_1 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 4
InPort_12941588_1 | SINK | PIPE | SEWAGE | SW_Odvětrání kanalizace 4
OutPort_12941323_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 4
InPort_13461523_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_12941325_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_12942839_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_13018612_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_12948195_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_12942839_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12943945_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12968852_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12943945_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12945464_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13014457_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12945464_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12945482_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12945476_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335586_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12945476_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12945482_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13335587_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12946222_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12946365_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12946222_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525236_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12946255_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12948616_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12946255_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12948346_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12946268_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12958678_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12946268_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12948580_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12946271_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12948346_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12946271_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12946365_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12966893_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12947097_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13013020_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12947097_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12948765_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12948031_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12968709_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12948031_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12955328_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12948053_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12968688_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12948053_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12968607_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12948053_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12958680_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12948054_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12955067_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12948054_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12968607_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13018608_2 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_12948155_0 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_12948155_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_13018620_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12948547_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12964064_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12948547_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12964060_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12948580_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525002_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12948580_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12964060_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12948616_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12963601_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12948745_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12968709_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12948745_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12968632_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12948745_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12968729_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12948746_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12968632_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12948746_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12955115_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12948751_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12948810_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12948751_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12948814_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12948763_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12948765_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12948763_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12948810_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12948814_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12948815_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_13018613_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_12948814_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12948815_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12966621_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12949126_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12949139_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12949126_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12949149_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12949139_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13068564_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12949149_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13011336_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12949223_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005468_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12949223_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13014812_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12949249_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13506976_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12949249_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12949363_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12949371_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12949363_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12949782_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12949371_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005516_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12949782_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13015039_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12949983_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950613_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12949983_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13645540_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12949985_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950258_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12949985_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950410_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12949991_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13645534_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12949991_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950259_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950060_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950262_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950060_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950256_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950258_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950256_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950262_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950258_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12954990_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950259_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12954990_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950318_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950402_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950318_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950400_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950402_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950400_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950410_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950568_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13646730_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950568_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950610_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13646730_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950610_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13016006_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950613_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13015969_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950936_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12951221_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12950936_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005470_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12951221_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13506976_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13533436_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_12951738_0 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_12951738_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_13018603_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12951956_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954711_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12951956_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12952125_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12952076_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13018303_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12952076_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13015240_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12952076_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954711_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12952095_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005495_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12952095_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12952634_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12952123_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12952125_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12952123_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12952127_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12952127_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005497_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12952634_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12953598_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12953589_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13507018_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12953589_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12953598_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13507018_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12953751_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12953761_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12953751_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12953771_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12953761_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13018604_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12953765_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13001322_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12953765_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954052_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12953771_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005540_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954042_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954052_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954042_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954198_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954184_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954281_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954184_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954355_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954198_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954282_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954224_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954285_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954224_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954279_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954281_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954279_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954285_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954281_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13001320_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954282_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13001320_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954309_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954357_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954309_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954353_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954355_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954353_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954357_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954377_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954608_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954377_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954438_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954887_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954438_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954608_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954440_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13001322_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954440_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954441_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954440_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954887_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12954441_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005538_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12955024_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12955067_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12955024_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12955103_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12955115_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12955103_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12955169_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12968688_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12955169_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12955230_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12955222_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12955230_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12955222_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12955320_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12955328_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12955320_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956184_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12967967_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956184_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956186_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13014585_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12956186_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13014587_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12956192_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956200_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956192_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13645928_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956194_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12967876_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956194_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956222_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956196_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12967541_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956196_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956226_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956198_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956222_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956198_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956200_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12967251_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956204_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12967403_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956204_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956282_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956206_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12968566_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956206_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956207_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956206_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12967543_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956207_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12966228_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956224_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12967890_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956224_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12967888_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956226_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12968054_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956226_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12967888_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956228_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12967876_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956228_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12967659_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956230_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12968054_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956230_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524449_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956232_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524449_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956232_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524451_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956240_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12967403_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956240_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12967311_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956240_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12967298_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956244_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12969016_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956244_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12969020_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956246_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956248_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956246_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12969016_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956248_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12967602_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956258_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524338_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956258_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13013112_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956258_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13645930_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956274_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12968566_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956274_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956278_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956276_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956278_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956276_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12965903_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956280_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956282_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956280_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12965933_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956444_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12984669_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956444_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956446_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13014511_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12956446_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13037757_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12956448_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13010259_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12956448_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12956452_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956460_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956452_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524091_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956454_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13013924_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956454_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956482_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956458_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956482_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956458_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956460_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12984671_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956466_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13009989_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956466_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956467_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956466_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13010161_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956467_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12984058_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956500_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13071903_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956500_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12984532_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956500_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12984687_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956501_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12984532_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956501_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956528_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956504_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13012636_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956504_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13012648_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956506_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13013806_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956506_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13012636_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956522_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12984058_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956522_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12984257_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956526_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956528_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956526_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12984182_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956532_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13071848_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956532_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13071850_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12956536_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13071921_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12956536_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13071923_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12958659_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12968731_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12958659_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12968657_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12958662_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12968729_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12958662_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12968731_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12958678_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12958680_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12963599_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
