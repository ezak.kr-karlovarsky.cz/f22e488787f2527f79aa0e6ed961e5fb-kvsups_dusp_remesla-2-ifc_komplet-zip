Properties of the parts of a building model (IFC4), part 44 of 60

# IfcPipeSegment: Typy trubek:Ocel_pozink (uvnitř / vně pozinkovaná) (155)
Name (Typy trubek:Ocel_pozink (uvnitř / vně pozinkovaná):...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Celková velikost | Relativní drsnost | CCI Technický systém | Referenční podlaží | Sklon | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Typ systému | Drsnost (mm) | Klasifikace systému | Materiál | Název systému = Group | Obrátit výšku (mm) | Plocha (m2) | Popis úseku | Průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení
13764077 | -1.PP_SO-102 | 2315.31 | 0.00620623 | 0.646638 | ø89 mm | 0 | JD | -1.PP_SO-102 |  | 3172.8 | 3172.8 | 857.487 | 857.487 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -3142.51 | 0.647366 | Zn | 89 | 390 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1836 | 1836 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13764097 | -1.PP_SO-102 | 9280.62 | 0.00620623 | 2.59196 | ø89 mm | 0.00117786 | JD | -1.PP_SO-102 | 0 | 3269.69 | 3225.24 | 3225.24 | 3180.79 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -817.212 | 2.59488 | Zn | 89 | 406 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1837 | 1837
13764105 | -1.PP_SO-102 | 5235.13 | 0.00620623 | 1.46211 | ø89 mm | 0.00117786 | JD | -1.PP_SO-102 | 0 | 3269.69 | 3225.24 | 3225.24 | 3180.79 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -817.212 | 1.46375 | Zn | 89 | 406 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1838 | 1838
13764114 | -1.PP_SO-102 | 2299.27 | 0.00620623 | 0.642157 | ø89 mm | 0 | JD | -1.PP_SO-102 |  | 3172.8 | 3172.8 | 873.531 | 873.531 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -3126.47 | 0.64288 | Zn | 89 | 406 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1839 | 1839
13764269 | -1.PP_SO-102 | 10110.9 | 0.00620623 | 2.82384 | ø89 mm | 0.00117786 | JD | -1.PP_SO-102 | 0 | 849.5 | 805.05 | 805.05 | 760.6 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -3237.4 | 2.82702 | Zn | 89 | 390 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1841 | 1841 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13764404 | -1.PP_SO-102 | 1994.59 | 0.00620623 | 0.557065 | ø89 mm | 0 | JD | -1.PP_SO-102 |  | 2852.08 | 2852.08 | 857.488 | 857.488 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -3142.51 | 0.557692 | Zn | 89 | 390 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1843 | 1843 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13764595 | -1.PP_SO-102 | 544.519 | 0.00620623 | 0.152077 | ø89 mm | 0.00117786 | JD | -1.PP_SO-102 | 0 | 2948.97 | 2904.52 | 2904.52 | 2860.07 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1137.93 | 0.152248 | Zn | 89 | 390 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1845 | 1845 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13807023 | -1.PP_SO-102 | 1238.88 | 0.00138523 | 0.163466 | ø42 mm | 0.0025641 | JB | -1.PP_SO-102 | 0 | 2821 | 2800 | 2800 | 2779 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -1219.5 | 0.163466 | Zn | 42 | 121 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø42 | 42 | 39 | TR03.04.1847 | 1847
13807208 | -1.PP_SO-102 | 7322.35 | 0.00138523 | 0.966162 | ø42 mm | 0.0025641 | JB | -1.PP_SO-102 | 0 | 3246.24 | 3225.24 | 3225.24 | 3204.24 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -794.262 | 0.966162 | Zn | 42 | 148 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø42 | 42 | 39 | TR03.04.1850 | 1850
13807356 | -1.PP_SO-102 | 542.125 | 0.00138523 | 0.0715317 | ø42 mm | 0 | JD | -1.PP_SO-102 |  | 3371.06 | 3371.06 | 2828.94 | 2828.94 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -1171.06 | 0.0715317 | Zn | 42 | 121 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø42 | 42 | 39 | TR03.04.1855 | 1855
13807764 | -1.PP_SO-102 | 367.363 | 0.00138523 | 0.0484724 | ø42 mm | 0 | JD | -1.PP_SO-102 |  | 3196.3 | 2828.94 | 3196.3 | 2828.94 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -1171.06 | 0.0484724 | Zn | 42 | 148 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø42 | 42 | 39 | TR03.04.1864 | 1864
13807976 | -1.PP_SO-102 | 2358.91 | 0.00620623 | 0.658815 | ø89 mm | 0.00117786 | JB | -1.PP_SO-102 | 0 | 2844.45 | 2800 | 2800 | 2755.55 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1242.45 | 0.659556 | Zn | 89 | 406 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1865 | 1865
13808029 | -1.PP_SO-102 | 320.363 | 0.00620623 | 0.0894734 | ø89 mm | 0 | JD | -1.PP_SO-102 |  | 3172.8 | 3172.8 | 2852.44 | 2852.44 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1147.56 | 0.0895741 | Zn | 89 | 406 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1866 | 1866
13808149 | -1.PP_SO-102 | 320.363 | 0.00620623 | 0.0894734 | ø89 mm | 0 | JD | -1.PP_SO-102 |  | 3172.8 | 3172.8 | 2852.44 | 2852.44 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1147.56 | 0.0895741 | Zn | 89 | 406 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1867 | 1867
13808263 | -1.PP_SO-102 | 8457.89 | 0.00620623 | 2.36218 | ø89 mm | 0.00117786 | JB | -1.PP_SO-102 | 0 | 3269.69 | 3225.24 | 3225.24 | 3180.79 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -817.212 | 2.36484 | Zn | 89 | 406 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1868 | 1868
13808272 | -1.PP_SO-102 | 1324.52 | 0.00620623 | 0.369922 | ø89 mm | 0.00117786 | JB | -1.PP_SO-102 | 0 | 3269.69 | 3225.24 | 3225.24 | 3180.79 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -817.212 | 0.370338 | Zn | 89 | 398 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1869 | 1869
13808317 | -1.PP_SO-102 | 2549.4 | 0.00620623 | 0.712016 | ø89 mm | 0.00117786 | JB | -1.PP_SO-102 | 0 | 2844.45 | 2800 | 2800 | 2755.55 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1242.45 | 0.712817 | Zn | 89 | 398 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1870 | 1870
13808365 | -1.PP_SO-102 | 320.363 | 0.00620623 | 0.0894734 | ø89 mm | 0 | JD | -1.PP_SO-102 |  | 3172.8 | 2852.44 | 3172.8 | 2852.44 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1147.56 | 0.0895741 | Zn | 89 | 398 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1871 | 1871
13808516 | -1.PP_SO-102 | 727.948 | 0.00620623 | 0.203307 | ø89 mm | 0.00117786 | JD | -1.PP_SO-102 | 0 | 2844.45 | 2800 | 2800 | 2755.55 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1242.45 | 0.203535 | Zn | 89 | 287 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1872 | 1872
13808523 | -1.PP_SO-102 | 1677.11 | 0.00620623 | 0.468397 | ø89 mm | 0.00117786 | JB | -1.PP_SO-102 | 0 | 2844.45 | 2800 | 2800 | 2755.55 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1242.45 | 0.468924 | Zn | 89 | 398 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1873 | 1873
13822531 | -1.PP_SO-102 | 755.299 | 0.00138523 | 0.0996594 | ø42 mm | 0.0025641 | JB | -1.PP_SO-102 | 0 | 2521 | 2500 | 2500 | 2479 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -1519.5 | 0.0996594 | Zn | 42 | 148 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø42 | 42 | 39 | TR03.04.1875 | 1875
13822603 | -1.PP_SO-102 | 1292.67 | 0.00620623 | 0.361028 | ø89 mm | 0.00117786 | JB | -1.PP_SO-102 | 0 | 2544.45 | 2500 | 2500 | 2455.55 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1542.45 | 0.361434 | Zn | 89 | 406 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1879 | 1879
13822812 | -1.PP_SO-102 | 32.0897 | 0.00620623 | 0.00896224 | ø89 mm | 0 | JD | -1.PP_SO-102 | 0 | 2644.45 | 2600 | 2600 | 2555.55 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1442.45 | 0.00897233 | Zn | 89 | 406 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1880 | 1880
13822813 | -1.PP_SO-102 | 97.9807 | 0.00620623 | 0.0273648 | ø89 mm | 0 | JD | -1.PP_SO-102 | 100 | 2616.07 | 2515.36 | 2584.64 | 2483.93 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1514.66 | 0.0273956 | Zn | 89 | 406 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1881 | 1881
13822992 | -1.PP_SO-102 | 342.125 | 0.00138523 | 0.0451423 | ø42 mm | 0 | JD | -1.PP_SO-102 |  | 2871.06 | 2528.94 | 2871.06 | 2528.94 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -1471.06 | 0.0451423 | Zn | 42 | 148 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø42 | 42 | 39 | TR03.04.1886 | 1886
13823015 | -1.PP_SO-102 | 42.125 | 0.00138523 | 0.00555826 | ø42 mm | 0 | JD | -1.PP_SO-102 |  | 2571.06 | 2528.94 | 2571.06 | 2528.94 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -1471.06 | 0.00555826 | Zn | 42 | 148 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø42 | 42 | 39 | TR03.04.1887 | 1887
13823196 | -1.PP_SO-102 | 1765.77 | 0.00620623 | 0.493159 | ø89 mm | 0 | JD | -1.PP_SO-102 | 0 | 2644.45 | 2600 | 2600 | 2555.55 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1442.45 | 0.493714 | Zn | 89 | 406 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1892 | 1892
13823197 | -1.PP_SO-102 | 97.9807 | 0.00620623 | 0.0273648 | ø89 mm | 0 | JD | -1.PP_SO-102 | 100 | 2616.07 | 2515.36 | 2584.64 | 2483.93 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1514.66 | 0.0273956 | Zn | 89 | 406 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1893 | 1893
13825256 | -1.PP_SO-102 | 7775.35 | 0.00620623 | 2.17156 | ø89 mm | 0.00117786 | JD | -1.PP_SO-102 | 0 | 3269.69 | 3225.24 | 3225.24 | 3180.79 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -817.212 | 2.174 | Zn | 89 | 406 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1912 | 1912
13825264 | -1.PP_SO-102 | 141.269 | 0.00620623 | 0.0394547 | ø89 mm | 0.00117786 | JD | -1.PP_SO-102 | 0 | 3269.69 | 3225.24 | 3225.24 | 3180.79 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -817.212 | 0.0394991 | Zn | 89 | 406 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.1913 | 1913
13826482 | -1.PP_SO-102 | 2614.3 | 0.0004908 | 0.205327 | ø25 mm | 0.000515464 | JB | -1.PP_SO-102 | 0 | 2662.5 | 2650 | 2650 | 2637.5 | Fáze 2 | WS_Požární zavodněný | 0.01 | Požární ochrana – vodní prostředky | Trubka Evo, S4 | WS_Požární zavodněný 3 | -1359.7 | 0.205327 | PP–RCT S4 | 25 | 58 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | ø25 | 25 | 19.4 | TR03.04.1922 | 1922
13826706 | -1.PP_SO-102 | 25197.9 | 0.000961968 | 2.77065 | ø35 mm | 0.003125 | JB | -1.PP_SO-102 | 0 | 3417.5 | 3400 | 3400 | 3382.5 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -616 | 2.77065 | Zn | 35 | 144 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 35 | 32 | TR03.04.1930 | 1930
13826847 | -1.PP_SO-102 | 533.963 | 0.0004908 | 0.0419374 | ø25 mm | 0 | JD | -1.PP_SO-102 |  | 3204.6 | 3204.6 | 2670.64 | 2670.64 | Fáze 2 | WS_Požární zavodněný | 0.01 | Požární ochrana – vodní prostředky | Trubka Evo, S4 | WS_Požární zavodněný 3 | -1329.36 | 0.0419374 | PP–RCT S4 | 25 | 58 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | ø25 | 25 | 19.4 | TR03.04.1931 | 1931
13827227 | -1.PP_SO-102 | 749.125 | 0.000961968 | 0.0823706 | ø35 mm | 0 | JD | -1.PP_SO-102 |  | 3374.56 | 2625.44 | 3374.56 | 2625.44 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -1374.56 | 0.0823706 | Zn | 35 | 144 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 35 | 32 | TR03.04.1939 | 1939
13829134 | -1.PP_SO-102 | 27.9812 | 0.000961968 | 0.0030767 | ø35 mm | 0 | JD | -1.PP_SO-102 |  | 3353.42 | 3325.44 | 3353.42 | 3325.44 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -674.562 | 0.0030767 | Zn | 35 | 145 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø35 | 35 | 32 | TR03.04.1949 | 1949
13839297 | -1.PP_SO-102 | 1523.4 | 0.00620623 | 0.425468 | ø89 mm | 0.00117786 | JB | -1.PP_SO-102 | 0 | 2444.45 | 2400 | 2400 | 2355.55 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1642.45 | 0.425946 | Zn | 89 | 406 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.2005 | 2005
13839483 | -1.PP_SO-102 | 2093.18 | 0.00138523 | 0.276188 | ø42 mm | 0.0025641 | JB | -1.PP_SO-102 | 0 | 2431 | 2410 | 2410 | 2389 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -1609.5 | 0.276188 | Zn | 42 | 148 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø42 | 42 | 39 | TR03.04.2008 | 2008
13840135 | -1.PP_SO-102 | 432.125 | 0.00138523 | 0.0570176 | ø42 mm | 0 | JD | -1.PP_SO-102 |  | 2871.06 | 2871.06 | 2438.94 | 2438.94 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -1561.06 | 0.0570176 | Zn | 42 | 148 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø42 | 42 | 39 | TR03.04.2013 | 2013
13840317 | -1.PP_SO-102 | 95.125 | 0.00620623 | 0.0265672 | ø89 mm | 0 | JD | -1.PP_SO-102 |  | 2547.56 | 2547.56 | 2452.44 | 2452.44 | Fáze 1 | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | Kov, ocel | WS_Požární nezavodněný 1 | -1547.56 | 0.0265971 | Zn | 89 | 406 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø89 | 88.9 | 84.9 | TR03.04.2018 | 2018
13986232 | -1.PP_SO-102 | 4946.29 | 0.00228988 | 0.839118 | ø54 mm | 0.00196078 | JB | -1.PP_SO-102 | 0 | 3252.24 | 3225.24 | 3225.24 | 3198.24 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -800.262 | 0.839118 | Zn | 54 | 130 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø54 | 54 | 51 | TR03.04.2048 | 2048
13986489 | -1.PP_SO-102 | 347.05 | 0.00228988 | 0.0588756 | ø54 mm | 0.00196078 | JD | -1.PP_SO-102 |  | 3190.3 | 2843.25 | 3190.3 | 2843.25 | Fáze 1 | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | Kov, ocel | WS_Požární zavodněný 1 | -1156.75 | 0.0588756 | Zn | 54 | 130 | Kov, ocel - Uhlíková ocel vně/uvnitř pozinkovaná | Uhlíková ocel vně/uvnitř pozinkovaná | ø54 | 54 | 51 | TR03.04.2053 | 2053

# IfcPipeSegment: Typy trubek:Ocel_pozink (vně pozinkovaná) (18)
Type - Material: 032-175-175
Type - Požární ochrana - Požární odolnost: –
Type - Identifikační data - ID kategorie: TR; Kód sestavy: TR03; Model: IVAR.IVCT; Název typu: Ocel_pozink (vně pozinkovaná); Označení typu: 06; Popis: POZINK; Popis sestavy: Ocel pozinková; Výrobce: IVAR CS
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR03 SNIM (SNIM); TR03 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: WPA; CCI Technický systém: JB
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Mechanické - Typ přípoje: Obecné
Jiné - Páteřní trasa: yes; Rodina: Typy trubek; Id typu: 9442257; Rodina a typ: Typy trubek: Ocel_pozink (vně pozinkovaná); Typ: Ocel_pozink (vně pozinkovaná)
Name (Typy trubek:Ocel_pozink (vně pozinkovaná):...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Celková velikost | Relativní drsnost | Referenční podlaží | Sklon | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Řez | Materiál | Typ systému | Drsnost (mm) | Klasifikace systému | Název systému = Group | Obrátit výšku (mm) | Plocha (m2) | Popis úseku | Průměr (mm) | Úsek potrubí | Výkaz/typ | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení
13157513 | 3.NP_SO-102 | 664.775 | 0.00061566 | 0.0584767 | ø28 mm | 0.000515464 | 3.NP_SO-102 | 0 | 3380.44 | 3366.44 | 3366.44 | 3352.44 | Fáze 1 | 5 | Kov, ocel | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 11353.9 | 0.0584767 | Zn | 28 | Kov, ocel - Uhlíková ocel vně pozinkovaná | Uhlíková ocel vně pozinkovaná | ø28 | 28 | 25 | TR03.06.1046 | 1046
13170045 | 1.NP_SO-102 | 878.309 | 0.00061566 | 0.0772601 | ø28 mm | 0.000515464 | 1.NP_SO-102 | 0 | 3214 | 3200 | 3200 | 3186 | Fáze 2 | 41 | Kov, ocel | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 3187.5 | 0.0772601 | Zn | 28 | Kov, ocel - Uhlíková ocel vně pozinkovaná | Uhlíková ocel vně pozinkovaná | ø28 | 28 | 25 | TR03.06.1088 | 1088
13170131 | 1.NP_SO-102 | 3536.12 | 0.00061566 | 0.311054 | ø28 mm | 0.000515464 | 1.NP_SO-102 | 0 | 3214 | 3200 | 3200 | 3186 | Fáze 2 | 41 | Kov, ocel | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 3187.5 | 0.311054 | Zn | 28 | Kov, ocel - Uhlíková ocel vně pozinkovaná | Uhlíková ocel vně pozinkovaná | ø28 | 28 | 25 | TR03.06.1090 | 1090
13170143 | 1.NP_SO-102 | 1311.27 | 0.00061566 | 0.115345 | ø28 mm | 0 | 1.NP_SO-102 |  | 3178.06 | 3178.06 | 1866.79 | 1866.79 | Fáze 2 | 41 | Kov, ocel | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 1866.79 | 0.115345 | Zn | 28 | Kov, ocel - Uhlíková ocel vně pozinkovaná | Uhlíková ocel vně pozinkovaná | ø28 | 28 | 25 | TR03.06.1091 | 1091
13358610 | 3.NP_SO-102 | 2686.28 | 0.00061566 | 0.236298 | ø28 mm | 0.004 | 3.NP_SO-102 | 0 | 3380.44 | 3366.44 | 3366.44 | 3352.44 | Fáze 1 | 5 | Kov, ocel | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 11353.9 | 0.236298 | Zn | 28 | Kov, ocel - Uhlíková ocel vně pozinkovaná | Uhlíková ocel vně pozinkovaná | ø28 | 28 | 25 | TR03.06.1275 | 1275
13358624 | 3.NP_SO-102 | 14356.1 | 0.00061566 | 1.26283 | ø28 mm | 0.004 | 3.NP_SO-102 | 0 | 3380.44 | 3366.44 | 3366.44 | 3352.44 | Fáze 1 | 5 | Kov, ocel | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 11353.9 | 1.26283 | Zn | 28 | Kov, ocel - Uhlíková ocel vně pozinkovaná | Uhlíková ocel vně pozinkovaná | ø28 | 28 | 25 | TR03.06.1276 | 1276
13358634 | 3.NP_SO-102 | 5556.13 | 0.00061566 | 0.488742 | ø28 mm | 0.004 | 3.NP_SO-102 | 0 | 3380.44 | 3366.44 | 3366.44 | 3352.44 | Fáze 1 | 5 | Kov, ocel | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 11353.9 | 0.488742 | Zn | 28 | Kov, ocel - Uhlíková ocel vně pozinkovaná | Uhlíková ocel vně pozinkovaná | ø28 | 28 | 25 | TR03.06.1277 | 1277
13358642 | 3.NP_SO-102 | 2378.06 | 0.00061566 | 0.209185 | ø28 mm | 0.004 | 3.NP_SO-102 | 0 | 3380.44 | 3366.44 | 3366.44 | 3352.44 | Fáze 1 | 5 | Kov, ocel | WS_Požární zavodněný | 0.1 | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 11353.9 | 0.209185 | Zn | 28 | Kov, ocel - Uhlíková ocel vně pozinkovaná | Uhlíková ocel vně pozinkovaná | ø28 | 28 | 25 | TR03.06.1278 | 1278
13358756 | 3.NP_SO-102 | 25.4 | 0.0019632 | 0.00398982 | ø50 mm | 0 | 3.NP_SO-102 | 0 | 1325 | 1300 | 1300 | 1275 | Fáze 1 | 321 |  | WS_Požární nezavodněný | 0 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 9275 | 0.00398982 |  | 50 |  |  | ø50 | 50 | 50 | TR03.06.1279 | 1279 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13358757 | 3.NP_SO-102 | 1951.28 | 0.00620623 | 0.544967 | ø89 mm | 0 | 3.NP_SO-102 |  | 3307.66 | 3307.66 | 1356.38 | 1356.38 | Fáze 1 | 325 | Kov, ocel | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 9356.38 | 0.54558 | Zn | 89 | Kov, ocel - Uhlíková ocel vně pozinkovaná | Uhlíková ocel vně pozinkovaná | ø89 | 88.9 | 84.9 | TR03.06.1280 | 1280 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13358900 | 4.NP_SO-102 | 1840.68 | 0.00620623 | 0.514078 | ø89 mm | 0 | 4.NP_SO-102 |  | 1259.56 | 1259.56 | -581.118 | -581.118 | Fáze 1 | 410 | Kov, ocel | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 11418.9 | 0.514656 | Zn | 89 | Kov, ocel - Uhlíková ocel vně pozinkovaná | Uhlíková ocel vně pozinkovaná | ø89 | 88.9 | 84.9 | TR03.06.1282 | 1282
13359073 | 3.NP_SO-102 | 2239.95 | 0.00620623 | 0.625591 | ø89 mm | 0 | 3.NP_SO-102 | 0 | 3410.89 | 3366.44 | 3366.44 | 3321.99 | Fáze 1 | 410 | Kov, ocel | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 11324 | 0.626294 | Zn | 89 | Kov, ocel - Uhlíková ocel vně pozinkovaná | Uhlíková ocel vně pozinkovaná | ø89 | 88.9 | 84.9 | TR03.06.1283 | 1283 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13359143 | 3.NP_SO-102 | 2797.29 | 0.00620623 | 0.78125 | ø89 mm | 0.00117786 | 3.NP_SO-102 | 0 | 3410.89 | 3366.44 | 3366.44 | 3321.99 | Fáze 1 | 410 | Kov, ocel | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 11324 | 0.782128 | Zn | 89 | Kov, ocel - Uhlíková ocel vně pozinkovaná | Uhlíková ocel vně pozinkovaná | ø89 | 88.9 | 84.9 | TR03.06.1284 | 1284 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13359151 | 3.NP_SO-102 | 672.825 | 0.00620623 | 0.187912 | ø89 mm | 0.00117786 | 3.NP_SO-102 | 0 | 3410.89 | 3366.44 | 3366.44 | 3321.99 | Fáze 1 | 323 | Kov, ocel | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 11324 | 0.188123 | Zn | 89 | Kov, ocel - Uhlíková ocel vně pozinkovaná | Uhlíková ocel vně pozinkovaná | ø89 | 88.9 | 84.9 | TR03.06.1285 | 1285 | Mechanické – tok - Doplňkový průtok: 0 m3/s
13359250 | 1.NP_SO-102 | 179.584 | 0.00620623 | 0.0501556 | ø89 mm | 0.00196078 | 1.NP_SO-102 | 0 | 1344.45 | 1300 | 1300 | 1255.55 | Fáze 1 | 336 | Kov, ocel | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 1257.55 | 0.0502121 | Zn | 89 | Kov, ocel - Uhlíková ocel vně pozinkovaná | Uhlíková ocel vně pozinkovaná | ø89 | 88.9 | 84.9 | TR03.06.1286 | 1286
13359474 | 2.NP_SO-102 | 165.29 | 0.00228988 | 0.0280409 | ø54 mm | 0.00196078 | 2.NP_SO-102 | 0 | 1327 | 1300 | 1300 | 1273 | Fáze 1 | 343 | Kov, ocel | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 5274.5 | 0.0280409 | Zn | 54 | Kov, ocel - Uhlíková ocel vně pozinkovaná | Uhlíková ocel vně pozinkovaná | ø54 | 54 | 51 | TR03.06.1288 | 1288
13359581 | 3.NP_SO-102 | 165.29 | 0.00228988 | 0.0280409 | ø54 mm | 0.00196078 | 3.NP_SO-102 | 0 | 1327 | 1300 | 1300 | 1273 | Fáze 1 | 349 | Kov, ocel | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 9274.5 | 0.0280409 | Zn | 54 | Kov, ocel - Uhlíková ocel vně pozinkovaná | Uhlíková ocel vně pozinkovaná | ø54 | 54 | 51 | TR03.06.1290 | 1290
14022621 | 4.NP_SO-102 | 44.5188 | 0.00620623 | 0.0124335 | ø89 mm | 0.00196078 | 4.NP_SO-102 | 0 | 1356.45 | 1312 | 1312 | 1267.55 | Fáze 1 | 326 | Kov, ocel | WS_Požární nezavodněný | 0.1 | Požární ochrana – suché prostředky | WS_Požární nezavodněný 2 | 13269.5 | 0.0124475 | Zn | 89 | Kov, ocel - Uhlíková ocel vně pozinkovaná | Uhlíková ocel vně pozinkovaná | ø89 | 88.9 | 84.9 | TR03.06.2193 | 2193

# IfcPipeSegment: Typy trubek:PP-RCT (1338)
Type - Material: 255-0-0
Type - Požární ochrana - Požární odolnost: –
Type - Identifikační data - ID kategorie: TR; Kód sestavy: TR10; Komentáře k typům: Pipes Plain End, welded sockets; Model: EVO; Název typu: PP-RCT; Označení typu: 03; Popis: PP-RCT; Popis sestavy: Polypropylene Random Cristallinity Temperature (PP RCT); Výrobce: Wavin
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR10 SNIM (SNIM); TR10 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: WPA
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Mechanické - Drsnost: 0.01 mm; Typ přípoje: Obecné
Jiné - Rodina: Typy trubek; Id typu: 9442190; Rodina a typ: Typy trubek: PP-RCT; Typ: PP-RCT
Name (Typy trubek:PP-RCT:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Instalační jednotky = Reynoldsovo číslo = Třecí faktor = Tření = Průtok (m3/s) = Rychlost (m/s) = Tlaková ztráta (Pa) | Stav průtoku | Doplňkový průtok (m3/s) | Relativní drsnost | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) | Spodní výška (mm) | Střední výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Délka (mm) | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
12914209 | 1.NP_SO-102 | 3780.94 | 0.0019632 | 0.593908 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | 1.NP_SO-102 | 3114.28 | -666.662 | 3114.28 | -666.662 | 3114.28 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -666.662 | PP–RCT S4 | 50 | 330 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3780.94 | ø50 | 38.8 | TR10.03.0033 | 0033 | yes | WS_Teplá vnitřní 83
12942839 | 4.NP_SO-102 | 19.8375 | 0.000804127 | 0.00199428 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3350 | 3350 | 3330.16 | 3330.16 | 3330.16 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15330.2 | PP–RCT S4 | 32 | 6 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 19.8375 | ø32 | 24.8 | TR10.03.0055 | 0055 | yes | WS_Teplá vnitřní 83
12943945 | 4.NP_SO-102 | 1424.64 | 0.000314112 | 0.0895127 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1510 | 1500 | 1500 | 1490 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 13492.3 | PP–RCT S4 | 20 | 78 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1424.64 | ø20 | 15.4 | TR10.03.0056 | 0056 | no | WS_Studená vnitřní 134 | 0
12945464 | 4.NP_SO-102 | 78.725 | 0.0004908 | 0.00618305 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 1212.5 | 1200 | 1200 | 1187.5 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 13190.3 | PP–RCT S4 | 25 | 22 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 78.725 | ø25 | 19.4 | TR10.03.0057 | 0057 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
12945476 | 4.NP_SO-102 | 3762.06 | 0.0004908 | 0.295471 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 1212.5 | 1200 | 1200 | 1187.5 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 13190.3 | PP–RCT S4 | 25 | 224 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3762.06 | ø25 | 19.4 | TR10.03.0058 | 0058 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12946222 | 4.NP_SO-102 | 454.701 | 0.0004908 | 0.0357122 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 1512.5 | 1500 | 1500 | 1487.5 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 13490.3 | PP–RCT S4 | 25 | 387 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 454.701 | ø25 | 19.4 | TR10.03.0059 | 0059 | no | WS_Studená vnitřní 134 | 0
12946255 | 4.NP_SO-102 | 5025.08 | 0.000314112 | 0.315735 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 13242.3 | PP–RCT S4 | 20 | 58 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5025.08 | ø20 | 15.4 | TR10.03.0060 | 0060 | no | WS_Studená vnitřní 134 | 0
12946268 | 4.NP_SO-102 | 453.75 | 0.0004908 | 0.0356375 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15340.3 | PP–RCT S4 | 25 | 48 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 453.75 | ø25 | 19.4 | TR10.03.0061 | 0061 | yes | WS_Studená vnitřní 134 | 0
12946271 | 4.NP_SO-102 | 1122.54 | 0.000314112 | 0.0705311 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 13242.3 | PP–RCT S4 | 20 | 58 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1122.54 | ø20 | 15.4 | TR10.03.0062 | 0062 | no | WS_Studená vnitřní 134 | 0
12947097 | 4.NP_SO-102 | 250.206 | 0.000804127 | 0.0251535 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3336 | 3320 | 3320 | 3304 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15307.6 | PP–RCT S4 | 32 | 98 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 250.206 | ø32 | 24.8 | TR10.03.0063 | 0063 | yes | WS_Teplá vnitřní 83 | 0
12948031 | 4.NP_SO-102 | 5123.64 | 0.000314112 | 0.321928 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3330 | 3320 | 3320 | 3310 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15312.3 | PP–RCT S4 | 20 | 34 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5123.64 | ø20 | 15.4 | TR10.03.0064 | 0064 | yes | WS_Teplá vnitřní 83 | 0
12948054 | 4.NP_SO-102 | 7148.41 | 0.000314112 | 0.449148 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15342.3 | PP–RCT S4 | 20 | 73 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 7148.41 | ø20 | 15.4 | TR10.03.0065 | 0065 | yes | WS_Studená vnitřní 134 | 0
12948155 | 4.NP_SO-102 | 40.4687 | 0.0004908 | 0.00317841 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3312.5 | 3300 | 3300 | 3287.5 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15290.3 | PP–RCT S4 | 25 | 199 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 40.4687 | ø25 | 19.4 | TR10.03.0066 | 0066 | yes | WS_Teplá vnitřní 83 | 0
12948547 | 4.NP_SO-102 | 1612.62 | 0.000314112 | 0.101324 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3315.87 | 3315.87 | 1703.25 | 1703.25 | 1703.25 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 13703.2 | PP–RCT S4 | 20 | 56 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1612.62 | ø20 | 15.4 | TR10.03.0067 | 0067 | no | WS_Studená vnitřní 134
12948746 | 4.NP_SO-102 | 7128.91 | 0.000314112 | 0.447923 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3330 | 3320 | 3320 | 3310 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15312.3 | PP–RCT S4 | 20 | 14 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 7128.91 | ø20 | 15.4 | TR10.03.0068 | 0068 | yes | WS_Teplá vnitřní 83 | 0
12948751 | 4.NP_SO-102 | 456.639 | 0.000804127 | 0.0459064 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3216 | 3200 | 3200 | 3184 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15187.6 | PP–RCT S4 | 32 | 98 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 456.639 | ø32 | 24.8 | TR10.03.0069 | 0069 | yes | WS_Teplá vnitřní 83 | 0
12948763 | 4.NP_SO-102 | 72.375 | 0.000804127 | 0.00727593 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3296.19 | 3223.81 | 3296.19 | 3223.81 | 3296.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15223.8 | PP–RCT S4 | 32 | 98 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 72.375 | ø32 | 24.8 | TR10.03.0070 | 0070 | yes | WS_Teplá vnitřní 83
12948815 | 4.NP_SO-102 | 1889.67 | 0.000804127 | 0.189971 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3169.84 | 3169.84 | 1280.16 | 1280.16 | 1280.16 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 13280.2 | PP–RCT S4 | 32 | 100 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1889.67 | ø32 | 24.8 | TR10.03.0071 | 0071 | yes | WS_Teplá vnitřní 83
12949126 | 4.NP_SO-102 | 237.858 | 0.0004908 | 0.0186813 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 1439.16 | 1426.66 | 1426.66 | 1414.16 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 13417 | PP–RCT S4 | 25 | 40 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 237.858 | ø25 | 19.4 | TR10.03.0072 | 0072 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12949223 | 4.NP_SO-102 | 674.544 | 0.0004908 | 0.0529786 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15340.3 | PP–RCT S4 | 25 | 180 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 674.544 | ø25 | 19.4 | TR10.03.0073 | 0073 | yes | WS_Studená vnitřní 134 | 0
12949249 | 4.NP_SO-102 | 739.362 | 0.0004908 | 0.0580694 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15340.3 | PP–RCT S4 | 25 | 180 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 739.362 | ø25 | 19.4 | TR10.03.0074 | 0074 | no | WS_Studená vnitřní 134 | 0
12949363 | 4.NP_SO-102 | 300.882 | 0.000804127 | 0.0302479 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15337.6 | PP–RCT S4 | 32 | 181 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 300.882 | ø32 | 24.8 | TR10.03.0075 | 0075 | yes | WS_Studená vnitřní 134 | 0
12949985 | 4.NP_SO-102 | 8337.69 | 0.000314112 | 0.523873 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15342.3 | PP–RCT S4 | 20 | 184 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 8337.69 | ø20 | 15.4 | TR10.03.0076 | 0076 | no | WS_Studená vnitřní 134 | 0
12950060 | 4.NP_SO-102 | 282.814 | 0.000314112 | 0.0177697 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 13242.3 | PP–RCT S4 | 20 | 185 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 282.814 | ø20 | 15.4 | TR10.03.0077 | 0077 | no | WS_Studená vnitřní 134 | 0
12950256 | 4.NP_SO-102 | 2058.72 | 0.000314112 | 0.129354 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3326.19 | 1267.46 | 3326.19 | 1267.46 | 3326.19 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 13267.5 | PP–RCT S4 | 20 | 185 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2058.72 | ø20 | 15.4 | TR10.03.0078 | 0078 | no | WS_Studená vnitřní 134
12950259 | 4.NP_SO-102 | 216.26 | 0.0004908 | 0.016985 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15340.3 | PP–RCT S4 | 25 | 183 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 216.26 | ø25 | 19.4 | TR10.03.0079 | 0079 | no | WS_Studená vnitřní 134 | 0
12950318 | 4.NP_SO-102 | 282.814 | 0.000314112 | 0.0177697 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 13242.3 | PP–RCT S4 | 20 | 184 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 282.814 | ø20 | 15.4 | TR10.03.0080 | 0080 | no | WS_Studená vnitřní 134 | 0
12950400 | 4.NP_SO-102 | 2065.07 | 0.000314112 | 0.129752 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3332.54 | 3332.54 | 1267.46 | 1267.46 | 1267.46 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 13267.5 | PP–RCT S4 | 20 | 184 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2065.07 | ø20 | 15.4 | TR10.03.0081 | 0081 | no | WS_Studená vnitřní 134
12950568 | 4.NP_SO-102 | 115.5 | 0.000314112 | 0.00725708 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 590 | 580 | 580 | 570 | 580 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 12572.3 | PP–RCT S4 | 20 | 186 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 115.5 | ø20 | 15.4 | TR10.03.0082 | 0082 | no | WS_Studená vnitřní 134 | 0
12950610 | 4.NP_SO-102 | 2713.64 | 0.000314112 | 0.170503 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3311.11 | 3311.11 | 597.462 | 597.462 | 597.462 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 12597.5 | PP–RCT S4 | 20 | 186 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2713.64 | ø20 | 15.4 | TR10.03.0083 | 0083 | no | WS_Studená vnitřní 134
12950613 | 4.NP_SO-102 | 2549.36 | 0.0004908 | 0.200226 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15340.3 | PP–RCT S4 | 25 | 442 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2549.36 | ø25 | 19.4 | TR10.03.0084 | 0084 | yes | WS_Studená vnitřní 134 | 0
12951221 | 4.NP_SO-102 | 3118.73 | 0.0004908 | 0.244944 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15340.3 | PP–RCT S4 | 25 | 180 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3118.73 | ø25 | 19.4 | TR10.03.0085 | 0085 | yes | WS_Studená vnitřní 134 | 0
12951738 | 4.NP_SO-102 | 3.82486 | 0.000804127 | 0.000384517 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3306.78 | 3290.78 | 3290.78 | 3274.78 | 3290.78 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15278.4 | PP–RCT S4 | 32 | 197 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3.82486 | ø32 | 24.8 | TR10.03.0086 | 0086 | yes | WS_Teplá vnitřní 83 | 0
12951956 | 4.NP_SO-102 | 470.469 | 0.0004908 | 0.0369505 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3212.5 | 3200 | 3200 | 3187.5 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15190.3 | PP–RCT S4 | 25 | 146 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 470.469 | ø25 | 19.4 | TR10.03.0087 | 0087 | yes | WS_Teplá vnitřní 83 | 0
12952095 | 4.NP_SO-102 | 1922.79 | 0.0004908 | 0.151015 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3379.16 | 3366.66 | 3366.66 | 3354.16 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15357 | PP–RCT S4 | 25 | 146 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1922.79 | ø25 | 19.4 | TR10.03.0088 | 0088 | yes | WS_Teplá vnitřní 83 | 0
12952123 | 4.NP_SO-102 | 125.387 | 0.0004908 | 0.00984791 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3346.02 | 3346.02 | 3220.64 | 3220.64 | 3220.64 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15220.6 | PP–RCT S4 | 25 | 146 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 125.387 | ø25 | 19.4 | TR10.03.0089 | 0089 | yes | WS_Teplá vnitřní 83
12953589 | 4.NP_SO-102 | 819.362 | 0.0004908 | 0.0643526 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3379.16 | 3366.66 | 3366.66 | 3354.16 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15357 | PP–RCT S4 | 25 | 146 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 819.362 | ø25 | 19.4 | TR10.03.0090 | 0090 | no | WS_Teplá vnitřní 83 | 0
12953598 | 4.NP_SO-102 | 2958.73 | 0.0004908 | 0.232378 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3379.16 | 3366.66 | 3366.66 | 3354.16 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15357 | PP–RCT S4 | 25 | 146 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2958.73 | ø25 | 19.4 | TR10.03.0091 | 0091 | yes | WS_Teplá vnitřní 83 | 0
12953751 | 4.NP_SO-102 | 253.934 | 0.000804127 | 0.0255282 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3406.19 | 3390.19 | 3390.19 | 3374.19 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15377.8 | PP–RCT S4 | 32 | 39 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 253.934 | ø32 | 24.8 | TR10.03.0092 | 0092 | yes | WS_Teplá vnitřní 83 | 0
12953765 | 4.NP_SO-102 | 2461.58 | 0.0004908 | 0.193332 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3402.69 | 3390.19 | 3390.19 | 3377.69 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15380.5 | PP–RCT S4 | 25 | 121 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2461.58 | ø25 | 19.4 | TR10.03.0093 | 0093 | yes | WS_Teplá vnitřní 83 | 0
12954042 | 4.NP_SO-102 | 5360.83 | 0.0004908 | 0.421039 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3402.69 | 3390.19 | 3390.19 | 3377.69 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15380.5 | PP–RCT S4 | 25 | 121 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5360.83 | ø25 | 19.4 | TR10.03.0094 | 0094 | yes | WS_Teplá vnitřní 83 | 0
12954184 | 4.NP_SO-102 | 8343.24 | 0.000314112 | 0.524221 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3400.19 | 3390.19 | 3390.19 | 3380.19 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15382.5 | PP–RCT S4 | 20 | 123 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 8343.24 | ø20 | 15.4 | TR10.03.0095 | 0095 | no | WS_Teplá vnitřní 83 | 0
12954224 | 4.NP_SO-102 | 348.545 | 0.000314112 | 0.0218997 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 13242.3 | PP–RCT S4 | 20 | 124 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 348.545 | ø20 | 15.4 | TR10.03.0096 | 0096 | no | WS_Teplá vnitřní 83 | 0
12954279 | 4.NP_SO-102 | 2098.92 | 0.000314112 | 0.131879 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3366.38 | 1267.46 | 3366.38 | 1267.46 | 3366.38 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 13267.5 | PP–RCT S4 | 20 | 124 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2098.92 | ø20 | 15.4 | TR10.03.0097 | 0097 | no | WS_Teplá vnitřní 83
12954282 | 4.NP_SO-102 | 203.894 | 0.0004908 | 0.0160138 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3402.69 | 3390.19 | 3390.19 | 3377.69 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15380.5 | PP–RCT S4 | 25 | 121 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 203.894 | ø25 | 19.4 | TR10.03.0098 | 0098 | no | WS_Teplá vnitřní 83 | 0
12954309 | 4.NP_SO-102 | 362.814 | 0.000314112 | 0.0227963 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 13242.3 | PP–RCT S4 | 20 | 123 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 362.814 | ø20 | 15.4 | TR10.03.0099 | 0099 | no | WS_Teplá vnitřní 83 | 0
12954353 | 4.NP_SO-102 | 2105.27 | 0.000314112 | 0.132278 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3372.73 | 1267.46 | 3372.73 | 1267.46 | 3372.73 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 13267.5 | PP–RCT S4 | 20 | 123 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2105.27 | ø20 | 15.4 | TR10.03.0100 | 0100 | no | WS_Teplá vnitřní 83
12954377 | 4.NP_SO-102 | 70.0455 | 0.000314112 | 0.00440109 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 590 | 580 | 580 | 570 | 580 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 12572.3 | PP–RCT S4 | 20 | 125 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 70.0455 | ø20 | 15.4 | TR10.03.0101 | 0101 | no | WS_Teplá vnitřní 83 | 0
12954438 | 4.NP_SO-102 | 2753.83 | 0.000314112 | 0.173029 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3351.3 | 597.462 | 3351.3 | 597.462 | 3351.3 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 12597.5 | PP–RCT S4 | 20 | 125 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2753.83 | ø20 | 15.4 | TR10.03.0102 | 0102 | no | WS_Teplá vnitřní 83
12954441 | 4.NP_SO-102 | 153.239 | 0.000804127 | 0.0154052 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3406.19 | 3390.19 | 3390.19 | 3374.19 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15377.8 | PP–RCT S4 | 32 | 39 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 153.239 | ø32 | 24.8 | TR10.03.0103 | 0103 | yes | WS_Teplá vnitřní 83 | 0
12955024 | 4.NP_SO-102 | 742.538 | 0.000314112 | 0.046655 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15342.3 | PP–RCT S4 | 20 | 73 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 742.538 | ø20 | 15.4 | TR10.03.0104 | 0104 | no | WS_Studená vnitřní 134 | 0
12955103 | 4.NP_SO-102 | 837.538 | 0.000314112 | 0.052624 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3330 | 3320 | 3320 | 3310 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15312.3 | PP–RCT S4 | 20 | 14 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 837.538 | ø20 | 15.4 | TR10.03.0105 | 0105 | no | WS_Teplá vnitřní 83 | 0
12955169 | 4.NP_SO-102 | 4967.46 | 0.000314112 | 0.312115 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15342.3 | PP–RCT S4 | 20 | 36 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4967.46 | ø20 | 15.4 | TR10.03.0106 | 0106 | yes | WS_Studená vnitřní 134 | 0
12955222 | 4.NP_SO-102 | 942.538 | 0.000314112 | 0.0592214 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15342.3 | PP–RCT S4 | 20 | 36 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 942.538 | ø20 | 15.4 | TR10.03.0107 | 0107 | no | WS_Studená vnitřní 134 | 0
12955320 | 4.NP_SO-102 | 1037.54 | 0.000314112 | 0.0651904 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3330 | 3320 | 3320 | 3310 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 15312.3 | PP–RCT S4 | 20 | 34 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1037.54 | ø20 | 15.4 | TR10.03.0108 | 0108 | no | WS_Teplá vnitřní 83 | 0
12956184 | 3.NP_SO-102 | 1720 | 0.000314112 | 0.108071 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1510 | 1500 | 1500 | 1490 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 9492.3 | PP–RCT S4 | 20 | 445 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1720 | ø20 | 15.4 | TR10.03.0109 | 0109 | no | WS_Studená vnitřní 134 | 0
12956186 | 3.NP_SO-102 | 78.725 | 0.000314112 | 0.00494644 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1210 | 1200 | 1200 | 1190 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 9192.3 | PP–RCT S4 | 20 | 338 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 78.725 | ø20 | 15.4 | TR10.03.0110 | 0110 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12956192 | 3.NP_SO-102 | 454.701 | 0.0004908 | 0.0357122 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 1512.5 | 1500 | 1500 | 1487.5 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 9490.3 | PP–RCT S4 | 25 | 444 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 454.701 | ø25 | 19.4 | TR10.03.0111 | 0111 | no | WS_Studená vnitřní 134 | 0
12956194 | 3.NP_SO-102 | 5014.76 | 0.000314112 | 0.315086 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 9242.3 | PP–RCT S4 | 20 | 105 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5014.76 | ø20 | 15.4 | TR10.03.0112 | 0112 | no | WS_Studená vnitřní 134 | 0
12956196 | 3.NP_SO-102 | 354.392 | 0.0004908 | 0.0278339 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11340.3 | PP–RCT S4 | 25 | 93 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 354.392 | ø25 | 19.4 | TR10.03.0113 | 0113 | yes | WS_Studená vnitřní 134 | 0
12956198 | 3.NP_SO-102 | 2582.54 | 0.000314112 | 0.162266 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 9242.3 | PP–RCT S4 | 20 | 105 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2582.54 | ø20 | 15.4 | TR10.03.0114 | 0114 | no | WS_Studená vnitřní 134 | 0
12956204 | 3.NP_SO-102 | 2347.71 | 0.000314112 | 0.147511 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11342.3 | PP–RCT S4 | 20 | 47 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2347.71 | ø20 | 15.4 | TR10.03.0115 | 0115 | yes | WS_Teplá vnitřní 83 | 0
12956207 | 3.NP_SO-102 | 5555.81 | 0.0004908 | 0.436352 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11340.3 | PP–RCT S4 | 25 | 96 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5555.81 | ø25 | 19.4 | TR10.03.0116 | 0116 | yes | WS_Studená vnitřní 134 | 0
12956224 | 3.NP_SO-102 | 1751.56 | 0.000314112 | 0.110054 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3315.87 | 3315.87 | 1564.31 | 1564.31 | 1564.31 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 9564.31 | PP–RCT S4 | 20 | 103 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1751.56 | ø20 | 15.4 | TR10.03.0117 | 0117 | no | WS_Studená vnitřní 134
12956230 | 3.NP_SO-102 | 124.38 | 0.000804127 | 0.0125041 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11337.6 | PP–RCT S4 | 32 | 388 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 124.38 | ø32 | 24.8 | TR10.03.0118 | 0118 | yes | WS_Studená vnitřní 134 | 0
12956232 | 3.NP_SO-102 | 377.327 | 0.000804127 | 0.0379331 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11337.6 | PP–RCT S4 | 32 | 388 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 377.327 | ø32 | 24.8 | TR10.03.0119 | 0119 | yes | WS_Studená vnitřní 134 | 0
12956244 | 3.NP_SO-102 | 456.639 | 0.000804127 | 0.0459064 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3216 | 3200 | 3200 | 3184 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11187.6 | PP–RCT S4 | 32 | 42 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 456.639 | ø32 | 24.8 | TR10.03.0120 | 0120 | yes | WS_Teplá vnitřní 83 | 0
12956246 | 3.NP_SO-102 | 102.375 | 0.000804127 | 0.0102919 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3326.19 | 3223.81 | 3326.19 | 3223.81 | 3326.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11223.8 | PP–RCT S4 | 32 | 42 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 102.375 | ø32 | 24.8 | TR10.03.0121 | 0121 | yes | WS_Teplá vnitřní 83
12956274 | 3.NP_SO-102 | 2192.48 | 0.000314112 | 0.137757 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11342.3 | PP–RCT S4 | 20 | 95 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2192.48 | ø20 | 15.4 | TR10.03.0122 | 0122 | yes | WS_Studená vnitřní 134 | 0
12956276 | 3.NP_SO-102 | 745.075 | 0.000314112 | 0.0468144 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11342.3 | PP–RCT S4 | 20 | 95 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 745.075 | ø20 | 15.4 | TR10.03.0123 | 0123 | no | WS_Studená vnitřní 134 | 0
12956280 | 3.NP_SO-102 | 765.075 | 0.000314112 | 0.0480711 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11342.3 | PP–RCT S4 | 20 | 47 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 765.075 | ø20 | 15.4 | TR10.03.0124 | 0124 | no | WS_Teplá vnitřní 83 | 0
12956444 | 1.NP_SO-102 | 1684.82 | 0.0004908 | 0.132325 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 1512.5 | 1500 | 1500 | 1487.5 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 1490.3 | PP–RCT S4 | 25 | 394 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1684.82 | ø25 | 19.4 | TR10.03.0125 | 0125 | no | WS_Studená vnitřní 134 | 0
12956446 | 1.NP_SO-102 | 63.6438 | 0.000314112 | 0.00399885 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 1210 | 1200 | 1200 | 1190 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 1192.3 | PP–RCT S4 | 20 | 56 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 63.6438 | ø20 | 15.4 | TR10.03.0126 | 0126 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12956448 | 1.NP_SO-102 | 3484.46 | 0.000314112 | 0.218935 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 1210 | 1200 | 1200 | 1190 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 1192.3 | PP–RCT S4 | 20 | 14 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3484.46 | ø20 | 15.4 | TR10.03.0127 | 0127 | no | WS_"Jiný typ" studená vnitřní 1 | 0
12956452 | 1.NP_SO-102 | 454.701 | 0.0004908 | 0.0357122 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 1512.5 | 1500 | 1500 | 1487.5 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 1490.3 | PP–RCT S4 | 25 | 394 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 454.701 | ø25 | 19.4 | TR10.03.0128 | 0128 | no | WS_Studená vnitřní 134 | 0
12956454 | 1.NP_SO-102 | 5025.08 | 0.000314112 | 0.315735 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 1242.3 | PP–RCT S4 | 20 | 54 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5025.08 | ø20 | 15.4 | TR10.03.0129 | 0129 | no | WS_Studená vnitřní 134 | 0
