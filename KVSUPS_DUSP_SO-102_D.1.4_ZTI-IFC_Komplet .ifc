Properties of the parts of a building model (IFC4), part 48 of 60

# IfcPipeSegment: Typy trubek:PP-RCT (1338)
Name (Typy trubek:PP-RCT:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Instalační jednotky = Reynoldsovo číslo = Třecí faktor = Tření = Průtok (m3/s) = Rychlost (m/s) = Tlaková ztráta (Pa) | Stav průtoku | Doplňkový průtok (m3/s) | Relativní drsnost | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) | Spodní výška (mm) | Střední výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Délka (mm) | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
13023013 | 4.NP_SO-102 | 3946.02 | 0.000804127 | 0.396698 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3261.11 | 3261.11 | -684.912 | -684.912 | -684.912 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11315.1 | PP–RCT S4 | 32 | 44 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3946.02 | ø32 | 24.8 | TR10.03.0554 | 0554 | yes | WS_Studená vnitřní 6 | Identifikační data - Komentáře: V4
13023021 | -1.PP_SO-102 | 4673.01 | 0.00125645 | 0.587228 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 2670 | 2650 | 2650 | 2630 | 2650 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | -1365.5 | PP–RCT S4 | 40 | 49 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4673.01 | ø40 | 31 | TR10.03.0555 | 0555 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 0
13023042 | -1.PP_SO-102 | 53.1495 | 0.00125645 | 0.00667897 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 2670 | 2650 | 2650 | 2630 | 2650 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | -1365.5 | PP–RCT S4 | 40 | 88 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 53.1495 | ø40 | 31 | TR10.03.0556 | 0556 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 0
13023110 | -1.PP_SO-102 | 14198.8 | 0.0019632 | 2.23034 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3425 | 3400 | 3400 | 3375 | 3400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -619.4 | PP–RCT S4 | 50 | 201 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 14198.8 | ø50 | 38.8 | TR10.03.0557 | 0557 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13023139 | 4.NP_SO-102 | 3941.26 | 0.000804127 | 0.396219 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3218.73 | 3218.73 | -722.531 | -722.531 | -722.531 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 11277.5 | PP–RCT S4 | 32 | 59 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3941.26 | ø32 | 24.8 | TR10.03.0558 | 0558 | yes | WS_"ŠEDÁ" studená vnitřní 2
13024730 | 4.NP_SO-102 | 342.071 | 0.000804127 | 0.0343887 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3360.93 | 3344.93 | 3344.93 | 3328.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15332.5 | PP–RCT S4 | 32 | 42 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 342.071 | ø32 | 24.8 | TR10.03.0559 | 0559 | yes | WS_Teplá vnitřní 8 | 0
13024746 | 4.NP_SO-102 | 2563.01 | 0.0004908 | 0.201299 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15335.2 | PP–RCT S4 | 25 | 31 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2563.01 | ø25 | 19.4 | TR10.03.0560 | 0560 | yes | WS_Teplá vnitřní 8 | 0
13024799 | 4.NP_SO-102 | 2782.54 | 0.000314112 | 0.174832 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15337.2 | PP–RCT S4 | 20 | 198 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2782.54 | ø20 | 15.4 | TR10.03.0561 | 0561 | no | WS_Teplá vnitřní 8 | 0
13024912 | 4.NP_SO-102 | 2438.54 | 0.0004908 | 0.191523 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15275.2 | PP–RCT S4 | 25 | 11 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2438.54 | ø25 | 19.4 | TR10.03.0562 | 0562 | yes | WS_Studená vnitřní 6 | 0
13024973 | 4.NP_SO-102 | 2862.54 | 0.000314112 | 0.179859 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15277.2 | PP–RCT S4 | 20 | 41 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2862.54 | ø20 | 15.4 | TR10.03.0563 | 0563 | no | WS_Studená vnitřní 6 | 0
13025048 | 4.NP_SO-102 | 688.406 | 0.000314112 | 0.0432538 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15277.2 | PP–RCT S4 | 20 | 42 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 688.406 | ø20 | 15.4 | TR10.03.0564 | 0564 | no | WS_Studená vnitřní 6 | 0
13025057 | 4.NP_SO-102 | 382.538 | 0.000314112 | 0.0240355 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15277.2 | PP–RCT S4 | 20 | 42 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 382.538 | ø20 | 15.4 | TR10.03.0565 | 0565 | no | WS_Studená vnitřní 6 | 0
13025084 | 4.NP_SO-102 | 2480.34 | 0.000314112 | 0.155844 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15277.2 | PP–RCT S4 | 20 | 41 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2480.34 | ø20 | 15.4 | TR10.03.0566 | 0566 | yes | WS_Studená vnitřní 6 | 0
13025090 | 4.NP_SO-102 | 11281.5 | 0.0004908 | 0.886046 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15275.2 | PP–RCT S4 | 25 | 11 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 11281.5 | ø25 | 19.4 | TR10.03.0567 | 0567 | yes | WS_Studená vnitřní 6 | 0
13025098 | 4.NP_SO-102 | 668.406 | 0.000314112 | 0.0419972 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15337.2 | PP–RCT S4 | 20 | 33 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 668.406 | ø20 | 15.4 | TR10.03.0568 | 0568 | no | WS_Teplá vnitřní 8 | 0
13025109 | 4.NP_SO-102 | 468.827 | 0.000314112 | 0.0294572 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15337.2 | PP–RCT S4 | 20 | 33 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 468.827 | ø20 | 15.4 | TR10.03.0569 | 0569 | yes | WS_Teplá vnitřní 8 | 0
13025147 | 4.NP_SO-102 | 302.702 | 0.0004908 | 0.0237742 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15275.2 | PP–RCT S4 | 25 | 18 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 302.702 | ø25 | 19.4 | TR10.03.0570 | 0570 | no | WS_Studená vnitřní 6 | 0
13025185 | 4.NP_SO-102 | 244.608 | 0.000804127 | 0.0245907 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3300.93 | 3284.93 | 3284.93 | 3268.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15272.5 | PP–RCT S4 | 32 | 14 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 244.608 | ø32 | 24.8 | TR10.03.0571 | 0571 | yes | WS_Studená vnitřní 6 | 0
13025191 | 4.NP_SO-102 | 296.251 | 0.000804127 | 0.0297824 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3300.93 | 3284.93 | 3284.93 | 3268.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15272.5 | PP–RCT S4 | 32 | 44 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 296.251 | ø32 | 24.8 | TR10.03.0572 | 0572 | yes | WS_Studená vnitřní 6 | 0
13025222 | 4.NP_SO-102 | 1645.33 | 0.000314112 | 0.103379 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15277.2 | PP–RCT S4 | 20 | 16 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1645.33 | ø20 | 15.4 | TR10.03.0573 | 0573 | no | WS_Studená vnitřní 6 | 0
13025232 | 4.NP_SO-102 | 63.9716 | 0.000314112 | 0.00401945 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15277.2 | PP–RCT S4 | 20 | 16 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 63.9716 | ø20 | 15.4 | TR10.03.0574 | 0574 | no | WS_Studená vnitřní 6 | 0
13025264 | 4.NP_SO-102 | 35.0505 | 0.0004908 | 0.00275286 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15275.2 | PP–RCT S4 | 25 | 39 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 35.0505 | ø25 | 19.4 | TR10.03.0575 | 0575 | no | WS_Teplá vnitřní 8 | 0
13025281 | 4.NP_SO-102 | 1662.9 | 0.000314112 | 0.104483 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15277.2 | PP–RCT S4 | 20 | 38 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1662.9 | ø20 | 15.4 | TR10.03.0576 | 0576 | no | WS_Teplá vnitřní 8 | 0
13025293 | 4.NP_SO-102 | 142.538 | 0.000314112 | 0.0089559 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15277.2 | PP–RCT S4 | 20 | 38 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 142.538 | ø20 | 15.4 | TR10.03.0577 | 0577 | no | WS_Teplá vnitřní 8 | 0
13025366 | 4.NP_SO-102 | 515.075 | 0.000314112 | 0.0323631 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15277.2 | PP–RCT S4 | 20 | 15 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 515.075 | ø20 | 15.4 | TR10.03.0578 | 0578 | no | WS_Studená vnitřní 6 | 0
13025376 | 4.NP_SO-102 | 102.538 | 0.000314112 | 0.00644262 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15277.2 | PP–RCT S4 | 20 | 15 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 102.538 | ø20 | 15.4 | TR10.03.0579 | 0579 | no | WS_Studená vnitřní 6 | 0
13025463 | 4.NP_SO-102 | 407.502 | 0.000314112 | 0.0256041 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15277.2 | PP–RCT S4 | 20 | 37 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 407.502 | ø20 | 15.4 | TR10.03.0580 | 0580 | no | WS_Teplá vnitřní 8 | 0
13025473 | 4.NP_SO-102 | 32.8271 | 0.000314112 | 0.00206259 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15277.2 | PP–RCT S4 | 20 | 37 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 32.8271 | ø20 | 15.4 | TR10.03.0581 | 0581 | no | WS_Teplá vnitřní 8 | 0
13025500 | 4.NP_SO-102 | 749.84 | 0.000314112 | 0.0471139 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15277.2 | PP–RCT S4 | 20 | 15 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 749.84 | ø20 | 15.4 | TR10.03.0582 | 0582 | no | WS_Studená vnitřní 6 | 0
13025506 | 4.NP_SO-102 | 950.941 | 0.0004908 | 0.0746867 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15275.2 | PP–RCT S4 | 25 | 18 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 950.941 | ø25 | 19.4 | TR10.03.0583 | 0583 | no | WS_Studená vnitřní 6 | 0
13025525 | 4.NP_SO-102 | 888.406 | 0.000314112 | 0.0558202 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15277.2 | PP–RCT S4 | 20 | 37 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 888.406 | ø20 | 15.4 | TR10.03.0584 | 0584 | no | WS_Teplá vnitřní 8 | 0
13025531 | 4.NP_SO-102 | 972.375 | 0.0004908 | 0.0763702 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15275.2 | PP–RCT S4 | 25 | 39 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 972.375 | ø25 | 19.4 | TR10.03.0585 | 0585 | no | WS_Teplá vnitřní 8 | 0
13025539 | 4.NP_SO-102 | 1625.08 | 0.000314112 | 0.102106 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 13242.3 | PP–RCT S4 | 20 | 1 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1625.08 | ø20 | 15.4 | TR10.03.0586 | 0586 | no | WS_Teplá vnitřní 8 | 0
13025564 | 4.NP_SO-102 | 1838.05 | 0.000314112 | 0.115488 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 13242.3 | PP–RCT S4 | 20 | 13 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1838.05 | ø20 | 15.4 | TR10.03.0587 | 0587 | no | WS_Studená vnitřní 6 | 0
13025659 | 4.NP_SO-102 | 1978.57 | 0.000314112 | 0.124317 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3246.03 | 1267.46 | 3246.03 | 1267.46 | 3246.03 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 13267.5 | PP–RCT S4 | 20 | 13 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1978.57 | ø20 | 15.4 | TR10.03.0588 | 0588 | no | WS_Studená vnitřní 6
13025691 | 4.NP_SO-102 | 2038.57 | 0.000314112 | 0.128087 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3306.03 | 1267.46 | 3306.03 | 1267.46 | 3306.03 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 13267.5 | PP–RCT S4 | 20 | 1 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2038.57 | ø20 | 15.4 | TR10.03.0589 | 0589 | no | WS_Teplá vnitřní 8
13025936 | 4.NP_SO-102 | 162.227 | 0.000804127 | 0.0163088 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3260.93 | 3244.93 | 3244.93 | 3228.93 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 15232.5 | PP–RCT S4 | 32 | 56 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 162.227 | ø32 | 24.8 | TR10.03.0590 | 0590 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 0
13025950 | 4.NP_SO-102 | 543.83 | 0.000314112 | 0.0341698 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3254.93 | 3244.93 | 3244.93 | 3234.93 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 15237.2 | PP–RCT S4 | 20 | 13 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 543.83 | ø20 | 15.4 | TR10.03.0591 | 0591 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13026078 | 4.NP_SO-102 | 1943.33 | 0.0004908 | 0.152629 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3224.29 | 1280.96 | 3224.29 | 1280.96 | 3224.29 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 13281 | PP–RCT S4 | 25 | 53 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1943.33 | ø25 | 19.4 | TR10.03.0592 | 0592 | no | WS_"ŠEDÁ" studená vnitřní 2
13026159 | 4.NP_SO-102 | 72.5375 | 0.000314112 | 0.00455767 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 13242.3 | PP–RCT S4 | 20 | 9 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 72.5375 | ø20 | 15.4 | TR10.03.0593 | 0593 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13026280 | 4.NP_SO-102 | 1358.66 | 0.0004908 | 0.106709 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 1262.5 | 1250 | 1250 | 1237.5 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 13240.3 | PP–RCT S4 | 25 | 50 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1358.66 | ø25 | 19.4 | TR10.03.0594 | 0594 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13026290 | 4.NP_SO-102 | 153.58 | 0.000314112 | 0.00964969 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 13242.3 | PP–RCT S4 | 20 | 9 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 153.58 | ø20 | 15.4 | TR10.03.0595 | 0595 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13026538 | 4.NP_SO-102 | 26.0553 | 0.0004908 | 0.00204638 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15335.2 | PP–RCT S4 | 25 | 39 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 26.0553 | ø25 | 19.4 | TR10.03.0596 | 0596 | no | WS_Teplá vnitřní 8 | 0
13026539 | 4.NP_SO-102 | 67.7561 | 0.0004908 | 0.00532156 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3347.72 | 3290.97 | 3338.88 | 3282.13 | 3338.88 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15284.1 | PP–RCT S4 | 25 | 39 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 67.7561 | ø25 | 19.4 | TR10.03.0597 | 0597 | no | WS_Teplá vnitřní 8 | 100
13026543 | 4.NP_SO-102 | 386.541 | 0.000804127 | 0.0388593 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3360.93 | 3344.93 | 3344.93 | 3328.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15332.5 | PP–RCT S4 | 32 | 139 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 386.541 | ø32 | 24.8 | TR10.03.0598 | 0598 | yes | WS_Teplá vnitřní 8 | 0
13026746 | 4.NP_SO-102 | 4854.64 | 0.0004908 | 0.381282 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15335.2 | PP–RCT S4 | 25 | 26 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4854.64 | ø25 | 19.4 | TR10.03.0599 | 0599 | yes | WS_Teplá vnitřní 8 | 0
13026754 | 4.NP_SO-102 | 277.129 | 0.000804127 | 0.0278601 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3360.93 | 3344.93 | 3344.93 | 3328.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15332.5 | PP–RCT S4 | 32 | 11 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 277.129 | ø32 | 24.8 | TR10.03.0600 | 0600 | yes | WS_Teplá vnitřní 8 | 0
13027009 | 4.NP_SO-102 | 83.3017 | 0.0004908 | 0.0065425 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3257.43 | 3244.93 | 3244.93 | 3232.43 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 15235.2 | PP–RCT S4 | 25 | 53 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 83.3017 | ø25 | 19.4 | TR10.03.0601 | 0601 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13027013 | 4.NP_SO-102 | 2062.54 | 0.000314112 | 0.129593 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3254.93 | 3244.93 | 3244.93 | 3234.93 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 15237.2 | PP–RCT S4 | 20 | 13 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2062.54 | ø20 | 15.4 | TR10.03.0602 | 0602 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13027152 | 4.NP_SO-102 | 1204.02 | 0.0004908 | 0.0945632 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15335.2 | PP–RCT S4 | 25 | 21 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1204.02 | ø25 | 19.4 | TR10.03.0603 | 0603 | no | WS_Teplá vnitřní 8 | 0
13027176 | 4.NP_SO-102 | 1042.25 | 0.000314112 | 0.0654864 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15277.2 | PP–RCT S4 | 20 | 20 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1042.25 | ø20 | 15.4 | TR10.03.0604 | 0604 | no | WS_Studená vnitřní 6 | 0
13027331 | 4.NP_SO-102 | 549.356 | 0.000314112 | 0.0345171 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15277.2 | PP–RCT S4 | 20 | 35 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 549.356 | ø20 | 15.4 | TR10.03.0605 | 0605 | no | WS_Studená vnitřní 6 | 0
13027340 | 4.NP_SO-102 | 345.075 | 0.000314112 | 0.0216817 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15277.2 | PP–RCT S4 | 20 | 35 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 345.075 | ø20 | 15.4 | TR10.03.0606 | 0606 | no | WS_Studená vnitřní 6 | 0
13027348 | 4.NP_SO-102 | 502.538 | 0.000314112 | 0.0315754 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15277.2 | PP–RCT S4 | 20 | 35 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 502.538 | ø20 | 15.4 | TR10.03.0607 | 0607 | no | WS_Studená vnitřní 6 | 0
13027366 | 4.NP_SO-102 | 701.807 | 0.000314112 | 0.0440958 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15277.2 | PP–RCT S4 | 20 | 25 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 701.807 | ø20 | 15.4 | TR10.03.0608 | 0608 | no | WS_Teplá vnitřní 8 | 0
13027375 | 4.NP_SO-102 | 385.075 | 0.000314112 | 0.024195 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15277.2 | PP–RCT S4 | 20 | 25 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 385.075 | ø20 | 15.4 | TR10.03.0609 | 0609 | no | WS_Teplá vnitřní 8 | 0
13027383 | 4.NP_SO-102 | 401.444 | 0.000314112 | 0.0252235 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15277.2 | PP–RCT S4 | 20 | 25 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 401.444 | ø20 | 15.4 | TR10.03.0610 | 0610 | no | WS_Teplá vnitřní 8 | 0
13027469 | 4.NP_SO-102 | 13.0829 | 0.000314112 | 0.000822026 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15337.2 | PP–RCT S4 | 20 | 25 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 13.0829 | ø20 | 15.4 | TR10.03.0611 | 0611 | no | WS_Teplá vnitřní 8 | 0
13027470 | 4.NP_SO-102 | 70.3864 | 0.000314112 | 0.00442251 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3346.88 | 3290.04 | 3339.81 | 3282.97 | 3339.81 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15284.6 | PP–RCT S4 | 20 | 25 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 70.3864 | ø20 | 15.4 | TR10.03.0612 | 0612 | no | WS_Teplá vnitřní 8 | 100
13027474 | 4.NP_SO-102 | 4046.06 | 0.0004908 | 0.317777 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15335.2 | PP–RCT S4 | 25 | 26 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4046.06 | ø25 | 19.4 | TR10.03.0613 | 0613 | yes | WS_Teplá vnitřní 8 | 0
13027513 | 4.NP_SO-102 | 3845.94 | 0.0004908 | 0.302059 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15275.2 | PP–RCT S4 | 25 | 29 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3845.94 | ø25 | 19.4 | TR10.03.0614 | 0614 | yes | WS_Studená vnitřní 6 | 0
13027739 | 4.NP_SO-102 | 11833 | 0.0004908 | 0.929362 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15335.2 | PP–RCT S4 | 25 | 21 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 11833 | ø25 | 19.4 | TR10.03.0615 | 0615 | yes | WS_Teplá vnitřní 8 | 0
13027781 | 4.NP_SO-102 | 11822.5 | 0.0004908 | 0.928533 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15275.2 | PP–RCT S4 | 25 | 198 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 11822.5 | ø25 | 19.4 | TR10.03.0616 | 0616 | yes | WS_Studená vnitřní 6 | 0
13027946 | 4.NP_SO-102 | 2491.81 | 0.000314112 | 0.156565 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15337.2 | PP–RCT S4 | 20 | 198 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2491.81 | ø20 | 15.4 | TR10.03.0617 | 0617 | yes | WS_Teplá vnitřní 8 | 0
13027952 | 4.NP_SO-102 | 11292.7 | 0.0004908 | 0.886924 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15335.2 | PP–RCT S4 | 25 | 31 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 11292.7 | ø25 | 19.4 | TR10.03.0618 | 0618 | yes | WS_Teplá vnitřní 8 | 0
13028213 | 4.NP_SO-102 | 193.841 | 0.000804127 | 0.019487 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3300.93 | 3284.93 | 3284.93 | 3268.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15272.5 | PP–RCT S4 | 32 | 14 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 193.841 | ø32 | 24.8 | TR10.03.0619 | 0619 | yes | WS_Studená vnitřní 6 | 0
13028231 | 4.NP_SO-102 | 103.551 | 0.000804127 | 0.0104101 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3360.93 | 3344.93 | 3344.93 | 3328.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15332.5 | PP–RCT S4 | 32 | 42 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 103.551 | ø32 | 24.8 | TR10.03.0620 | 0620 | yes | WS_Teplá vnitřní 8 | 0
13028309 | 4.NP_SO-102 | 109.841 | 0.0004908 | 0.0086269 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15275.2 | PP–RCT S4 | 25 | 18 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 109.841 | ø25 | 19.4 | TR10.03.0621 | 0621 | no | WS_Studená vnitřní 6 | 0
13028325 | 4.NP_SO-102 | 116.768 | 0.0004908 | 0.00917093 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 15275.2 | PP–RCT S4 | 25 | 39 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 116.768 | ø25 | 19.4 | TR10.03.0622 | 0622 | no | WS_Teplá vnitřní 8 | 0
13028539 | 4.NP_SO-102 | 5219.58 | 0.0004908 | 0.409945 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15275.2 | PP–RCT S4 | 25 | 29 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5219.58 | ø25 | 19.4 | TR10.03.0623 | 0623 | yes | WS_Studená vnitřní 6 | 0
13028551 | 4.NP_SO-102 | 104.138 | 0.0004908 | 0.00817895 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 15275.2 | PP–RCT S4 | 25 | 38 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 104.138 | ø25 | 19.4 | TR10.03.0624 | 0624 | yes | WS_Studená vnitřní 6 | 0
13030322 | 3.NP_SO-102 | 342.071 | 0.000804127 | 0.0343887 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3360.93 | 3344.93 | 3344.93 | 3328.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11332.5 | PP–RCT S4 | 32 | 54 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 342.071 | ø32 | 24.8 | TR10.03.0625 | 0625 | yes | WS_Teplá vnitřní 8 | 0
13030326 | 3.NP_SO-102 | 2563.01 | 0.0004908 | 0.201299 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11335.2 | PP–RCT S4 | 25 | 147 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2563.01 | ø25 | 19.4 | TR10.03.0626 | 0626 | yes | WS_Teplá vnitřní 8 | 0
13030342 | 3.NP_SO-102 | 2438.54 | 0.0004908 | 0.191523 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11275.2 | PP–RCT S4 | 25 | 146 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2438.54 | ø25 | 19.4 | TR10.03.0627 | 0627 | yes | WS_Studená vnitřní 6 | 0
13030356 | 3.NP_SO-102 | 698.725 | 0.0004908 | 0.0548777 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11275.2 | PP–RCT S4 | 25 | 197 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 698.725 | ø25 | 19.4 | TR10.03.0628 | 0628 | no | WS_Studená vnitřní 6 | 0
13030358 | 3.NP_SO-102 | 379.363 | 0.0004908 | 0.0297951 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11275.2 | PP–RCT S4 | 25 | 197 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 379.363 | ø25 | 19.4 | TR10.03.0629 | 0629 | no | WS_Studená vnitřní 6 | 0
13030368 | 3.NP_SO-102 | 678.725 | 0.0004908 | 0.0533069 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11335.2 | PP–RCT S4 | 25 | 154 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 678.725 | ø25 | 19.4 | TR10.03.0630 | 0630 | no | WS_Teplá vnitřní 8 | 0
13030370 | 3.NP_SO-102 | 465.652 | 0.0004908 | 0.0365722 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11335.2 | PP–RCT S4 | 25 | 154 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 465.652 | ø25 | 19.4 | TR10.03.0631 | 0631 | no | WS_Teplá vnitřní 8 | 0
13030372 | 3.NP_SO-102 | 302.702 | 0.0004908 | 0.0237742 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11275.2 | PP–RCT S4 | 25 | 70 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 302.702 | ø25 | 19.4 | TR10.03.0632 | 0632 | no | WS_Studená vnitřní 6 | 0
13030374 | 3.NP_SO-102 | 244.608 | 0.000804127 | 0.0245907 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3300.93 | 3284.93 | 3284.93 | 3268.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11272.5 | PP–RCT S4 | 32 | 46 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 244.608 | ø32 | 24.8 | TR10.03.0633 | 0633 | yes | WS_Studená vnitřní 6 | 0
13030379 | 3.NP_SO-102 | 289.901 | 0.000804127 | 0.029144 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3300.93 | 3284.93 | 3284.93 | 3268.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11272.5 | PP–RCT S4 | 32 | 45 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 289.901 | ø32 | 24.8 | TR10.03.0634 | 0634 | yes | WS_Studená vnitřní 6 | 0
13030382 | 3.NP_SO-102 | 1645.33 | 0.000314112 | 0.103379 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11277.2 | PP–RCT S4 | 20 | 74 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1645.33 | ø20 | 15.4 | TR10.03.0635 | 0635 | no | WS_Studená vnitřní 6 | 0
13030384 | 3.NP_SO-102 | 63.9716 | 0.000314112 | 0.00401945 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11277.2 | PP–RCT S4 | 20 | 74 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 63.9716 | ø20 | 15.4 | TR10.03.0636 | 0636 | no | WS_Studená vnitřní 6 | 0
13030386 | 3.NP_SO-102 | 35.0505 | 0.0004908 | 0.00275286 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11275.2 | PP–RCT S4 | 25 | 76 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 35.0505 | ø25 | 19.4 | TR10.03.0637 | 0637 | no | WS_Teplá vnitřní 8 | 0
13030388 | 3.NP_SO-102 | 1662.9 | 0.000314112 | 0.104483 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11277.2 | PP–RCT S4 | 20 | 80 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1662.9 | ø20 | 15.4 | TR10.03.0638 | 0638 | no | WS_Teplá vnitřní 8 | 0
13030390 | 3.NP_SO-102 | 142.538 | 0.000314112 | 0.0089559 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11277.2 | PP–RCT S4 | 20 | 80 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 142.538 | ø20 | 15.4 | TR10.03.0639 | 0639 | no | WS_Teplá vnitřní 8 | 0
13030392 | 3.NP_SO-102 | 515.075 | 0.000314112 | 0.0323631 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11277.2 | PP–RCT S4 | 20 | 72 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 515.075 | ø20 | 15.4 | TR10.03.0640 | 0640 | no | WS_Studená vnitřní 6 | 0
13030396 | 3.NP_SO-102 | 102.538 | 0.000314112 | 0.00644262 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11277.2 | PP–RCT S4 | 20 | 72 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 102.538 | ø20 | 15.4 | TR10.03.0641 | 0641 | no | WS_Studená vnitřní 6 | 0
13030400 | 3.NP_SO-102 | 407.502 | 0.000314112 | 0.0256041 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11277.2 | PP–RCT S4 | 20 | 78 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 407.502 | ø20 | 15.4 | TR10.03.0642 | 0642 | no | WS_Teplá vnitřní 8 | 0
13030404 | 3.NP_SO-102 | 32.8271 | 0.000314112 | 0.00206259 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11277.2 | PP–RCT S4 | 20 | 78 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 32.8271 | ø20 | 15.4 | TR10.03.0643 | 0643 | no | WS_Teplá vnitřní 8 | 0
13030408 | 3.NP_SO-102 | 749.84 | 0.000314112 | 0.0471139 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11277.2 | PP–RCT S4 | 20 | 72 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 749.84 | ø20 | 15.4 | TR10.03.0644 | 0644 | no | WS_Studená vnitřní 6 | 0
13030413 | 3.NP_SO-102 | 950.941 | 0.0004908 | 0.0746867 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11275.2 | PP–RCT S4 | 25 | 70 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 950.941 | ø25 | 19.4 | TR10.03.0645 | 0645 | no | WS_Studená vnitřní 6 | 0
13030416 | 3.NP_SO-102 | 888.406 | 0.000314112 | 0.0558202 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11277.2 | PP–RCT S4 | 20 | 78 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 888.406 | ø20 | 15.4 | TR10.03.0646 | 0646 | no | WS_Teplá vnitřní 8 | 0
13030421 | 3.NP_SO-102 | 972.375 | 0.0004908 | 0.0763702 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11275.2 | PP–RCT S4 | 25 | 76 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 972.375 | ø25 | 19.4 | TR10.03.0647 | 0647 | no | WS_Teplá vnitřní 8 | 0
13030424 | 3.NP_SO-102 | 1625.08 | 0.000314112 | 0.102106 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 9242.3 | PP–RCT S4 | 20 | 74 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1625.08 | ø20 | 15.4 | TR10.03.0648 | 0648 | no | WS_Teplá vnitřní 8 | 0
13030426 | 3.NP_SO-102 | 1722.54 | 0.000314112 | 0.10823 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 9242.3 | PP–RCT S4 | 20 | 68 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1722.54 | ø20 | 15.4 | TR10.03.0649 | 0649 | no | WS_Studená vnitřní 6 | 0
13030428 | 3.NP_SO-102 | 1978.57 | 0.000314112 | 0.124317 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3246.03 | 1267.46 | 3246.03 | 1267.46 | 3246.03 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 9267.46 | PP–RCT S4 | 20 | 68 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1978.57 | ø20 | 15.4 | TR10.03.0650 | 0650 | no | WS_Studená vnitřní 6
13030434 | 3.NP_SO-102 | 2038.57 | 0.000314112 | 0.128087 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3306.03 | 1267.46 | 3306.03 | 1267.46 | 3306.03 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 9267.46 | PP–RCT S4 | 20 | 74 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2038.57 | ø20 | 15.4 | TR10.03.0651 | 0651 | no | WS_Teplá vnitřní 8
13030440 | 3.NP_SO-102 | 544.629 | 0.0004908 | 0.0427751 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3257.43 | 3244.93 | 3244.93 | 3232.43 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 11235.2 | PP–RCT S4 | 25 | 66 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 544.629 | ø25 | 19.4 | TR10.03.0652 | 0652 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 0
13030446 | 3.NP_SO-102 | 1943.33 | 0.0004908 | 0.152629 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3224.29 | 1280.96 | 3224.29 | 1280.96 | 3224.29 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 9280.96 | PP–RCT S4 | 25 | 69 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1943.33 | ø25 | 19.4 | TR10.03.0653 | 0653 | no | WS_"ŠEDÁ" studená vnitřní 2
13030448 | 3.NP_SO-102 | 72.5375 | 0.000314112 | 0.00455767 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 9242.3 | PP–RCT S4 | 20 | 23 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 72.5375 | ø20 | 15.4 | TR10.03.0654 | 0654 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13030452 | 3.NP_SO-102 | 3919.81 | 0.0004908 | 0.307861 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 1262.5 | 1250 | 1250 | 1237.5 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 9240.3 | PP–RCT S4 | 25 | 71 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3919.81 | ø25 | 19.4 | TR10.03.0655 | 0655 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13030455 | 3.NP_SO-102 | 153.58 | 0.000314112 | 0.00964969 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 9242.3 | PP–RCT S4 | 20 | 23 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 153.58 | ø20 | 15.4 | TR10.03.0656 | 0656 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13030458 | 3.NP_SO-102 | 26.0553 | 0.0004908 | 0.00204638 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11335.2 | PP–RCT S4 | 25 | 76 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 26.0553 | ø25 | 19.4 | TR10.03.0657 | 0657 | no | WS_Teplá vnitřní 8 | 0
13030459 | 3.NP_SO-102 | 67.7561 | 0.0004908 | 0.00532156 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3347.72 | 3290.97 | 3338.88 | 3282.13 | 3338.88 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11284.1 | PP–RCT S4 | 25 | 76 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 67.7561 | ø25 | 19.4 | TR10.03.0658 | 0658 | no | WS_Teplá vnitřní 8 | 100
13030463 | 3.NP_SO-102 | 380.191 | 0.000804127 | 0.0382209 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3360.93 | 3344.93 | 3344.93 | 3328.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11332.5 | PP–RCT S4 | 32 | 53 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 380.191 | ø32 | 24.8 | TR10.03.0659 | 0659 | yes | WS_Teplá vnitřní 8 | 0
13030472 | 3.NP_SO-102 | 4854.64 | 0.0004908 | 0.381282 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11335.2 | PP–RCT S4 | 25 | 57 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4854.64 | ø25 | 19.4 | TR10.03.0660 | 0660 | yes | WS_Teplá vnitřní 8 | 0
13030475 | 3.NP_SO-102 | 277.129 | 0.000804127 | 0.0278601 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3360.93 | 3344.93 | 3344.93 | 3328.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11332.5 | PP–RCT S4 | 32 | 70 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 277.129 | ø32 | 24.8 | TR10.03.0661 | 0661 | yes | WS_Teplá vnitřní 8 | 0
13030493 | 3.NP_SO-102 | 533.511 | 0.0004908 | 0.0419018 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3257.43 | 3244.93 | 3244.93 | 3232.43 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 11235.2 | PP–RCT S4 | 25 | 68 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 533.511 | ø25 | 19.4 | TR10.03.0662 | 0662 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13030496 | 3.NP_SO-102 | 2059.36 | 0.0004908 | 0.161742 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3257.43 | 3244.93 | 3244.93 | 3232.43 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 11235.2 | PP–RCT S4 | 25 | 68 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2059.36 | ø25 | 19.4 | TR10.03.0663 | 0663 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13030516 | 3.NP_SO-102 | 3482.54 | 0.000314112 | 0.218814 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11337.2 | PP–RCT S4 | 20 | 144 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3482.54 | ø20 | 15.4 | TR10.03.0664 | 0664 | no | WS_Teplá vnitřní 8 | 0
13030544 | 3.NP_SO-102 | 549.356 | 0.000314112 | 0.0345171 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11277.2 | PP–RCT S4 | 20 | 59 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 549.356 | ø20 | 15.4 | TR10.03.0665 | 0665 | no | WS_Studená vnitřní 6 | 0
13030546 | 3.NP_SO-102 | 345.075 | 0.000314112 | 0.0216817 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11277.2 | PP–RCT S4 | 20 | 59 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 345.075 | ø20 | 15.4 | TR10.03.0666 | 0666 | no | WS_Studená vnitřní 6 | 0
13030548 | 3.NP_SO-102 | 1476.5 | 0.000314112 | 0.0927713 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11277.2 | PP–RCT S4 | 20 | 59 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1476.5 | ø20 | 15.4 | TR10.03.0667 | 0667 | no | WS_Studená vnitřní 6 | 0
13030552 | 3.NP_SO-102 | 701.807 | 0.000314112 | 0.0440958 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11277.2 | PP–RCT S4 | 20 | 67 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 701.807 | ø20 | 15.4 | TR10.03.0668 | 0668 | no | WS_Teplá vnitřní 8 | 0
13030554 | 3.NP_SO-102 | 385.075 | 0.000314112 | 0.024195 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11277.2 | PP–RCT S4 | 20 | 67 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 385.075 | ø20 | 15.4 | TR10.03.0669 | 0669 | no | WS_Teplá vnitřní 8 | 0
13030556 | 3.NP_SO-102 | 1401.44 | 0.000314112 | 0.0880553 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11277.2 | PP–RCT S4 | 20 | 67 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1401.44 | ø20 | 15.4 | TR10.03.0670 | 0670 | no | WS_Teplá vnitřní 8 | 0
13030560 | 3.NP_SO-102 | 13.0829 | 0.000314112 | 0.000822026 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11337.2 | PP–RCT S4 | 20 | 67 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 13.0829 | ø20 | 15.4 | TR10.03.0671 | 0671 | no | WS_Teplá vnitřní 8 | 0
13030561 | 3.NP_SO-102 | 70.3864 | 0.000314112 | 0.00442251 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3346.88 | 3290.04 | 3339.81 | 3282.97 | 3339.81 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11284.6 | PP–RCT S4 | 20 | 67 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 70.3864 | ø20 | 15.4 | TR10.03.0672 | 0672 | no | WS_Teplá vnitřní 8 | 100
13030565 | 3.NP_SO-102 | 2009.12 | 0.0004908 | 0.157796 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11335.2 | PP–RCT S4 | 25 | 57 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2009.12 | ø25 | 19.4 | TR10.03.0673 | 0673 | yes | WS_Teplá vnitřní 8 | 0
13030577 | 3.NP_SO-102 | 1809.01 | 0.0004908 | 0.142079 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11275.2 | PP–RCT S4 | 25 | 49 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1809.01 | ø25 | 19.4 | TR10.03.0674 | 0674 | yes | WS_Studená vnitřní 6 | 0
13030593 | 3.NP_SO-102 | 912.949 | 0.0004908 | 0.0717029 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11275.2 | PP–RCT S4 | 25 | 154 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 912.949 | ø25 | 19.4 | TR10.03.0675 | 0675 | yes | WS_Studená vnitřní 6 | 0
13030641 | 3.NP_SO-102 | 193.841 | 0.000804127 | 0.019487 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3300.93 | 3284.93 | 3284.93 | 3268.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11272.5 | PP–RCT S4 | 32 | 46 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 193.841 | ø32 | 24.8 | TR10.03.0676 | 0676 | yes | WS_Studená vnitřní 6 | 0
13030644 | 3.NP_SO-102 | 103.551 | 0.000804127 | 0.0104101 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3360.93 | 3344.93 | 3344.93 | 3328.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11332.5 | PP–RCT S4 | 32 | 54 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 103.551 | ø32 | 24.8 | TR10.03.0677 | 0677 | yes | WS_Teplá vnitřní 8 | 0
13030647 | 3.NP_SO-102 | 109.841 | 0.0004908 | 0.0086269 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11275.2 | PP–RCT S4 | 25 | 70 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 109.841 | ø25 | 19.4 | TR10.03.0678 | 0678 | no | WS_Studená vnitřní 6 | 0
13030650 | 3.NP_SO-102 | 116.768 | 0.0004908 | 0.00917093 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11275.2 | PP–RCT S4 | 25 | 76 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 116.768 | ø25 | 19.4 | TR10.03.0679 | 0679 | no | WS_Teplá vnitřní 8 | 0
13030662 | 3.NP_SO-102 | 5219.58 | 0.0004908 | 0.409945 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11275.2 | PP–RCT S4 | 25 | 49 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5219.58 | ø25 | 19.4 | TR10.03.0680 | 0680 | yes | WS_Studená vnitřní 6 | 0
13030665 | 3.NP_SO-102 | 104.138 | 0.0004908 | 0.00817895 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11275.2 | PP–RCT S4 | 25 | 63 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 104.138 | ø25 | 19.4 | TR10.03.0681 | 0681 | yes | WS_Studená vnitřní 6 | 0
13030729 | 2.NP_SO-102 | 342.071 | 0.000804127 | 0.0343887 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3360.93 | 3344.93 | 3344.93 | 3328.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7332.53 | PP–RCT S4 | 32 | 83 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 342.071 | ø32 | 24.8 | TR10.03.0682 | 0682 | yes | WS_Teplá vnitřní 8 | 0
13030733 | 2.NP_SO-102 | 2563.01 | 0.0004908 | 0.201299 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7335.23 | PP–RCT S4 | 25 | 101 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2563.01 | ø25 | 19.4 | TR10.03.0683 | 0683 | yes | WS_Teplá vnitřní 8 | 0
13030749 | 2.NP_SO-102 | 2438.54 | 0.0004908 | 0.191523 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7275.23 | PP–RCT S4 | 25 | 97 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2438.54 | ø25 | 19.4 | TR10.03.0684 | 0684 | yes | WS_Studená vnitřní 6 | 0
13030763 | 2.NP_SO-102 | 698.725 | 0.0004908 | 0.0548777 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7275.23 | PP–RCT S4 | 25 | 162 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 698.725 | ø25 | 19.4 | TR10.03.0685 | 0685 | no | WS_Studená vnitřní 6 | 0
13030765 | 2.NP_SO-102 | 379.363 | 0.0004908 | 0.0297951 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7275.23 | PP–RCT S4 | 25 | 162 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 379.363 | ø25 | 19.4 | TR10.03.0686 | 0686 | no | WS_Studená vnitřní 6 | 0
13030775 | 2.NP_SO-102 | 678.725 | 0.0004908 | 0.0533069 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7335.23 | PP–RCT S4 | 25 | 163 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 678.725 | ø25 | 19.4 | TR10.03.0687 | 0687 | no | WS_Teplá vnitřní 8 | 0
13030777 | 2.NP_SO-102 | 465.652 | 0.0004908 | 0.0365722 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7335.23 | PP–RCT S4 | 25 | 163 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 465.652 | ø25 | 19.4 | TR10.03.0688 | 0688 | no | WS_Teplá vnitřní 8 | 0
13030779 | 2.NP_SO-102 | 302.702 | 0.0004908 | 0.0237742 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7275.23 | PP–RCT S4 | 25 | 101 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 302.702 | ø25 | 19.4 | TR10.03.0689 | 0689 | no | WS_Studená vnitřní 6 | 0
13030781 | 2.NP_SO-102 | 244.608 | 0.000804127 | 0.0245907 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3300.93 | 3284.93 | 3284.93 | 3268.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7272.53 | PP–RCT S4 | 32 | 77 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 244.608 | ø32 | 24.8 | TR10.03.0690 | 0690 | yes | WS_Studená vnitřní 6 | 0
13030786 | 2.NP_SO-102 | 276.407 | 0.000804127 | 0.0277875 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3300.93 | 3284.93 | 3284.93 | 3268.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7272.53 | PP–RCT S4 | 32 | 184 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 276.407 | ø32 | 24.8 | TR10.03.0691 | 0691 | yes | WS_Studená vnitřní 6 | 0
13030789 | 2.NP_SO-102 | 1645.33 | 0.000314112 | 0.103379 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7277.23 | PP–RCT S4 | 20 | 105 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1645.33 | ø20 | 15.4 | TR10.03.0692 | 0692 | no | WS_Studená vnitřní 6 | 0
13030791 | 2.NP_SO-102 | 63.9716 | 0.000314112 | 0.00401945 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7277.23 | PP–RCT S4 | 20 | 105 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 63.9716 | ø20 | 15.4 | TR10.03.0693 | 0693 | no | WS_Studená vnitřní 6 | 0
