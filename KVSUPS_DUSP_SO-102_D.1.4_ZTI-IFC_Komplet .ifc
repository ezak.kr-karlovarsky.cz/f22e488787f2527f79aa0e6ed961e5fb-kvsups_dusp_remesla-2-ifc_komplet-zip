Properties of the parts of a building model (IFC4), part 49 of 60

# IfcPipeSegment: Typy trubek:PP-RCT (1338)
Name (Typy trubek:PP-RCT:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Instalační jednotky = Reynoldsovo číslo = Třecí faktor = Tření = Průtok (m3/s) = Rychlost (m/s) = Tlaková ztráta (Pa) | Stav průtoku | Doplňkový průtok (m3/s) | Relativní drsnost | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) | Spodní výška (mm) | Střední výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Délka (mm) | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
13030793 | 2.NP_SO-102 | 35.0505 | 0.0004908 | 0.00275286 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7275.23 | PP–RCT S4 | 25 | 105 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 35.0505 | ø25 | 19.4 | TR10.03.0694 | 0694 | no | WS_Teplá vnitřní 8 | 0
13030795 | 2.NP_SO-102 | 1662.9 | 0.000314112 | 0.104483 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7277.23 | PP–RCT S4 | 20 | 109 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1662.9 | ø20 | 15.4 | TR10.03.0695 | 0695 | no | WS_Teplá vnitřní 8 | 0
13030797 | 2.NP_SO-102 | 142.538 | 0.000314112 | 0.0089559 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7277.23 | PP–RCT S4 | 20 | 109 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 142.538 | ø20 | 15.4 | TR10.03.0696 | 0696 | no | WS_Teplá vnitřní 8 | 0
13030799 | 2.NP_SO-102 | 515.075 | 0.000314112 | 0.0323631 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7277.23 | PP–RCT S4 | 20 | 103 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 515.075 | ø20 | 15.4 | TR10.03.0697 | 0697 | no | WS_Studená vnitřní 6 | 0
13030803 | 2.NP_SO-102 | 102.538 | 0.000314112 | 0.00644262 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7277.23 | PP–RCT S4 | 20 | 103 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 102.538 | ø20 | 15.4 | TR10.03.0698 | 0698 | no | WS_Studená vnitřní 6 | 0
13030807 | 2.NP_SO-102 | 407.502 | 0.000314112 | 0.0256041 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7277.23 | PP–RCT S4 | 20 | 107 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 407.502 | ø20 | 15.4 | TR10.03.0699 | 0699 | no | WS_Teplá vnitřní 8 | 0
13030811 | 2.NP_SO-102 | 32.8271 | 0.000314112 | 0.00206259 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7277.23 | PP–RCT S4 | 20 | 107 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 32.8271 | ø20 | 15.4 | TR10.03.0700 | 0700 | no | WS_Teplá vnitřní 8 | 0
13030815 | 2.NP_SO-102 | 749.84 | 0.000314112 | 0.0471139 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7277.23 | PP–RCT S4 | 20 | 103 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 749.84 | ø20 | 15.4 | TR10.03.0701 | 0701 | no | WS_Studená vnitřní 6 | 0
13030820 | 2.NP_SO-102 | 950.941 | 0.0004908 | 0.0746867 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7275.23 | PP–RCT S4 | 25 | 101 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 950.941 | ø25 | 19.4 | TR10.03.0702 | 0702 | no | WS_Studená vnitřní 6 | 0
13030823 | 2.NP_SO-102 | 888.406 | 0.000314112 | 0.0558202 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7277.23 | PP–RCT S4 | 20 | 107 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 888.406 | ø20 | 15.4 | TR10.03.0703 | 0703 | no | WS_Teplá vnitřní 8 | 0
13030828 | 2.NP_SO-102 | 972.375 | 0.0004908 | 0.0763702 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7275.23 | PP–RCT S4 | 25 | 105 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 972.375 | ø25 | 19.4 | TR10.03.0704 | 0704 | no | WS_Teplá vnitřní 8 | 0
13030831 | 2.NP_SO-102 | 1625.08 | 0.000314112 | 0.102106 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 5242.3 | PP–RCT S4 | 20 | 103 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1625.08 | ø20 | 15.4 | TR10.03.0705 | 0705 | no | WS_Teplá vnitřní 8 | 0
13030833 | 2.NP_SO-102 | 1838.05 | 0.000314112 | 0.115488 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 5242.3 | PP–RCT S4 | 20 | 99 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1838.05 | ø20 | 15.4 | TR10.03.0706 | 0706 | no | WS_Studená vnitřní 6 | 0
13030835 | 2.NP_SO-102 | 1978.57 | 0.000314112 | 0.124317 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3246.03 | 1267.46 | 3246.03 | 1267.46 | 3246.03 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 5267.46 | PP–RCT S4 | 20 | 99 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1978.57 | ø20 | 15.4 | TR10.03.0707 | 0707 | no | WS_Studená vnitřní 6
13030841 | 2.NP_SO-102 | 2038.57 | 0.000314112 | 0.128087 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3306.03 | 1267.46 | 3306.03 | 1267.46 | 3306.03 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 5267.46 | PP–RCT S4 | 20 | 103 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2038.57 | ø20 | 15.4 | TR10.03.0708 | 0708 | no | WS_Teplá vnitřní 8
13030847 | 2.NP_SO-102 | 538.511 | 0.000804127 | 0.054137 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3260.93 | 3244.93 | 3244.93 | 3228.93 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 7232.53 | PP–RCT S4 | 32 | 77 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 538.511 | ø32 | 24.8 | TR10.03.0709 | 0709 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 0
13030853 | 2.NP_SO-102 | 1943.33 | 0.0004908 | 0.152629 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3224.29 | 1280.96 | 3224.29 | 1280.96 | 3224.29 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 5280.96 | PP–RCT S4 | 25 | 73 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1943.33 | ø25 | 19.4 | TR10.03.0710 | 0710 | no | WS_"ŠEDÁ" studená vnitřní 2
13030855 | 2.NP_SO-102 | 72.5375 | 0.000314112 | 0.00455767 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 5242.3 | PP–RCT S4 | 20 | 29 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 72.5375 | ø20 | 15.4 | TR10.03.0711 | 0711 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13030859 | 2.NP_SO-102 | 3919.81 | 0.0004908 | 0.307861 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 1262.5 | 1250 | 1250 | 1237.5 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 5240.3 | PP–RCT S4 | 25 | 72 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3919.81 | ø25 | 19.4 | TR10.03.0712 | 0712 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13030862 | 2.NP_SO-102 | 153.58 | 0.000314112 | 0.00964969 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 5242.3 | PP–RCT S4 | 20 | 29 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 153.58 | ø20 | 15.4 | TR10.03.0713 | 0713 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13030865 | 2.NP_SO-102 | 26.0553 | 0.0004908 | 0.00204638 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7335.23 | PP–RCT S4 | 25 | 105 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 26.0553 | ø25 | 19.4 | TR10.03.0714 | 0714 | no | WS_Teplá vnitřní 8 | 0
13030866 | 2.NP_SO-102 | 67.7561 | 0.0004908 | 0.00532156 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3347.72 | 3290.97 | 3338.88 | 3282.13 | 3338.88 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7284.11 | PP–RCT S4 | 25 | 105 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 67.7561 | ø25 | 19.4 | TR10.03.0715 | 0715 | no | WS_Teplá vnitřní 8 | 100
13030870 | 2.NP_SO-102 | 366.697 | 0.000804127 | 0.0368644 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3360.93 | 3344.93 | 3344.93 | 3328.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7332.53 | PP–RCT S4 | 32 | 184 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 366.697 | ø32 | 24.8 | TR10.03.0716 | 0716 | yes | WS_Teplá vnitřní 8 | 0
13030879 | 2.NP_SO-102 | 4854.64 | 0.0004908 | 0.381282 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7335.23 | PP–RCT S4 | 25 | 87 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4854.64 | ø25 | 19.4 | TR10.03.0717 | 0717 | yes | WS_Teplá vnitřní 8 | 0
13030882 | 2.NP_SO-102 | 277.129 | 0.000804127 | 0.0278601 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3360.93 | 3344.93 | 3344.93 | 3328.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7332.53 | PP–RCT S4 | 32 | 99 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 277.129 | ø32 | 24.8 | TR10.03.0718 | 0718 | yes | WS_Teplá vnitřní 8 | 0
13030900 | 2.NP_SO-102 | 543.83 | 0.000314112 | 0.0341698 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3254.93 | 3244.93 | 3244.93 | 3234.93 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 7237.23 | PP–RCT S4 | 20 | 26 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 543.83 | ø20 | 15.4 | TR10.03.0719 | 0719 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13030903 | 2.NP_SO-102 | 2062.54 | 0.000314112 | 0.129593 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3254.93 | 3244.93 | 3244.93 | 3234.93 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 7237.23 | PP–RCT S4 | 20 | 26 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2062.54 | ø20 | 15.4 | TR10.03.0720 | 0720 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13030935 | 2.NP_SO-102 | 716.386 | 0.000314112 | 0.0450119 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7277.23 | PP–RCT S4 | 20 | 88 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 716.386 | ø20 | 15.4 | TR10.03.0721 | 0721 | no | WS_Studená vnitřní 6 | 0
13030937 | 2.NP_SO-102 | 365.075 | 0.000314112 | 0.0229383 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7277.23 | PP–RCT S4 | 20 | 88 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 365.075 | ø20 | 15.4 | TR10.03.0722 | 0722 | no | WS_Studená vnitřní 6 | 0
13030939 | 2.NP_SO-102 | 342.083 | 0.000314112 | 0.0214937 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7277.23 | PP–RCT S4 | 20 | 88 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 342.083 | ø20 | 15.4 | TR10.03.0723 | 0723 | no | WS_Studená vnitřní 6 | 0
13030943 | 2.NP_SO-102 | 936.386 | 0.000314112 | 0.0588349 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7337.23 | PP–RCT S4 | 20 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 936.386 | ø20 | 15.4 | TR10.03.0724 | 0724 | no | WS_Teplá vnitřní 8 | 0
13030945 | 2.NP_SO-102 | 425.075 | 0.000314112 | 0.0267082 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7337.23 | PP–RCT S4 | 20 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 425.075 | ø20 | 15.4 | TR10.03.0725 | 0725 | no | WS_Teplá vnitřní 8 | 0
13030947 | 2.NP_SO-102 | 271.226 | 0.000314112 | 0.0170417 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7337.23 | PP–RCT S4 | 20 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 271.226 | ø20 | 15.4 | TR10.03.0726 | 0726 | no | WS_Teplá vnitřní 8 | 0
13030951 | 2.NP_SO-102 | 568.406 | 0.000314112 | 0.035714 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7277.23 | PP–RCT S4 | 20 | 90 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 568.406 | ø20 | 15.4 | TR10.03.0727 | 0727 | no | WS_Studená vnitřní 6 | 0
13030953 | 2.NP_SO-102 | 345.075 | 0.000314112 | 0.0216817 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7277.23 | PP–RCT S4 | 20 | 90 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 345.075 | ø20 | 15.4 | TR10.03.0728 | 0728 | no | WS_Studená vnitřní 6 | 0
13030955 | 2.NP_SO-102 | 502.538 | 0.000314112 | 0.0315754 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7277.23 | PP–RCT S4 | 20 | 90 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 502.538 | ø20 | 15.4 | TR10.03.0729 | 0729 | no | WS_Studená vnitřní 6 | 0
13030959 | 2.NP_SO-102 | 701.807 | 0.000314112 | 0.0440958 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7277.23 | PP–RCT S4 | 20 | 96 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 701.807 | ø20 | 15.4 | TR10.03.0730 | 0730 | no | WS_Teplá vnitřní 8 | 0
13030961 | 2.NP_SO-102 | 385.075 | 0.000314112 | 0.024195 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7277.23 | PP–RCT S4 | 20 | 96 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 385.075 | ø20 | 15.4 | TR10.03.0731 | 0731 | no | WS_Teplá vnitřní 8 | 0
13030963 | 2.NP_SO-102 | 401.444 | 0.000314112 | 0.0252235 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7277.23 | PP–RCT S4 | 20 | 96 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 401.444 | ø20 | 15.4 | TR10.03.0732 | 0732 | no | WS_Teplá vnitřní 8 | 0
13030967 | 2.NP_SO-102 | 32.1329 | 0.000314112 | 0.00201897 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7337.23 | PP–RCT S4 | 20 | 96 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 32.1329 | ø20 | 15.4 | TR10.03.0733 | 0733 | no | WS_Teplá vnitřní 8 | 0
13030968 | 2.NP_SO-102 | 70.3864 | 0.000314112 | 0.00442251 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3346.88 | 3290.04 | 3339.81 | 3282.97 | 3339.81 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7284.6 | PP–RCT S4 | 20 | 96 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 70.3864 | ø20 | 15.4 | TR10.03.0734 | 0734 | no | WS_Teplá vnitřní 8 | 100
13030972 | 2.NP_SO-102 | 4072.25 | 0.0004908 | 0.319834 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7335.23 | PP–RCT S4 | 25 | 87 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4072.25 | ø25 | 19.4 | TR10.03.0735 | 0735 | yes | WS_Teplá vnitřní 8 | 0
13030984 | 2.NP_SO-102 | 3872.13 | 0.0004908 | 0.304117 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7275.23 | PP–RCT S4 | 25 | 81 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3872.13 | ø25 | 19.4 | TR10.03.0736 | 0736 | yes | WS_Studená vnitřní 6 | 0
13030992 | 2.NP_SO-102 | 8186.98 | 0.000314112 | 0.514403 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7337.23 | PP–RCT S4 | 20 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 8186.98 | ø20 | 15.4 | TR10.03.0737 | 0737 | yes | WS_Teplá vnitřní 8 | 0
13031000 | 2.NP_SO-102 | 8172.36 | 0.000314112 | 0.513485 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7277.23 | PP–RCT S4 | 20 | 88 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 8172.36 | ø20 | 15.4 | TR10.03.0738 | 0738 | yes | WS_Studená vnitřní 6 | 0
13031048 | 2.NP_SO-102 | 193.841 | 0.000804127 | 0.019487 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3300.93 | 3284.93 | 3284.93 | 3268.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7272.53 | PP–RCT S4 | 32 | 77 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 193.841 | ø32 | 24.8 | TR10.03.0739 | 0739 | yes | WS_Studená vnitřní 6 | 0
13031051 | 2.NP_SO-102 | 103.551 | 0.000804127 | 0.0104101 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3360.93 | 3344.93 | 3344.93 | 3328.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7332.53 | PP–RCT S4 | 32 | 83 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 103.551 | ø32 | 24.8 | TR10.03.0740 | 0740 | yes | WS_Teplá vnitřní 8 | 0
13031054 | 2.NP_SO-102 | 109.841 | 0.0004908 | 0.0086269 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7275.23 | PP–RCT S4 | 25 | 101 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 109.841 | ø25 | 19.4 | TR10.03.0741 | 0741 | no | WS_Studená vnitřní 6 | 0
13031057 | 2.NP_SO-102 | 116.768 | 0.0004908 | 0.00917093 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7275.23 | PP–RCT S4 | 25 | 105 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 116.768 | ø25 | 19.4 | TR10.03.0742 | 0742 | no | WS_Teplá vnitřní 8 | 0
13031069 | 2.NP_SO-102 | 5219.58 | 0.0004908 | 0.409945 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7275.23 | PP–RCT S4 | 25 | 81 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5219.58 | ø25 | 19.4 | TR10.03.0743 | 0743 | yes | WS_Studená vnitřní 6 | 0
13031072 | 2.NP_SO-102 | 104.138 | 0.0004908 | 0.00817895 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7275.23 | PP–RCT S4 | 25 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 104.138 | ø25 | 19.4 | TR10.03.0744 | 0744 | yes | WS_Studená vnitřní 6 | 0
13031138 | 1.NP_SO-102 | 348.421 | 0.000804127 | 0.0350271 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3360.93 | 3344.93 | 3344.93 | 3328.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3332.53 | PP–RCT S4 | 32 | 112 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 348.421 | ø32 | 24.8 | TR10.03.0745 | 0745 | yes | WS_Teplá vnitřní 8 | 0
13031142 | 1.NP_SO-102 | 2556.66 | 0.0004908 | 0.2008 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3335.23 | PP–RCT S4 | 25 | 187 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2556.66 | ø25 | 19.4 | TR10.03.0746 | 0746 | yes | WS_Teplá vnitřní 8 | 0
13031158 | 1.NP_SO-102 | 2432.19 | 0.0004908 | 0.191024 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3275.23 | PP–RCT S4 | 25 | 187 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2432.19 | ø25 | 19.4 | TR10.03.0747 | 0747 | yes | WS_Studená vnitřní 6 | 0
13031172 | 1.NP_SO-102 | 705.075 | 0.000314112 | 0.0443012 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3277.23 | PP–RCT S4 | 20 | 169 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 705.075 | ø20 | 15.4 | TR10.03.0748 | 0748 | no | WS_Studená vnitřní 6 | 0
13031174 | 1.NP_SO-102 | 382.538 | 0.000314112 | 0.0240355 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3277.23 | PP–RCT S4 | 20 | 169 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 382.538 | ø20 | 15.4 | TR10.03.0749 | 0749 | no | WS_Studená vnitřní 6 | 0
13031181 | 1.NP_SO-102 | 9816.96 | 0.000314112 | 0.616818 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3277.23 | PP–RCT S4 | 20 | 169 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 9816.96 | ø20 | 15.4 | TR10.03.0750 | 0750 | yes | WS_Studená vnitřní 6 | 0
13031184 | 1.NP_SO-102 | 685.075 | 0.000314112 | 0.0430445 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3337.23 | PP–RCT S4 | 20 | 168 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 685.075 | ø20 | 15.4 | TR10.03.0751 | 0751 | no | WS_Teplá vnitřní 8 | 0
13031186 | 1.NP_SO-102 | 468.827 | 0.000314112 | 0.0294572 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3337.23 | PP–RCT S4 | 20 | 168 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 468.827 | ø20 | 15.4 | TR10.03.0752 | 0752 | no | WS_Teplá vnitřní 8 | 0
13031188 | 1.NP_SO-102 | 302.702 | 0.0004908 | 0.0237742 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3275.23 | PP–RCT S4 | 25 | 132 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 302.702 | ø25 | 19.4 | TR10.03.0753 | 0753 | no | WS_Studená vnitřní 6 | 0
13031190 | 1.NP_SO-102 | 245.402 | 0.000804127 | 0.0246705 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3300.93 | 3284.93 | 3284.93 | 3268.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3272.53 | PP–RCT S4 | 32 | 108 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 245.402 | ø32 | 24.8 | TR10.03.0754 | 0754 | yes | WS_Studená vnitřní 6 | 0
13031195 | 1.NP_SO-102 | 276.407 | 0.000804127 | 0.0277875 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3300.93 | 3284.93 | 3284.93 | 3268.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3272.53 | PP–RCT S4 | 32 | 185 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 276.407 | ø32 | 24.8 | TR10.03.0755 | 0755 | yes | WS_Studená vnitřní 6 | 0
13031198 | 1.NP_SO-102 | 1645.33 | 0.000314112 | 0.103379 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3277.23 | PP–RCT S4 | 20 | 136 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1645.33 | ø20 | 15.4 | TR10.03.0756 | 0756 | no | WS_Studená vnitřní 6 | 0
13031200 | 1.NP_SO-102 | 63.9716 | 0.000314112 | 0.00401945 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3277.23 | PP–RCT S4 | 20 | 136 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 63.9716 | ø20 | 15.4 | TR10.03.0757 | 0757 | no | WS_Studená vnitřní 6 | 0
13031202 | 1.NP_SO-102 | 35.0505 | 0.0004908 | 0.00275286 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3275.23 | PP–RCT S4 | 25 | 134 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 35.0505 | ø25 | 19.4 | TR10.03.0758 | 0758 | no | WS_Teplá vnitřní 8 | 0
13031204 | 1.NP_SO-102 | 1662.9 | 0.000314112 | 0.104483 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3277.23 | PP–RCT S4 | 20 | 138 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1662.9 | ø20 | 15.4 | TR10.03.0759 | 0759 | no | WS_Teplá vnitřní 8 | 0
13031206 | 1.NP_SO-102 | 142.538 | 0.000314112 | 0.0089559 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3277.23 | PP–RCT S4 | 20 | 138 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 142.538 | ø20 | 15.4 | TR10.03.0760 | 0760 | no | WS_Teplá vnitřní 8 | 0
13031208 | 1.NP_SO-102 | 515.075 | 0.000314112 | 0.0323631 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3277.23 | PP–RCT S4 | 20 | 134 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 515.075 | ø20 | 15.4 | TR10.03.0761 | 0761 | no | WS_Studená vnitřní 6 | 0
13031212 | 1.NP_SO-102 | 102.538 | 0.000314112 | 0.00644262 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3277.23 | PP–RCT S4 | 20 | 134 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 102.538 | ø20 | 15.4 | TR10.03.0762 | 0762 | no | WS_Studená vnitřní 6 | 0
13031216 | 1.NP_SO-102 | 407.502 | 0.000314112 | 0.0256041 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3277.23 | PP–RCT S4 | 20 | 136 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 407.502 | ø20 | 15.4 | TR10.03.0763 | 0763 | no | WS_Teplá vnitřní 8 | 0
13031220 | 1.NP_SO-102 | 32.8271 | 0.000314112 | 0.00206259 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3277.23 | PP–RCT S4 | 20 | 136 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 32.8271 | ø20 | 15.4 | TR10.03.0764 | 0764 | no | WS_Teplá vnitřní 8 | 0
13031224 | 1.NP_SO-102 | 749.84 | 0.000314112 | 0.0471139 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3277.23 | PP–RCT S4 | 20 | 134 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 749.84 | ø20 | 15.4 | TR10.03.0765 | 0765 | no | WS_Studená vnitřní 6 | 0
13031229 | 1.NP_SO-102 | 950.941 | 0.0004908 | 0.0746867 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3275.23 | PP–RCT S4 | 25 | 132 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 950.941 | ø25 | 19.4 | TR10.03.0766 | 0766 | no | WS_Studená vnitřní 6 | 0
13031232 | 1.NP_SO-102 | 888.406 | 0.000314112 | 0.0558202 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3277.23 | PP–RCT S4 | 20 | 136 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 888.406 | ø20 | 15.4 | TR10.03.0767 | 0767 | no | WS_Teplá vnitřní 8 | 0
13031237 | 1.NP_SO-102 | 972.375 | 0.0004908 | 0.0763702 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3275.23 | PP–RCT S4 | 25 | 134 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 972.375 | ø25 | 19.4 | TR10.03.0768 | 0768 | no | WS_Teplá vnitřní 8 | 0
13031240 | 1.NP_SO-102 | 1625.08 | 0.000314112 | 0.102106 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 1242.3 | PP–RCT S4 | 20 | 132 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1625.08 | ø20 | 15.4 | TR10.03.0769 | 0769 | no | WS_Teplá vnitřní 8 | 0
13031242 | 1.NP_SO-102 | 1838.05 | 0.000314112 | 0.115488 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 1242.3 | PP–RCT S4 | 20 | 130 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1838.05 | ø20 | 15.4 | TR10.03.0770 | 0770 | no | WS_Studená vnitřní 6 | 0
13031244 | 1.NP_SO-102 | 1978.57 | 0.000314112 | 0.124317 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3246.03 | 1267.46 | 3246.03 | 1267.46 | 3246.03 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 1267.46 | PP–RCT S4 | 20 | 130 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1978.57 | ø20 | 15.4 | TR10.03.0771 | 0771 | no | WS_Studená vnitřní 6
13031250 | 1.NP_SO-102 | 2038.57 | 0.000314112 | 0.128087 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3306.03 | 1267.46 | 3306.03 | 1267.46 | 3306.03 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 1267.46 | PP–RCT S4 | 20 | 132 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2038.57 | ø20 | 15.4 | TR10.03.0772 | 0772 | no | WS_Teplá vnitřní 8
13031256 | 1.NP_SO-102 | 530.573 | 0.0004908 | 0.0416711 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3257.43 | 3244.93 | 3244.93 | 3232.43 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 3235.23 | PP–RCT S4 | 25 | 80 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 530.573 | ø25 | 19.4 | TR10.03.0773 | 0773 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 0
13031262 | 1.NP_SO-102 | 1936.98 | 0.0004908 | 0.15213 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3217.94 | 3217.94 | 1280.96 | 1280.96 | 1280.96 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 1280.96 | PP–RCT S4 | 25 | 85 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1936.98 | ø25 | 19.4 | TR10.03.0774 | 0774 | no | WS_"ŠEDÁ" studená vnitřní 2
13031264 | 1.NP_SO-102 | 72.5375 | 0.000314112 | 0.00455767 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 1242.3 | PP–RCT S4 | 20 | 35 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 72.5375 | ø20 | 15.4 | TR10.03.0775 | 0775 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13031268 | 1.NP_SO-102 | 3919.81 | 0.0004908 | 0.307861 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 1262.5 | 1250 | 1250 | 1237.5 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 1240.3 | PP–RCT S4 | 25 | 83 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3919.81 | ø25 | 19.4 | TR10.03.0776 | 0776 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13031271 | 1.NP_SO-102 | 153.58 | 0.000314112 | 0.00964969 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 1242.3 | PP–RCT S4 | 20 | 35 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 153.58 | ø20 | 15.4 | TR10.03.0777 | 0777 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13031274 | 1.NP_SO-102 | 26.0553 | 0.0004908 | 0.00204638 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3335.23 | PP–RCT S4 | 25 | 134 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 26.0553 | ø25 | 19.4 | TR10.03.0778 | 0778 | no | WS_Teplá vnitřní 8 | 0
13031275 | 1.NP_SO-102 | 67.7561 | 0.0004908 | 0.00532156 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3347.72 | 3290.97 | 3338.88 | 3282.13 | 3338.88 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3284.11 | PP–RCT S4 | 25 | 134 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 67.7561 | ø25 | 19.4 | TR10.03.0779 | 0779 | no | WS_Teplá vnitřní 8 | 100
13031279 | 1.NP_SO-102 | 366.697 | 0.000804127 | 0.0368644 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3360.93 | 3344.93 | 3344.93 | 3328.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3332.53 | PP–RCT S4 | 32 | 185 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 366.697 | ø32 | 24.8 | TR10.03.0780 | 0780 | yes | WS_Teplá vnitřní 8 | 0
13031288 | 1.NP_SO-102 | 5.075 | 0.000314112 | 0.000318872 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 510 | 500 | 500 | 490 | 500 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 492.3 | PP–RCT S4 | 20 | 206 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5.075 | ø20 | 15.4 | TR10.03.0781 | 0781 | no | WS_Teplá vnitřní 83 | 0
13031291 | 1.NP_SO-102 | 283.479 | 0.000804127 | 0.0284985 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3360.93 | 3344.93 | 3344.93 | 3328.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3332.53 | PP–RCT S4 | 32 | 112 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 283.479 | ø32 | 24.8 | TR10.03.0782 | 0782 | yes | WS_Teplá vnitřní 8 | 0
13031309 | 1.NP_SO-102 | 543.83 | 0.000314112 | 0.0341698 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3254.93 | 3244.93 | 3244.93 | 3234.93 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 3237.23 | PP–RCT S4 | 20 | 32 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 543.83 | ø20 | 15.4 | TR10.03.0783 | 0783 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13031312 | 1.NP_SO-102 | 2062.54 | 0.000314112 | 0.129593 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3254.93 | 3244.93 | 3244.93 | 3234.93 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 3237.23 | PP–RCT S4 | 20 | 32 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2062.54 | ø20 | 15.4 | TR10.03.0784 | 0784 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13031441 | 1.NP_SO-102 | 9609.05 | 0.000314112 | 0.603754 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3337.23 | PP–RCT S4 | 20 | 168 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 9609.05 | ø20 | 15.4 | TR10.03.0785 | 0785 | yes | WS_Teplá vnitřní 8 | 0
13031457 | 1.NP_SO-102 | 193.841 | 0.000804127 | 0.019487 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3300.93 | 3284.93 | 3284.93 | 3268.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3272.53 | PP–RCT S4 | 32 | 108 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 193.841 | ø32 | 24.8 | TR10.03.0786 | 0786 | yes | WS_Studená vnitřní 6 | 0
13031460 | 1.NP_SO-102 | 103.551 | 0.000804127 | 0.0104101 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3360.93 | 3344.93 | 3344.93 | 3328.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3332.53 | PP–RCT S4 | 32 | 112 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 103.551 | ø32 | 24.8 | TR10.03.0787 | 0787 | yes | WS_Teplá vnitřní 8 | 0
13031463 | 1.NP_SO-102 | 109.841 | 0.0004908 | 0.0086269 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3275.23 | PP–RCT S4 | 25 | 132 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 109.841 | ø25 | 19.4 | TR10.03.0788 | 0788 | no | WS_Studená vnitřní 6 | 0
13031466 | 1.NP_SO-102 | 116.768 | 0.0004908 | 0.00917093 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3275.23 | PP–RCT S4 | 25 | 134 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 116.768 | ø25 | 19.4 | TR10.03.0789 | 0789 | no | WS_Teplá vnitřní 8 | 0
13031478 | 1.NP_SO-102 | 137.7 | 0.000314112 | 0.00865193 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 510 | 500 | 500 | 490 | 500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 492.3 | PP–RCT S4 | 20 | 501 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 137.7 | ø20 | 15.4 | TR10.03.0790 | 0790 | no | WS_Studená vnitřní 134 | 0
13031481 | 1.NP_SO-102 | 122.394 | 0.0004908 | 0.00961279 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3275.23 | PP–RCT S4 | 25 | 125 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 122.394 | ø25 | 19.4 | TR10.03.0791 | 0791 | yes | WS_Studená vnitřní 6 | 0
13031572 | 3.NP_SO-102 | 3926.18 | 0.00125645 | 0.493378 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 3.NP_SO-102 | 3304.44 | 3304.44 | -621.737 | -621.737 | -621.737 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7378.26 | PP–RCT S4 | 40 | 4 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3926.18 | ø40 | 31 | TR10.03.0792 | 0792 | yes | WS_Teplá vnitřní 8
13031604 | 3.NP_SO-102 | 3926.18 | 0.00125645 | 0.493378 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 3.NP_SO-102 | 3244.44 | 3244.44 | -681.737 | -681.737 | -681.737 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7318.26 | PP–RCT S4 | 40 | 7 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3926.18 | ø40 | 31 | TR10.03.0793 | 0793 | yes | WS_Studená vnitřní 6 | Identifikační data - Komentáře: V4
13031640 | 3.NP_SO-102 | 83.3017 | 0.0004908 | 0.0065425 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3257.43 | 3244.93 | 3244.93 | 3232.43 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 11235.2 | PP–RCT S4 | 25 | 69 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 83.3017 | ø25 | 19.4 | TR10.03.0794 | 0794 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13031644 | 3.NP_SO-102 | 3931.74 | 0.000804127 | 0.395261 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3212.38 | 3212.38 | -719.356 | -719.356 | -719.356 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 7280.64 | PP–RCT S4 | 32 | 64 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3931.74 | ø32 | 24.8 | TR10.03.0795 | 0795 | yes | WS_"ŠEDÁ" studená vnitřní 2
13031684 | 2.NP_SO-102 | 83.3017 | 0.0004908 | 0.0065425 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3257.43 | 3244.93 | 3244.93 | 3232.43 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 7235.23 | PP–RCT S4 | 25 | 73 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 83.3017 | ø25 | 19.4 | TR10.03.0796 | 0796 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 0
13031688 | 2.NP_SO-102 | 3929.36 | 0.00125645 | 0.493777 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 2.NP_SO-102 | 3207.62 | 3207.62 | -721.737 | -721.737 | -721.737 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 3278.26 | PP–RCT S4 | 40 | 24 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3929.36 | ø40 | 31 | TR10.03.0797 | 0797 | yes | WS_"ŠEDÁ" studená vnitřní 2
13031754 | 2.NP_SO-102 | 3933.33 | 0.00125645 | 0.494276 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 2.NP_SO-102 | 3251.59 | 3251.59 | -681.737 | -681.737 | -681.737 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3318.26 | PP–RCT S4 | 40 | 75 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3933.33 | ø40 | 31 | TR10.03.0798 | 0798 | yes | WS_Studená vnitřní 6 | Identifikační data - Komentáře: V4
13031792 | 2.NP_SO-102 | 3933.33 | 0.00125645 | 0.494276 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 2.NP_SO-102 | 3311.59 | 3311.59 | -621.737 | -621.737 | -621.737 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3378.26 | PP–RCT S4 | 40 | 81 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3933.33 | ø40 | 31 | TR10.03.0799 | 0799 | yes | WS_Teplá vnitřní 8
13031836 | 1.NP_SO-102 | 4534.6 | 0.00125645 | 0.569835 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 1.NP_SO-102 | 3211.59 | -1323.01 | 3211.59 | -1323.01 | 3211.59 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | -1323.01 | PP–RCT S4 | 40 | 63 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4534.6 | ø40 | 31 | TR10.03.0800 | 0800 | yes | WS_"ŠEDÁ" studená vnitřní 2
13031880 | 1.NP_SO-102 | 4554.96 | 0.0019632 | 0.715491 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | 1.NP_SO-102 | 3238.09 | -1316.86 | 3238.09 | -1316.86 | 3238.09 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | -1316.86 | PP–RCT S4 | 50 | 183 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4554.96 | ø50 | 38.8 | TR10.03.0801 | 0801 | yes | WS_Studená vnitřní 6 | Identifikační data - Komentáře: V4
13031907 | 1.NP_SO-102 | 4614.81 | 0.0019632 | 0.724892 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | 1.NP_SO-102 | 3298.09 | -1316.71 | 3298.09 | -1316.71 | 3298.09 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | -1316.71 | PP–RCT S4 | 50 | 183 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4614.81 | ø50 | 38.8 | TR10.03.0802 | 0802 | yes | WS_Teplá vnitřní 8
13032123 | 4.NP_SO-102 | 46.025 | 0.000804127 | 0.00462694 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3300.93 | 3284.93 | 3284.93 | 3268.93 | 3284.93 | Fáze 2 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 3 | 15272.5 | PP–RCT S4 | 32 | 8 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 46.025 | ø32 | 24.8 | TR10.03.0803 | 0803 | yes | WS_Cirkulace vnitřní 3; WS_Teplá vnitřní 8 | 0
13032178 | 4.NP_SO-102 | 3879.67 | 0.000804127 | 0.390027 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3254.76 | 3254.76 | -624.912 | -624.912 | -624.912 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11375.1 | PP–RCT S4 | 32 | 52 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3879.67 | ø32 | 24.8 | TR10.03.0804 | 0804 | yes | WS_Teplá vnitřní 8
13032662 | 3.NP_SO-102 | 3272.22 | 0.000314112 | 0.2056 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11277.2 | PP–RCT S4 | 20 | 142 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3272.22 | ø20 | 15.4 | TR10.03.0805 | 0805 | no | WS_Studená vnitřní 6 | 0
13033363 | 3.NP_SO-102 | 340.925 | 0.000314112 | 0.021421 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11277.2 | PP–RCT S4 | 20 | 156 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 340.925 | ø20 | 15.4 | TR10.03.0806 | 0806 | no | WS_Studená vnitřní 6 | 0
13033403 | 3.NP_SO-102 | 505.869 | 0.000314112 | 0.0317847 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11337.2 | PP–RCT S4 | 20 | 157 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 505.869 | ø20 | 15.4 | TR10.03.0807 | 0807 | no | WS_Teplá vnitřní 8 | 0
13033477 | 3.NP_SO-102 | 1001.11 | 0.0004908 | 0.0786272 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11335.2 | PP–RCT S4 | 25 | 152 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1001.11 | ø25 | 19.4 | TR10.03.0808 | 0808 | yes | WS_Teplá vnitřní 8 | 0
13033522 | 3.NP_SO-102 | 11084.5 | 0.0004908 | 0.870576 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11335.2 | PP–RCT S4 | 25 | 145 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 11084.5 | ø25 | 19.4 | TR10.03.0809 | 0809 | yes | WS_Teplá vnitřní 8 | 0
13033733 | 3.NP_SO-102 | 708.406 | 0.000314112 | 0.0445105 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11337.2 | PP–RCT S4 | 20 | 156 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 708.406 | ø20 | 15.4 | TR10.03.0810 | 0810 | no | WS_Teplá vnitřní 8 | 0
13033742 | 3.NP_SO-102 | 505.075 | 0.000314112 | 0.0317348 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11337.2 | PP–RCT S4 | 20 | 156 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 505.075 | ø20 | 15.4 | TR10.03.0811 | 0811 | no | WS_Teplá vnitřní 8 | 0
13033752 | 3.NP_SO-102 | 268.918 | 0.000314112 | 0.0168966 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11337.2 | PP–RCT S4 | 20 | 156 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 268.918 | ø20 | 15.4 | TR10.03.0812 | 0812 | no | WS_Teplá vnitřní 8 | 0
13033818 | 3.NP_SO-102 | 3060.14 | 0.0004908 | 0.240343 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11335.2 | PP–RCT S4 | 25 | 147 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3060.14 | ø25 | 19.4 | TR10.03.0813 | 0813 | yes | WS_Teplá vnitřní 8 | 0
13033826 | 3.NP_SO-102 | 8184.91 | 0.0004908 | 0.642841 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 11335.2 | PP–RCT S4 | 25 | 154 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 8184.91 | ø25 | 19.4 | TR10.03.0814 | 0814 | yes | WS_Teplá vnitřní 8 | 0
13033836 | 3.NP_SO-102 | 708.406 | 0.000314112 | 0.0445105 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3294.92 | 3284.92 | 3284.9 | 3274.9 | 3284.9 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11277.2 | PP–RCT S4 | 20 | 153 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 708.406 | ø20 | 15.4 | TR10.03.0815 | 0815 | no | WS_Studená vnitřní 6 | 0
13033845 | 3.NP_SO-102 | 425.075 | 0.000314112 | 0.0267082 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3294.9 | 3284.9 | 3284.9 | 3274.9 | 3284.9 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11277.2 | PP–RCT S4 | 20 | 153 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 425.075 | ø20 | 15.4 | TR10.03.0816 | 0816 | no | WS_Studená vnitřní 6 | 0
13033853 | 3.NP_SO-102 | 348.261 | 0.000314112 | 0.0218819 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3294.9 | 3284.9 | 3284.9 | 3274.9 | 3284.9 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11277.2 | PP–RCT S4 | 20 | 153 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 348.261 | ø20 | 15.4 | TR10.03.0817 | 0817 | no | WS_Studená vnitřní 6 | 0
13034103 | 3.NP_SO-102 | 3092.36 | 0.0004908 | 0.242873 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11275.2 | PP–RCT S4 | 25 | 146 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3092.36 | ø25 | 19.4 | TR10.03.0818 | 0818 | yes | WS_Studená vnitřní 6 | 0
13034115 | 3.NP_SO-102 | 8141.51 | 0.0004908 | 0.639433 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11275.2 | PP–RCT S4 | 25 | 197 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 8141.51 | ø25 | 19.4 | TR10.03.0819 | 0819 | yes | WS_Studená vnitřní 6 | 0
13034185 | 3.NP_SO-102 | 11378 | 0.0004908 | 0.893626 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 11275.2 | PP–RCT S4 | 25 | 140 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 11378 | ø25 | 19.4 | TR10.03.0820 | 0820 | yes | WS_Studená vnitřní 6 | 0
13034312 | 2.NP_SO-102 | 777.675 | 0.000314112 | 0.0488628 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7342.3 | PP–RCT S4 | 20 | 164 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 777.675 | ø20 | 15.4 | TR10.03.0821 | 0821 | no | WS_Teplá vnitřní 8 | 0
13034321 | 2.NP_SO-102 | 365.075 | 0.000314112 | 0.0229383 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7342.3 | PP–RCT S4 | 20 | 164 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 365.075 | ø20 | 15.4 | TR10.03.0822 | 0822 | no | WS_Teplá vnitřní 8 | 0
13034329 | 2.NP_SO-102 | 300.194 | 0.000314112 | 0.0188617 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7342.3 | PP–RCT S4 | 20 | 164 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 300.194 | ø20 | 15.4 | TR10.03.0823 | 0823 | no | WS_Teplá vnitřní 8 | 0
13034389 | 2.NP_SO-102 | 8007.71 | 0.0004908 | 0.628924 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7335.23 | PP–RCT S4 | 25 | 163 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 8007.71 | ø25 | 19.4 | TR10.03.0824 | 0824 | yes | WS_Teplá vnitřní 8 | 0
13034398 | 2.NP_SO-102 | 3237.34 | 0.0004908 | 0.25426 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 7335.23 | PP–RCT S4 | 25 | 101 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3237.34 | ø25 | 19.4 | TR10.03.0825 | 0825 | yes | WS_Teplá vnitřní 8 | 0
13034408 | 2.NP_SO-102 | 857.675 | 0.000314112 | 0.0538893 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.97 | 3284.93 | 3284.97 | 3274.93 | 3284.97 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7277.23 | PP–RCT S4 | 20 | 164 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 857.675 | ø20 | 15.4 | TR10.03.0826 | 0826 | no | WS_Studená vnitřní 6 | 0.00528613
13034417 | 2.NP_SO-102 | 405.075 | 0.000314112 | 0.0254516 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.97 | 3284.97 | 3284.97 | 3274.97 | 3284.97 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7277.27 | PP–RCT S4 | 20 | 164 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 405.075 | ø20 | 15.4 | TR10.03.0827 | 0827 | no | WS_Studená vnitřní 6 | 0
13034425 | 2.NP_SO-102 | 293.269 | 0.000314112 | 0.0184266 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 3294.97 | 3284.97 | 3284.97 | 3274.97 | 3284.97 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7277.27 | PP–RCT S4 | 20 | 164 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 293.269 | ø20 | 15.4 | TR10.03.0828 | 0828 | no | WS_Studená vnitřní 6 | 0
13034717 | 2.NP_SO-102 | 3035.28 | 0.0004908 | 0.238391 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7275.23 | PP–RCT S4 | 25 | 97 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3035.28 | ø25 | 19.4 | TR10.03.0829 | 0829 | yes | WS_Studená vnitřní 6 | 0
13034723 | 2.NP_SO-102 | 8198.59 | 0.0004908 | 0.643915 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 7275.23 | PP–RCT S4 | 25 | 162 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 8198.59 | ø25 | 19.4 | TR10.03.0830 | 0830 | yes | WS_Studená vnitřní 6 | 0
13035209 | 1.NP_SO-102 | 1512.79 | 0.000314112 | 0.0950516 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3337.23 | PP–RCT S4 | 20 | 167 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1512.79 | ø20 | 15.4 | TR10.03.0831 | 0831 | no | WS_Teplá vnitřní 8 | 0
13035304 | 1.NP_SO-102 | 1592.79 | 0.000314112 | 0.100078 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3277.23 | PP–RCT S4 | 20 | 168 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1592.79 | ø20 | 15.4 | TR10.03.0832 | 0832 | no | WS_Studená vnitřní 6 | 0
13035962 | -1.PP_SO-102 | 2836.15 | 0.0004908 | 0.22275 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3238.09 | 3225.59 | 3225.59 | 3213.09 | 3225.59 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | -784.112 | PP–RCT S4 | 25 | 205 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2836.15 | ø25 | 19.4 | TR10.03.0833 | 0833 | yes | WS_Teplá vnitřní 8 | 0
