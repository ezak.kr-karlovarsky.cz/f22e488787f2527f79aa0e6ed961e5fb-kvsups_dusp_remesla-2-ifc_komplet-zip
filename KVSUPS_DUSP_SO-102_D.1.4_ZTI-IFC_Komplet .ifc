Properties of the parts of a building model (IFC4), part 41 of 60

# IfcPipeFitting: M_Spoj T, obecný:Standardní (104)
Name (M_Spoj T, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) = Štítek, od středu ke konci (mm) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Vnější poloměr tvarovky (mm)
13074813 | -1.PP_SO-102 | ø63 mm-ø63 mm-ø63 mm | -1.PP_SO-102 | 3226.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000375825 | 45.7875 | ø63-ø63-ø63 | 26.47 | 66.175 | TT00.03.0770 | 0770 | yes | 33.0875
13081063 | -1.PP_SO-102 | ø63 mm-ø63 mm-ø63 mm | -1.PP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000375825 | 45.7875 | ø63-ø63-ø63 | 26.47 | 66.175 | TT00.03.0777 | 0777 | yes | 33.0875
13347289 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1076 | 1076 | no | 17.4625
13347297 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1078 | 1078 | no | 17.4625
13357395 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1095 | 1095 | no | 17.4625
13357427 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1097 | 1097 | no | 17.4625
13401998 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1150 | 1150 | no | 17.4625
13402068 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1153 | 1153 | no | 17.4625
13473802 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1237 | 1237 | no | 17.4625
13473817 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1241 | 1241 | no | 17.4625
13473845 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1245 | 1245 | no | 17.4625
13473883 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1246 | 1246 | no | 17.4625
13473895 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1247 | 1247 | no | 17.4625
13473916 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1254 | 1254 | no | 17.4625
13473959 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1258 | 1258 | no | 17.4625
13473992 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1263 | 1263 | no | 17.4625
13474030 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1265 | 1265 | no | 17.4625
13474043 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1268 | 1268 | no | 17.4625
13474075 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1271 | 1271 | no | 17.4625
13474104 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1273 | 1273 | no | 17.4625
13474435 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1275 | 1275 | no | 17.4625
13483682 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1277 | 1277 | no | 17.4625
13483690 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1279 | 1279 | no | 17.4625
13524451 | 3.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1354 | 1354 | yes | 17.4625
13525238 | 4.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 4.NP_SO-102 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1358 | 1358 | yes | 17.4625
13525272 | 4.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1360 | 1360 | yes | 17.4625
13573400 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1457 | 1457 | no | 17.4625
13641661 | -1.PP_SO-102 | ø32 mm-ø32 mm-ø32 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1490 | 1490 | yes | 17.4625
13641872 | -1.PP_SO-102 | ø32 mm-ø32 mm-ø32 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1492 | 1492 | yes | 17.4625
13642219 | -1.PP_SO-102 | ø32 mm-ø32 mm-ø32 mm | -1.PP_SO-102 | 3100 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1500 | 1500 | yes | 17.4625
13642563 | -1.PP_SO-102 | ø32 mm-ø32 mm-ø32 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 3 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1510 | 1510 | yes | 17.4625
13646333 | 3.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 3.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.1540 | 1540 | yes | 17.4625
13705064 | -1.PP_SO-102 | ø63 mm-ø63 mm-ø63 mm | -1.PP_SO-102 | 2410 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 31.5 | 63 | 0.000375825 | 45.7875 | ø63-ø63-ø63 | 26.47 | 66.175 | TT00.03.1729 | 1729 | yes | 33.0875
13706078 | -1.PP_SO-102 | ø63 mm-ø63 mm-ø63 mm | -1.PP_SO-102 | 3226.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000375825 | 45.7875 | ø63-ø63-ø63 | 26.47 | 66.175 | TT00.03.1743 | 1743 | yes | 33.0875
13805725 | -1.PP_SO-102 | ø63 mm-ø63 mm-ø63 mm | -1.PP_SO-102 | 2900 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 31.5 | 63 | 0.000375825 | 45.7875 | ø63-ø63-ø63 | 26.47 | 66.175 | TT00.03.1765 | 1765 | yes | 33.0875
13805860 | -1.PP_SO-102 | ø63 mm-ø63 mm-ø63 mm | -1.PP_SO-102 | 2900 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000375825 | 45.7875 | ø63-ø63-ø63 | 26.47 | 66.175 | TT00.03.1766 | 1766 | yes | 33.0875
13823507 | -1.PP_SO-102 | ø63 mm-ø63 mm-ø63 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000375825 | 45.7875 | ø63-ø63-ø63 | 26.47 | 66.175 | TT00.03.1830 | 1830 | yes | 33.0875
13823651 | -1.PP_SO-102 | ø63 mm-ø63 mm-ø63 mm | -1.PP_SO-102 | 2500 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 31.5 | 63 | 0.000375825 | 45.7875 | ø63-ø63-ø63 | 26.47 | 66.175 | TT00.03.1833 | 1833 | yes | 33.0875
13828947 | -1.PP_SO-102 | ø63 mm-ø63 mm-ø63 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 31.5 | 63 | 0.000375825 | 45.7875 | ø63-ø63-ø63 | 26.47 | 66.175 | TT00.03.1883 | 1883 | yes | 33.0875
13829337 | -1.PP_SO-102 | ø63 mm-ø63 mm-ø63 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000375825 | 45.7875 | ø63-ø63-ø63 | 26.47 | 66.175 | TT00.03.1890 | 1890 | yes | 33.0875
13830453 | -1.PP_SO-102 | ø63 mm-ø63 mm-ø63 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000375825 | 45.7875 | ø63-ø63-ø63 | 26.47 | 66.175 | TT00.03.1893 | 1893 | yes | 33.0875
13830504 | -1.PP_SO-102 | ø63 mm-ø63 mm-ø63 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 31.5 | 63 | 0.000375825 | 45.7875 | ø63-ø63-ø63 | 26.47 | 66.175 | TT00.03.1896 | 1896 | yes | 33.0875
13839805 | -1.PP_SO-102 | ø63 mm-ø63 mm-ø63 mm | -1.PP_SO-102 | 2400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000375825 | 45.7875 | ø63-ø63-ø63 | 26.47 | 66.175 | TT00.03.1956 | 1956 | yes | 33.0875
13916165 | -1.PP_SO-102 | ø63 mm-ø63 mm-ø63 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 31.5 | 63 | 0.000375825 | 45.7875 | ø63-ø63-ø63 | 26.47 | 66.175 | TT00.03.1983 | 1983 | yes | 33.0875

# IfcPipeFitting: M_Spoj T, obecný:Standardní (9)
Type - Classification: TT00 SNIM (SNIM); Material: 255-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: WMB; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní
Name (M_Spoj T, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) = Úhel 1 (deg) | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) = Štítek, od středu ke konci (mm) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Vnější poloměr tvarovky (mm) | Group
13170680 | 2.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 2.NP_SO-102 | 3110 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 90 | 67.5 | 135 | 0.00279973 | 81.7875 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.0916 | 0916 | 69.0875 | SW_Odvětrání kanalizace 16
13653671 | -1.PP_SO-102 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-102 | 2360 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 90 | 55 | 110 | 0.00160778 | 69.2875 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.1583 | 1583 | 56.5875 | SW_Odvětrání kanalizace 16
13681870 | 2.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 2.NP_SO-102 | 3100 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 90 | 67.5 | 135 | 0.00279973 | 81.7875 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.1668 | 1668 | 69.0875 | SW_Odvětrání kanalizace 16
13682360 | 2.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 2.NP_SO-102 | 3100 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 90 | 67.5 | 135 | 0.00279973 | 81.7875 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.1669 | 1669 | 69.0875 | SW_Odvětrání kanalizace 16
13682644 | 2.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 2.NP_SO-102 | 3100 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 90 | 67.5 | 135 | 0.00279973 | 81.7875 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.1670 | 1670 | 69.0875 | SW_Odvětrání kanalizace 16
13704672 | 2.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 2.NP_SO-102 | 2900 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 90 | 67.5 | 135 | 0.00279973 | 81.7875 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.1721 | 1721 | 69.0875 | SW_Odvětrání kanalizace 16
13981227 | -1.PP_SO-102 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-102 | -1100 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 90 | 55 | 110 | 0.00160778 | 69.2875 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.2004 | 2004 | 56.5875 | SW_Odvětrání kanalizace 16
13982638 | -1.PP_SO-102 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-102 | 2980 | SW_Deště vnitřní podtlak | Sanitární | SW_Deště vnitřní podtlak 4 | 90 | 55 | 110 | 0.00160778 | 69.2875 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.2014 | 2014 | 56.5875 | SW_Deště vnitřní podtlak 4; SW_Deště čerpání 1
14018287 | 2.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 2.NP_SO-102 | 2572.31 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 89.9998 | 67.5 | 135 | 0.00279973 | 81.7875 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.2164 | 2164 | 69.0875 | SW_Odvětrání kanalizace 16

# IfcPipeFitting: M_Spojka, obecná:Standardní (2)
In: -1.PP_SO-102
Type - Classification: TT00 SNIM (SNIM); Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: S; Kód sestavy: TT00; Komentáře k typům: ZAZÁTKOVÁNO; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 01; Popis: Spojení; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spojka, obecná; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat)
Qto_PipeFittingBaseQuantities - Length: 26.9875 mm; GrossCrossSectionArea: 0.0022878 m2; NetCrossSectionArea: 0.0022878 m2; OuterSurfaceArea: 0.0045762 m2
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø50 mm-ø50 mm
Text - CCI Funkční systém: F; CCI Komponenta: WMB; CCI Technický systém: JB
Vazby - Podlaží: -1.PP_SO-102; Výška od podlaží: 2600 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Kóty - Délka: 26.9875 mm; Jmenovitý poloměr: 25 mm; Jmenovitý průměr: 50 mm; Maximální velikost: 50 mm; Minimální velikost: 50 mm; Objem: 0.0000617472 m3; Velikost: ø50-ø50; Velikost značky: 21.59 mm; Vnější průměr tvarovky: 53.975 mm
Jiné - Páteřní trasa: yes; Id typu: 1484366; Rodina: M_Spojka, obecná; Rodina a typ: M_Spojka, obecná: Standardní; Typ: Standardní; Vnější poloměr tvarovky: 26.9875 mm
Name (M_Spojka, obecná:Standardní:...) | Typ systému | Klasifikace systému | Název systému = Group | Kód prvku | Označení
13047373 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | TT00.01.0707 | 0707
13047442 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | TT00.01.0709 | 0709

# IfcPipeFitting: M_Spojka, obecná:Standardní (4)
Type - Classification: TT00 SNIM (SNIM); Material: 0-128-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: S; Kód sestavy: TT00; Komentáře k typům: ZAZÁTKOVÁNO; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 01; Popis: Spojení; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spojka, obecná; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: WMB; CCI Technický systém: JB
Mechanické - Klasifikace systému: Sanitární
Grafika - Použít měřítko poznámky: no
Jiné - Id typu: 1484366; Rodina: M_Spojka, obecná; Rodina a typ: M_Spojka, obecná: Standardní; Typ: Standardní
Name (M_Spojka, obecná:Standardní:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Název systému = Group | Délka (mm) = Vnější poloměr tvarovky (mm) | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa
13242487 | 1.NP_SO-102 | 65.0875 | 0.0133072 | 0.026618 | ø125 mm-ø125 mm | 1.NP_SO-102 | 3225.34 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 65.0875 | 62.5 | 125 | 0.000866208 | ø125-ø125 | 52.07 | 130.175 | TT00.01.0986 | 0986 | yes | Mechanické – tok - Tlaková ztráta: 0 Pa; Identifikační data - Komentáře: ZAZÁTKOVÁNO
13432833 | -1.PP_SO-102 | 65.0875 | 0.0133072 | 0.026618 | ø125 mm-ø125 mm | -1.PP_SO-102 | -1811.41 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 65.0875 | 62.5 | 125 | 0.000866208 | ø125-ø125 | 52.07 | 130.175 | TT00.01.1185 | 1185 | yes | Identifikační data - Komentáře: ZAZÁTKOVÁNO
14016857 | 1.NP_SO-102 | 65.0875 | 0.0133072 | 0.026618 | ø125 mm-ø125 mm | 1.NP_SO-102 | 3238.24 | Fáze 2 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 65.0875 | 62.5 | 125 | 0.000866208 | ø125-ø125 | 52.07 | 130.175 | TT00.01.2155 | 2155 | Mechanické – tok - Tlaková ztráta: 0 Pa
14028667 | -1.PP_SO-102 | 159.087 | 0.0794994 | 0.15902 | ø315 mm-ø315 mm | -1.PP_SO-102 | -1218.83 | Fáze 1 | SW_Deště vnitřní gravitační | SW_Deště vnitřní gravitační 3 | 159.088 | 157.5 | 315 | 0.0126485 | ø315-ø315 | 127.27 | 318.175 | TT00.01.2212 | 2212 | yes

# IfcPipeFitting: M_Spojka, obecná:Standardní (31)
Type - Classification: TT00 SNIM (SNIM); Material: 128-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: S; Kód sestavy: TT00; Komentáře k typům: ZAZÁTKOVÁNO; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 01; Popis: Spojení; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spojka, obecná; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: WMB; CCI Technický systém: JB
Grafika - Použít měřítko poznámky: no
Jiné - Páteřní trasa: yes; Id typu: 1484366; Rodina: M_Spojka, obecná; Rodina a typ: M_Spojka, obecná: Standardní; Typ: Standardní
Name (M_Spojka, obecná:Standardní:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Délka (mm) = Vnější poloměr tvarovky (mm) | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Group
12904288 | 4.NP_SO-102 | 81.5875 | 0.0209093 | 0.0418241 | ø160 mm-ø160 mm | 4.NP_SO-102 | 2000 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 81.5875 | 80 | 160 | 0.00170608 | ø160-ø160 | 65.27 | 163.175 | TT00.01.0001 | 0001 | SW_Odvětrání kanalizace 1; SW_Splašky vnitřní gravitační 35 (1)
12917856 | 4.NP_SO-102 | 56.5875 | 0.0100585 | 0.0201197 | ø110 mm-ø110 mm | 4.NP_SO-102 | 2000 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 56.5875 | 55 | 110 | 0.000569234 | ø110-ø110 | 45.27 | 113.175 | TT00.01.0002 | 0002 | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 2
12917990 | 4.NP_SO-102 | 56.5875 | 0.0100585 | 0.0201197 | ø110 mm-ø110 mm | 4.NP_SO-102 | 2000 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 56.5875 | 55 | 110 | 0.000569234 | ø110-ø110 | 45.27 | 113.175 | TT00.01.0003 | 0003 | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 3
12924278 | 4.NP_SO-102 | 81.5875 | 0.0209093 | 0.0418241 | ø160 mm-ø160 mm | 4.NP_SO-102 | 2000 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 81.5875 | 80 | 160 | 0.00170608 | ø160-ø160 | 65.27 | 163.175 | TT00.01.0009 | 0009 | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 7
12941325 | 4.NP_SO-102 | 40.5875 | 0.0051746 | 0.0103506 | ø78 mm-ø78 mm | 4.NP_SO-102 | 2000.42 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 40.5875 | 39 | 78 | 0.000210042 | ø78-ø78 | 32.47 | 81.175 | TT00.01.0018 | 0018 | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 4
13095690 | 4.NP_SO-102 | 40.5875 | 0.0051746 | 0.0103506 | ø78 mm-ø78 mm | 4.NP_SO-102 | 956.416 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 40.5875 | 39 | 78 | 0.000210042 | ø78-ø78 | 32.47 | 81.175 | TT00.01.0791 | 0791 | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 11 | Identifikační data - Komentáře: S19
13096384 | 4.NP_SO-102 | 40.5875 | 0.0051746 | 0.0103506 | ø78 mm-ø78 mm | 4.NP_SO-102 | 1491.46 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 40.5875 | 39 | 78 | 0.000210042 | ø78-ø78 | 32.47 | 81.175 | TT00.01.0794 | 0794 | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 10 | Identifikační data - Komentáře: S18
13099715 | 4.NP_SO-102 | 40.5875 | 0.0051746 | 0.0103506 | ø78 mm-ø78 mm | 4.NP_SO-102 | 1612.06 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 40.5875 | 39 | 78 | 0.000210042 | ø78-ø78 | 32.47 | 81.175 | TT00.01.0800 | 0800 | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 17 | Identifikační data - Komentáře: S16
13101492 | 4.NP_SO-102 | 40.5875 | 0.0051746 | 0.0103506 | ø78 mm-ø78 mm | 4.NP_SO-102 | 1976.01 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 40.5875 | 39 | 78 | 0.000210042 | ø78-ø78 | 32.47 | 81.175 | TT00.01.0807 | 0807 | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 9
13101983 | 4.NP_SO-102 | 40.5875 | 0.0051746 | 0.0103506 | ø78 mm-ø78 mm | 4.NP_SO-102 | 1190 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 40.5875 | 39 | 78 | 0.000210042 | ø78-ø78 | 32.47 | 81.175 | TT00.01.0809 | 0809 | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 8
13152188 | -1.PP_SO-102 | 81.5875 | 0.0209093 | 0.0418241 | ø160 mm-ø160 mm | -1.PP_SO-102 | -3415.23 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 81.5875 | 80 | 160 | 0.00170608 | ø160-ø160 | 65.27 | 163.175 | TT00.01.0826 | 0826 | SW_Splašky vnitřní gravitační 3
13152534 | -1.PP_SO-102 | 56.5875 | 0.0100585 | 0.0201197 | ø110 mm-ø110 mm | -1.PP_SO-102 | 1936.52 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 56.5875 | 55 | 110 | 0.000569234 | ø110-ø110 | 45.27 | 113.175 | TT00.01.0828 | 0828 | SW_Odvětrání kanalizace 16; SW_Splašky vnitřní gravitační 3
13152738 | -1.PP_SO-102 | 56.5875 | 0.0100585 | 0.0201197 | ø110 mm-ø110 mm | -1.PP_SO-102 | 1660.57 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 4 | 56.5875 | 55 | 110 | 0.000569234 | ø110-ø110 | 45.27 | 113.175 | TT00.01.0829 | 0829 | SW_Splašky vnitřní gravitační 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13156786 | -1.PP_SO-102 | 56.5875 | 0.0100585 | 0.0201197 | ø110 mm-ø110 mm | -1.PP_SO-102 | 3000 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 56.5875 | 55 | 110 | 0.000569234 | ø110-ø110 | 45.27 | 113.175 | TT00.01.0871 | 0871 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
13161055 | 2.NP_SO-102 | 69.0875 | 0.0149931 | 0.0299902 | ø135 mm-ø135 mm | 2.NP_SO-102 | 1513.69 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 69.0875 | 67.5 | 135 | 0.00103592 | ø135-ø135 | 55.27 | 138.175 | TT00.01.0881 | 0881 | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 16
13163384 | 2.NP_SO-102 | 69.0875 | 0.0149931 | 0.0299902 | ø135 mm-ø135 mm | 2.NP_SO-102 | 1500 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 69.0875 | 67.5 | 135 | 0.00103592 | ø135-ø135 | 55.27 | 138.175 | TT00.01.0884 | 0884 | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 16
13163888 | 2.NP_SO-102 | 69.0875 | 0.0149931 | 0.0299902 | ø135 mm-ø135 mm | 2.NP_SO-102 | 1500 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 69.0875 | 67.5 | 135 | 0.00103592 | ø135-ø135 | 55.27 | 138.175 | TT00.01.0885 | 0885 | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 16
13163910 | 2.NP_SO-102 | 69.0875 | 0.0149931 | 0.0299902 | ø135 mm-ø135 mm | 2.NP_SO-102 | 1500 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 69.0875 | 67.5 | 135 | 0.00103592 | ø135-ø135 | 55.27 | 138.175 | TT00.01.0886 | 0886 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13267077 | 2.NP_SO-102 | 69.0875 | 0.0149931 | 0.0299902 | ø135 mm-ø135 mm | 2.NP_SO-102 | 1542.56 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 69.0875 | 67.5 | 135 | 0.00103592 | ø135-ø135 | 55.27 | 138.175 | TT00.01.1018 | 1018 | SW_Odvětrání kanalizace 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
13402627 | 3.NP_SO-102 | 40.5875 | 0.0051746 | 0.0103506 | ø78 mm-ø78 mm | 3.NP_SO-102 | 1401.25 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 40.5875 | 39 | 78 | 0.000210042 | ø78-ø78 | 32.47 | 81.175 | TT00.01.1156 | 1156 | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 20
13403769 | 3.NP_SO-102 | 56.5875 | 0.0100585 | 0.0201197 | ø110 mm-ø110 mm | 3.NP_SO-102 | 1782.86 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 56.5875 | 55 | 110 | 0.000569234 | ø110-ø110 | 45.27 | 113.175 | TT00.01.1160 | 1160 | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 14
13444203 | 4.NP_SO-102 | 81.5875 | 0.0209093 | 0.0418241 | ø160 mm-ø160 mm | 4.NP_SO-102 | 3913.89 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 81.5875 | 80 | 160 | 0.00170608 | ø160-ø160 | 65.27 | 163.175 | TT00.01.1208 | 1208 | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 15 | Identifikační data - Komentáře: S20
13461548 | 3.NP_SO-102 | 40.5875 | 0.0051746 | 0.0103506 | ø78 mm-ø78 mm | 3.NP_SO-102 | 1273.94 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 40.5875 | 39 | 78 | 0.000210042 | ø78-ø78 | 32.47 | 81.175 | TT00.01.1213 | 1213 | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 18
13506056 | 4.NP_SO-102 | 40.5875 | 0.0051746 | 0.0103506 | ø78 mm-ø78 mm | 4.NP_SO-102 | 1491.46 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 40.5875 | 39 | 78 | 0.000210042 | ø78-ø78 | 32.47 | 81.175 | TT00.01.1306 | 1306 | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 19 | Identifikační data - Komentáře: S21
13516709 | -1.PP_SO-102 | 56.5875 | 0.0100585 | 0.0201197 | ø110 mm-ø110 mm | -1.PP_SO-102 | -2517.51 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 56.5875 | 55 | 110 | 0.000569234 | ø110-ø110 | 45.27 | 113.175 | TT00.01.1322 | 1322 | SW_Splašky vnitřní gravitační 3 | Identifikační data - Komentáře: ZAZÁTKOVÁNO
13527545 | -1.PP_SO-102 | 56.5875 | 0.0100585 | 0.0201197 | ø110 mm-ø110 mm | -1.PP_SO-102 | -3019.07 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 56.5875 | 55 | 110 | 0.000569234 | ø110-ø110 | 45.27 | 113.175 | TT00.01.1389 | 1389 | SW_Splašky vnitřní gravitační 3
13639135 | -1.PP_SO-102 | 103.187 | 0.0334461 | 0.0669012 | ø200 mm-ø200 mm | -1.PP_SO-102 | 2709.75 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 103.188 | 100 | 200 | 0.00345152 | ø200-ø200 | 82.55 | 206.375 | TT00.01.1479 | 1479 | SW_Splašky vnitřní gravitační 35 (1) | Identifikační data - Komentáře: ZAZÁTKOVÁNO
13653317 | -1.PP_SO-102 | 56.5875 | 0.0100585 | 0.0201197 | ø110 mm-ø110 mm | -1.PP_SO-102 | 1383.86 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 56.5875 | 55 | 110 | 0.000569234 | ø110-ø110 | 45.27 | 113.175 | TT00.01.1579 | 1579 | SW_Splašky vnitřní gravitační 3 | Mechanické – tok - Tlaková ztráta: 0 Pa
13671995 | -1.PP_SO-102 | 56.5875 | 0.0100585 | 0.0201197 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2639.16 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 56.5875 | 55 | 110 | 0.000569234 | ø110-ø110 | 45.27 | 113.175 | TT00.01.1613 | 1613 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
13997321 | 2.NP_SO-102 | 69.0875 | 0.0149931 | 0.0299902 | ø135 mm-ø135 mm | 2.NP_SO-102 | 1873.54 | Fáze 1 | SW_Odvětrání kanalizace | Průduch | SW_Odvětrání kanalizace 16 | 69.0875 | 67.5 | 135 | 0.00103592 | ø135-ø135 | 55.27 | 138.175 | TT00.01.2071 | 2071 | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 16
14028059 | -1.PP_SO-102 | 128.588 | 0.0519385 | 0.103891 | ø250 mm-ø250 mm | -1.PP_SO-102 | -1419.6 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 128.588 | 125 | 250 | 0.00667922 | ø250-ø250 | 102.87 | 257.175 | TT00.01.2211 | 2211 | SW_Splašky vnitřní gravitační 35 (1)

# IfcPipeFitting: M_Spojka, obecná:Standardní (2)
In: -1.PP_SO-102
Type - Classification: TT00 SNIM (SNIM); Material: 128-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: S; Kód sestavy: TT00; Komentáře k typům: ZAZÁTKOVÁNO; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 01; Popis: Spojení; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spojka, obecná; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat)
Qto_PipeFittingBaseQuantities - Length: 17.4625 mm; GrossCrossSectionArea: 0.000957866 m2; NetCrossSectionArea: 0.000957866 m2; OuterSurfaceArea: 0.00191599 m2
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø32 mm-ø32 mm
Text - CCI Funkční systém: F; CCI Komponenta: WMB; CCI Technický systém: JB
Vazby - Podlaží: -1.PP_SO-102; Výška od podlaží: 2600 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Kóty - Délka: 17.4625 mm; Jmenovitý poloměr: 16 mm; Jmenovitý průměr: 32 mm; Maximální velikost: 32 mm; Minimální velikost: 32 mm; Objem: 0.0000167282 m3; Velikost: ø32-ø32; Velikost značky: 13.97 mm; Vnější průměr tvarovky: 34.925 mm
Jiné - Páteřní trasa: yes; Id typu: 1484366; Rodina: M_Spojka, obecná; Rodina a typ: M_Spojka, obecná: Standardní; Typ: Standardní; Vnější poloměr tvarovky: 17.4625 mm
Name (M_Spojka, obecná:Standardní:...) | Typ systému | Klasifikace systému | Název systému = Group | Kód prvku | Označení
13047350 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | TT00.01.0706 | 0706
13047399 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | TT00.01.0708 | 0708

# IfcPipeFitting: M_Uzavření, obecné:Standardní (4)
Type - Classification: TT00 SNIM (SNIM); Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Není definováno
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 04; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Uzavření, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat); Group: WS_Studená vnitřní 134
Qto_PipeFittingBaseQuantities - Length: 14.2875 mm; GrossCrossSectionArea: 0.000641216 m2; NetCrossSectionArea: 0.000641216 m2; OuterSurfaceArea: 0.0012826 m2
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø25 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_Studená vnitřní; Klasifikace systému: Studená voda v domácnosti; Název systému: WS_Studená vnitřní 134
Grafika - Použít měřítko poznámky: no
Kóty - Jmenovitý poloměr: 12.5 mm; Jmenovitý průměr: 25 mm; Maximální velikost: 25 mm; Minimální velikost: 25 mm; Objem: 0.00000916216 m3; Velikost: ø25; Vnější průměr tvarovky: 28.575 mm; Výš.: 14.2875 mm
Jiné - Typ: Standardní; Páteřní trasa: no; Id typu: 1486833; Rodina: M_Uzavření, obecné; Rodina a typ: M_Uzavření, obecné: Standardní; Vnější poloměr tvarovky: 14.2875 mm
Name (M_Uzavření, obecné:Standardní:...) | In | Podlaží | Výška od podlaží (mm) | Kód prvku | Označení
13644880 | 1.NP_SO-102 | 1.NP_SO-102 | 3350.65 | TT00.04.1518 | 1518
13645243 | 2.NP_SO-102 | 2.NP_SO-102 | 3340 | TT00.04.1521 | 1521
13645406 | 3.NP_SO-102 | 3.NP_SO-102 | 3350 | TT00.04.1524 | 1524
13645519 | 4.NP_SO-102 | 4.NP_SO-102 | 3350 | TT00.04.1525 | 1525

# IfcPipeFitting: M_Uzavření, obecné:Standardní, M_Uzavření, obecné:Standardní:13170158
In: -1.PP_SO-102
Type - Classification: TT00 SNIM (SNIM); Material: 032-175-175
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Není definováno
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 04; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Uzavření, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat); Group: WS_Požární zavodněný 1
Qto_PipeFittingBaseQuantities - Length: 19.0875 mm; GrossCrossSectionArea: 0.00114443 m2; NetCrossSectionArea: 0.00114443 m2; OuterSurfaceArea: 0.00228917 m2
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø35 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Vazby - Podlaží: -1.PP_SO-102; Výška od podlaží: 2600 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_Požární zavodněný; Klasifikace systému: Požární ochrana – vodní prostředky; Název systému: WS_Požární zavodněný 1
Grafika - Použít měřítko poznámky: no
Kóty - Jmenovitý poloměr: 17.5 mm; Jmenovitý průměr: 35 mm; Maximální velikost: 35 mm; Minimální velikost: 35 mm; Objem: 0.0000218462 m3; Velikost: ø35; Vnější průměr tvarovky: 38.175 mm; Výš.: 19.0875 mm
Identifikační data - Kód prvku: TT00.04.0913; Komentáře: ZAVÍČKOVÁNO; Označení: 0913
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 1486833; Rodina: M_Uzavření, obecné; Rodina a typ: M_Uzavření, obecné: Standardní; Vnější poloměr tvarovky: 19.0875 mm

# IfcPipeFitting: M_Uzavření, obecné:Standardní, M_Uzavření, obecné:Standardní:12948195
In: 4.NP_SO-102
Type - Classification: TT00 SNIM (SNIM); Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Není definováno
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 04; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Uzavření, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat); Group: WS_Teplá vnitřní 83
Qto_PipeFittingBaseQuantities - Length: 17.4625 mm; GrossCrossSectionArea: 0.000957866 m2; NetCrossSectionArea: 0.000957866 m2; OuterSurfaceArea: 0.00191599 m2
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø32 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Vazby - Podlaží: 4.NP_SO-102; Výška od podlaží: 3350 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_Teplá vnitřní; Klasifikace systému: Teplá voda v domácnosti; Název systému: WS_Teplá vnitřní 83
Grafika - Použít měřítko poznámky: no
Kóty - Jmenovitý poloměr: 16 mm; Jmenovitý průměr: 32 mm; Maximální velikost: 32 mm; Minimální velikost: 32 mm; Objem: 0.0000167282 m3; Velikost: ø32; Vnější průměr tvarovky: 34.925 mm; Výš.: 17.4625 mm
Identifikační data - Kód prvku: TT00.04.0022; Označení: 0022
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 1486833; Rodina: M_Uzavření, obecné; Rodina a typ: M_Uzavření, obecné: Standardní; Vnější poloměr tvarovky: 17.4625 mm

# IfcPipeFitting: Z-DO_NOT_USE__PIF_QS outlet_connector_Wavin:Var. (8)
In: 4.NP_SO-102
Type - Description: Roofoutlet coupler; PredefinedType: TRANSITION; Classification: VP01 SNIM (SNIM); Material: PE, Black, RAL9200
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Není definováno
Type - Materiály a povrchové úpravy - material: PE, Black, RAL9200
Type - Identifikační data - Kód sestavy: VP01; Komentáře k typům: minimal length 20mm!; Model: PE coupler; Název typu: Var.; Označení typu: 07; Popis: Roofoutlet coupler; Popis sestavy: Střešní; product_series: Quickstream; Výrobce: Wavin
Type - Jiné - Kategorie: Tvarovky; Název rodiny: Z-DO_NOT_USE__PIF_QS outlet_connector_Wavin
Classification: VP01 SNIM (SNIM); VP01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: WMB; CCI Technický systém: JD
Vazby - Přesunout s blízkými prvky: no; Podlaží: STŘECHA_SO-102; shorten_coupler: no; user_length: 370 mm; Výška od podlaží: 8093 mm
Kóty - connection_diameter1: 56 mm; connection_diameter2: 90 mm; DN1: 56 mm; DN2: 90 mm; Do1: 56 mm; Do2: 90 mm; Ds1: 50.2 mm; Ds2: 73 mm; L: 403 mm; Objem: 0.00100148 m3; P2: 33 mm; Q1: 365 mm; s1: 2.9 mm; s2: 8.5 mm; Z1: 370 mm
Identifikační data - artnr_wcz: OF925156W; artnr_wtu: 0; desc_wcz: QSPE SPOJKA VNITŘ. ZÁV. 56/2,5; desc_wtu: 0; EAN_code: 5907444012031; GTIN_Code: 05907444012031; item_description: QSPE SPOJKA VNITŘ. ZÁV. 56/2,5; productcode: OF925156W
Jiné - IsCustom: no; region_index: 8; config_lookup_table_name: outlet connector config; coupler_length: 370 mm; geometry_lookup_table_name: outlet connector geometry; global_index: 536; Id typu: 13236380; localisation: CZ; Rodina: Z-DO_NOT_USE__PIF_QS outlet_connector_Wavin; Rodina a typ: Z-DO_NOT_USE__PIF_QS outlet_connector_Wavin: Var.; rs2: 36.5 mm; Typ: Var.; valid: yes
Name (Z-DO_NOT_USE__PIF_QS outlet_connector_Wavin:Var.:...) | Fáze vytvoření | Kód prvku | Označení
13236766 | Fáze 1 | XXXX.07.0945 | 0945
13236943 | Fáze 1 | XXXX.07.0946 | 0946
13237041 | Fáze 1 | XXXX.07.0949 | 0949
13237044 | Fáze 1 | XXXX.07.0950 | 0950
13238472 | Fáze 1 | XXXX.07.0963 | 0963
13238525 | Fáze 1 | XXXX.07.0964 | 0964
13242560 | Fáze 2 | VP01.07.0987 | 0987
13242574 | Fáze 2 | VP01.07.0988 | 0988

# IfcPipeSegment: Ohebné trubky:Hadice sprchového setu (8)
Type - PredefinedType: FLEXIBLESEGMENT; Material: 255-0-0
Type - Tvarovky - Preferovaný typ spojky: T-spoj
Type - Požární ochrana - Požární odolnost: –
Type - Mechanické - Drsnost: 0.04572 mm
Type - Identifikační data - ID kategorie: OP; Kód sestavy: TR00; Komentáře k typům: Hadice je součástí sprchového setu; Název typu: Hadice sprchového setu; Označení typu: 01; Popis: Sprchová hadice; Popis sestavy: Obecný prvek; Výrobce: HANSA
Type - Jiné - Kategorie: Ohebné trubky; Název rodiny: Ohebné trubky
Classification: TR00 SNIM (SNIM); TR00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 15 mmø
Mechanické – tok - Doplňkový průtok: 0 m3/s; Instalační jednotky: 0; Průtok: 0 m3/s; Relativní drsnost: 0.003048; Reynoldsovo číslo: 0; Rychlost: 0 m/s; Stav průtoku: Laminární; Tlaková ztráta: 0 Pa; Třecí faktor: 0; Tření: 0
Text - CCI Funkční systém: F; CCI Komponenta: WPA; CCI Technický systém: JB
Vazby - Počáteční střední výška: 912.695 mm
Mechanické - Typ systému: WS_Teplá vnitřní; Klasifikace systému: Teplá voda v domácnosti; Průměr: 15 mm; Řez: 1
Grafika - Vzor ohybu: Nedefinovaný
Kóty - Délka: 1411.12 mm; Vnější průměr: 15 mm; Vnitřní průměr: 15 mm
Identifikační data - Název sestavy: Sprchový kout - vanička (nástěnná baterie)
Jiné - Id typu: 9913313; Rodina: Ohebné trubky; Rodina a typ: Ohebné trubky: Hadice sprchového setu; Typ: Hadice sprchového setu
Name (Ohebné trubky:Hadice sprchového setu:...) | In | Referenční podlaží | Fáze vytvoření | Název systému = Group | Kód prvku | Označení
12797927 | -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | WS_Teplá vnitřní 1 | TR00.01.0001 | 0001
12805487 | -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | WS_Teplá vnitřní 3 | TR00.01.0002 | 0002
12833687 | -2.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | WS_Teplá vnitřní 6 | TR00.01.0005 | 0005
12833751 | -2.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | WS_Teplá vnitřní 2 | TR00.01.0006 | 0006
12893446 | 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní 20 | TR00.01.0118 | 0118
12893491 | 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní 95 | TR00.01.0119 | 0119
12893970 | 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní 66 | TR00.01.0120 | 0120
13325309 | -1.PP_SO-102 | -1.PP_SO-102 | Fáze 2 | WS_Teplá vnitřní 16 | TR00.01.0209 | 0209

# IfcPipeSegment: Ohebné trubky:Pancéřová hadice (265)
Type - PredefinedType: FLEXIBLESEGMENT; Material: 255-0-0
Type - Tvarovky - Preferovaný typ spojky: T-spoj
Type - Požární ochrana - Požární odolnost: –
Type - Mechanické - Drsnost: 0.04572 mm
Type - Identifikační data - ID kategorie: OP; Kód sestavy: TR00; Název typu: Pancéřová hadice; Označení typu: 02; Popis: Pancéřová hadice; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Ohebné trubky; Název rodiny: Ohebné trubky
Classification: TR00 SNIM (SNIM); TR00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø15 mm
Mechanické – tok - Instalační jednotky: 0; Reynoldsovo číslo: 0; Stav průtoku: Laminární; Třecí faktor: 0; Tření: 0; Doplňkový průtok: 0 m3/s; Průtok: 0 m3/s; Relativní drsnost: 0.003048; Rychlost: 0 m/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: WPA; CCI Technický systém: JB
Mechanické - Řez: 1; Průměr: 15 mm
Grafika - Vzor ohybu: Jediná linie
Kóty - Vnější průměr: 15 mm; Vnitřní průměr: 15 mm
Jiné - Rodina: Ohebné trubky; Id typu: 9893359; Rodina a typ: Ohebné trubky: Pancéřová hadice; Typ: Pancéřová hadice
Name (Ohebné trubky:Pancéřová hadice:...) | In | Referenční podlaží | Počáteční střední výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Délka (mm) | Kód prvku | Název sestavy | Označení
12825623 | -2.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 7 | 239.66 | TR00.02.0003 | Umyvadlo | 0003
12825625 | -2.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 5 | 239.66 | TR00.02.0004 | Umyvadlo | 0004
12864819 | 1.NP_SO-102 | 1.NP_SO-102 | 709.551 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 24 | 1042.73 | TR00.02.0007 | Vana (nástěnná baterie) | 0007
12865981 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 26 | 239.66 | TR00.02.0008 | Umyvadlo + modul | 0008
12865983 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 25 | 239.66 | TR00.02.0009 | Umyvadlo + modul | 0009
12871085 | -2.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 19 | 239.66 | TR00.02.0010 | Umyvadlo + modul | 0010
12871087 | -2.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 16 | 239.66 | TR00.02.0011 | Umyvadlo + modul | 0011
12871113 | -2.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 10 | 239.66 | TR00.02.0012 | Umyvadlo + modul | 0012
12871115 | -2.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 15 | 239.66 | TR00.02.0013 | Umyvadlo + modul | 0013
12871174 | -2.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 9 | 239.66 | TR00.02.0014 | Umyvadlo + modul | 0014
12871176 | -2.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 7 | 239.66 | TR00.02.0015 | Umyvadlo + modul | 0015
12879375 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 27 | 239.66 | TR00.02.0016 | Umyvadlo + modul | 0016
12879377 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 26 | 239.66 | TR00.02.0017 | Umyvadlo + modul | 0017
12879416 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 25 | 239.66 | TR00.02.0018 | Umyvadlo + modul | 0018
12879418 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 21 | 239.66 | TR00.02.0019 | Umyvadlo + modul | 0019
12879445 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 28 | 239.66 | TR00.02.0020 | Umyvadlo + modul | 0020
12879447 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 27 | 239.66 | TR00.02.0021 | Umyvadlo + modul | 0021
12879476 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 29 | 239.66 | TR00.02.0022 | Umyvadlo + modul | 0022
12879478 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 28 | 239.66 | TR00.02.0023 | Umyvadlo + modul | 0023
12879503 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 30 | 239.66 | TR00.02.0024 | Umyvadlo + modul | 0024
12879505 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 29 | 239.66 | TR00.02.0025 | Umyvadlo + modul | 0025
12879532 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 31 | 239.66 | TR00.02.0026 | Umyvadlo + modul | 0026
12879534 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 30 | 239.66 | TR00.02.0027 | Umyvadlo + modul | 0027
12880694 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 42 | 239.66 | TR00.02.0028 | Umyvadlo + modul | 0028
12880696 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 41 | 239.66 | TR00.02.0029 | Umyvadlo + modul | 0029
12880708 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 44 | 239.66 | TR00.02.0030 | Umyvadlo + modul | 0030
12880710 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 43 | 239.66 | TR00.02.0031 | Umyvadlo + modul | 0031
12880736 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 48 | 239.66 | TR00.02.0032 | Umyvadlo + modul | 0032
12880738 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 47 | 239.66 | TR00.02.0033 | Umyvadlo + modul | 0033
12880750 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 50 | 239.66 | TR00.02.0034 | Umyvadlo + modul | 0034
12880752 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 49 | 239.66 | TR00.02.0035 | Umyvadlo + modul | 0035
12880764 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 52 | 239.66 | TR00.02.0036 | Umyvadlo + modul | 0036
12880766 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 51 | 239.66 | TR00.02.0037 | Umyvadlo + modul | 0037
12880864 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 43 | 239.66 | TR00.02.0038 | Umyvadlo + modul | 0038
12880866 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 42 | 239.66 | TR00.02.0039 | Umyvadlo + modul | 0039
12880878 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 47 | 239.66 | TR00.02.0040 | Umyvadlo + modul | 0040
12880880 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 46 | 239.66 | TR00.02.0041 | Umyvadlo + modul | 0041
12880906 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 54 | 239.66 | TR00.02.0042 | Umyvadlo + modul | 0042
12880908 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 53 | 239.66 | TR00.02.0043 | Umyvadlo + modul | 0043
12880920 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 56 | 239.66 | TR00.02.0044 | Umyvadlo + modul | 0044
12880922 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 55 | 239.66 | TR00.02.0045 | Umyvadlo + modul | 0045
12880934 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 58 | 239.66 | TR00.02.0046 | Umyvadlo + modul | 0046
12880936 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 57 | 239.66 | TR00.02.0047 | Umyvadlo + modul | 0047
12881034 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 45 | 239.66 | TR00.02.0048 | Umyvadlo + modul | 0048
12881036 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 44 | 239.66 | TR00.02.0049 | Umyvadlo + modul | 0049
12881048 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 53 | 239.66 | TR00.02.0050 | Umyvadlo + modul | 0050
12881050 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 52 | 239.66 | TR00.02.0051 | Umyvadlo + modul | 0051
12881076 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 60 | 239.66 | TR00.02.0052 | Umyvadlo + modul | 0052
12881078 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 59 | 239.66 | TR00.02.0053 | Umyvadlo + modul | 0053
12881090 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 62 | 239.66 | TR00.02.0054 | Umyvadlo + modul | 0054
12881092 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 61 | 239.66 | TR00.02.0055 | Umyvadlo + modul | 0055
12881104 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 64 | 239.66 | TR00.02.0056 | Umyvadlo + modul | 0056
12881106 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 63 | 239.66 | TR00.02.0057 | Umyvadlo + modul | 0057
12881935 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 68 | 239.66 | TR00.02.0058 | Umyvadlo + modul | 0058
12881937 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 67 | 239.66 | TR00.02.0059 | Umyvadlo + modul | 0059
12882000 | 1.NP_SO-102 | 2.NP_SO-102 | 120 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 4 | 355.681 | TR00.02.0060 | Bidet + modul | 0060
12882002 | 1.NP_SO-102 | 2.NP_SO-102 | 120 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 2 | 349.775 | TR00.02.0061 | Bidet + modul | 0061
12884684 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 72 | 239.66 | TR00.02.0062 | Umyvadlo | 0062
12884686 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 71 | 239.66 | TR00.02.0063 | Umyvadlo | 0063
12884794 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 76 | 239.66 | TR00.02.0064 | Umyvadlo | 0064
12884796 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 75 | 239.66 | TR00.02.0065 | Umyvadlo | 0065
12886220 | -2.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 70 | 239.66 | TR00.02.0066 | Umyvadlo + modul | 0066
12886222 | -2.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 69 | 239.66 | TR00.02.0067 | Umyvadlo + modul | 0067
12888135 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 34 | 239.66 | TR00.02.0068 | Umyvadlo + modul | 0068
12888137 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 33 | 239.66 | TR00.02.0069 | Umyvadlo + modul | 0069
12888842 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 35 | 239.66 | TR00.02.0070 | Umyvadlo + modul | 0070
12888844 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 34 | 239.66 | TR00.02.0071 | Umyvadlo + modul | 0071
12888866 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 38 | 239.66 | TR00.02.0072 | Umyvadlo + modul | 0072
12888868 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 37 | 239.66 | TR00.02.0073 | Umyvadlo + modul | 0073
12889676 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 81 | 239.66 | TR00.02.0074 | Umyvadlo + modul | 0074
12889678 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 80 | 239.66 | TR00.02.0075 | Umyvadlo + modul | 0075
12890308 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 239.66 | TR00.02.0076 | Umyvadlo + modul | 0076
12890310 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 82 | 239.66 | TR00.02.0077 | Umyvadlo + modul | 0077
12890335 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 84 | 239.66 | TR00.02.0078 | Umyvadlo + modul | 0078
12890337 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 83 | 239.66 | TR00.02.0079 | Umyvadlo + modul | 0079
12890446 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 82 | 239.66 | TR00.02.0080 | Umyvadlo + modul | 0080
12890448 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 81 | 239.66 | TR00.02.0081 | Umyvadlo + modul | 0081
12890831 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 85 | 239.66 | TR00.02.0082 | Umyvadlo + modul | 0082
12890833 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 84 | 239.66 | TR00.02.0083 | Umyvadlo + modul | 0083
12890855 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 86 | 239.66 | TR00.02.0084 | Umyvadlo + modul | 0084
12890857 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 85 | 239.66 | TR00.02.0085 | Umyvadlo + modul | 0085
12891276 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 32 | 239.66 | TR00.02.0086 | Umyvadlo + modul | 0086
12891278 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 31 | 239.66 | TR00.02.0087 | Umyvadlo + modul | 0087
