Properties of the parts of a building model (IFC4), part 40 of 60

# IfcPipeFitting: M_Spoj T, obecný:Standardní (161)
Name (M_Spoj T, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) = Štítek, od středu ke konci (mm) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Vnější poloměr tvarovky (mm)
13641520 | -1.PP_SO-102 | ø40 mm-ø40 mm-ø40 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.1488 | 1488 | yes | 20.6375
13641941 | -1.PP_SO-102 | ø50 mm-ø50 mm-ø50 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.1494 | 1494 | yes | 26.9875
13641975 | -1.PP_SO-102 | ø40 mm-ø40 mm-ø40 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.1496 | 1496 | yes | 20.6375
13642186 | -1.PP_SO-102 | ø40 mm-ø40 mm-ø40 mm | -1.PP_SO-102 | 3100 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.1498 | 1498 | yes | 20.6375
13642256 | -1.PP_SO-102 | ø40 mm-ø40 mm-ø40 mm | -1.PP_SO-102 | 3100 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.1502 | 1502 | yes | 20.6375
13642303 | -1.PP_SO-102 | ø25 mm-ø25 mm-ø25 mm | -1.PP_SO-102 | 3100 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.1504 | 1504 | yes | 14.2875
13642497 | -1.PP_SO-102 | ø40 mm-ø40 mm-ø40 mm | -1.PP_SO-102 | 2650.2 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.1506 | 1506 | yes | 20.6375
13642529 | -1.PP_SO-102 | ø50 mm-ø50 mm-ø50 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.1508 | 1508 | yes | 26.9875
13642595 | -1.PP_SO-102 | ø50 mm-ø50 mm-ø50 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.1512 | 1512 | yes | 26.9875
13643546 | 1.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.1517 | 1517 | no | 14.2875
13645148 | 2.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.1519 | 1519 | no | 14.2875
13645315 | 3.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.1522 | 1522 | no | 14.2875
13645539 | 4.NP_SO-102 | ø25 mm-ø25 mm-ø25 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.1527 | 1527 | no | 14.2875
13645709 | 3.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 3.NP_SO-102 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.1530 | 1530 | no | 11.1125
13646488 | 3.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 3.NP_SO-102 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.1545 | 1545 | yes | 20.6375
13647930 | 1.NP_SO-102 | ø20 mm-ø20 mm-ø20 mm | 1.NP_SO-102 | 1250 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT00.03.1559 | 1559 | no | 11.1125
13650969 | -1.PP_SO-102 | ø50 mm-ø50 mm-ø50 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.1565 | 1565 | yes | 26.9875
13704885 | 2.NP_SO-102 | ø40 mm-ø40 mm-ø40 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.1725 | 1725 | no | 20.6375
13705737 | -1.PP_SO-102 | ø50 mm-ø50 mm-ø50 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.1733 | 1733 | yes | 26.9875
13828696 | -1.PP_SO-102 | ø50 mm-ø50 mm-ø50 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT00.03.1877 | 1877 | yes | 26.9875
13828816 | -1.PP_SO-102 | ø40 mm-ø40 mm-ø40 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.1880 | 1880 | yes | 20.6375
13833035 | -1.PP_SO-102 | ø25 mm-ø25 mm-ø25 mm | -1.PP_SO-102 | 1000 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.1912 | 1912 | no | 14.2875
13833054 | -1.PP_SO-102 | ø25 mm-ø25 mm-ø25 mm | -1.PP_SO-102 | 1000 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.1913 | 1913 | no | 14.2875
13833117 | -1.PP_SO-102 | ø25 mm-ø25 mm-ø25 mm | -1.PP_SO-102 | 1000 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.1914 | 1914 | no | 14.2875
13833144 | -1.PP_SO-102 | ø25 mm-ø25 mm-ø25 mm | -1.PP_SO-102 | 1000 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.1915 | 1915 | no | 14.2875
13835653 | -1.PP_SO-102 | ø25 mm-ø25 mm-ø25 mm | -1.PP_SO-102 | 3225.94 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.1923 | 1923 | yes | 14.2875
13835692 | -1.PP_SO-102 | ø25 mm-ø25 mm-ø25 mm | -1.PP_SO-102 | 3225.59 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.1924 | 1924 | yes | 14.2875
13836768 | -1.PP_SO-102 | ø25 mm-ø25 mm-ø25 mm | -1.PP_SO-102 | 2900 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.1940 | 1940 | no | 14.2875
13836789 | -1.PP_SO-102 | ø25 mm-ø25 mm-ø25 mm | -1.PP_SO-102 | 2900 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT00.03.1942 | 1942 | no | 14.2875
13839894 | -1.PP_SO-102 | ø40 mm-ø40 mm-ø40 mm | -1.PP_SO-102 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT00.03.1958 | 1958 | yes | 20.6375
13987622 | -1.PP_SO-102 | ø75 mm-ø75 mm-ø75 mm | -1.PP_SO-102 | 1521.55 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 37.5 | 75 | 0.000586434 | 51.7875 | ø75-ø75-ø75 | 31.27 | 78.175 | TT00.03.2024 | 2024 | yes | 39.0875

# IfcPipeFitting: M_Spoj T, obecný:Standardní (13)
Type - Classification: TT00 SNIM (SNIM); Material: 0-128-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: WMB; CCI Technický systém: JB
Mechanické - Klasifikace systému: Sanitární
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní
Name (M_Spoj T, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Úhel tvarovky 1 (sdílený) (deg) = Úhel 1 (deg) | Páteřní trasa | Štítek, od středu ke konci (mm) | Vnější poloměr tvarovky (mm)
13182043 | 4.NP_SO-102 | ø110 mm-ø110 mm-ø110 mm | 4.NP_SO-102 | 3250 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.00343946 | 69.2875 | 135 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0942 | 0942 | 45 | no | 136.614 | 56.5875
13237722 | 1.NP_SO-102 | ø110 mm-ø110 mm-ø110 mm | 1.NP_SO-102 | 2958.05 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.00343997 | 69.2875 | 44.9976 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0961 | 0961 | 44.9976 | yes | 136.622 | 56.5875
13239243 | 4.NP_SO-102 | ø56 mm-ø56 mm-ø56 mm | 4.NP_SO-102 | 3077.88 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.000491771 | 42.2875 | 45 | ø56-ø56-ø56 | 23.67 | 59.175 | TT00.03.0967 | 0967 | 45 | no | 71.4305 | 29.5875
13242399 | 1.NP_SO-102 | ø110 mm-ø110 mm-ø110 mm | 1.NP_SO-102 | 3088.2 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.00343997 | 69.2875 | 44.9976 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0985 | 0985 | 44.9976 | yes | 136.622 | 56.5875
13242831 | 4.NP_SO-102 | ø56 mm-ø56 mm-ø56 mm | 4.NP_SO-102 | 3249 | Fáze 2 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 28 | 56 | 0.000491771 | 42.2875 | 45 | ø56-ø56-ø56 | 23.67 | 59.175 | TT00.03.0991 | 0991 | 45 | no | 71.4305 | 29.5875
13514844 | -1.PP_SO-102 | ø125 mm-ø125 mm-ø125 mm | -1.PP_SO-102 | -2612.02 | Fáze 1 | SW_Deště vnitřní gravitační | SW_Deště vnitřní gravitační 2 | 62.5 | 125 | 0.0052357 | 77.7875 | 44.9976 | ø125-ø125-ø125 | 52.07 | 130.175 | TT00.03.1318 | 1318 | 44.9976 | yes | 157.144 | 65.0875
13678538 | -1.PP_SO-102 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-102 | 2684.5 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.00343997 | 69.2875 | 44.9976 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.1649 | 1649 | 44.9976 | yes | 136.622 | 56.5875
13687789 | 2.NP_SO-102 | ø125 mm-ø125 mm-ø125 mm | 2.NP_SO-102 | 2790.98 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.0052357 | 77.7875 | 44.9976 | ø125-ø125-ø125 | 52.07 | 130.175 | TT00.03.1682 | 1682 | 44.9976 | yes | 157.144 | 65.0875
13706121 | 2.NP_SO-102 | ø125 mm-ø125 mm-ø125 mm | 2.NP_SO-102 | 2563.7 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.00531474 | 77.7875 | 44.4271 | ø125-ø125-ø125 | 52.07 | 130.175 | TT00.03.1746 | 1746 | 44.4271 | yes | 159.384 | 65.0875
14002679 | 2.NP_SO-102 | ø125 mm-ø125 mm-ø125 mm | 2.NP_SO-102 | -1134.77 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.00523571 | 77.7875 | 44.9976 | ø125-ø125-ø125 | 52.07 | 130.175 | TT00.03.2125 | 2125 | 44.9976 | yes | 157.145 | 65.0875
14004214 | 2.NP_SO-102 | ø125 mm-ø125 mm-ø125 mm | 2.NP_SO-102 | -1311.45 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.0053166 | 77.7875 | 44.4138 | ø125-ø125-ø125 | 52.07 | 130.175 | TT00.03.2129 | 2129 | 44.4138 | yes | 159.437 | 65.0875
14016014 | 2.NP_SO-102 | ø125 mm-ø125 mm-ø125 mm | 2.NP_SO-102 | 2509.96 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.00523537 | 77.7875 | 45 | ø125-ø125-ø125 | 52.07 | 130.175 | TT00.03.2141 | 2141 | 45 |  | 157.135 | 65.0875
14016450 | 2.NP_SO-102 | ø125 mm-ø125 mm-ø125 mm | 2.NP_SO-102 | 2056.45 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 62.5 | 125 | 0.00523537 | 77.7875 | 45 | ø125-ø125-ø125 | 52.07 | 130.175 | TT00.03.2149 | 2149 | 45 |  | 157.135 | 65.0875

# IfcPipeFitting: M_Spoj T, obecný:Standardní (10)
Type - Classification: TT00 SNIM (SNIM); Material: 032-175-175
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: WMB; CCI Technický systém: JB
Mechanické - Typ systému: WS_Požární zavodněný; Klasifikace systému: Požární ochrana – vodní prostředky
Grafika - Použít měřítko poznámky: no
Kóty - Úhel: 90 deg
Jiné - Páteřní trasa: yes; Typ: Standardní; Úhel tvarovky 1 (sdílený): 90 deg; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní; Úhel 1: 90 deg
Name (M_Spoj T, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) = Štítek, od středu ke konci (mm) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Vnější poloměr tvarovky (mm)
13157494 | -1.PP_SO-102 | ø42 mm-ø42 mm-ø42 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Požární zavodněný 1 | 21 | 42 | 0.000138944 | 35.2875 | ø42-ø42-ø42 | 18.07 | 45.175 | TT00.03.0878 | 0878 | 22.5875
13157515 | 3.NP_SO-102 | ø28 mm-ø28 mm-ø28 mm | 3.NP_SO-102 | 3366.44 | Fáze 1 | WS_Požární zavodněný 1 | 14 | 28 | 0.0000546752 | 28.2875 | ø28-ø28-ø28 | 12.47 | 31.175 | TT00.03.0880 | 0880 | 15.5875
13168963 | -1.PP_SO-102 | ø42 mm-ø42 mm-ø42 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární zavodněný 1 | 21 | 42 | 0.000138944 | 35.2875 | ø42-ø42-ø42 | 18.07 | 45.175 | TT00.03.0892 | 0892 | 22.5875
13169842 | 2.NP_SO-102 | ø35 mm-ø35 mm-ø35 mm | 2.NP_SO-102 | 3177.41 | Fáze 2 | WS_Požární zavodněný 3 | 17.5 | 35 | 0.0000906028 | 31.7875 | ø35-ø35-ø35 | 15.27 | 38.175 | TT00.03.0905 | 0905 | 19.0875
13169977 | 1.NP_SO-102 | ø35 mm-ø35 mm-ø35 mm | 1.NP_SO-102 | 3200 | Fáze 2 | WS_Požární zavodněný 3 | 17.5 | 35 | 0.0000906028 | 31.7875 | ø35-ø35-ø35 | 15.27 | 38.175 | TT00.03.0908 | 0908 | 19.0875
13323054 | -1.PP_SO-102 | ø28 mm-ø28 mm-ø28 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární zavodněný 1 | 14 | 28 | 0.0000546752 | 28.2875 | ø28-ø28-ø28 | 12.47 | 31.175 | TT00.03.1036 | 1036 | 15.5875
13323184 | 1.NP_SO-102 | ø28 mm-ø28 mm-ø28 mm | 1.NP_SO-102 | 3364.28 | Fáze 1 | WS_Požární zavodněný 1 | 14 | 28 | 0.0000546752 | 28.2875 | ø28-ø28-ø28 | 12.47 | 31.175 | TT00.03.1038 | 1038 | 15.5875
13324385 | 3.NP_SO-102 | ø28 mm-ø28 mm-ø28 mm | 3.NP_SO-102 | 3198.93 | Fáze 1 | WS_Požární zavodněný 1 | 14 | 28 | 0.0000546752 | 28.2875 | ø28-ø28-ø28 | 12.47 | 31.175 | TT00.03.1053 | 1053 | 15.5875
13325003 | 2.NP_SO-102 | ø28 mm-ø28 mm-ø28 mm | 2.NP_SO-102 | 3310.29 | Fáze 1 | WS_Požární zavodněný 1 | 14 | 28 | 0.0000546752 | 28.2875 | ø28-ø28-ø28 | 12.47 | 31.175 | TT00.03.1063 | 1063 | 15.5875
13651694 | -1.PP_SO-102 | ø54 mm-ø54 mm-ø54 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární zavodněný 1 | 27 | 54 | 0.000255701 | 41.2875 | ø54-ø54-ø54 | 22.87 | 57.175 | TT00.03.1570 | 1570 | 28.5875

# IfcPipeFitting: M_Spoj T, obecný:Standardní (68)
Type - Classification: TT00 SNIM (SNIM); Material: 128-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: WMB; CCI Technický systém: JB
Mechanické - Klasifikace systému: Sanitární
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní
Name (M_Spoj T, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Štítek, od středu ke konci (mm) | Úhel 1 (deg) = Úhel tvarovky 1 (sdílený) (deg) | Vnější poloměr tvarovky (mm)
13144748 | -1.PP_SO-102 | ø160 mm-ø160 mm-ø160 mm | -1.PP_SO-102 | -2346.21 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.0103142 | 94.2875 | 44.9905 | ø160-ø160-ø160 | 65.27 | 163.175 | TT00.03.0816 | 0816 | yes | 197.016 | 44.9905 | 81.5875
13152150 | -1.PP_SO-102 | ø160 mm-ø160 mm-ø160 mm | -1.PP_SO-102 | -3423.79 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.0103142 | 94.2875 | 44.9905 | ø160-ø160-ø160 | 65.27 | 163.175 | TT00.03.0825 | 0825 | yes | 197.016 | 44.9905 | 81.5875
13153282 | -1.PP_SO-102 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-102 | -2381.62 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.00343976 | 69.2875 | 45 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0835 | 0835 | yes | 136.614 | 45 | 56.5875
13153315 | -1.PP_SO-102 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-102 | -2746.17 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 4 | 55 | 110 | 0.00343976 | 69.2875 | 45 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0837 | 0837 | yes | 136.614 | 45 | 56.5875
13153862 | -1.PP_SO-102 | ø160 mm-ø160 mm-ø160 mm | -1.PP_SO-102 | -2493.21 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.0106279 | 94.2875 | 43.8542 | ø160-ø160-ø160 | 65.27 | 163.175 | TT00.03.0843 | 0843 | yes | 202.678 | 43.8542 | 81.5875
13153985 | -1.PP_SO-102 | ø160 mm-ø160 mm-ø160 mm | -1.PP_SO-102 | -2837.47 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.0102611 | 94.2875 | 45.1881 | ø160-ø160-ø160 | 65.27 | 163.175 | TT00.03.0844 | 0844 | yes | 196.059 | 45.1881 | 81.5875
13154016 | -1.PP_SO-102 | ø160 mm-ø160 mm-ø160 mm | -1.PP_SO-102 | -2510.35 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.0106279 | 94.2875 | 43.8542 | ø160-ø160-ø160 | 65.27 | 163.175 | TT00.03.0846 | 0846 | yes | 202.678 | 43.8542 | 81.5875
13155565 | -1.PP_SO-102 | ø160 mm-ø160 mm-ø160 mm | -1.PP_SO-102 | -3054.1 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.0103142 | 94.2875 | 44.9905 | ø160-ø160-ø160 | 65.27 | 163.175 | TT00.03.0861 | 0861 | yes | 197.016 | 44.9905 | 81.5875
13155838 | -1.PP_SO-102 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-102 | 6.60422 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 55 | 110 | 0.00343976 | 69.2875 | 45 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0864 | 0864 | yes | 136.614 | 45 | 56.5875
13157389 | -1.PP_SO-102 | ø160 mm-ø160 mm-ø160 mm | -1.PP_SO-102 | -2552.23 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.0103142 | 94.2875 | 44.9905 | ø160-ø160-ø160 | 65.27 | 163.175 | TT00.03.0872 | 0872 | yes | 197.016 | 44.9905 | 81.5875
13161570 | -1.PP_SO-102 | ø160 mm-ø160 mm-ø160 mm | -1.PP_SO-102 | -3144.81 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.0103142 | 94.2875 | 44.9905 | ø160-ø160-ø160 | 65.27 | 163.175 | TT00.03.0882 | 0882 | yes | 197.016 | 44.9905 | 81.5875
13237315 | 4.NP_SO-102 | ø110 mm-ø110 mm-ø110 mm | 4.NP_SO-102 | 3250 | Fáze 1 | SW_Deště vnitřní podtlak | SW_Deště vnitřní podtlak 4 | 55 | 110 | 0.00343976 | 69.2875 | 45 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.0955 | 0955 | no | 136.614 | 45 | 56.5875
13363558 | 3.NP_SO-102 | ø110 mm-ø110 mm-ø110 mm | 3.NP_SO-102 | 3219.8 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.00343976 | 69.2875 | 45 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.1139 | 1139 | yes | 136.614 | 45 | 56.5875
13404007 | 3.NP_SO-102 | ø110 mm-ø110 mm-ø110 mm | 3.NP_SO-102 | 2968.59 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.00343976 | 69.2875 | 45 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.1162 | 1162 | yes | 136.614 | 45 | 56.5875
13432491 | -1.PP_SO-102 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-102 | 2942.32 | Fáze 2 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.00344061 | 69.2875 | 44.9905 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.1179 | 1179 | yes | 136.646 | 44.9905 | 56.5875
13432652 | -1.PP_SO-102 | ø160 mm-ø160 mm-ø160 mm | -1.PP_SO-102 | -1831.64 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.0103142 | 94.2875 | 44.9905 | ø160-ø160-ø160 | 65.27 | 163.175 | TT00.03.1180 | 1180 | yes | 197.016 | 44.9905 | 81.5875
13438554 | -1.PP_SO-102 | ø200 mm-ø200 mm-ø200 mm | -1.PP_SO-102 | 2439.61 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.0208566 | 115.888 | 44.9976 | ø200-ø200-ø200 | 82.55 | 206.375 | TT00.03.1202 | 1202 | yes | 249.131 | 44.9976 | 103.188
13439204 | -1.PP_SO-102 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-102 | 2598.59 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.0035452 | 69.2875 | 43.8543 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.1205 | 1205 | yes | 140.573 | 43.8543 | 56.5875
13440192 | -1.PP_SO-102 | ø200 mm-ø200 mm-ø200 mm | -1.PP_SO-102 | 2823.8 | Fáze 2 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.0208563 | 115.888 | 44.9981 | ø200-ø200-ø200 | 82.55 | 206.375 | TT00.03.1207 | 1207 | yes | 249.128 | 44.9981 | 103.188
13461522 | 3.NP_SO-102 | ø78 mm-ø78 mm-ø78 mm | 3.NP_SO-102 | 3219.8 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.0012695 | 53.2875 | 45.0002 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.1212 | 1212 | yes | 97.9864 | 45.0002 | 40.5875
13462677 | 2.NP_SO-102 | ø78 mm-ø78 mm-ø78 mm | 2.NP_SO-102 | 2618.57 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.0012695 | 53.2875 | 45 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.1221 | 1221 | yes | 97.9868 | 45 | 40.5875
13496692 | 1.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 1.NP_SO-102 | 2539.58 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00645322 | 81.7875 | 43.8542 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.1300 | 1300 | yes | 171.626 | 43.8542 | 69.0875
13506139 | 3.NP_SO-102 | ø78 mm-ø78 mm-ø78 mm | 3.NP_SO-102 | 2902.26 | Fáze 2 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000648971 | 53.2875 | 88.8542 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.1307 | 1307 | yes | 53.2875 | 88.8542 | 40.5875
13517063 | -1.PP_SO-102 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-102 | -2656.37 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 55 | 110 | 0.0035452 | 69.2875 | 43.8542 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.1323 | 1323 | yes | 140.574 | 43.8542 | 56.5875
13528000 | -1.PP_SO-102 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-102 | -3030.26 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 55 | 110 | 0.00344059 | 69.2875 | 44.9908 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.1391 | 1391 | yes | 136.645 | 44.9908 | 56.5875
13546049 | 2.NP_SO-102 | ø78 mm-ø78 mm-ø78 mm | 2.NP_SO-102 | 2990.41 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.00127001 | 53.2875 | 44.9847 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.1444 | 1444 | yes | 98.0239 | 44.9847 | 40.5875
13546845 | 2.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 2.NP_SO-102 | 1250.73 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00615719 | 81.7875 | 134.367 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.1448 | 1448 | yes | 164.221 | 45.6328 | 69.0875
13646634 | 3.NP_SO-102 | ø78 mm-ø78 mm-ø78 mm | 3.NP_SO-102 | 3047.87 | Fáze 2 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.00133851 | 53.2875 | 43 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.1550 | 1550 | yes | 103.037 | 43 | 40.5875 | Identifikační data - Komentáře: S17
13658920 | -1.PP_SO-102 | ø160 mm-ø160 mm-ø160 mm | -1.PP_SO-102 | -2582.66 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.0103124 | 94.2875 | 44.997 | ø160-ø160-ø160 | 65.27 | 163.175 | TT00.03.1599 | 1599 | yes | 196.984 | 44.997 | 81.5875
13659879 | -1.PP_SO-102 | ø160 mm-ø160 mm-ø160 mm | -1.PP_SO-102 | -2539.32 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.0103142 | 94.2875 | 44.9905 | ø160-ø160-ø160 | 65.27 | 163.175 | TT00.03.1603 | 1603 | yes | 197.016 | 44.9905 | 81.5875
13660548 | -1.PP_SO-102 | ø78 mm-ø78 mm-ø78 mm | -1.PP_SO-102 | -1387.29 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 3 | 39 | 78 | 0.0012695 | 53.2875 | 45 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.1609 | 1609 | yes | 97.9869 | 45 | 40.5875
13671997 | -1.PP_SO-102 | ø200 mm-ø200 mm-ø200 mm | -1.PP_SO-102 | 2625.98 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.0208563 | 115.888 | 44.9981 | ø200-ø200-ø200 | 82.55 | 206.375 | TT00.03.1614 | 1614 | yes | 249.128 | 44.9981 | 103.188
13672550 | -1.PP_SO-102 | ø200 mm-ø200 mm-ø200 mm | -1.PP_SO-102 | 2678.87 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.0208563 | 115.888 | 44.9981 | ø200-ø200-ø200 | 82.55 | 206.375 | TT00.03.1616 | 1616 | yes | 249.128 | 44.9981 | 103.188
13672690 | -1.PP_SO-102 | ø200 mm-ø200 mm-ø200 mm | -1.PP_SO-102 | 2698.56 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.0208563 | 115.888 | 44.9981 | ø200-ø200-ø200 | 82.55 | 206.375 | TT00.03.1620 | 1620 | yes | 249.128 | 44.9981 | 103.188
13672972 | -1.PP_SO-102 | ø200 mm-ø200 mm-ø200 mm | -1.PP_SO-102 | 2669.26 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.0208563 | 115.888 | 44.9981 | ø200-ø200-ø200 | 82.55 | 206.375 | TT00.03.1625 | 1625 | yes | 249.128 | 44.9981 | 103.188
13673737 | -1.PP_SO-102 | ø110 mm-ø110 mm-ø110 mm | -1.PP_SO-102 | 2833.82 | Fáze 2 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.00343993 | 69.2875 | 44.9981 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.1633 | 1633 | yes | 136.621 | 44.9981 | 56.5875
13675116 | -1.PP_SO-102 | ø200 mm-ø200 mm-ø200 mm | -1.PP_SO-102 | 2632.62 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.0208563 | 115.888 | 44.9981 | ø200-ø200-ø200 | 82.55 | 206.375 | TT00.03.1638 | 1638 | yes | 249.128 | 44.9981 | 103.188
13675651 | -1.PP_SO-102 | ø200 mm-ø200 mm-ø200 mm | -1.PP_SO-102 | 2814.84 | Fáze 2 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.0211708 | 115.888 | 44.4276 | ø200-ø200-ø200 | 82.55 | 206.375 | TT00.03.1644 | 1644 | yes | 252.679 | 44.4276 | 103.188
13675739 | -1.PP_SO-102 | ø200 mm-ø200 mm-ø200 mm | -1.PP_SO-102 | 2750.64 | Fáze 2 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.0208563 | 115.888 | 44.9981 | ø200-ø200-ø200 | 82.55 | 206.375 | TT00.03.1646 | 1646 | yes | 249.128 | 44.9981 | 103.188
13680741 | 3.NP_SO-102 | ø160 mm-ø160 mm-ø160 mm | 3.NP_SO-102 | 3287.88 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 80 | 160 | 0.00446649 | 94.2875 | 88.8557 | ø160-ø160-ø160 | 65.27 | 163.175 | TT00.03.1655 | 1655 | yes | 94.2875 | 88.8557 | 81.5875
13680815 | 2.NP_SO-102 | ø160 mm-ø160 mm-ø160 mm | 2.NP_SO-102 | 3297.86 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 80 | 160 | 0.00446649 | 94.2875 | 88.8564 | ø160-ø160-ø160 | 65.27 | 163.175 | TT00.03.1658 | 1658 | yes | 94.2875 | 88.8564 | 81.5875
13680870 | 1.NP_SO-102 | ø160 mm-ø160 mm-ø160 mm | 1.NP_SO-102 | 3064.26 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 80 | 160 | 0.00446649 | 94.2875 | 88.8542 | ø160-ø160-ø160 | 65.27 | 163.175 | TT00.03.1661 | 1661 | yes | 94.2875 | 88.8542 | 81.5875
13681275 | 2.NP_SO-102 | ø78 mm-ø78 mm-ø78 mm | 2.NP_SO-102 | 2958.35 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.00130883 | 53.2875 | 43.8434 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.1664 | 1664 | yes | 100.854 | 43.8434 | 40.5875
13688922 | -1.PP_SO-102 | ø200 mm-ø200 mm-ø200 mm | -1.PP_SO-102 | 2617.16 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.0211711 | 115.888 | 44.4271 | ø200-ø200-ø200 | 82.55 | 206.375 | TT00.03.1689 | 1689 | yes | 252.683 | 44.4271 | 103.188
13689240 | -1.PP_SO-102 | ø200 mm-ø200 mm-ø200 mm | -1.PP_SO-102 | 2457.61 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.0208605 | 115.888 | 44.9905 | ø200-ø200-ø200 | 82.55 | 206.375 | TT00.03.1692 | 1692 | yes | 249.175 | 44.9905 | 103.188
13689680 | -1.PP_SO-102 | ø200 mm-ø200 mm-ø200 mm | -1.PP_SO-102 | 2544.84 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.0208537 | 115.888 | 45.0029 | ø200-ø200-ø200 | 82.55 | 206.375 | TT00.03.1697 | 1697 | yes | 249.099 | 45.0029 | 103.188
13689916 | -1.PP_SO-102 | ø200 mm-ø200 mm-ø200 mm | -1.PP_SO-102 | 2512.48 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 100 | 200 | 0.0208563 | 115.888 | 44.9981 | ø200-ø200-ø200 | 82.55 | 206.375 | TT00.03.1703 | 1703 | yes | 249.129 | 44.9981 | 103.188
13993470 | 2.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 2.NP_SO-102 | -967.793 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00645218 | 81.7875 | 43.8603 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.2029 | 2029 | yes | 171.6 | 43.8603 | 69.0875
13993570 | 1.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 1.NP_SO-102 | 3017.05 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00626269 | 81.7875 | 44.9905 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.2032 | 2032 | yes | 166.831 | 44.9905 | 69.0875
13993939 | 2.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 2.NP_SO-102 | -1024.39 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00645319 | 81.7875 | 43.8544 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.2038 | 2038 | yes | 171.625 | 43.8544 | 69.0875
13994340 | 1.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 1.NP_SO-102 | 2900.18 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00645322 | 81.7875 | 43.8543 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.2042 | 2042 | yes | 171.626 | 43.8543 | 69.0875
13995022 | 1.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 1.NP_SO-102 | 2801.49 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00645322 | 81.7875 | 43.8543 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.2046 | 2046 | yes | 171.626 | 43.8543 | 69.0875
13995698 | 1.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 1.NP_SO-102 | 2752.79 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00446048 | 81.7875 | 59.0668 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.2049 | 2049 | yes | 121.946 | 59.0668 | 69.0875
13996568 | 1.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 1.NP_SO-102 | 2724.43 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00645322 | 81.7875 | 43.8542 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.2059 | 2059 | yes | 171.626 | 43.8542 | 69.0875
13996692 | 2.NP_SO-102 | ø110 mm-ø110 mm-ø110 mm | 2.NP_SO-102 | -927.789 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.00344061 | 69.2875 | 44.9905 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.2062 | 2062 | yes | 136.646 | 44.9905 | 56.5875
13996740 | 1.NP_SO-102 | ø110 mm-ø110 mm-ø110 mm | 1.NP_SO-102 | 3062.73 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.00344061 | 69.2875 | 44.9905 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.2064 | 2064 | yes | 136.646 | 44.9905 | 56.5875
13996813 | 1.NP_SO-102 | ø110 mm-ø110 mm-ø110 mm | 1.NP_SO-102 | 3077.21 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.00344061 | 69.2875 | 44.9905 | ø110-ø110-ø110 | 45.27 | 113.175 | TT00.03.2067 | 2067 | yes | 136.646 | 44.9905 | 56.5875
13998581 | 2.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 2.NP_SO-102 | -984.627 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00645322 | 81.7875 | 43.8542 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.2075 | 2075 | yes | 171.626 | 43.8542 | 69.0875
13998912 | 1.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 1.NP_SO-102 | 2625.18 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00645322 | 81.7875 | 43.8542 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.2078 | 2078 | yes | 171.626 | 43.8542 | 69.0875
13999072 | 1.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 1.NP_SO-102 | 2951.52 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00645322 | 81.7875 | 43.8542 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.2080 | 2080 | yes | 171.626 | 43.8542 | 69.0875
13999279 | 1.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 1.NP_SO-102 | 2992.31 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00626301 | 81.7875 | 44.9886 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.2083 | 2083 | yes | 166.839 | 44.9886 | 69.0875
13999588 | 1.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 1.NP_SO-102 | 3062.6 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00626251 | 81.7875 | 44.9916 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.2091 | 2091 | yes | 166.826 | 44.9916 | 69.0875
13999669 | 1.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 1.NP_SO-102 | 2577.58 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00645322 | 81.7875 | 43.8542 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.2092 | 2092 | yes | 171.626 | 43.8542 | 69.0875
14000904 | 1.NP_SO-102 | ø160 mm-ø160 mm-ø160 mm | 1.NP_SO-102 | 2114.12 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 80 | 160 | 0.0103116 | 94.2875 | 44.9999 | ø160-ø160-ø160 | 65.27 | 163.175 | TT00.03.2101 | 2101 | yes | 196.97 | 44.9999 | 81.5875
14001587 | 2.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 2.NP_SO-102 | -1529.71 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00645322 | 81.7875 | 43.8542 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.2108 | 2108 | yes | 171.626 | 43.8542 | 69.0875
14002103 | 1.NP_SO-102 | ø78 mm-ø78 mm-ø78 mm | 1.NP_SO-102 | 2846.92 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.00129735 | 53.2875 | 44.1752 | ø78-ø78-ø78 | 32.47 | 81.175 | TT00.03.2115 | 2115 | yes | 100.017 | 44.1752 | 40.5875
14004637 | 1.NP_SO-102 | ø135 mm-ø135 mm-ø135 mm | 1.NP_SO-102 | 2927.43 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.00626269 | 81.7875 | 44.9905 | ø135-ø135-ø135 | 55.27 | 138.175 | TT00.03.2130 | 2130 | yes | 166.831 | 44.9905 | 69.0875
14027575 | -1.PP_SO-102 | ø250 mm-ø250 mm-ø250 mm | -1.PP_SO-102 | -1266.15 | Fáze 1 | SW_Splašky vnitřní gravitační | SW_Splašky vnitřní gravitační 35 (1) | 125 | 250 | 0.0403622 | 141.288 | 44.9981 | ø250-ø250-ø250 | 102.87 | 257.175 | TT00.03.2209 | 2209 | yes | 310.452 | 44.9981 | 128.588

# IfcPipeFitting: M_Spoj T, obecný:Standardní, M_Spoj T, obecný:Standardní:13641179
In: -1.PP_SO-102
Type - Classification: TT00 SNIM (SNIM); Material: 128-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat); Group: WS_"Jiný typ" studená vnitřní 1
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø32 mm-ø32 mm-ø32 mm
Text - CCI Funkční systém: F; CCI Komponenta: WMB; CCI Technický systém: JB
Vazby - Podlaží: -1.PP_SO-102; Výška od podlaží: 3299.87 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_"ŠEDÁ" studená vnitřní; Klasifikace systému: Studená voda v domácnosti; Název systému: WS_"Jiný typ" studená vnitřní 1
Grafika - Použít měřítko poznámky: no
Kóty - Jmenovitý poloměr: 16 mm; Jmenovitý průměr: 32 mm; Maximální velikost: 32 mm; Minimální velikost: 32 mm; Objem: 0.0000724839 m3; Od středu ke konci: 30.1625 mm; Úhel: 90.0001 deg; Velikost: ø32-ø32-ø32; Velikost značky: 13.97 mm; Vnější průměr tvarovky: 34.925 mm
Identifikační data - Kód prvku: TT00.03.1484; Označení: 1484
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní; Štítek, od středu ke konci: 30.1625 mm; Úhel 1: 89.9999 deg; Úhel tvarovky 1 (sdílený): 89.9999 deg; Vnější poloměr tvarovky: 17.4625 mm

# IfcPipeFitting: M_Spoj T, obecný:Standardní (10)
Type - Classification: TT00 SNIM (SNIM); Material: 175-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat); Group: WS_Požární nezavodněný 1
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: WMB; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: WS_Požární nezavodněný; Název systému: WS_Požární nezavodněný 1
Grafika - Použít měřítko poznámky: no
Kóty - Úhel: 90 deg
Jiné - Páteřní trasa: yes; Typ: Standardní; Úhel tvarovky 1 (sdílený): 90 deg; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní; Úhel 1: 90 deg
Name (M_Spoj T, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Klasifikace systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) = Štítek, od středu ke konci (mm) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Vnější poloměr tvarovky (mm)
13356242 | -1.PP_SO-102 | ø89 mm-ø89 mm-ø89 mm | -1.PP_SO-102 | 3225.24 | Studená voda v domácnosti | 44.5 | 89 | 0.000915761 | 58.7875 | ø89-ø89-ø89 | 36.87 | 92.175 | TT00.03.1089 | 1089 | 46.0875
13356913 | -1.PP_SO-102 | ø15 mm-ø15 mm-ø15 mm | -1.PP_SO-102 | 1300 | Studená voda v domácnosti | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT00.03.1093 | 1093 | 7.9375
13358425 | 1.NP_SO-102 | ø89 mm-ø89 mm-ø89 mm | 1.NP_SO-102 | 1300 | Studená voda v domácnosti | 44.5 | 89 | 0.000915761 | 58.7875 | ø89-ø89-ø89 | 36.87 | 92.175 | TT00.03.1100 | 1100 | 46.0875
13358513 | 2.NP_SO-102 | ø89 mm-ø89 mm-ø89 mm | 2.NP_SO-102 | 2000 | Studená voda v domácnosti | 44.5 | 89 | 0.000915761 | 58.7875 | ø89-ø89-ø89 | 36.87 | 92.175 | TT00.03.1103 | 1103 | 46.0875
13359150 | 3.NP_SO-102 | ø89 mm-ø89 mm-ø89 mm | 3.NP_SO-102 | 3366.44 | Studená voda v domácnosti | 44.5 | 89 | 0.000915761 | 58.7875 | ø89-ø89-ø89 | 36.87 | 92.175 | TT00.03.1114 | 1114 | 46.0875
13359426 | 1.NP_SO-102 | ø89 mm-ø89 mm-ø89 mm | 1.NP_SO-102 | 1300 | Požární ochrana – suché prostředky | 44.5 | 89 | 0.000915761 | 58.7875 | ø89-ø89-ø89 | 36.87 | 92.175 | TT00.03.1115 | 1115 | 46.0875
13359541 | 2.NP_SO-102 | ø89 mm-ø89 mm-ø89 mm | 2.NP_SO-102 | 1300 | Požární ochrana – suché prostředky | 44.5 | 89 | 0.000915761 | 58.7875 | ø89-ø89-ø89 | 36.87 | 92.175 | TT00.03.1117 | 1117 | 46.0875
13359799 | 3.NP_SO-102 | ø89 mm-ø89 mm-ø89 mm | 3.NP_SO-102 | 1300 | Požární ochrana – suché prostředky | 44.5 | 89 | 0.000915761 | 58.7875 | ø89-ø89-ø89 | 36.87 | 92.175 | TT00.03.1120 | 1120 | 46.0875
13808271 | -1.PP_SO-102 | ø89 mm-ø89 mm-ø89 mm | -1.PP_SO-102 | 3225.24 | Požární ochrana – suché prostředky | 44.5 | 89 | 0.000915761 | 58.7875 | ø89-ø89-ø89 | 36.87 | 92.175 | TT00.03.1795 | 1795 | 46.0875
13808522 | -1.PP_SO-102 | ø89 mm-ø89 mm-ø89 mm | -1.PP_SO-102 | 2800 | Požární ochrana – suché prostředky | 44.5 | 89 | 0.000915761 | 58.7875 | ø89-ø89-ø89 | 36.87 | 92.175 | TT00.03.1799 | 1799 | 46.0875

# IfcPipeFitting: M_Spoj T, obecný:Standardní (104)
Type - Classification: TT00 SNIM (SNIM); Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT00; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT00 SNIM (SNIM); TT00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: WMB; CCI Technický systém: JB
Grafika - Použít měřítko poznámky: no
Kóty - Úhel: 90 deg
Jiné - Typ: Standardní; Úhel tvarovky 1 (sdílený): 90 deg; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní; Úhel 1: 90 deg
Name (M_Spoj T, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) = Štítek, od středu ke konci (mm) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Vnější poloměr tvarovky (mm)
12948745 | 4.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 4.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0026 | 0026 | yes | 17.4625
12948814 | 4.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 4.NP_SO-102 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0029 | 0029 | yes | 17.4625
12952076 | 4.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 4.NP_SO-102 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0041 | 0041 | yes | 17.4625
12954440 | 4.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 4.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0053 | 0053 | yes | 17.4625
12956240 | 3.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0067 | 0067 | yes | 17.4625
12956500 | 1.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 1.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0075 | 0075 | yes | 17.4625
12966000 | 3.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0088 | 0088 | yes | 17.4625
12966621 | 4.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 4.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0095 | 0095 | yes | 17.4625
12969020 | 3.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 3.NP_SO-102 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0131 | 0131 | yes | 17.4625
12971240 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0137 | 0137 | yes | 17.4625
12971298 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0147 | 0147 | yes | 17.4625
12995075 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0183 | 0183 | no | 17.4625
12995229 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0186 | 0186 | no | 17.4625
12995771 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0192 | 0192 | no | 17.4625
12996033 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0197 | 0197 | no | 17.4625
13003589 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0282 | 0282 | yes | 17.4625
13003699 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0286 | 0286 | yes | 17.4625
13003811 | 1.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0291 | 0291 | yes | 17.4625
13003921 | 1.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 1.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0301 | 0301 | yes | 17.4625
13013928 | 1.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0389 | 0389 | yes | 17.4625
13014020 | 1.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 1.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0391 | 0391 | yes | 17.4625
13014513 | 1.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 1.NP_SO-102 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0396 | 0396 | yes | 17.4625
13015038 | 4.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0404 | 0404 | yes | 17.4625
13015899 | 3.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0417 | 0417 | yes | 17.4625
13015998 | 4.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0420 | 0420 | yes | 17.4625
13018603 | 4.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 4.NP_SO-102 | 3290.78 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0422 | 0422 | yes | 17.4625
13018612 | 4.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 4.NP_SO-102 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0425 | 0425 | yes | 17.4625
13020886 | -1.PP_SO-102 | ø63 mm-ø63 mm-ø63 mm | -1.PP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 31.5 | 63 | 0.000375825 | 45.7875 | ø63-ø63-ø63 | 26.47 | 66.175 | TT00.03.0427 | 0427 | yes | 33.0875
13022585 | -1.PP_SO-102 | ø32 mm-ø32 mm-ø32 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0430 | 0430 | yes | 17.4625
13025190 | 4.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0445 | 0445 | yes | 17.4625
13025661 | 4.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0454 | 0454 | yes | 17.4625
13025693 | 4.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0456 | 0456 | yes | 17.4625
13026542 | 4.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0461 | 0461 | yes | 17.4625
13026753 | 4.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0465 | 0465 | yes | 17.4625
13028550 | 4.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0486 | 0486 | yes | 17.4625
13030378 | 3.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0496 | 0496 | yes | 17.4625
13030430 | 3.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0505 | 0505 | yes | 17.4625
13030436 | 3.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0507 | 0507 | yes | 17.4625
13030462 | 3.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0511 | 0511 | yes | 17.4625
13030474 | 3.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0515 | 0515 | yes | 17.4625
13030664 | 3.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0531 | 0531 | yes | 17.4625
13030785 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0540 | 0540 | yes | 17.4625
13030837 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0549 | 0549 | yes | 17.4625
13030843 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0551 | 0551 | yes | 17.4625
13030869 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0555 | 0555 | yes | 17.4625
13030881 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0559 | 0559 | yes | 17.4625
13031071 | 2.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0577 | 0577 | yes | 17.4625
13031194 | 1.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0586 | 0586 | yes | 17.4625
13031246 | 1.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0595 | 0595 | yes | 17.4625
13031252 | 1.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 1.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0597 | 0597 | yes | 17.4625
13031278 | 1.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 1.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0601 | 0601 | yes | 17.4625
13031571 | 3.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0615 | 0615 | yes | 17.4625
13031603 | 3.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0616 | 0616 | yes | 17.4625
13032177 | 4.NP_SO-102 | ø32 mm-ø32 mm-ø32 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0628 | 0628 | yes | 17.4625
13036060 | -1.PP_SO-102 | ø32 mm-ø32 mm-ø32 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0688 | 0688 | yes | 17.4625
13048237 | -1.PP_SO-102 | ø63 mm-ø63 mm-ø63 mm | -1.PP_SO-102 | 3226.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000375825 | 45.7875 | ø63-ø63-ø63 | 26.47 | 66.175 | TT00.03.0712 | 0712 | yes | 33.0875
13048365 | -1.PP_SO-102 | ø63 mm-ø63 mm-ø63 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 31.5 | 63 | 0.000375825 | 45.7875 | ø63-ø63-ø63 | 26.47 | 66.175 | TT00.03.0715 | 0715 | yes | 33.0875
13074608 | -1.PP_SO-102 | ø63 mm-ø63 mm-ø63 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 31.5 | 63 | 0.000375825 | 45.7875 | ø63-ø63-ø63 | 26.47 | 66.175 | TT00.03.0764 | 0764 | yes | 33.0875
13074654 | -1.PP_SO-102 | ø63 mm-ø63 mm-ø63 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 31.5 | 63 | 0.000375825 | 45.7875 | ø63-ø63-ø63 | 26.47 | 66.175 | TT00.03.0766 | 0766 | yes | 33.0875
13074779 | -1.PP_SO-102 | ø32 mm-ø32 mm-ø32 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT00.03.0768 | 0768 | yes | 17.4625
