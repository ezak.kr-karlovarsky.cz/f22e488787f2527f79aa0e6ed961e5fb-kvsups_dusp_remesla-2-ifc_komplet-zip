Properties of the parts of a building model (IFC4), part 34 of 60

# IfcPipeFitting: M_Koleno, obecné:Standardní (1248)
Name (M_Koleno, obecné:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm) | Group
13807511 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1774 | 1774 | yes | 33.3375 | 26.9875 | WS_"Jiný typ" studená vnitřní 1
13807614 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1775 | 1775 | yes | 33.3375 | 26.9875 | WS_"Jiný typ" studená vnitřní 1
13807622 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1776 | 1776 | yes | 33.3375 | 26.9875 | WS_"Jiný typ" studená vnitřní 1
13807626 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1777 | 1777 | yes | 33.3375 | 26.9875 | WS_"Jiný typ" studená vnitřní 1
13807653 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 3226.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1778 | 1778 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
13807661 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1779 | 1779 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
13807665 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1780 | 1780 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
13807693 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1781 | 1781 | yes | 26.9875 | 20.6375 | WS_Cirkulace vnitřní 9
13807701 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1782 | 1782 | yes | 26.9875 | 20.6375 | WS_Cirkulace vnitřní 9
13807705 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1783 | 1783 | yes | 26.9875 | 20.6375 | WS_Cirkulace vnitřní 9
13807730 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1784 | 1784 | yes | 39.4375 | 33.0875 | WS_Teplá vnitřní 83
13807738 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1785 | 1785 | yes | 39.4375 | 33.0875 | WS_Teplá vnitřní 83
13807742 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1786 | 1786 | yes | 39.4375 | 33.0875 | WS_Teplá vnitřní 83
13807766 | -1.PP_SO-102 | ø42 mm-ø42 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 21 | 42 | 0.0000728541 | 28.9375 | 90 | ø42-ø42 | 18.07 | 45.175 | TT01.02.1787 | 1787 | yes | 28.9375 | 22.5875 | WS_Požární zavodněný 1
13807778 | -1.PP_SO-102 | ø42 mm-ø42 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 21 | 42 | 0.0000728541 | 28.9375 | 90 | ø42-ø42 | 18.07 | 45.175 | TT01.02.1789 | 1789 | yes | 28.9375 | 22.5875 | WS_Požární zavodněný 1
13808043 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1790 | 1790 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13808076 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1791 | 1791 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13808151 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1792 | 1792 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13808159 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1793 | 1793 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13808268 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 1300 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1794 | 1794 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13808367 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1796 | 1796 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13808375 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1797 | 1797 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13808377 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1798 | 1798 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13808526 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1800 | 1800 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13817238 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 3146.36 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000381558 | 46.9375 | 89.9999 | ø78-ø78 | 32.47 | 81.175 | TT01.02.1801 | 1801 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13817596 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 3135.65 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190737 | 19.4376 | 44.9905 | ø78-ø78 | 13.4464 | 81.175 | TT01.02.1802 | 1802 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13817623 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 3140.05 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000185919 | 18.8946 | 43.8542 | ø78-ø78 | 13.0707 | 81.175 | TT01.02.1803 | 1803 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13817648 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 3350.61 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.1804 | 1804 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13817652 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 3137.63 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0082 | 88.8543 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.1805 | 1805 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13818869 | 1.NP_SO-102 | ø58 mm-ø58 mm | 1.NP_SO-102 | 3090.14 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 29 | 58 | 0.0000852662 | 15.3 | 45 | ø58-ø58 | 10.1358 | 61.175 | TT01.02.1806 | 1806 | yes | 36.9375 | 30.5875 | SW_Splašky vnitřní gravitační 35 (1)
13822818 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000274808 | 21.7203 | 45 | ø89-ø89 | 15.2721 | 92.175 | TT01.02.1808 | 1808 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13822868 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2500 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1809 | 1809 | yes | 39.4375 | 33.0875 | WS_"Jiný typ" studená vnitřní 1
13822902 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1810 | 1810 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
13822963 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1811 | 1811 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 83
13823017 | -1.PP_SO-102 | ø42 mm-ø42 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 21 | 42 | 0.0000728541 | 28.9375 | 90 | ø42-ø42 | 18.07 | 45.175 | TT01.02.1812 | 1812 | yes | 28.9375 | 22.5875 | WS_Požární zavodněný 1
13823025 | -1.PP_SO-102 | ø42 mm-ø42 mm | -1.PP_SO-102 | 2500 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 21 | 42 | 0.0000728541 | 28.9375 | 90 | ø42-ø42 | 18.07 | 45.175 | TT01.02.1813 | 1813 | yes | 28.9375 | 22.5875 | WS_Požární zavodněný 1
13823029 | -1.PP_SO-102 | ø42 mm-ø42 mm | -1.PP_SO-102 | 2500 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 21 | 42 | 0.0000728541 | 28.9375 | 90 | ø42-ø42 | 18.07 | 45.175 | TT01.02.1814 | 1814 | yes | 28.9375 | 22.5875 | WS_Požární zavodněný 1
13823054 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1815 | 1815 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 83
13823062 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 2500 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1816 | 1816 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 83
13823066 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 2500 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1817 | 1817 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 83
13823091 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1818 | 1818 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9
13823099 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 2500 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1819 | 1819 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9
13823103 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 2500 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1820 | 1820 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9
13823127 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1821 | 1821 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
13823135 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1822 | 1822 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
13823139 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1823 | 1823 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
13823172 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2500 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1824 | 1824 | yes | 39.4375 | 33.0875 | WS_"Jiný typ" studená vnitřní 1
13823200 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000274808 | 21.7203 | 45 | ø89-ø89 | 15.2721 | 92.175 | TT01.02.1825 | 1825 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13823208 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 2500 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000274808 | 21.7203 | 45 | ø89-ø89 | 15.2721 | 92.175 | TT01.02.1826 | 1826 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13823212 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 2500 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000274808 | 21.7203 | 45 | ø89-ø89 | 15.2721 | 92.175 | TT01.02.1827 | 1827 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13823422 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 2500 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1828 | 1828 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13823511 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 2500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1831 | 1831 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13823667 | -1.PP_SO-102 | ø20 mm-ø20 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1835 | 1835 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13824405 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 3000 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1836 | 1836 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
13824507 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 3000 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1837 | 1837 | yes | 26.9875 | 20.6375 | WS_Cirkulace vnitřní 9
13824588 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 3000 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1838 | 1838 | yes | 39.4375 | 33.0875 | WS_Teplá vnitřní 83
13824860 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 3000 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1839 | 1839 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
13824864 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2519.53 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1840 | 1840 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
13824900 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 3000 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1841 | 1841 | yes | 26.9875 | 20.6375 | WS_Cirkulace vnitřní 9
13824938 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 3000 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1842 | 1842 | yes | 39.4375 | 33.0875 | WS_Teplá vnitřní 83
13824942 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2519.53 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1843 | 1843 | yes | 39.4375 | 33.0875 | WS_Teplá vnitřní 83
13825057 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 2519.53 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1844 | 1844 | yes | 26.9875 | 20.6375 | WS_Cirkulace vnitřní 9
13825233 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 2400 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1845 | 1845 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13825285 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1846 | 1846 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13825289 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1847 | 1847 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13825604 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 3100 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1848 | 1848 | yes | 26.9875 | 20.6375 | WS_Teplá vnitřní 83
13825643 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 3100 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1850 | 1850 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9
13825665 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 3100 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1851 | 1851 | yes | 26.9875 | 20.6375 | WS_Studená vnitřní 134
13825705 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3100 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1853 | 1853 | yes | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
13826849 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1855 | 1855 | yes | 20.6375 | 14.2875 | WS_Požární zavodněný 3
13826857 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3225.24 | Fáze 2 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1856 | 1856 | yes | 20.6375 | 14.2875 | WS_Požární zavodněný 3 | Mechanické – tok - Tlaková ztráta: 0 Pa
13826859 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3225.24 | Fáze 2 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 3 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1857 | 1857 | yes | 20.6375 | 14.2875 | WS_Požární zavodněný 3
13826907 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 2649.95 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1858 | 1858 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13826915 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3225.59 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1859 | 1859 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13826917 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3225.59 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1860 | 1860 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13826954 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 2649.8 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1861 | 1861 | yes | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13826962 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3225.94 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1862 | 1862 | yes | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13826964 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3225.94 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1863 | 1863 | yes | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13827011 | -1.PP_SO-102 | ø20 mm-ø20 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1864 | 1864 | yes | 17.4625 | 11.1125 | WS_"ŠEDÁ" studená vnitřní 2
13827019 | -1.PP_SO-102 | ø20 mm-ø20 mm | -1.PP_SO-102 | 3225.94 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1865 | 1865 | yes | 17.4625 | 11.1125 | WS_"ŠEDÁ" studená vnitřní 2
13827021 | -1.PP_SO-102 | ø20 mm-ø20 mm | -1.PP_SO-102 | 3225.94 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1866 | 1866 | yes | 17.4625 | 11.1125 | WS_"ŠEDÁ" studená vnitřní 2
13827085 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1867 | 1867 | yes | 26.9875 | 20.6375 | WS_"Jiný typ" studená vnitřní 1
13827095 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1868 | 1868 | yes | 26.9875 | 20.6375 | WS_"Jiný typ" studená vnitřní 1
13827122 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1869 | 1869 | yes | 33.3375 | 26.9875 | WS_Studená vnitřní 134
13827132 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1870 | 1870 | yes | 33.3375 | 26.9875 | WS_Studená vnitřní 134
13827159 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1871 | 1871 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9
13827169 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1872 | 1872 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9
13827192 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1873 | 1873 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 83
13827202 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1874 | 1874 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 83
13827229 | -1.PP_SO-102 | ø35 mm-ø35 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 17.5 | 35 | 0.000045733 | 25.4375 | 90 | ø35-ø35 | 15.27 | 38.175 | TT01.02.1875 | 1875 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 1
13827239 | -1.PP_SO-102 | ø35 mm-ø35 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 17.5 | 35 | 0.000045733 | 25.4375 | 90 | ø35-ø35 | 15.27 | 38.175 | TT01.02.1876 | 1876 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 1 | Identifikační data - Komentáře: ZAVÍČKOVÁNO
13828715 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 3300.54 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 16 | 32 | 0.0000358143 | 23.7937 | 89.9548 | ø32-ø32 | 13.959 | 34.925 | TT01.02.1879 | 1879 | yes | 23.8125 | 17.4625 | WS_"Jiný typ" studená vnitřní 1
13828832 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1882 | 1882 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13828963 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1885 | 1885 | yes | 26.9875 | 20.6375 | WS_Teplá vnitřní 83
13829217 | -1.PP_SO-102 | ø35 mm-ø35 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 17.5 | 35 | 0.000045733 | 25.4375 | 90 | ø35-ø35 | 15.27 | 38.175 | TT01.02.1887 | 1887 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 1
13829221 | -1.PP_SO-102 | ø35 mm-ø35 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 17.5 | 35 | 0.000045733 | 25.4375 | 90 | ø35-ø35 | 15.27 | 38.175 | TT01.02.1888 | 1888 | yes | 25.4375 | 19.0875 | WS_Požární zavodněný 1
13829353 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1892 | 1892 | yes | 26.9875 | 20.6375 | WS_Studená vnitřní 134
13830469 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1895 | 1895 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13830520 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1898 | 1898 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13830808 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1899 | 1899 | yes | 33.3375 | 26.9875 | WS_Studená vnitřní 134
13830849 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1900 | 1900 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 83
13831116 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1901 | 1901 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13831139 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1902 | 1902 | yes | 33.3375 | 26.9875 | WS_Studená vnitřní 134
13831168 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1903 | 1903 | yes | 26.9875 | 20.6375 | WS_"Jiný typ" studená vnitřní 1
13832146 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2900 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1905 | 1905 | yes | 39.4375 | 33.0875 | WS_Teplá vnitřní 83
13832156 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1906 | 1906 | yes | 39.4375 | 33.0875 | WS_Teplá vnitřní 83
13832184 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 2900 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1907 | 1907 | yes | 26.9875 | 20.6375 | WS_Cirkulace vnitřní 9
13832192 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 3350 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1908 | 1908 | yes | 26.9875 | 20.6375 | WS_Cirkulace vnitřní 9
13832196 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 3350 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1909 | 1909 | yes | 26.9875 | 20.6375 | WS_Cirkulace vnitřní 9
13832221 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2900 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1910 | 1910 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
13832231 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1911 | 1911 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
13833173 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 1000 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1916 | 1916 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13833183 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 2900 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1917 | 1917 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13833236 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 1000 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1918 | 1918 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13833246 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 2900 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1919 | 1919 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13835340 | 1.NP_SO-102 | ø32 mm-ø32 mm | 1.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1920 | 1920 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 8
13835358 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1921 | 1921 | yes | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13835831 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 500 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1925 | 1925 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13835900 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 500 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1927 | 1927 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13836085 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 500 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1929 | 1929 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
13836116 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1931 | 1931 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
13836301 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 2900 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1933 | 1933 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13836311 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 2900 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1934 | 1934 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13836339 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1935 | 1935 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
13836349 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 500 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1936 | 1936 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
13836400 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 2900 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1937 | 1937 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13836441 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 2900 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1938 | 1938 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13836462 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 2900 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1939 | 1939 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13836772 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 2900 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1941 | 1941 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13836793 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 2900 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1943 | 1943 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
13837024 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3225.59 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1944 | 1944 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13837026 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3225.59 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1945 | 1945 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 8
13837045 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3225.94 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1946 | 1946 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13837047 | -1.PP_SO-102 | ø25 mm-ø25 mm | -1.PP_SO-102 | 3225.94 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1947 | 1947 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 6
13837458 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2758.68 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497142 | 26.0635 | 44.9905 | ø110-ø110 | 18.7471 | 113.175 | TT01.02.1948 | 1948 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13837944 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2972.13 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.1949 | 1949 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13838019 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 3861.21 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.1950 | 1950 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13838149 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 3212.41 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.1951 | 1951 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13838256 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 3452.32 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.1952 | 1952 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13838581 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 3671.68 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.1953 | 1953 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13838585 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 3668.03 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.0004873 | 25.4922 | 44.0998 | ø110-ø110 | 18.3362 | 113.175 | TT01.02.1954 | 1954 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1)
13839803 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2519.53 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1955 | 1955 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
13839892 | -1.PP_SO-102 | ø40 mm-ø40 mm | -1.PP_SO-102 | 2519.53 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.1957 | 1957 | yes | 26.9875 | 20.6375 | WS_Cirkulace vnitřní 9
13840007 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2519.53 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1961 | 1961 | yes | 39.4375 | 33.0875 | WS_Teplá vnitřní 83
13840137 | -1.PP_SO-102 | ø42 mm-ø42 mm | -1.PP_SO-102 | 2410 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 21 | 42 | 0.0000728541 | 28.9375 | 90 | ø42-ø42 | 18.07 | 45.175 | TT01.02.1962 | 1962 | yes | 28.9375 | 22.5875 | WS_Požární zavodněný 1
13840145 | -1.PP_SO-102 | ø42 mm-ø42 mm | -1.PP_SO-102 | 2900 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 21 | 42 | 0.0000728541 | 28.9375 | 90 | ø42-ø42 | 18.07 | 45.175 | TT01.02.1963 | 1963 | yes | 28.9375 | 22.5875 | WS_Požární zavodněný 1
13840149 | -1.PP_SO-102 | ø42 mm-ø42 mm | -1.PP_SO-102 | 2900 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 21 | 42 | 0.0000728541 | 28.9375 | 90 | ø42-ø42 | 18.07 | 45.175 | TT01.02.1964 | 1964 | yes | 28.9375 | 22.5875 | WS_Požární zavodněný 1
13840176 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 2410 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1965 | 1965 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 83
13840186 | -1.PP_SO-102 | ø50 mm-ø50 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.1966 | 1966 | yes | 33.3375 | 26.9875 | WS_Teplá vnitřní 83
13840211 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1967 | 1967 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9
13840219 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1968 | 1968 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9
13840223 | -1.PP_SO-102 | ø32 mm-ø32 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.1969 | 1969 | yes | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9
13840248 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1970 | 1970 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
13840258 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2800 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1971 | 1971 | yes | 39.4375 | 33.0875 | WS_Studená vnitřní 134
13840280 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1972 | 1972 | yes | 39.4375 | 33.0875 | WS_"Jiný typ" studená vnitřní 1
13840288 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1973 | 1973 | yes | 39.4375 | 33.0875 | WS_"Jiný typ" studená vnitřní 1
13840292 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1974 | 1974 | yes | 39.4375 | 33.0875 | WS_"Jiný typ" studená vnitřní 1
13840319 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 2400 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1975 | 1975 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13840327 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1976 | 1976 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13840329 | -1.PP_SO-102 | ø89 mm-ø89 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | WS_Požární nezavodněný 1 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.02.1977 | 1977 | yes | 52.4375 | 46.0875 | WS_Požární nezavodněný 1
13840869 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 3178.12 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 11 | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.1978 | 1978 | no | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 11
13840882 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2252.22 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 11 | 55 | 110 | 0.000998125 | 63.2983 | 90.3275 | ø110-ø110 | 45.5295 | 113.175 | TT01.02.1979 | 1979 | no | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 11
13840887 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2252.31 | Fáze 2 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 11 | 55 | 110 | 0.000994385 | 62.9256 | 89.9891 | ø110-ø110 | 45.2614 | 113.175 | TT01.02.1980 | 1980 | no | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 11
13859227 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | -2519.66 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.0014015 | 35.2331 | 43.6681 | ø160-ø160 | 26.1511 | 163.175 | TT01.02.1981 | 1981 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3
13916173 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1984 | 1984 | yes | 39.4375 | 33.0875 | WS_"Jiný typ" studená vnitřní 1
13916177 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.1985 | 1985 | yes | 39.4375 | 33.0875 | WS_"Jiný typ" studená vnitřní 1
13976077 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1988 | 1988 |  | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13976118 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1990 | 1990 |  | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13976145 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 2800 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1991 | 1991 |  | 20.6375 | 14.2875 | WS_"ŠEDÁ" studená vnitřní 2
13976153 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1992 | 1992 | yes | 20.6375 | 14.2875 | WS_"ŠEDÁ" studená vnitřní 2
13976155 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.1993 | 1993 |  | 20.6375 | 14.2875 | WS_"ŠEDÁ" studená vnitřní 2
13976198 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1994 | 1994 |  | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13976204 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 2800 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1995 | 1995 |  | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13976208 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 2800 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1996 | 1996 |  | 17.4625 | 11.1125 | WS_Teplá vnitřní 8
13976251 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1997 | 1997 |  | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13976257 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 2800 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1998 | 1998 |  | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13976261 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 2800 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.1999 | 1999 |  | 17.4625 | 11.1125 | WS_Studená vnitřní 6
13976304 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 2800 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.2000 | 2000 |  | 20.6375 | 14.2875 | WS_"ŠEDÁ" studená vnitřní 2
13976310 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.2001 | 2001 | no | 20.6375 | 14.2875 | WS_"ŠEDÁ" studená vnitřní 2
13976312 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.2002 | 2002 |  | 20.6375 | 14.2875 | WS_"ŠEDÁ" studená vnitřní 2
13981921 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -1304.18 | Fáze 1 | SW_Deště čerpání | Sanitární | SW_Deště čerpání 1 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.2005 | 2005 | yes | 62.9375 | 56.5875 | SW_Deště čerpání 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13981953 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -1304.18 | Fáze 1 | SW_Deště čerpání | Sanitární | SW_Deště čerpání 1 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.2006 | 2006 | yes | 62.9375 | 56.5875 | SW_Deště čerpání 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13982052 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -2851.56 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 2 | 55 | 110 | 0.000447899 | 23.2402 | 40.5342 | ø110-ø110 | 16.7163 | 113.175 | TT01.02.2007 | 2007 |  | 62.9375 | 56.5875 | SW_Deště vnitřní gravitační 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13982061 | -1.PP_SO-102 | ø125 mm-ø125 mm | -1.PP_SO-102 | -2850.2 | Fáze 1 | SW_Deště vnitřní gravitační | Sanitární | SW_Deště vnitřní gravitační 2 | 62.5 | 125 | 0.000672647 | 26.3813 | 40.5375 | ø125-ø125 | 19.229 | 130.175 | TT01.02.2009 | 2009 |  | 71.4375 | 65.0875 | SW_Deště vnitřní gravitační 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13982191 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | -1304.18 | Fáze 1 | SW_Deště čerpání | Sanitární | SW_Deště čerpání 1 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.2010 | 2010 | yes | 62.9375 | 56.5875 | SW_Deště čerpání 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13982195 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2980 | Fáze 1 | SW_Deště čerpání | Sanitární | SW_Deště čerpání 1 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.2011 | 2011 | yes | 62.9375 | 56.5875 | SW_Deště čerpání 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13982572 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2980 | Fáze 1 | SW_Deště čerpání | Sanitární | SW_Deště čerpání 1 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.2012 | 2012 | yes | 62.9375 | 56.5875 | SW_Deště čerpání 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13982636 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 2980 | Fáze 1 | SW_Deště čerpání | Sanitární | SW_Deště čerpání 1 | 55 | 110 | 0.000994506 | 62.9375 | 90 | ø110-ø110 | 45.27 | 113.175 | TT01.02.2013 | 2013 | yes | 62.9375 | 56.5875 | SW_Deště čerpání 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13986471 | -1.PP_SO-102 | ø75 mm-ø75 mm | -1.PP_SO-102 | 3226.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 37.5 | 75 | 0.000342568 | 45.4375 | 90 | ø75-ø75 | 31.27 | 78.175 | TT01.02.2016 | 2016 | yes | 45.4375 | 39.0875 | WS_Studená vnitřní 134
13986502 | -1.PP_SO-102 | ø54 mm-ø54 mm | -1.PP_SO-102 | 3225.24 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 27 | 54 | 0.000140897 | 34.9375 | 90 | ø54-ø54 | 22.87 | 57.175 | TT01.02.2017 | 2017 | yes | 34.9375 | 28.5875 | WS_Požární zavodněný 1
13986513 | -1.PP_SO-102 | ø54 mm-ø54 mm | -1.PP_SO-102 | 2808.31 | Fáze 1 | WS_Požární zavodněný | Požární ochrana – vodní prostředky | WS_Požární zavodněný 1 | 27 | 54 | 0.000140897 | 34.9375 | 90 | ø54-ø54 | 22.87 | 57.175 | TT01.02.2018 | 2018 | yes | 34.9375 | 28.5875 | WS_Požární zavodněný 1
13986520 | -1.PP_SO-102 | ø75 mm-ø75 mm | -1.PP_SO-102 | 2896.63 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 37.5 | 75 | 0.000342568 | 45.4375 | 90 | ø75-ø75 | 31.27 | 78.175 | TT01.02.2019 | 2019 | yes | 45.4375 | 39.0875 | WS_Studená vnitřní 134
13986524 | -1.PP_SO-102 | ø75 mm-ø75 mm | -1.PP_SO-102 | 2896.63 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 37.5 | 75 | 0.000342568 | 45.4375 | 90 | ø75-ø75 | 31.27 | 78.175 | TT01.02.2020 | 2020 | yes | 45.4375 | 39.0875 | WS_Studená vnitřní 134
13986530 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 2896.63 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.2021 | 2021 | yes | 39.4375 | 33.0875 | WS_"Jiný typ" studená vnitřní 1
13986532 | -1.PP_SO-102 | ø63 mm-ø63 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 31.5 | 63 | 0.000213056 | 39.4375 | 90 | ø63-ø63 | 26.47 | 66.175 | TT01.02.2022 | 2022 | yes | 39.4375 | 33.0875 | WS_"Jiný typ" studená vnitřní 1
13986609 | -1.PP_SO-102 | ø75 mm-ø75 mm | -1.PP_SO-102 | 500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 37.5 | 75 | 0.000342568 | 45.4375 | 90 | ø75-ø75 | 31.27 | 78.175 | TT01.02.2023 | 2023 | yes | 45.4375 | 39.0875 | WS_Studená vnitřní 134
13993144 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | -585.875 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.0008884 | 31.2473 | 45.0001 | ø135-ø135 | 22.8937 | 138.175 | TT01.02.2025 | 2025 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1)
13993160 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | -878.558 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.000865778 | 30.3672 | 43.8542 | ø135-ø135 | 22.2488 | 138.175 | TT01.02.2026 | 2026 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1)
13993274 | 2.NP_SO-102 | ø135 mm-ø135 mm | 2.NP_SO-102 | -940.264 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 67.5 | 135 | 0.000888212 | 31.24 | 44.9906 | ø135-ø135 | 22.8883 | 138.175 | TT01.02.2027 | 2027 | yes | 75.4375 | 69.0875 | SW_Splašky vnitřní gravitační 35 (1)
13993466 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | -717.444 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000190777 | 19.4421 | 45 | ø78-ø78 | 13.4495 | 81.175 | TT01.02.2028 | 2028 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1)
13993525 | -1.PP_SO-102 | ø110 mm-ø110 mm | -1.PP_SO-102 | 7280.8 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.2031 | 2031 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
