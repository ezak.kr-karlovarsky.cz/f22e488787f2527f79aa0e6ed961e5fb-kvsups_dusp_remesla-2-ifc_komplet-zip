Properties of the parts of a building model (IFC4), part 14 of 60

# IfcDistributionPort (11856)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_12996644_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12999786_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12996669_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12999816_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12996669_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12999818_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12996671_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12999741_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12996671_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12999766_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12996671_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12999816_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12996675_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12999818_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12996675_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12999796_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12996752_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13000258_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12996752_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12996764_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12996754_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12999768_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12996754_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13347287_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12996754_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13000258_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12996755_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402489_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12996755_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13347289_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12996762_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473818_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12996764_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13000250_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12996785_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13000265_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12996785_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13000267_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12996787_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12999777_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12996787_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13347295_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12996787_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13000265_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12996788_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13402505_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12996788_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13347297_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12996795_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473803_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12996797_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13000267_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12997245_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997363_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997360_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997443_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997360_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997447_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997363_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997969_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997440_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997447_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997440_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997443_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997970_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997443_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997712_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997447_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997448_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997448_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997645_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13484700_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997645_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12998027_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997712_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997767_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997767_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13000982_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997767_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13080145_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997768_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13484698_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997768_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13000982_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997772_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13080210_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997772_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997961_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997969_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997961_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997979_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997969_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997970_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997973_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997979_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997973_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12998001_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997981_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12998001_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12997981_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12998016_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12998075_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12998016_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12998027_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13000984_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12998069_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12998071_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12998069_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12998075_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12998071_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13000984_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12998071_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_14025072_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12998152_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13573396_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12998152_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13573408_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12998181_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473990_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12998181_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473996_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12998202_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13402161_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12998202_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12998229_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_14025072_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12998229_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_14025074_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12998315_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_14024895_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_12998349_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13401998_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12998424_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402181_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12998424_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12998581_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12998881_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12998581_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12999741_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12998824_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12999731_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12998824_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12998828_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12998826_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13083352_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12998828_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13083348_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12998828_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13083350_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12998828_4 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13083352_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12998848_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12998879_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12998877_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646856_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12998877_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12998879_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13083354_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12998881_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646856_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12998881_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646888_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12998881_4 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13083354_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_12999007_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_12999454_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_12999458_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_12999007_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12999016_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13083370_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_12999057_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_13083372_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_12999454_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_12999057_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12999059_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13083370_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12999059_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12999060_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_13083372_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_12999059_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_12999095_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12999193_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12999095_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12999104_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13083374_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12999181_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13083376_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12999181_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12999193_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12999183_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13083374_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12999183_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12999184_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12999183_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13083376_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12999936_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13000006_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_12999936_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13000000_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13000002_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13000000_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13000006_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13000002_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13000215_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13000002_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13000003_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13000003_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473806_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13000025_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13000078_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13000025_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13000072_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13000074_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13000072_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13000078_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13000074_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13000226_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13000074_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13000075_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13000075_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473821_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13000215_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473917_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13000226_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473896_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13000328_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13402542_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13000546_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13402207_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13000564_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13401936_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13000580_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13464830_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13000594_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14024838_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13000748_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_14024984_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13000748_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13000796_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13000796_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13704886_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13001416_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13001622_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13001416_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13001600_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13001620_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13001600_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13001622_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13001612_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13070191_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13001612_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13001613_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13001612_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13001620_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13001613_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13011334_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13001967_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13012640_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003331_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13646513_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003331_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13011799_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003335_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003379_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003335_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003337_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003339_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003337_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13646431_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003339_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005982_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003341_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13646515_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003341_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13533568_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003355_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004836_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003355_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005088_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003365_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003375_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003365_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13015907_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003375_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003379_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004420_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003379_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13011800_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003413_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646484_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003413_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646496_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003421_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005951_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003421_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13011777_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003423_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646484_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003423_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003427_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003427_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005953_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003445_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13957992_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003445_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003447_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004454_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003447_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13011778_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003447_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13957992_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003455_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13015237_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003455_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13015396_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003465_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646320_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003465_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13356061_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003467_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004951_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003467_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005156_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003475_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646329_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003475_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003477_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646329_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003477_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646341_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003551_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13008586_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003551_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13008360_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003555_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13509253_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003555_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003557_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003559_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003557_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003569_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003559_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13008632_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003569_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13646007_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003571_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13645148_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003571_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13573436_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003585_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13007475_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003585_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003595_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003587_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13007473_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003587_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13573436_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003589_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13007473_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003589_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003590_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003589_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13007475_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003590_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13008630_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003595_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003633_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13532767_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003633_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003645_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003637_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003638_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003637_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13015529_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003637_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13532767_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003638_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13015482_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003641_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13008606_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003641_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13008387_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003643_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003645_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003643_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13008383_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003665_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13509257_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003665_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003668_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13008276_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003668_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13509257_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003675_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13015480_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003675_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13015490_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003679_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003717_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003679_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13573456_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003683_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13573454_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003683_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13573456_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003687_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14017545_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003687_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003695_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003703_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003695_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003697_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003709_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003697_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003703_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003699_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003717_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003699_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003700_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003699_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003709_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003700_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13008646_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003773_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13010560_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003773_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13533277_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003775_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13144309_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003775_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13009405_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003777_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13336484_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003777_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003779_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003781_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003779_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13533256_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003781_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13010746_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003789_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13533256_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003789_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13533258_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003793_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13425926_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003793_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13643546_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003797_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13643546_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003797_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13643520_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003807_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13007462_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003807_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003817_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003809_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13007460_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003809_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13425926_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003811_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13007460_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003811_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003812_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003811_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13007462_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003812_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13010744_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003817_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003819_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003822_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003819_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13010562_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003821_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13144309_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003821_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003822_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003821_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13336484_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13003855_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003859_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003855_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003867_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003859_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003860_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003859_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13533522_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003860_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13015528_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003863_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13010578_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003863_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003873_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003865_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13015598_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003865_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003869_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003867_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13015598_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003869_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13010580_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003871_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13533764_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003871_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13533806_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003873_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003890_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003887_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13336461_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003887_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003889_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13533764_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003889_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003890_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003889_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13336461_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003897_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13015526_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003897_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13015536_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003901_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003939_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003901_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003907_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003905_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003907_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003905_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13008948_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003909_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13008948_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003909_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13009764_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003917_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003925_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003917_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003919_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003931_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003919_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003925_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003921_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003939_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003921_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003922_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003921_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003931_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13003922_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13010762_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004409_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13507194_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004409_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004420_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13507194_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004435_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13507146_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004435_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004454_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13507140_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004527_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004705_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004527_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004547_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004677_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004547_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004671_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004673_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004671_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004677_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004673_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005417_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004673_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13361336_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004699_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004701_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004699_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004705_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004701_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005409_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004701_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13361214_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004770_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004840_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004770_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004834_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004836_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004834_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004840_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004836_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005411_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004837_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005409_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004837_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005411_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13004857_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004955_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004857_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004949_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004951_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004949_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004955_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004951_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005419_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004952_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005417_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13004952_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005419_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005057_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005090_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005057_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005086_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005088_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005086_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005090_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005107_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005158_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005107_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005154_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005156_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005154_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005158_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_13533436_2 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_13005332_0 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_13005332_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
OutPort_13533499_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13005468_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005470_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005495_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005497_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005514_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005516_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005514_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13015999_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005538_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005540_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005641_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13647712_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005641_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13534556_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13070673_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 3
OutPort_13005643_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 3
InPort_13005643_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 3
Port_13005647_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 3
Port_13005657_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 3
Port_13005647_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 3
Port_13005649_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 3
Port_13005655_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 3
Port_13005649_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 3
Port_13005657_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 3
InPort_13005651_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 3
OutPort_13005659_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 3
Port_13005651_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 3
Port_13005651_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 3
Port_13005655_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 3
InPort_13005659_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 3
OutPort_13070640_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 3
Port_13005676_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13643260_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005676_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13533233_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13070732_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13005678_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13005678_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005682_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005692_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005682_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005684_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005690_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005684_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005692_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13005686_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13071131_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005686_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13011257_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005686_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005690_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005709_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13519796_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005709_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13519807_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005715_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005725_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005715_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005717_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005723_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005717_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005725_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13005719_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13071375_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005719_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005720_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005719_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005723_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005720_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13010639_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13005935_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 3
Port_13005935_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 3
Port_13005951_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005953_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13005979_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005982_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13005979_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13015900_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13006126_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13006128_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13006126_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646334_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13006128_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13015237_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13006828_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13533392_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13006828_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13533414_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13007385_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13533621_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13007385_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13533623_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
