Properties of the parts of a building model (IFC4), part 56 of 60

# IfcPipeSegment: Typy trubek:PP_Skolan SAFE dB (426)
Name (Typy trubek:PP_Skolan SAFE dB:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Relativní drsnost | CCI Funkční systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) | Spodní výška (mm) | Střední výška (mm) | Fáze vytvoření | Drsnost (mm) | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Typ systému | Úsek potrubí | Výkaz/typ | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Instalační jednotky | Sklon
13673210 | -1.PP_SO-102 | 331.588 | 0.00950189 | 0.114589 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2988.39 | 2930.08 | 2933.4 | 2875.08 | 2933.4 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1119.62 | PP–SKEM | 110 | 592 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1751 | 1751 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1 | Identifikační data - Komentáře: S18
13673729 | -1.PP_SO-102 | 273.505 | 0.00950189 | 0.0945164 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2897.01 | 2842.02 | 2836.56 | 2781.57 | 2836.56 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1213.14 | PP–SKEM | 110 | 5 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1752 | 1752 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13673738 | -1.PP_SO-102 | 885.21 | 0.00950189 | 0.305907 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2899.04 | 2835.19 | 2844.04 | 2780.19 | 2844.04 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1214.51 | PP–SKEM | 110 | 592 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1753 | 1753 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1 | Identifikační data - Komentáře: S18
13673743 | -1.PP_SO-102 | 4827.05 | 0.00950189 | 1.66811 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2994.58 | 2939.59 | 2843.07 | 2788.08 | 2843.07 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1206.62 | PP–SKEM | 110 | 5 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1754 | 1754 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13675531 | -1.PP_SO-102 | 329.739 | 0.0201032 | 0.165745 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | 3342.52 | 3255.95 | 3262.54 | 3175.96 | 3262.54 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -818.739 | PP–SKEM | 160 | 248 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.1756 | 1756 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2 | Identifikační data - Komentáře: S20
13678921 | 1.NP_SO-102 | 710.992 | 0.0143117 | 0.301543 | ø135 mm | 0.0000803859 | G | 1.NP_SO-102 | 4008.47 | 4008.47 | 3297.48 | 3297.48 | 3297.48 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3297.48 | PP–SKEM | 135 | 619 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1763 | 1763 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
13679011 | 1.NP_SO-102 | 314.802 | 0.0143117 | 0.133512 | ø135 mm | 0.0000803859 | G | 1.NP_SO-102 | 3291.87 | 3021.54 | 3244.14 | 2973.81 | 3244.14 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2977.56 | PP–SKEM | 135 | 619 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1764 | 1764 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13679117 | 2.NP_SO-102 | 853.771 | 0.0143117 | 0.362097 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 176.947 | 109.478 | 83.876 | 16.4064 | 83.876 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 4021.7 | PP–SKEM | 135 | 619 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1765 | 1765 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 3
13680697 | 3.NP_SO-102 | 1132.57 | 0.00950189 | 0.391389 | ø110 mm | 0.000100604 | G | 3.NP_SO-102 | 3368.19 | 3290.58 | 3313.2 | 3235.59 | 3290.58 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11240.9 | PP–SKEM | 110 | 317 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1766 | 1766 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1.99741
13680742 | 4.NP_SO-102 | 2577.04 | 0.0201032 | 1.29536 | ø160 mm | 0.0000669344 | G | 4.NP_SO-102 | 1959.21 | -617.83 | 1959.21 | -617.83 | 1959.21 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11382.2 | PP–SKEM | 160 | 175 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.1767 | 1767 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S6
13680816 | 3.NP_SO-102 | 3801.45 | 0.0201032 | 1.91082 | ø160 mm | 0.0000669344 | G | 3.NP_SO-102 | 3193.59 | -607.852 | 3193.59 | -607.852 | 3193.59 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7392.15 | PP–SKEM | 160 | 313 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.1768 | 1768 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S6
13680853 | 1.NP_SO-102 | 3898.35 | 0.0201032 | 1.95953 | ø160 mm | 0.0000669344 | G | 1.NP_SO-102 | 2969.97 | -928.38 | 2969.97 | -928.38 | 2969.97 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -928.38 | PP–SKEM | 160 | 571 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.1769 | 1769 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S6
13680871 | 2.NP_SO-102 | 4045.02 | 0.0201032 | 2.03325 | ø160 mm | 0.0000669344 | G | 2.NP_SO-102 | 3203.57 | -841.45 | 3203.57 | -841.45 | 3203.57 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3158.55 | PP–SKEM | 160 | 318 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.1770 | 1770 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S6
13681213 | 2.NP_SO-102 | 3560.16 | 0.00477764 | 0.872396 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 2995.31 | 2884.45 | 2956.32 | 2845.46 | 2956.32 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 6849.96 | PP–SKEM | 78 | 550 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1771 | 1771 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2.01907
13681265 | 2.NP_SO-102 | 106.56 | 0.00477764 | 0.0261118 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3132.6 | 3105.02 | 3029.67 | 3002.09 | 3029.67 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7005.27 | PP–SKEM | 78 | 553 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1772 | 1772 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13681276 | 2.NP_SO-102 | 1384.69 | 0.00477764 | 0.339311 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3027.33 | 2960.39 | 2988.34 | 2921.4 | 2988.34 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 6925.9 | PP–SKEM | 78 | 439 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1773 | 1773 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2.01907
13681812 | 2.NP_SO-102 | 726.483 | 0.0143117 | 0.308112 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 3167.5 | 3100 | 3100 | 3032.5 | 3100 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 7037.8 | PP–SKEM | 135 | 116 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1774 | 1774 | yes | SW_Odvětrání kanalizace 16 |  | 0
13681821 | 2.NP_SO-102 | 1841.86 | 0.0143117 | 0.78116 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 2639.81 | 2572.31 | 2572.31 | 2504.81 | 2572.31 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 6510.11 | PP–SKEM | 135 | 136 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1775 | 1775 | yes | SW_Odvětrání kanalizace 16 |  | 0
13681871 | 2.NP_SO-102 | 2137.63 | 0.0143117 | 0.906603 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 3167.5 | 3100 | 3100 | 3032.5 | 3100 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 7037.8 | PP–SKEM | 135 | 46 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1776 | 1776 | yes | SW_Odvětrání kanalizace 16 |  | 0
13682361 | 2.NP_SO-102 | 4312.37 | 0.0143117 | 1.82894 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 3167.5 | 3100 | 3100 | 3032.5 | 3100 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 7037.8 | PP–SKEM | 135 | 122 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1777 | 1777 | yes | SW_Odvětrání kanalizace 16 |  | 0
13682645 | 2.NP_SO-102 | 6722.19 | 0.0143117 | 2.85098 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 3167.5 | 3100 | 3100 | 3032.5 | 3100 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 7037.8 | PP–SKEM | 135 | 121 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1778 | 1778 | yes | SW_Odvětrání kanalizace 16 |  | 0
13682700 | 2.NP_SO-102 | 877.435 | 0.0143117 | 0.372133 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 3125.63 | 2457.46 | 3077.9 | 2409.73 | 3077.9 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 6413.48 | PP–SKEM | 135 | 122 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1779 | 1779 | yes | SW_Odvětrání kanalizace 16 |  | 100
13682777 | 2.NP_SO-102 | 1343.09 | 0.0143117 | 0.569626 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 3167.5 | 3100 | 3100 | 3032.5 | 3100 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 7037.8 | PP–SKEM | 135 | 136 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1780 | 1780 | yes | SW_Odvětrání kanalizace 16 |  | 0
13682906 | 2.NP_SO-102 | 688.072 | 0.0143117 | 0.291822 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 2637.38 | 2103.11 | 2589.65 | 2055.38 | 2589.65 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 6059.12 | PP–SKEM | 135 | 137 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1781 | 1781 | yes | SW_Odvětrání kanalizace 16 |  | 100
13682968 | 2.NP_SO-102 | 683.766 | 0.0143117 | 0.289995 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 3125.63 | 3077.9 | 2594.41 | 2546.68 | 2594.41 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 6550.43 | PP–SKEM | 135 | 136 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1782 | 1782 | yes | SW_Odvětrání kanalizace 16 |  | 100
13683072 | 2.NP_SO-102 | 3804.56 | 0.0143117 | 1.61357 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 3179.38 | 3111.88 | 3111.88 | 3044.38 | 3111.88 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 7049.68 | PP–SKEM | 135 | 121 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1783 | 1783 | yes | SW_Odvětrání kanalizace 16 |  | 0
13683121 | 2.NP_SO-102 | 1964.76 | 0.0143117 | 0.833283 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 2467.5 | 2400 | 2400 | 2332.5 | 2400 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 6337.8 | PP–SKEM | 135 | 121 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1784 | 1784 | yes | SW_Odvětrání kanalizace 16 |  | 0
13683131 | 2.NP_SO-102 | 561 | 0.0143117 | 0.237929 | ø135 mm | 0 | G | 2.NP_SO-102 | 3036.44 | 2475.44 | 3036.44 | 2475.44 | 3036.44 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 6475.44 | PP–SKEM | 135 | 121 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1785 | 1785 | yes | SW_Odvětrání kanalizace 16
13683181 | 2.NP_SO-102 | 549.125 | 0.0143117 | 0.232892 | ø135 mm | 0 | G | 2.NP_SO-102 | 3024.56 | 2475.44 | 3024.56 | 2475.44 | 3024.56 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 6475.44 | PP–SKEM | 135 | 121 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1786 | 1786 | yes | SW_Odvětrání kanalizace 16
13688672 | 4.NP_SO-102 | 15185.6 | 0.0201032 | 7.63311 | ø160 mm | 0.0000669344 | G | 4.NP_SO-102 | 1959.21 | 1959.21 | -13226.4 | -13226.4 | -13226.4 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1226.38 | PP–SKEM | 160 | 1 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.1794 | 1794 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S4
13688751 | -1.PP_SO-102 | 327.201 | 0.0201032 | 0.164469 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | 3063.68 | 2983.7 | 2977.16 | 2897.17 | 2977.16 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1097.53 | PP–SKEM | 160 | 571 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.1795 | 1795 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13688777 | -1.PP_SO-102 | 115.679 | 0.0201032 | 0.0581465 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | 2970.68 | 2832.32 | 2914.12 | 2775.75 | 2832.32 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1220.5 | PP–SKEM | 160 | 571 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.1796 | 1796 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13689997 | -1.PP_SO-102 | 263.92 | 0.00950189 | 0.0912043 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2799.95 | 2574.44 | 2761.06 | 2535.55 | 2761.06 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1460.7 | PP–SKEM | 110 | 574 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1809 | 1809 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13690234 | -1.PP_SO-102 | 1213.19 | 0.00950189 | 0.41925 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2911.69 | 2856.69 | 2844.56 | 2789.57 | 2844.56 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1205.14 | PP–SKEM | 110 | 592 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1810 | 1810 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1 | Identifikační data - Komentáře: S18
13690249 | -1.PP_SO-102 | 5448.42 | 0.00950189 | 1.88284 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2966.69 | 2911.7 | 2857.21 | 2802.22 | 2857.21 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1192.48 | PP–SKEM | 110 | 592 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1811 | 1811 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1 | Identifikační data - Komentáře: S18
13690823 | -1.PP_SO-102 | 8961.61 | 0.00477747 | 2.19599 | ø78 mm | 0.000144928 | G | -1.PP_SO-102 | 3083.01 | 2953.95 | 3044.02 | 2914.95 | 3044.02 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1080.55 | PP–SKEM | 78 | 593 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1812 | 1812 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1.00505 | Identifikační data - Komentáře: S17
13690840 | -1.PP_SO-102 | 223.405 | 0.00477764 | 0.0547442 | ø78 mm | 0.000144928 | G | -1.PP_SO-102 | 3262.99 | 3077.44 | 3235.41 | 3049.86 | 3235.41 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -946.958 | PP–SKEM | 78 | 593 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1813 | 1813 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100 | Identifikační data - Komentáře: S17
13690992 | -1.PP_SO-102 | 537.502 | 0.00477764 | 0.131712 | ø78 mm | 0.000144928 | G | -1.PP_SO-102 | 2992.47 | 2953.47 | 2945.62 | 2906.62 | 2945.62 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1088.88 | PP–SKEM | 78 | 593 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1814 | 1814 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1.46112 | Identifikační data - Komentáře: S17
13704156 | -1.PP_SO-102 | 28.4044 | 0.00950189 | 0.00981587 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2865 | 2810 | 2810 | 2755 | 2810 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | -1239.7 | PP–SKEM | 110 | 127 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1815 | 1815 | yes | SW_Odvětrání kanalizace 16 |  | 0
13704337 | 2.NP_SO-102 | 68.9327 | 0.0143117 | 0.0292354 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 2967.5 | 2900 | 2900 | 2832.5 | 2900 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 6837.8 | PP–SKEM | 135 | 159 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1816 | 1816 | yes | SW_Odvětrání kanalizace 16 |  | 0
13704673 | 2.NP_SO-102 | 7910.73 | 0.0143117 | 3.35506 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 2818.21 | 2818.21 | -5092.52 | -5092.52 | -5092.52 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | -1092.52 | PP–SKEM | 135 | 129 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1817 | 1817 | yes | SW_Odvětrání kanalizace 16 | Identifikační data - Komentáře: S14
13817615 | 1.NP_SO-102 | 259.437 | 0.00477764 | 0.0635736 | ø78 mm | 0.000144928 | F | 1.NP_SO-102 | 3364.44 | 3336.86 | 3153.41 | 3125.84 | 3153.41 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3129.02 | PP–SKEM | 78 | 707 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1874 | 1874 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13840854 | -1.PP_SO-102 | 251.186 | 0.00950189 | 0.0868036 | ø110 mm | 0.000100604 | F | -1.PP_SO-102 | 2244.7 | 2206.59 | 2025.49 | 1987.38 | 2025.49 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 11 | -2008.95 | PP–SKEM | 110 | 100 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2019 | 2019 | no | SW_Splašky vnitřní gravitační 11 | 0 | 104.04
13840858 | -1.PP_SO-102 | 348.556 | 0.00950189 | 0.120452 | ø110 mm | 0.000100604 | F | -1.PP_SO-102 | 2307.3 | 2252.3 | 2252.23 | 2197.23 | 2252.23 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 11 | -1797.47 | PP–SKEM | 110 | 100 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2020 | 2020 | no | SW_Splašky vnitřní gravitační 11 | 0 | 0.0189827
13840867 | -1.PP_SO-102 | 801.193 | 0.00950189 | 0.276873 | ø110 mm | 0.000100604 | F | -1.PP_SO-102 | 3116.43 | 2315.24 | 3116.43 | 2315.24 | 3116.43 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 11 | -1684.76 | PP–SKEM | 110 | 100 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2021 | 2021 | no | SW_Splašky vnitřní gravitační 11 | 0
13993128 | 2.NP_SO-102 | 352.302 | 0.0143117 | 0.149416 | ø135 mm | 0.0000803859 | F | 2.NP_SO-102 | -560.24 | -857.085 | -607.97 | -904.815 | -607.97 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3098.93 | PP–SKEM | 135 | 114 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2059 | 2059 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13993148 | 2.NP_SO-102 | 3024.35 | 0.0143117 | 1.28267 | ø135 mm | 0.0000803859 | F | 2.NP_SO-102 | -811.678 | -939.639 | -879.164 | -1007.13 | -879.164 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2998.17 | PP–SKEM | 135 | 114 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2060 | 2060 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13993407 | 2.NP_SO-102 | 128.461 | 0.00477764 | 0.0314787 | ø78 mm | 0.000144928 | F | 2.NP_SO-102 | -703.615 | -822.028 | -731.192 | -849.605 | -731.192 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3153.58 | PP–SKEM | 78 | 644 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.2061 | 2061 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13993513 | -1.PP_SO-102 | 186.347 | 0.00950189 | 0.064397 | ø110 mm | 0.000100604 | F | -1.PP_SO-102 | 7301.26 | 7130.6 | 7262.37 | 7091.71 | 7262.37 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3095.46 | PP–SKEM | 110 | 91 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2062 | 2062 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13993561 | 1.NP_SO-102 | 406.136 | 0.00950189 | 0.140351 | ø110 mm | 0.000100604 | F | 1.NP_SO-102 | 3084.19 | 3029.2 | 3021.08 | 2966.09 | 3021.08 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2971.39 | PP–SKEM | 110 | 91 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2063 | 2063 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13993571 | 1.NP_SO-102 | 420.631 | 0.0143117 | 0.178396 | ø135 mm | 0.0000803859 | G | 1.NP_SO-102 | 3096.28 | 3020.38 | 3028.79 | 2952.9 | 3028.79 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2958.2 | PP–SKEM | 135 | 641 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2064 | 2064 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1.99964
13993575 | 1.NP_SO-102 | 4097.84 | 0.00950189 | 1.41611 | ø110 mm | 0.000100604 | F | 1.NP_SO-102 | 3167.17 | 3112.18 | 3030.24 | 2975.25 | 3030.24 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2980.55 | PP–SKEM | 110 | 91 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2065 | 2065 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13993771 | 2.NP_SO-102 | 143.274 | 0.00477764 | 0.0351084 | ø78 mm | 0.000144928 | F | 2.NP_SO-102 | -765.946 | -894.833 | -793.523 | -922.41 | -793.523 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3080.77 | PP–SKEM | 78 | 727 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.2066 | 2066 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13993940 | 1.NP_SO-102 | 1734.13 | 0.0143117 | 0.735472 | ø135 mm | 0.0000803859 | G | 1.NP_SO-102 | 3081.2 | 2979.04 | 3013.71 | 2911.56 | 3013.71 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2916.86 | PP–SKEM | 135 | 642 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2067 | 2067 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1.99964
13994063 | 2.NP_SO-102 | 143.673 | 0.00950189 | 0.0496499 | ø110 mm | 0.000100604 | F | 2.NP_SO-102 | -808.029 | -948.512 | -846.92 | -987.403 | -846.92 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3016.34 | PP–SKEM | 110 | 647 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2068 | 2068 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13994144 | 1.NP_SO-102 | 4167.68 | 0.00950189 | 1.44025 | ø110 mm | 0.000100604 | F | 1.NP_SO-102 | 3077.03 | 2938.71 | 3022.04 | 2883.72 | 3022.04 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2889.02 | PP–SKEM | 110 | 725 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2069 | 2069 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13994721 | 1.NP_SO-102 | 1013.89 | 0.00477764 | 0.248449 | ø78 mm | 0.000144928 | F | 1.NP_SO-102 | 3197.43 | 3158.43 | 3138.4 | 3099.41 | 3138.4 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3103.91 | PP–SKEM | 78 | 657 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.2070 | 2070 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1.97643
13994909 | 1.NP_SO-102 | 22.8694 | 0.00477764 | 0.005604 | ø78 mm | 0.000144928 | F | 1.NP_SO-102 | 3152.24 | 3124.66 | 3108.49 | 3080.91 | 3108.49 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3084.09 | PP–SKEM | 78 | 657 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.2071 | 2071 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13994930 | 1.NP_SO-102 | 173.796 | 0.00477764 | 0.0425876 | ø78 mm | 0.000144928 | F | 1.NP_SO-102 | 3097.74 | 2947.27 | 3070.16 | 2919.69 | 3070.16 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2922.88 | PP–SKEM | 78 | 657 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.2072 | 2072 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13994933 | 1.NP_SO-102 | 4592.55 | 0.0143117 | 1.94777 | ø135 mm | 0.0000803859 | G | 1.NP_SO-102 | 2964.24 | 2896.75 | 2804.92 | 2737.43 | 2804.92 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2742.73 | PP–SKEM | 135 | 651 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2073 | 2073 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1.99994
13995057 | 2.NP_SO-102 | 510.951 | 0.00950189 | 0.176572 | ø110 mm | 0.000100604 | F | 2.NP_SO-102 | -512.307 | -912.494 | -551.198 | -951.385 | -551.198 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3052.36 | PP–SKEM | 110 | 633 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2074 | 2074 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13995230 | 1.NP_SO-102 | 2141.75 | 0.0143117 | 0.908348 | ø135 mm | 0.0000803859 | G | 1.NP_SO-102 | 2865.54 | 2798.06 | 2755.23 | 2687.74 | 2755.23 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2693.04 | PP–SKEM | 135 | 660 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2075 | 2075 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1.99996
13995689 | 1.NP_SO-102 | 137.016 | 0.00950189 | 0.0473494 | ø110 mm | 0.000100604 | F | 1.NP_SO-102 | 2999.22 | 2960.33 | 2863.45 | 2824.56 | 2863.45 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2828.3 | PP–SKEM | 110 | 633 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2076 | 2076 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13995705 | 1.NP_SO-102 | 4142.1 | 0.00950189 | 1.43141 | ø110 mm | 0.000100604 | F | 1.NP_SO-102 | 3124.07 | 3069.08 | 2986.26 | 2931.27 | 2986.26 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2936.57 | PP–SKEM | 110 | 633 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2077 | 2077 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13996038 | 2.NP_SO-102 | 205.732 | 0.00477764 | 0.0504134 | ø78 mm | 0.000144928 | F | 2.NP_SO-102 | -726.757 | -899.809 | -754.334 | -927.386 | -754.334 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3075.8 | PP–SKEM | 78 | 676 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.2078 | 2078 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13996054 | 2.NP_SO-102 | 289.698 | 0.00477764 | 0.0709888 | ø78 mm | 0.000144928 | F | 2.NP_SO-102 | -874.555 | -919.34 | -913.547 | -958.332 | -913.547 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3046.17 | PP–SKEM | 78 | 676 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.2079 | 2079 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13996065 | 2.NP_SO-102 | 218.73 | 0.00477764 | 0.0535985 | ø78 mm | 0.000144928 | F | 2.NP_SO-102 | -881.125 | -924.491 | -920.117 | -963.483 | -920.117 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3041.02 | PP–SKEM | 78 | 676 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.2080 | 2080 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13996087 | 1.NP_SO-102 | 311.831 | 0.00950189 | 0.107761 | ø110 mm | 0.000100604 | F | 1.NP_SO-102 | 3361.66 | 3102.27 | 3322.77 | 3063.38 | 3322.77 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3067.13 | PP–SKEM | 110 | 596 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2081 | 2081 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13996103 | 1.NP_SO-102 | 197.865 | 0.00950189 | 0.0683771 | ø110 mm | 0.000100604 | F | 1.NP_SO-102 | 3129.47 | 3070.52 | 3074.48 | 3015.53 | 3074.48 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3020.83 | PP–SKEM | 110 | 679 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2082 | 2082 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13996157 | 1.NP_SO-102 | 1124.82 | 0.0143117 | 0.477051 | ø135 mm | 0.0000803859 | G | 1.NP_SO-102 | 2817.84 | 2750.35 | 2727.86 | 2660.38 | 2727.86 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2665.67 | PP–SKEM | 135 | 663 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2083 | 2083 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1.99999
13996477 | 1.NP_SO-102 | 192.206 | 0.00950189 | 0.0664217 | ø110 mm | 0.000100604 | F | 1.NP_SO-102 | 3109.97 | 3051.14 | 3054.98 | 2996.15 | 3054.98 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3001.45 | PP–SKEM | 110 | 677 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2084 | 2084 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13996491 | 1.NP_SO-102 | 219.197 | 0.00950189 | 0.0757491 | ø110 mm | 0.000100604 | F | 1.NP_SO-102 | 3064.1 | 2870.21 | 3025.21 | 2831.32 | 3025.21 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2835.07 | PP–SKEM | 110 | 677 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2085 | 2085 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13996625 | 1.NP_SO-102 | 198.729 | 0.00950189 | 0.0686758 | ø110 mm | 0.000100604 | F | 1.NP_SO-102 | 3114.99 | 3056.02 | 3060 | 3001.03 | 3060 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3006.33 | PP–SKEM | 110 | 677 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2086 | 2086 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13996693 | 1.NP_SO-102 | 983.421 | 0.00950189 | 0.339846 | ø110 mm | 0.000100604 | F | 1.NP_SO-102 | 3149.6 | 3074.94 | 3094.61 | 3019.95 | 3094.61 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3025.25 | PP–SKEM | 110 | 672 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2087 | 2087 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13996731 | 1.NP_SO-102 | 200.872 | 0.00950189 | 0.0694163 | ø110 mm | 0.000100604 | F | 1.NP_SO-102 | 3124.47 | 3069.48 | 3065.46 | 3010.47 | 3065.46 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3015.77 | PP–SKEM | 110 | 679 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2088 | 2088 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13996741 | 1.NP_SO-102 | 200.929 | 0.00950189 | 0.069436 | ø110 mm | 0.000100604 | F | 1.NP_SO-102 | 3124.47 | 3065.46 | 3069.48 | 3010.47 | 3069.48 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3015.77 | PP–SKEM | 110 | 410 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2089 | 2089 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13996802 | 1.NP_SO-102 | 28.2615 | 0.00264168 | 0.0051496 | ø58 mm | 0.0002 | F | 1.NP_SO-102 | 3110.07 | 3081.07 | 3080.51 | 3051.51 | 3080.51 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3055.51 | PP–SKEM | 58 | 398 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø58 | 50 | TR08.01.2090 | 2090 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13996814 | 1.NP_SO-102 | 195.665 | 0.00950189 | 0.0676168 | ø110 mm | 0.000100604 | F | 1.NP_SO-102 | 3138.84 | 3079.94 | 3083.85 | 3024.95 | 3083.85 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3030.25 | PP–SKEM | 110 | 596 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2091 | 2091 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13996817 | 1.NP_SO-102 | 516.337 | 0.00264168 | 0.0940831 | ø58 mm | 0.0002 | F | 1.NP_SO-102 | 3121 | 3092.01 | 3081.68 | 3052.69 | 3081.68 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3056.69 | PP–SKEM | 58 | 398 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø58 | 50 | TR08.01.2092 | 2092 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13997319 | 2.NP_SO-102 | 582.439 | 0.0143117 | 0.247021 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 2490.52 | 1908.08 | 2490.52 | 1908.08 | 2490.52 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 5908.08 | PP–SKEM | 135 | 112 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2093 | 2093 | yes | SW_Odvětrání kanalizace 16
13997346 | 2.NP_SO-102 | 372.322 | 0.0143117 | 0.157907 | ø135 mm | 0.0000803859 | F | 2.NP_SO-102 | -571.692 | -882.694 | -619.422 | -930.423 | -619.422 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3073.32 | PP–SKEM | 135 | 632 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2094 | 2094 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13997521 | 2.NP_SO-102 | 190.522 | 0.0143117 | 0.0808032 | ø135 mm | 0.0000803859 | F | 2.NP_SO-102 | -961.144 | -1032.44 | -1028.63 | -1099.93 | -1028.63 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2905.37 | PP–SKEM | 135 | 699 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2095 | 2095 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13997588 | 1.NP_SO-102 | 4620.45 | 0.0143117 | 1.9596 | ø135 mm | 0.0000803859 | G | 1.NP_SO-102 | 2788.49 | 2721 | 2628.61 | 2561.12 | 2628.61 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2566.42 | PP–SKEM | 135 | 347 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2096 | 2096 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1.99999
13997873 | 2.NP_SO-102 | 817.762 | 0.0143117 | 0.346825 | ø135 mm | 0.0000803859 | F | 2.NP_SO-102 | -943.543 | -1027.38 | -1011.03 | -1094.87 | -1011.03 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2910.43 | PP–SKEM | 135 | 699 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2097 | 2097 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13998403 | 2.NP_SO-102 | 293.323 | 0.0143117 | 0.124403 | ø135 mm | 0.0000803859 | F | 2.NP_SO-102 | -591.141 | -846.282 | -638.871 | -894.011 | -638.871 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3109.74 | PP–SKEM | 135 | 133 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2098 | 2098 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13998904 | 1.NP_SO-102 | 118.274 | 0.0143117 | 0.0501618 | ø135 mm | 0.0000803859 | F | 1.NP_SO-102 | 2877.9 | 2830.17 | 2746.53 | 2698.8 | 2746.53 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2702.55 | PP–SKEM | 135 | 697 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2099 | 2099 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13998938 | 1.NP_SO-102 | 567.806 | 0.0143117 | 0.240815 | ø135 mm | 0.0000803859 | F | 1.NP_SO-102 | 3033.8 | 2966.31 | 2954.96 | 2887.47 | 2954.96 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2892.77 | PP–SKEM | 135 | 699 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2100 | 2100 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13999084 | 1.NP_SO-102 | 377.064 | 0.0143117 | 0.159919 | ø135 mm | 0.0000803859 | F | 1.NP_SO-102 | 3387.24 | 3339.51 | 3072.88 | 3025.15 | 3072.88 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3028.9 | PP–SKEM | 135 | 134 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2101 | 2101 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13999095 | 1.NP_SO-102 | 299.462 | 0.0143117 | 0.127006 | ø135 mm | 0.0000803859 | F | 1.NP_SO-102 | 3435.06 | 3367.58 | 3361.59 | 3294.1 | 3361.59 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3299.4 | PP–SKEM | 135 | 134 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2102 | 2102 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13999270 | 1.NP_SO-102 | 142.596 | 0.00950189 | 0.0492778 | ø110 mm | 0.000100604 | F | 1.NP_SO-102 | 3054.17 | 2999.19 | 2996.33 | 2941.34 | 2996.33 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2946.64 | PP–SKEM | 110 | 701 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2103 | 2103 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13999280 | 2.NP_SO-102 | 815.062 | 0.0143117 | 0.34568 | ø135 mm | 0.0000803859 | F | 2.NP_SO-102 | -920.572 | -1004.36 | -988.059 | -1071.84 | -988.059 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2933.46 | PP–SKEM | 135 | 696 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2104 | 2104 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13999290 | 1.NP_SO-102 | 358.661 | 0.00950189 | 0.123944 | ø110 mm | 0.000100604 | F | 1.NP_SO-102 | 3062.39 | 3000.23 | 3007.4 | 2945.24 | 3007.4 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2950.54 | PP–SKEM | 110 | 701 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2105 | 2105 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13999300 | 1.NP_SO-102 | 244.57 | 0.00950189 | 0.0845172 | ø110 mm | 0.000100604 | F | 1.NP_SO-102 | 3255.76 | 3043.94 | 3216.87 | 3005.05 | 3216.87 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3008.79 | PP–SKEM | 110 | 424 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2106 | 2106 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13999388 | 1.NP_SO-102 | 326.951 | 0.0143117 | 0.138665 | ø135 mm | 0.0000803859 | F | 1.NP_SO-102 | 3412.95 | 3134.03 | 3365.22 | 3086.3 | 3365.22 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3090.05 | PP–SKEM | 135 | 600 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2107 | 2107 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13999405 | 1.NP_SO-102 | 2301.01 | 0.0143117 | 0.975893 | ø135 mm | 0.0000803859 | F | 1.NP_SO-102 | 3179.43 | 3065.94 | 3111.95 | 2998.45 | 3111.95 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3003.75 | PP–SKEM | 135 | 600 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2108 | 2108 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13999563 | 2.NP_SO-102 | 2014.96 | 0.0143117 | 0.854573 | ø135 mm | 0.0000803859 | F | 2.NP_SO-102 | -873.262 | -981.195 | -940.748 | -1048.68 | -940.748 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2956.62 | PP–SKEM | 135 | 702 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2109 | 2109 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2.00776
13999589 | 2.NP_SO-102 | 1458.48 | 0.0143117 | 0.618562 | ø135 mm | 0.0000803859 | F | 2.NP_SO-102 | -837.287 | -934.05 | -904.774 | -1001.54 | -904.774 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3003.76 | PP–SKEM | 135 | 632 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2110 | 2110 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2.00776
13999660 | 1.NP_SO-102 | 101.465 | 0.00477764 | 0.0248634 | ø78 mm | 0.000144928 | F | 1.NP_SO-102 | 2822.69 | 2795.11 | 2723.36 | 2695.79 | 2723.36 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2698.97 | PP–SKEM | 78 | 706 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.2111 | 2111 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13999670 | 1.NP_SO-102 | 2037.1 | 0.0143117 | 0.863963 | ø135 mm | 0.0000803859 | G | 1.NP_SO-102 | 2689.23 | 2581.01 | 2621.75 | 2513.52 | 2621.75 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2518.82 | PP–SKEM | 135 | 694 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2112 | 2112 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13999679 | 1.NP_SO-102 | 373.957 | 0.00477764 | 0.091636 | ø78 mm | 0.000144928 | F | 1.NP_SO-102 | 2860.91 | 2821.92 | 2814.45 | 2775.45 | 2814.45 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2779.95 | PP–SKEM | 78 | 706 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.2113 | 2113 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13999902 | 1.NP_SO-102 | 145.565 | 0.0143117 | 0.0617361 | ø135 mm | 0.0000803859 | F | 1.NP_SO-102 | 2613.74 | 2546.25 | 2543.34 | 2475.85 | 2543.34 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2481.15 | PP–SKEM | 135 | 704 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2114 | 2114 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
14000408 | 1.NP_SO-102 | 209.748 | 0.0143117 | 0.0889573 | ø135 mm | 0.0000803859 | F | 1.NP_SO-102 | 2478.29 | 2282.25 | 2430.56 | 2234.52 | 2430.56 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2238.27 | PP–SKEM | 135 | 714 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2115 | 2115 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
14000540 | 1.NP_SO-102 | 89.0707 | 0.00950189 | 0.0307806 | ø110 mm | 0.000100604 | G | 1.NP_SO-102 | 2846.11 | 2757.03 | 2846.1 | 2757.02 | 2846.1 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2757.02 | PP–SKEM | 110 | 435 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2116 | 2116 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S1
14000754 | 1.NP_SO-102 | 324.783 | 0.0143117 | 0.137745 | ø135 mm | 0.0000803859 | F | 1.NP_SO-102 | 2621.3 | 2553.82 | 2547.48 | 2479.99 | 2547.48 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2485.29 | PP–SKEM | 135 | 704 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2117 | 2117 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1.95234
14000765 | 1.NP_SO-102 | 958.044 | 0.0143117 | 0.406321 | ø135 mm | 0.0000803859 | F | 1.NP_SO-102 | 2641.63 | 2574.15 | 2555.05 | 2487.57 | 2555.05 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2492.86 | PP–SKEM | 135 | 704 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2118 | 2118 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1.99361
14000889 | 1.NP_SO-102 | 6803.53 | 0.0201032 | 3.41983 | ø160 mm | 0.0000669344 | G | 1.NP_SO-102 | 1917.15 | -4886.37 | 1917.15 | -4886.37 | 1917.15 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -4886.37 | PP–SKEM | 160 | 730 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.2119 | 2119 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S1
14000905 | 1.NP_SO-102 | 405.139 | 0.0201032 | 0.203645 | ø160 mm | 0.0000669344 | G | 1.NP_SO-102 | 2716.23 | 2311.09 | 2716.23 | 2311.09 | 2716.23 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2311.09 | PP–SKEM | 160 | 186 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.2120 | 2120 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S1
14001037 | 2.NP_SO-102 | 296.386 | 0.0143117 | 0.125702 | ø135 mm | 0.0000803859 | F | 2.NP_SO-102 | -448.909 | -706.216 | -496.639 | -753.945 | -496.639 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3249.8 | PP–SKEM | 135 | 131 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2121 | 2121 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
14001050 | 2.NP_SO-102 | 2351.73 | 0.0143117 | 0.997406 | ø135 mm | 0.0000803859 | F | 2.NP_SO-102 | -660.809 | -775.321 | -728.296 | -842.808 | -728.296 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3162.49 | PP–SKEM | 135 | 131 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2122 | 2122 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
14001114 | 2.NP_SO-102 | 241.623 | 0.0143117 | 0.102476 | ø135 mm | 0.0000803859 | F | 2.NP_SO-102 | -749.671 | -968.254 | -797.401 | -1015.98 | -797.401 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2987.76 | PP–SKEM | 135 | 131 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2123 | 2123 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
14001381 | 2.NP_SO-102 | 157.506 | 0.0143117 | 0.0668005 | ø135 mm | 0.0000803859 | F | 2.NP_SO-102 | -1021.6 | -1179.1 | -1021.6 | -1179.1 | -1021.6 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2820.9 | PP–SKEM | 135 | 131 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2124 | 2124 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
14001543 | 2.NP_SO-102 | 248.764 | 0.0143117 | 0.105505 | ø135 mm | 0.0000803859 | F | 2.NP_SO-102 | -1184.71 | -1408.35 | -1232.44 | -1456.08 | -1232.44 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2547.67 | PP–SKEM | 135 | 131 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2125 | 2125 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
14001588 | 1.NP_SO-102 | 243.939 | 0.0143117 | 0.103458 | ø135 mm | 0.0000803859 | G | 1.NP_SO-102 | 2534.35 | 2466.86 | 2461.99 | 2394.5 | 2461.99 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2399.8 | PP–SKEM | 135 | 714 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2126 | 2126 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
14001802 | 1.NP_SO-102 | 179.098 | 0.0143117 | 0.0759581 | ø135 mm | 0.0000803859 | F | 1.NP_SO-102 | 3439.89 | 3372.41 | 3368.82 | 3301.34 | 3368.82 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3306.64 | PP–SKEM | 135 | 134 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2127 | 2127 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
14001813 | 1.NP_SO-102 | 279.775 | 0.0143117 | 0.118657 | ø135 mm | 0.0000803859 | F | 1.NP_SO-102 | 3649.04 | 3403.48 | 3601.32 | 3355.75 | 3601.32 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3359.5 | PP–SKEM | 135 | 134 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2128 | 2128 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100.001
14001885 | 1.NP_SO-102 | 525.16 | 0.00477764 | 0.128688 | ø78 mm | 0.000144928 | F | 1.NP_SO-102 | 3132.6 | 3083.1 | 3093.6 | 3044.11 | 3093.6 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3048.61 | PP–SKEM | 78 | 707 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.2129 | 2129 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
14001898 | 1.NP_SO-102 | 1121.36 | 0.00477764 | 0.274782 | ø78 mm | 0.000144928 | F | 1.NP_SO-102 | 3121.32 | 3059.9 | 3082.33 | 3020.91 | 3082.33 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3025.41 | PP–SKEM | 78 | 707 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.2130 | 2130 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
14002033 | 1.NP_SO-102 | 533.634 | 0.00477764 | 0.130764 | ø78 mm | 0.000144928 | F | 1.NP_SO-102 | 3098.2 | 3048.54 | 3059.21 | 3009.55 | 3059.21 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3014.05 | PP–SKEM | 78 | 707 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.2131 | 2131 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
14002041 | 1.NP_SO-102 | 156.654 | 0.00477764 | 0.0383871 | ø78 mm | 0.000144928 | F | 1.NP_SO-102 | 3056.55 | 2918.04 | 3029.03 | 2890.51 | 3029.03 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2893.69 | PP–SKEM | 78 | 707 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.2132 | 2132 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100.4
14002090 | 1.NP_SO-102 | 1111.15 | 0.00477764 | 0.272281 | ø78 mm | 0.000144928 | F | 1.NP_SO-102 | 2883.91 | 2822.7 | 2844.92 | 2783.71 | 2844.92 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2788.21 | PP–SKEM | 78 | 706 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.2133 | 2133 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
14002104 | 1.NP_SO-102 | 254.931 | 0.00477764 | 0.0624693 | ø78 mm | 0.000144928 | F | 1.NP_SO-102 | 2893.01 | 2848.92 | 2854.02 | 2809.93 | 2854.02 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2814.43 | PP–SKEM | 78 | 717 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.2134 | 2134 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
14004504 | 1.NP_SO-102 | 2071.26 | 0.0143117 | 0.878454 | ø135 mm | 0.0000803859 | G | 1.NP_SO-102 | 3039.67 | 2972.18 | 2930.77 | 2863.28 | 2930.77 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2868.58 | PP–SKEM | 135 | 719 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2149 | 2149 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1.99994
14004629 | 1.NP_SO-102 | 310.412 | 0.00950189 | 0.107271 | ø110 mm | 0.000100604 | F | 1.NP_SO-102 | 2992.65 | 2937.66 | 2931.46 | 2876.47 | 2931.46 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2881.77 | PP–SKEM | 110 | 725 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2150 | 2150 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
14004638 | 1.NP_SO-102 | 1024.29 | 0.0143117 | 0.434418 | ø135 mm | 0.0000803859 | G | 1.NP_SO-102 | 2991.58 | 2924.09 | 2903.61 | 2836.13 | 2903.61 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2841.43 | PP–SKEM | 135 | 723 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2151 | 2151 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1.99994
14018204 | 2.NP_SO-102 | 3485.26 | 0.0143112 | 1.47815 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 2679.25 | 2611.74 | 2611.75 | 2544.24 | 2611.75 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 6549.54 | PP–SKEM | 135 | 137 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2181 | 2181 | yes | SW_Odvětrání kanalizace 16 |  | 0
14018312 | 2.NP_SO-102 | 816.498 | 0.0143117 | 0.346289 | ø135 mm | 0.0000803859 | F | 2.NP_SO-102 | 3067.5 | 3000 | 3000 | 2932.5 | 3000 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 6937.8 | PP–SKEM | 135 | 137 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2182 | 2182 | yes | SW_Odvětrání kanalizace 16 |  | 0
14018325 | 2.NP_SO-102 | 270.465 | 0.0143117 | 0.114708 | ø135 mm | 0 | F | 2.NP_SO-102 | 2924.56 | 2924.56 | 2654.1 | 2654.1 | 2654.1 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 6654.1 | PP–SKEM | 135 | 137 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2183 | 2183 | yes | SW_Odvětrání kanalizace 16
14018377 | 2.NP_SO-102 | 237.372 | 0.0143117 | 0.100673 | ø135 mm | 0 | F | 2.NP_SO-102 | 2924.56 | 2687.19 | 2924.56 | 2687.19 | 2924.56 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 6687.19 | PP–SKEM | 135 | 137 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2184 | 2184 | yes | SW_Odvětrání kanalizace 16
14019769 | -1.PP_SO-102 | 13322 | 0.00950189 | 4.60376 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2415 | 2360 | 2360 | 2305 | 2360 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | -1689.7 | PP–SKEM | 110 | 24 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2187 | 2187 | yes | SW_Odvětrání kanalizace 16 |  | 0
14019908 | -1.PP_SO-102 | 391.911 | 0.00950189 | 0.135435 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 3826 | 3509.99 | 3787.11 | 3471.1 | 3787.11 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -525.154 | PP–SKEM | 110 | 726 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2188 | 2188 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
14020024 | -1.PP_SO-102 | 497.861 | 0.00950189 | 0.172048 | ø110 mm | 0.000100604 | F | -1.PP_SO-102 | 3465.49 | 2967.62 | 3465.49 | 2967.62 | 3465.49 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1032.38 | PP–SKEM | 110 | 726 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2189 | 2189 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
14020349 | 2.NP_SO-102 | 3450.07 | 0.0143117 | 1.46323 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 3179.2 | 3111.7 | 3110 | 3042.5 | 3110 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 7047.8 | PP–SKEM | 135 | 159 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2190 | 2190 | yes | SW_Odvětrání kanalizace 16 |  | 0.0493972
14020874 | 4.NP_SO-102 | 460.978 | 0.0201032 | 0.231713 | ø160 mm | 0.0000669344 | G | STŘECHA_SO-102 | -1348.23 | -1348.23 | -1809.21 | -1809.21 | -1809.21 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 7 | 14040.8 | PP–SKEM | 160 | 2 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.2191 | 2191 | yes | SW_Odvětrání kanalizace 7 | Identifikační data - Komentáře: S6
14020947 | 4.NP_SO-102 | 1424.13 | 0.0201032 | 0.715843 | ø160 mm | 0.0000669344 | F | STŘECHA_SO-102 | -1180.29 | -1260.29 | -1260.29 | -1340.29 | -1260.29 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 7 | 14515 | PP–SKEM | 160 | 2 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.2192 | 2192 | yes | SW_Odvětrání kanalizace 7 |  | 0
14022793 | 2.NP_SO-102 | 470.748 | 0.00477764 | 0.115354 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3742.92 | 3354.31 | 3718.18 | 3329.56 | 3354.31 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7332.42 | PP–SKEM | 78 | 727 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.2194 | 2194 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 121.83
14025283 | 2.NP_SO-102 | 4662.15 | 0.0143117 | 1.97729 | ø135 mm | 0.0000803859 | F | 2.NP_SO-102 | 2967.5 | 2900 | 2900 | 2832.5 | 2900 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 6837.8 | PP–SKEM | 135 | 159 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2205 | 2205 | yes | SW_Odvětrání kanalizace 16 |  | 0
14025289 | 2.NP_SO-102 | 7373.03 | 0.0143117 | 3.12701 | ø135 mm | 0.0000803859 | F | 2.NP_SO-102 | 2472.28 | 2404.78 | 2404.78 | 2337.28 | 2404.78 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 6342.58 | PP–SKEM | 135 | 159 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2206 | 2206 | yes | SW_Odvětrání kanalizace 16 |  | 0
14025333 | 2.NP_SO-102 | 344.125 | 0.0143117 | 0.145949 | ø135 mm | 0 | F | 2.NP_SO-102 | 2824.56 | 2480.44 | 2824.56 | 2480.44 | 2824.56 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 6480.44 | PP–SKEM | 135 | 159 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2207 | 2207 | yes | SW_Odvětrání kanalizace 16
14025590 | 2.NP_SO-102 | 1533.28 | 0.0143117 | 0.650286 | ø135 mm | 0.0000803859 | F | 2.NP_SO-102 | 2472.28 | 2404.78 | 2404.78 | 2337.28 | 2404.78 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 6342.58 | PP–SKEM | 135 | 159 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2208 | 2208 | yes | SW_Odvětrání kanalizace 16 |  | 0
14033720 | 3.NP_SO-102 | 2019.43 | 0.00950189 | 0.697864 | ø110 mm | 0.000100604 | G | 3.NP_SO-102 | 3006.29 | 2951.29 | 2951.29 | 2896.29 | 2951.29 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 14 | 10901.6 | PP–SKEM | 110 | 15 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2217 | 2217 | yes | SW_Odvětrání kanalizace 14 |  | 0
14033840 | 3.NP_SO-102 | 3580.12 | 0.00950189 | 1.2372 | ø110 mm | 0.000100604 | F | 3.NP_SO-102 | 3354.28 | 3299.28 | 3299.28 | 3244.28 | 3299.28 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 14 | 11249.6 | PP–SKEM | 110 | 15 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2218 | 2218 | yes | SW_Odvětrání kanalizace 14 |  | 0
14033855 | 3.NP_SO-102 | 222.117 | 0.00950189 | 0.0767581 | ø110 mm | 0 | F | 3.NP_SO-102 | 3236.35 | 3236.35 | 3014.23 | 3014.23 | 3014.23 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 14 | 11014.2 | PP–SKEM | 110 | 15 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.2219 | 2219 | yes | SW_Odvětrání kanalizace 14
14036671 | 2.NP_SO-102 | 340.333 | 0.0143117 | 0.14434 | ø135 mm | 0.0000803859 | F | 2.NP_SO-102 | 3179.21 | 3111.71 | 3111.71 | 3044.21 | 3111.71 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 7049.51 | PP–SKEM | 135 | 159 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2224 | 2224 |  | SW_Odvětrání kanalizace 16 |  | 0
14036744 | 2.NP_SO-102 | 556.053 | 0.0143117 | 0.235831 | ø135 mm | 0 | F | 2.NP_SO-102 | 3036.27 | 3036.27 | 2480.22 | 2480.22 | 2480.22 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 6480.22 | PP–SKEM | 135 | 159 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.2225 | 2225 |  | SW_Odvětrání kanalizace 16

# IfcPipeSegment: Typy trubek:PVC-U_KG systém (166)
Type - Material: 128-0-0
Type - Požární ochrana - Požární odolnost: –
Type - Identifikační data - Cena: 0; ID kategorie: TR; Kód sestavy: TR06; Název typu: PVC-U_KG systém; Označení typu: 05; Popis: PVC-U; Popis sestavy: Polyvinyl chlorid (PVC); Výrobce: Ostendorf - OSMA
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR06 SNIM (SNIM); TR06 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Komponenta: WPA; CCI Technický systém: JD
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Mechanické - Drsnost: 0.125 mm; Materiál: PVC–U_KG SYSTEM; Popis úseku: PVC–KGEM SN4; Typ přípoje: Obecné; Úsek potrubí: PVC–U_KG SYSTEM - SN4; Výkaz/typ: SN4
Jiné - Rodina: Typy trubek; Id typu: 9442186; Rodina a typ: Typy trubek: PVC-U_KG systém; Typ: PVC-U_KG systém
