Properties of the parts of a building model (IFC4), part 23 of 60

# IfcDistributionPort (11856)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_13646333_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646341_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646475_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646488_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646488_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646489_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646488_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646496_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646513_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13646515_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13646560_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13646630_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13646560_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13646634_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13646634_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13646635_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13646833_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646886_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646833_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646888_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13647428_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13647437_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13647647_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13647712_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13647930_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13647986_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13647986_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13647994_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13647988_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13647994_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13647988_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13648000_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13647998_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13648000_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13650926_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13823507_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13650926_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13822902_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13650969_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13650970_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13650969_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13823439_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13650970_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13822963_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13651129_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13651690_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13651129_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13651702_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13651242_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705735_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13651242_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705737_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13651512_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705738_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13651663_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13651695_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13651694_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13651744_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13651694_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13651695_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13651694_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13651702_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13651761_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13651761_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13651771_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13651789_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13706074_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13651789_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13706078_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13651883_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13651885_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13651883_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13651893_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13651885_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764097_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13651893_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13823196_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
InPort_14019771_3 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13652325_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13652325_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14019710_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13652478_0 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13653671_2 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13652478_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13653553_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13652541_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13653606_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13653122_0 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13653130_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13653122_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13653140_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13653130_2 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_14019769_0 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13653140_2 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13653672_0 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13653315_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13653317_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13653545_0 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13653608_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13653545_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13653553_2 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13653600_0 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13653606_2 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13653600_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13653608_2 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13653639_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13653681_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13653685_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13653639_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13653671_3 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13653669_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13653669_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13653685_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13653671_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13653672_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13654065_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13654070_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13654065_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13654072_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13654072_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13807208_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13654079_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13654081_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13654079_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13654083_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13654090_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13654092_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13654090_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13654094_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13654101_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13654103_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13654101_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13654105_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13654112_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13654114_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13654112_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13654116_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13654120_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13839350_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13654123_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13825233_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13654123_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13825285_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13654131_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13839297_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
InPort_13998413_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13656215_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14001841_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13656334_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13656393_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13997321_2 | SOURCE | PIPE | VENT | SW_Splašky vnitřní gravitační 35 (1)
InPort_13997357_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13656393_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13656691_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993752_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13656691_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993934_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13658165_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13658921_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13658774_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13659147_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13658774_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13659151_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13658792_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13659147_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13658792_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13658928_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13658920_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13658921_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13658920_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13658928_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13659003_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_14023707_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13659003_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13659151_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13659236_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13660434_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13659236_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13660438_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13659290_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13660434_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13659290_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13660554_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13659337_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13680398_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13659337_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13680402_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13659865_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13659887_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13659865_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13660156_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13659879_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13659880_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13659879_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13659887_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13660054_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13680398_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13660054_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13660160_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13660086_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13660156_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13660086_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13660160_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13660536_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13660548_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13660536_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13660554_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13660548_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13680402_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13660771_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_14023707_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13660771_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13661001_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14022860_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13661001_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14022846_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13661221_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14022846_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13661221_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993752_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13665575_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14018287_3 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13681628_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13665575_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13669806_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13689358_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13669806_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13669853_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13669853_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13688923_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13671796_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13675112_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13675124_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13671796_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13675112_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13671812_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13672005_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13671937_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13671937_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13671995_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13671997_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13671998_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13671997_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675117_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13671997_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13672005_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13671998_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13688922_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672542_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672558_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672542_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672617_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672550_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672551_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672550_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672691_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672550_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672558_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672551_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672972_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672568_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672617_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672568_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672621_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13672729_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13672682_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13672682_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13672742_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672690_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672691_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13672690_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13672729_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13672742_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13672698_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13672698_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13672748_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13672748_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13672746_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672964_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672997_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672964_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675325_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672972_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672973_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672972_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672997_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672973_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675116_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672979_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675321_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672979_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675325_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13673260_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13673210_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13673729_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13673737_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13673729_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13673771_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13673737_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13673738_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13673743_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13673771_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675043_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13690992_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675116_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675117_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13675116_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13675124_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13675531_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13675438_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13675646_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13675531_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675651_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675740_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675651_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675652_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13675651_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13675660_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675729_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675747_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675729_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13837458_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675739_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675740_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675739_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675747_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675750_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13837458_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675750_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13837944_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13678529_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13982915_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13678534_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13982628_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13678538_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13982915_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13678538_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13678539_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13678921_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13994336_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13678921_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13679153_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13679011_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13994336_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13679011_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13994340_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13679117_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13679153_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13679117_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13679157_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13680697_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13680737_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13680750_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13680697_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13680816_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13680741_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13680741_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13680742_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13680741_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13680750_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13680871_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13680815_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13680815_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13680816_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13680815_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13680824_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13680853_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13680870_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13688785_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13680853_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13680870_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13680871_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13680870_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13680879_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13681213_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13681275_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13681265_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13681275_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13681265_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13681489_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13681275_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13681276_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13681821_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13681628_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13681812_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13681865_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13681870_3 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13681812_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13682976_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13681821_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13681870_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13682777_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13681871_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13681870_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13682644_3 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13681871_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13682360_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13682361_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13682361_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13682743_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13682645_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13682644_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13683183_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13682645_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13682743_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13682700_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13682700_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13682747_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13682777_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13683007_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14018462_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13682906_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13682906_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13682932_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13682968_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13682976_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13683007_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13682968_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13683072_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13683133_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13683191_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13683121_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13683121_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13683195_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13683133_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13683131_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13683131_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13683191_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13683181_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13683183_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13683195_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13683181_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13706121_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13683857_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13683857_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13684869_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13687747_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13687760_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13687789_3 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13687747_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13687764_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13687789_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13687976_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13687764_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13687789_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13687837_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13687837_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13687894_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13687846_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13706115_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13687894_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13687846_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13687968_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13687976_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13688473_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13687968_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13688043_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13688473_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14002516_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13688043_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13688679_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13688672_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13688918_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13688751_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13688751_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13688785_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13688777_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13688918_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13688930_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13688777_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13688922_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13688923_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13688922_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13688930_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13689226_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13689240_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13689226_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13689362_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689240_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13689241_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13689358_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13689681_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689701_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13689672_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689672_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13689801_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13689680_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13689917_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13689680_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13689681_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689680_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13689701_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689801_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13689686_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689686_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13689889_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689855_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13689885_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689889_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13689855_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689925_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13689907_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689907_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13689934_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13689916_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13689917_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689916_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13689925_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689934_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13689928_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689928_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13689975_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689975_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13689963_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689963_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13690056_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689980_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13690052_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13690056_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13689980_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13690052_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13689997_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13690097_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13690095_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13690234_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13690281_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13690281_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13690249_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13690249_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13690285_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13690823_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13691045_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13690823_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13691049_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13690840_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13690904_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13690840_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13691045_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13690992_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13691049_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13691385_1 | SOURCE | PIPE | SEWAGE
InPort_13691387_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_13691387_2 | SINK | PIPE | DOMESTICCOLDWATER
Port_13691412_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13691415_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_13704156_0 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13704170_2 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13704156_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13704174_2 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13704170_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13704458_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13704337_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13704669_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13704672_3 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13704337_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13704458_2 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13704673_0 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13704669_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14025283_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13704672_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13704673_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13704703_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13839806_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13704707_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13839895_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13704838_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13704850_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13704838_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13824405_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13704885_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13704889_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13704885_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13704891_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13704885_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13704886_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13704891_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13705040_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705065_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705062_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705074_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705062_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13824588_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705064_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705818_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705064_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705065_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705064_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13825010_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705183_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13832192_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13705183_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13824507_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13705186_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13840219_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13705186_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13840223_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13705587_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13986287_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13705730_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705737_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705730_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705771_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705737_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705810_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705738_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705810_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705818_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13839369_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705969_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 4
Port_13705992_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 4
Port_13706046_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13706071_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13706071_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13706103_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13706078_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13706103_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13706078_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13706079_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13706125_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13706117_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13706121_3 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13706119_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13706119_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13706125_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13706122_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13706121_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016378_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13706122_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13725003_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 18
Port_13725003_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 18
Port_13725005_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 18
Port_13725004_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 13
Port_13725004_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 13
Port_13725007_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 13
Port_13725005_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 18
Port_13725007_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 13
Port_13725009_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13725009_2 | SOURCEANDSINK | PIPE | SEWAGE
OutPort_13725013_1 | SOURCE | PIPE | SEWAGE
InPort_13725014_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_13725014_2 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_13725113_1 | SOURCE | PIPE | SEWAGE
InPort_13725115_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_13728394_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_13728409_1 | SOURCE | PIPE | SEWAGE
InPort_13728475_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_13728476_1 | SOURCE | PIPE | SEWAGE
Port_13728591_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 22
Port_13728591_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 22
Port_13728593_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 22
Port_13728592_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 14
Port_13728592_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 14
Port_13728595_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 14
Port_13728593_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 22
Port_13728595_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 14
Port_13728597_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13728597_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13728602_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_13728602_2 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_13728621_1 | SOURCE | PIPE | SEWAGE
Port_13728667_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 5
Port_13728667_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 5
Port_13728669_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 5
Port_13728668_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 11
Port_13728668_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 11
Port_13728671_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 11
Port_13728669_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 5
Port_13728671_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 11
Port_13728673_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13728673_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13728677_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_13728677_2 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_13728678_1 | SOURCE | PIPE | SEWAGE
Port_13733480_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 39
Port_13733480_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 39
Port_13733482_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 39
Port_13733481_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 17
Port_13733481_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 17
Port_13733484_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 17
Port_13733482_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 39
Port_13733484_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 17
Port_13733486_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13733486_2 | SOURCEANDSINK | PIPE | SEWAGE
OutPort_13733490_1 | SOURCE | PIPE | SEWAGE
InPort_13733491_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_13733491_2 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_13733494_1 | SOURCE | PIPE | SEWAGE
InPort_13733496_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_13981857_0 | SINK | PIPE | SEWAGE | SW_Deště čerpání 1
OutPort_13736833_1 | SOURCE | PIPE | SEWAGE | SW_Deště čerpání 1
OutPort_13736833_3 | SOURCE | PIPE
InPort_13981225_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13736833_4 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13736833_5 | SOURCE | PIPE
InPort_13736833_6 | SINK | PIPE
InPort_13736833_7 | SINK | PIPE
InPort_13736833_8 | SINK | PIPE
InPort_13736833_9 | SINK | PIPE
InPort_13736833_10 | SINK | PIPE
InPort_13736833_12 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13982050_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
Port_13736833_13 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_13763799_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764057_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13763906_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764116_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13763913_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764079_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764057_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764087_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764065_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764083_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764065_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764087_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764077_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764079_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764077_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764083_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764097_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764125_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764105_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764121_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764105_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764125_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764114_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764118_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764114_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764121_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764116_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764118_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764220_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764231_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764220_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764363_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764269_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764281_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764269_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764406_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764361_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764363_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764361_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764525_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764404_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764406_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764404_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764603_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764517_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764525_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764517_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764569_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
InPort_13764567_1 | SINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
OutPort_13764569_2 | SOURCE | PIPE | FIREPROTECTION | WS_Požární nezavodněný 1
Port_13764595_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764603_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764595_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
Port_13764626_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
InPort_13764624_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
OutPort_13764626_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
