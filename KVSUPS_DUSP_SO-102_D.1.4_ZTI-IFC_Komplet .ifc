Properties of the parts of a building model (IFC4), part 10 of 60

# IfcSpace: Zpevněné plochy 12:12794526, 12
Jiné - Do bilance na množství odváděných dešťových vod: yes; Do bilance pro přípojku SO101: no; ID schématu plochy: 9494; Kategorie: Plochy; Do bilance pro akumaci: no; Do bilance pro přípojku SO102: no; Koeficient vsaku: 0.9; Typ plochy: Společné plochy budovy

# IfcSpace: Zpevněné plochy 15:12795641, 15
In: 4.NP_SO-102
LongName: Zpevněné plochy; PredefinedType: SPACE; Group: Pronajmutelné
Qto_SpaceBaseQuantities - Height: 1 mm
Vazby - Podlaží: STŘECHA_SO-102
Kóty - Výpočtová výška: 0 mm; Obvod: 17306.2 mm; Plocha: 10.5923 m2
Identifikační data - Číslo: 15; Název: Zpevněné plochy
Jiné - Do bilance na množství odváděných dešťových vod: yes; Do bilance pro přípojku SO101: no; ID schématu plochy: 9494; Kategorie: Plochy; Do bilance pro akumaci: no; Do bilance pro přípojku SO102: no; Koeficient vsaku: 0.9; Typ plochy: Společné plochy budovy

# IfcSpace: Zpevněné plochy 17:12796159, 17
In: 4.NP_SO-102
LongName: Zpevněné plochy; PredefinedType: SPACE; Group: Pronajmutelné
Qto_SpaceBaseQuantities - Height: 1 mm
Vazby - Podlaží: STŘECHA_SO-102
Kóty - Výpočtová výška: 0 mm; Obvod: 67016.9 mm; Plocha: 96.4365 m2
Identifikační data - Číslo: 17; Název: Zpevněné plochy
Jiné - Do bilance na množství odváděných dešťových vod: yes; Do bilance pro akumaci: yes; Do bilance pro přípojku SO101: no; Do bilance pro přípojku SO102: yes; ID schématu plochy: 9494; Kategorie: Plochy; Koeficient vsaku: 0.9; Typ plochy: Společné plochy budovy

# IfcSpace: Zpevněné plochy 19:12796169, 19
In: 4.NP_SO-102
LongName: Zpevněné plochy; PredefinedType: SPACE; Group: Pronajmutelné
Qto_SpaceBaseQuantities - Height: 1 mm
Vazby - Podlaží: STŘECHA_SO-102
Kóty - Výpočtová výška: 0 mm; Obvod: 20965.6 mm; Plocha: 23.3394 m2
Identifikační data - Číslo: 19; Název: Zpevněné plochy
Jiné - Do bilance na množství odváděných dešťových vod: yes; Do bilance pro přípojku SO101: no; ID schématu plochy: 9494; Kategorie: Plochy; Do bilance pro akumaci: no; Do bilance pro přípojku SO102: no; Koeficient vsaku: 0.9; Typ plochy: Společné plochy budovy

# IfcSpace: Zádveří B0142:13756871, B0142
In: -1.PP_SO-102
LongName: Zádveří; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2438.4 mm; GrossVolume: 29.0164 m3; NetVolume: 29.0169 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.416492; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 128.088 W; Specifikované výkonové zatížení: 166.514 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00460986 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 2438.4 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Výpočtová výška: 0 mm; Neohraničená výška: 2438.4 mm; Obvod: 0 mm; Objem: 29.0169 m3; Plocha: 11.8998 m2
Identifikační data - Číslo: B0142; Číslo místnosti: Neobsazené; Název: Zádveří; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Úklid. vozík B0119:13756825, B0119
In: -1.PP_SO-102
LongName: Úklid. vozík; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2438.4 mm; GrossVolume: 13.9642 m3; NetVolume: 13.9642 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.200438; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 61.6428 W; Specifikované výkonové zatížení: 80.1356 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00221851 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 2438.4 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Výpočtová výška: 0 mm; Neohraničená výška: 2438.4 mm; Obvod: 0 mm; Objem: 13.9642 m3; Plocha: 5.7268 m2
Identifikační data - Číslo: B0119; Číslo místnosti: Neobsazené; Název: Úklid. vozík; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Ústředna EPS B0132.1:13756872, B0132.1
In: -1.PP_SO-102
LongName: Ústředna EPS; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2438.4 mm; GrossVolume: 4.77463 m3; NetVolume: 4.77463 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.0685335; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 21.0768 W; Specifikované výkonové zatížení: 27.3999 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00075855 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 2438.4 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Výpočtová výška: 0 mm; Neohraničená výška: 2438.4 mm; Obvod: 0 mm; Objem: 4.77463 m3; Plocha: 1.9581 m2
Identifikační data - Číslo: B0132.1; Číslo místnosti: Neobsazené; Název: Ústředna EPS; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna B0126.2:13757027, B0126.2
In: -1.PP_SO-102
LongName: Šatna; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2438.4 mm; GrossVolume: 11.1163 m3; NetVolume: 11.1163 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.15956; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 49.0712 W; Specifikované výkonové zatížení: 63.7926 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00176606 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 2438.4 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Výpočtová výška: 0 mm; Neohraničená výška: 2438.4 mm; Obvod: 0 mm; Objem: 11.1163 m3; Plocha: 4.55886 m2
Identifikační data - Číslo: B0126.2; Číslo místnosti: Neobsazené; Název: Šatna; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Šatna B0132:13756855, B0132
In: -1.PP_SO-102
LongName: Šatna; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2438.4 mm; GrossVolume: 474.684 m3; NetVolume: 474.684 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 6.81346; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 2095.41 W; Specifikované výkonové zatížení: 2724.04 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0754134 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 2438.4 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Výpočtová výška: 0 mm; Neohraničená výška: 2438.4 mm; Obvod: 0 mm; Objem: 474.684 m3; Plocha: 194.67 m2
Identifikační data - Číslo: B0132; Číslo místnosti: Neobsazené; Název: Šatna; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna chlapci B0135.1:13756856, B0135.1
In: -1.PP_SO-102
LongName: Šatna chlapci; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2438.4 mm; NetVolume: 43.2854 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.624164; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 0 W; Specifikované výkonové zatížení: 0 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00147286 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 2438.4 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Výpočtová výška: 0 mm; Neohraničená výška: 2438.4 mm
Identifikační data - Číslo: B0135.1; Číslo místnosti: Neobsazené; Název: Šatna chlapci; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna dívky B0136.1:13756821, B0136.1
In: -1.PP_SO-102
LongName: Šatna dívky; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 2438.4 mm; GrossVolume: 24.2865 m3; NetVolume: 24.2865 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.3486; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 107.209 W; Specifikované výkonové zatížení: 139.371 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00385841 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 2438.4 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Výpočtová výška: 0 mm; Neohraničená výška: 2438.4 mm; Obvod: 0 mm; Objem: 24.2865 m3; Plocha: 9.96 m2
Identifikační data - Číslo: B0136.1; Číslo místnosti: Neobsazené; Název: Šatna dívky; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcBuildingElementProxy: Expanzní nádoba:Expanzní nádoba 50, Expanzní nádoba:Expanzní nádoba 50:13805465
In: -1.PP_SO-102
Type - Classification: EN02 SNIM (SNIM); Material: Color RGB 128-128-128, Color RGB-000-000-000, Color RGB-250-250-250, Color RGB-160-197-081
Type - Obecné - ETIM Article Class: EC010958; ETIM Name: Membrane pressure expansion vessel
Type - Výsledky analýzy - Objem: 80 m3
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Materiály a povrchové úpravy - Reflex_item_color: Color RGB 128-128-128
Type - Kóty - D: 441 mm; Délka: 441 mm; DN: 20 mm; H: 492 mm; Jmenovitá velikost vstupu: 20 mm; Šířka: 441 mm; Výška: 492 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.11.14; Color: grey; Connection: R 3/4; Copyright: © CADprofi; Kód sestavy: EN02; Komentáře k typům: EXPANZNÍ NÁDOBA; Nadpis OmniClass: Expansion Vessels; Název typu: Expanzní nádoba 50; Označení typu: 05; PN: 6 bar; Popis: Membrane pressure expansion vessel; Popis sestavy: Expanzní nádoba; Revision: 2022; Volume: 0.05 m3
Type - Jiné - Kategorie: Mechanické zařízení; A: 26.9 mm; Ang1: 90 deg; AngVent: 90 deg; B1: 21.5 mm; D1: 409 mm; DL: 191.2 mm; H1: 21 mm; H2: 460 mm; H3: 227 mm; H4: 102.25 mm; HC1: 178.7 mm; HL: 365 mm; LC1: 230 mm; Název rodiny: Expanzní nádoba; RLG: 170 mm; RN: 340 mm; RO: 5.375 mm; RY: 368.1 mm; Scale: 0.7 mm; VLeg_b: no; VLeg_s: yes; VTrans: no; VVent_s: yes; W: 103.9 mm
Classification: EN02 SNIM (SNIM); EN02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.820167 m2; NetVolume: 0.0520008 m3
Text - CCI Funkční systém: H; CCI Komponenta: FLE; CCI Technický systém: HD
Vazby - Podlaží: -1.PP_SO-102; Hostitel: Podlaží : -1.PP_SO-102; Odsazení od hostitele: -1200 mm; Výška od podlaží: -1200 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Flow: 0 m3/s; Klasifikace systému: Nedefinovaný; Pressure Drop: 0 Pa
Kóty - Objem: 0.0519516 m3
Identifikační data - ID pozice: 07; ID systému: 5; Kód prvku: EN02.05.0005; Komentáře: Tlaková expanzní nádoba pro okruh TUV, médium voda; Označení: 0005
Jiné - Páteřní trasa: yes; Id typu: 13695678; Rodina: Expanzní nádoba; Rodina a typ: Expanzní nádoba: Expanzní nádoba 50; Typ: Expanzní nádoba 50

# IfcBuildingElementProxy: Nádrž dešťové vody:Nádrž dešťové vody, Nádrž dešťové vody:Nádrž dešťové vody:12797038
In: -2.PP_SO-102
Type - Classification: RT03 SNIM (SNIM); Material: <Unnamed>
Type - Výsledky analýzy - Objem: 59.5685 m3
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - Délka: 5470 mm; Šířka: 6600.02 mm; Výška: 1650 mm
Type - Identifikační data - ID kategorie: AN; Kód sestavy: RT03; Komentáře k typům: AKUMULAČNÍ NÁDRŽ DEŠŤOVÉ VODY; Název typu: Nádrž dešťové vody; Označení typu: 01; Popis sestavy: Jímka
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Nádrž dešťové vody
Classification: RT03 SNIM (SNIM); RT03 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 112.035 m2; NetVolume: 59.5685 m3
Text - CCI Funkční systém: F; CCI Komponenta: CMA; CCI Technický systém: JB
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 59.5685 m3; Plocha: 36.1021 m2
Identifikační data - ID pozice: 01; ID systému: 002; Kód prvku: RT03.01.0001; Označení: 0001
Jiné - Id typu: 12797036; Páteřní trasa: yes; Rodina: Nádrž dešťové vody; Rodina a typ: Nádrž dešťové vody: Nádrž dešťové vody; Typ: Nádrž dešťové vody

# IfcBuildingElementProxy: Přečerpávací stanice SO102_01:Přečerpávací stanice SO102_01, Přečerpávací stanice SO102_01:Přečerpávací stanice SO102_01:13150415
In: -1.PP_SO-102
Type - Classification: CO00 SNIM (SNIM); Material: Plastic - Grundfos - White, Steel - Grundfos - Black
Type - Data - Minimum Operating Temperature: 0 C; Speed at the working points: http://product-selection.grundfos.com/product-detail.html?productnumber=97901084&custid=GMA
Type - Elektroinstalace - Enclosure Rating: 68; Frequency: 50 Hz; Full Load Amperes: 9 A; Load Classification: Other; Maximum Starting Current: 39 A; Motor_IP_Rating: 68; Motor Type: Asynchronous motor; Number of Poles: 1; Number of Poles Integer: 2; Phase: 1; PowerFactor: 0.93; Voltage: 230 V; Wattage: 1400 W
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Connection Type: DIN flange; Flow: 0.0166667 m3/s; FluidTempMax: 40 C; FluidTempMin: 0 C; Head: 6724000 Pa; Maximum Operating Temperature: 40 C; Pump Type: Wastewater pump (macerator); RPM: 1430; Speed Type: Fixed; Suction Connection diameter: 110 mm
Type - Konstrukce - Gross Weight: 1.37293 kN
Type - Materiály a povrchové úpravy - Coupler Material: Steel - Grundfos - Black; Impeller Material: Luranyl; Material: Cast Iron; Pump Material: Steel - Grundfos - Black; Tank Material: Plastic - Grundfos - White
Type - Kóty - Jmenovitá velikost vstupu: 110 mm; Jmenovitá velikost výstupu: 110 mm
Type - Identifikační data - Approvals: CE, EAC, LGA; Author: Grundfos Holding A/S; Číslo OmniClass: 23.27.17.00; Copyright: Grundfos Holding A/S; Date Last Modified: August 1, 2017; Equipment Abbreviation: PMP; Kód sestavy: CO00; Komentáře k typům: PŘEČERPÁVACÍ ZAŘÍZENÍ SPLAŠEK; Manufacturer Website: http://www.grundfos.com; Model: MD.12.1.4; Model Disclaimer: For More Information, Contact Grundfos; Název typu: Přečerpávací stanice SO102_01; Označení typu: 02; Popis: Lifting stations for collecting and removing wastewater of inside buildings; Popis sestavy: Obecný prvek; ProductCode: MD.12.1.4; Product Literature: http://product-selection.grundfos.com/product-detail.html?productnumber=97901084&custid=GMA; Product Model Number: 97901084; Product Range: MD000; Uniclass2: Pr_65_53_96_50; URL: http://product-selection.grundfos.com/; Výrobce: Grundfos
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Přečerpávací stanice SO102_01
Classification: CO00 SNIM (SNIM); CO00 Uniformat (Uniformat); Group: SW_Odvětrání kanalizace 16; SW_Splašky vnitřní gravitační 3; SW_Splašky čerpání 1; SW_Splašky vnitřní gravitační 15; SW_Splašky vnitřní gravitační 65
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.65383 m2; NetVolume: 0.212942 m3
Mechanické – tok - Průtok: 0.01 m3/s
Text - CCI Funkční systém: F; CCI Komponenta: DAD; CCI Technický systém: JB
Vazby - Podlaží: -1.PP_SO-102; Hostitel: Podlaží : -1.PP_SO-102; Odsazení od hostitele: -3945.56 mm; Výška od podlaží: -3945.56 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární,Nedefinovaný,Průduch,Nedefinovaný,Sanitární,Nedefinovaný,Sanitární,Nedefinovaný,Sanitární,Napájení; Název systému: SW_Splašky čerpání 1,SW_Odvětrání kanalizace 16,SW_Splašky vnitřní gravitační 15,SW_Splašky vnitřní gravitační 65,SW_Splašky vnitřní gravitační 3
Grafika - Annotative Symbol Native Radius: 3.175 mm; Clearance Depth Back: 600 mm; Clearance Depth Front: 600 mm; Clearance Depth Left: 600 mm; Clearance Depth Right: 600 mm; Clearance Height: 600 mm; Has Clearance Areas: no; Show Annotative Symbol: no; Show Masking Regions: yes
Stavba - Rear Inlet Eccentric Disk Angle: 0 deg
Kóty - Objem: 0.209412 m3; Plocha: 9.72696 m2
Identifikační data - Kód prvku: CO00.02.0002; Označení: 0002; Part Description: Lifting stations for collecting and removing wastewater of inside buildings; Part Number: MD.12.1.4
Jiné - Páteřní trasa: yes; Id typu: 13149519; Rodina: Přečerpávací stanice SO102_01; Rodina a typ: Přečerpávací stanice SO102_01: Přečerpávací stanice SO102_01; Typ: Přečerpávací stanice SO102_01

# IfcBuildingElementProxy: Přečerpávací stanice SO102_01:Přečerpávací stanice SO102_02, Přečerpávací stanice SO102_01:Přečerpávací stanice SO102_02:13736833
In: -1.PP_SO-102
Type - Material: Plastic - Grundfos - White, Steel - Grundfos - Black
Type - Data - Minimum Operating Temperature: 0 C; Speed at the working points: http://product-selection.grundfos.com/product-detail.html?productnumber=97901084&custid=GMA
Type - Elektroinstalace - Load Classification: Other; Number of Poles: 1; Number of Poles Integer: 2; Phase: 1; Enclosure Rating: 68; Frequency: 50 Hz; Full Load Amperes: 9 A; Maximum Starting Current: 39 A; Motor_IP_Rating: 68; Motor Type: Asynchronous motor; PowerFactor: 0.93; Voltage: 230 V; Wattage: 1400 W
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Connection Type: DIN flange; Flow: 0.0166667 m3/s; FluidTempMax: 40 C; FluidTempMin: 0 C; Head: 6724000 Pa; Maximum Operating Temperature: 40 C; Pump Type: Wastewater pump (macerator); RPM: 1430; Speed Type: Fixed; Suction Connection diameter: 110 mm
Type - Konstrukce - Gross Weight: 1.37293 kN
Type - Materiály a povrchové úpravy - Coupler Material: Steel - Grundfos - Black; Pump Material: Steel - Grundfos - Black; Tank Material: Plastic - Grundfos - White; Impeller Material: Luranyl; Material: Cast Iron
Type - Kóty - Jmenovitá velikost vstupu: 110 mm; Jmenovitá velikost výstupu: 110 mm
Type - Identifikační data - Approvals: CE, EAC, LGA; Author: Grundfos Holding A/S; Číslo OmniClass: 23.27.17.00; Copyright: Grundfos Holding A/S; Date Last Modified: August 1, 2017; Equipment Abbreviation: PMP; Komentáře k typům: PŘEČERPÁVACÍ ZAŘÍZENÍ DEŠŤŮ; Manufacturer Website: http://www.grundfos.com; Model: MD.12.1.4; Model Disclaimer: For More Information, Contact Grundfos; Název typu: Přečerpávací stanice SO102_02; Označení typu: 03; Popis: Lifting stations for collecting and removing wastewater of inside buildings; ProductCode: MD.12.1.4; Product Literature: http://product-selection.grundfos.com/product-detail.html?productnumber=97901084&custid=GMA; Product Model Number: 97901084; Product Range: MD000; Uniclass2: Pr_65_53_96_50; URL: http://product-selection.grundfos.com/; Výrobce: Grundfos
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Přečerpávací stanice SO102_01
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.65383 m2; NetVolume: 0.212942 m3
Mechanické – tok - Průtok: 0.01 m3/s
Text - CCI Funkční systém: F; CCI Komponenta: DAD; CCI Technický systém: JB
Vazby - Podlaží: -1.PP_SO-102; Hostitel: Podlaží : -1.PP_SO-102; Odsazení od hostitele: -3166.56 mm; Výška od podlaží: -3166.56 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Sanitární,Nedefinovaný,Průduch,Nedefinovaný,Sanitární,Napájení; Název systému: SW_Deště čerpání 1,SW_Odvětrání kanalizace 16,SW_Deště vnitřní gravitační 2
Grafika - Has Clearance Areas: no; Show Annotative Symbol: no; Show Masking Regions: yes; Annotative Symbol Native Radius: 3.175 mm; Clearance Depth Back: 600 mm; Clearance Depth Front: 600 mm; Clearance Depth Left: 600 mm; Clearance Depth Right: 600 mm; Clearance Height: 600 mm
Stavba - Rear Inlet Eccentric Disk Angle: 0 deg
Kóty - Objem: 0.209412 m3; Plocha: 9.72696 m2
Identifikační data - Kód prvku: .03.0003; Označení: 0003; Part Description: Lifting stations for collecting and removing wastewater of inside buildings; Part Number: MD.12.1.4
Jiné - Páteřní trasa: yes; Rodina: Přečerpávací stanice SO102_01; Id typu: 13981703; Rodina a typ: Přečerpávací stanice SO102_01: Přečerpávací stanice SO102_02; Typ: Přečerpávací stanice SO102_02
Group: SW_Odvětrání kanalizace 16; SW_Deště vnitřní gravitační 2; SW_Deště čerpání 1

# IfcBuildingElementProxy: Zásobník TUV:Standardní (4)
In: -1.PP_SO-102
Type - Classification: ZN01 SNIM (SNIM); Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - Horká voda, poloměr: 10 mm; Poloměr oběhu: 10 mm; Poloměr vytápění: 12.5 mm; Studená voda, poloměr: 12.5 mm
Type - Identifikační data - Cena: 82600; Kód sestavy: ZN01; Název typu: Standardní; Označení typu: 04; Popis sestavy: Stojatý
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Zásobník TUV
Classification: ZN01 SNIM (SNIM); ZN01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 8.59363 m2; NetVolume: 1.38889 m3
Text - CCI Funkční systém: H; CCI Komponenta: CPA; CCI Technický systém: HD
Vazby - Podlaží: -1.PP_SO-102; Hostitel: Podlaží : -1.PP_SO-102; Odsazení od hostitele: -1200 mm; Výška od podlaží: -1200 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Teplá voda v domácnosti,Přívod teplé vody,Teplá voda v domácnosti,Zpětné vedení teplé vody,Studená voda v domácnosti; Objem vody: 0 m3; Pokles tlaku užitkové vody: 0 Pa; Tlakový spád vody: 0 Pa; Tok vody: 0 m3/s
Kóty - Objem: 1.38889 m3; Poloměr: 500 mm; Výš.: 1850 mm; Výška A: 93.24 mm; Výška B: 264.273 mm; Výška C: 155.4 mm
Identifikační data - ID systému: 3; Komentáře: Zásobník TUV
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 13702958; Rodina: Zásobník TUV; Rodina a typ: Zásobník TUV: Standardní
Name (Zásobník TUV:Standardní:...) | ID pozice | Kód prvku | Označení
13805464 | 04 | ZN01.04.0004 | 0004
13805466 | 05 | ZN01.04.0006 | 0006
13805467 | 06 | ZN01.04.0007 | 0007
13805468 | 03 | ZN01.04.0008 | 0008

# IfcDistributionPort (11856)
Description: Flow
Name | FlowDirection | PredefinedType | SystemType | Group
InPort_12797920_1 | SINK | PIPE | SEWAGE
OutPort_12797919_1 | SOURCE | PIPE | SEWAGE
Port_12797920_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12797925_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 1
OutPort_12797927_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 1
InPort_12797926_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_12797926_2 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12797927_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 1
OutPort_12797926_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 1
InPort_12805480_1 | SINK | PIPE | SEWAGE
OutPort_12805479_1 | SOURCE | PIPE | SEWAGE
Port_12805480_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky přípojka 1
InPort_12805485_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 3
OutPort_12805487_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 3
InPort_12805486_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_12805486_2 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12805487_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 3
OutPort_12805486_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 3
InPort_12825629_1 | SINK | PIPE | SEWAGE
OutPort_12825620_1 | SOURCE | PIPE | SEWAGE
InPort_12825621_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 7
InPort_12825623_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 7
OutPort_12825621_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 7
InPort_12825622_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 5
InPort_12825625_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 5
OutPort_12825622_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 5
InPort_12825627_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 7
OutPort_12825623_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 7
InPort_12825627_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 5
OutPort_12825625_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 5
Port_12825629_2 | SOURCEANDSINK | PIPE | SEWAGE
OutPort_12828508_1 | SOURCE | PIPE | SEWAGE
InPort_12832321_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12832321_2 | SINK | PIPE | DOMESTICHOTWATER
Port_12832321_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER
InPort_12833265_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_12833329_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12833329_2 | SINK | PIPE | DOMESTICHOTWATER
Port_12833329_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER
InPort_12833330_1 | SINK | PIPE | DOMESTICHOTWATER
Port_12833554_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12833557_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12833579_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12833582_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12833680_1 | SINK | PIPE | SEWAGE
OutPort_12833679_1 | SOURCE | PIPE | SEWAGE
Port_12833680_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky přípojka 3
InPort_12833685_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 6
OutPort_12833687_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 6
InPort_12833686_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_12833686_2 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12833687_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 6
OutPort_12833686_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 6
InPort_12833744_1 | SINK | PIPE | SEWAGE
OutPort_12833743_1 | SOURCE | PIPE | SEWAGE
Port_12833744_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky přípojka 2
InPort_12833749_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 2
OutPort_12833751_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 2
InPort_12833750_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_12833750_2 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12833751_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 2
OutPort_12833750_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 2
InPort_12864816_2 | SINK | PIPE | SEWAGE
OutPort_12864814_1 | SOURCE | PIPE | SEWAGE
Port_12864816_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12864817_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_12864817_2 | SINK | PIPE | DOMESTICCOLDWATER
Port_12864817_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 24
Port_12864819_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 24
Port_12864818_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 24
Port_12864819_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 24
InPort_12865987_1 | SINK | PIPE | SEWAGE
OutPort_12865978_1 | SOURCE | PIPE | SEWAGE
InPort_12865979_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 26
InPort_12865981_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 26
OutPort_12865979_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 26
InPort_12865980_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 25
InPort_12865983_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 25
OutPort_12865980_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 25
InPort_12865985_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 26
OutPort_12865981_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 26
InPort_12865985_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 25
OutPort_12865983_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 25
Port_12865987_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_12866033_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12866036_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12871091_1 | SINK | PIPE | SEWAGE
OutPort_12871082_1 | SOURCE | PIPE | SEWAGE
InPort_12871083_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 19
InPort_12871085_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 19
OutPort_12871083_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 19
InPort_12871084_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 16
InPort_12871087_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 16
OutPort_12871084_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 16
InPort_12871089_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 19
OutPort_12871085_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 19
InPort_12871089_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 16
OutPort_12871087_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 16
Port_12871091_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12871119_1 | SINK | PIPE | SEWAGE
OutPort_12871110_1 | SOURCE | PIPE | SEWAGE
InPort_12871111_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 10
InPort_12871113_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 10
OutPort_12871111_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 10
InPort_12871112_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 15
InPort_12871115_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 15
OutPort_12871112_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 15
InPort_12871117_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 10
OutPort_12871113_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 10
InPort_12871117_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 15
OutPort_12871115_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 15
Port_12871119_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12871180_1 | SINK | PIPE | SEWAGE
OutPort_12871171_1 | SOURCE | PIPE | SEWAGE
InPort_12871172_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 9
InPort_12871174_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 9
OutPort_12871172_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 9
InPort_12871173_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 7
InPort_12871176_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 7
OutPort_12871173_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 7
InPort_12871178_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 9
OutPort_12871174_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 9
InPort_12871178_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 7
OutPort_12871176_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 7
Port_12871180_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12874867_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_12874867_2 | SINK | PIPE | DOMESTICCOLDWATER
Port_12879216_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12879219_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12879265_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12879268_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12879276_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12879279_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12879291_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12879294_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12879304_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12879307_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12879381_1 | SINK | PIPE | SEWAGE
OutPort_12879372_1 | SOURCE | PIPE | SEWAGE
InPort_12879373_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 27
InPort_12879375_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 27
OutPort_12879373_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 27
InPort_12879374_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 26
InPort_12879377_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 26
OutPort_12879374_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 26
InPort_12879379_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 27
OutPort_12879375_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 27
InPort_12879379_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 26
OutPort_12879377_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 26
Port_12879381_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12879422_1 | SINK | PIPE | SEWAGE
OutPort_12879413_1 | SOURCE | PIPE | SEWAGE
InPort_12879414_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 25
InPort_12879416_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 25
OutPort_12879414_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 25
InPort_12879415_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 21
InPort_12879418_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 21
OutPort_12879415_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 21
InPort_12879420_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 25
OutPort_12879416_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 25
InPort_12879420_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 21
OutPort_12879418_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 21
Port_12879422_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12879451_1 | SINK | PIPE | SEWAGE
OutPort_12879442_1 | SOURCE | PIPE | SEWAGE
InPort_12879443_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 28
InPort_12879445_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 28
OutPort_12879443_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 28
InPort_12879444_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 27
InPort_12879447_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 27
OutPort_12879444_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 27
InPort_12879449_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 28
OutPort_12879445_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 28
InPort_12879449_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 27
OutPort_12879447_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 27
Port_12879451_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12879482_1 | SINK | PIPE | SEWAGE
OutPort_12879473_1 | SOURCE | PIPE | SEWAGE
InPort_12879474_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 29
InPort_12879476_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 29
OutPort_12879474_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 29
InPort_12879475_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 28
InPort_12879478_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 28
OutPort_12879475_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 28
InPort_12879480_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 29
OutPort_12879476_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 29
InPort_12879480_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 28
OutPort_12879478_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 28
Port_12879482_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12879509_1 | SINK | PIPE | SEWAGE
OutPort_12879500_1 | SOURCE | PIPE | SEWAGE
InPort_12879501_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 30
InPort_12879503_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 30
OutPort_12879501_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 30
InPort_12879502_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 29
InPort_12879505_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 29
OutPort_12879502_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 29
InPort_12879507_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 30
OutPort_12879503_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 30
InPort_12879507_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 29
OutPort_12879505_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 29
Port_12879509_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12879538_1 | SINK | PIPE | SEWAGE
OutPort_12879529_1 | SOURCE | PIPE | SEWAGE
InPort_12879530_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 31
InPort_12879532_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 31
OutPort_12879530_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 31
InPort_12879531_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 30
InPort_12879534_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 30
OutPort_12879531_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 30
InPort_12879536_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 31
OutPort_12879532_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 31
InPort_12879536_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 30
OutPort_12879534_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 30
Port_12879538_2 | SOURCEANDSINK | PIPE | SEWAGE
OutPort_12879585_1 | SOURCE | PIPE | SEWAGE
InPort_12879586_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12879587_1 | SOURCE | PIPE | SEWAGE
Port_12879587_2 | SOURCEANDSINK | PIPE
OutPort_12879627_1 | SOURCE | PIPE | SEWAGE
InPort_12879628_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12879629_1 | SOURCE | PIPE | SEWAGE
Port_12879629_2 | SOURCEANDSINK | PIPE
OutPort_12879639_1 | SOURCE | PIPE | SEWAGE
InPort_12879640_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12879641_1 | SOURCE | PIPE | SEWAGE
Port_12879641_2 | SOURCEANDSINK | PIPE
Port_12880184_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12880187_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12880670_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12880673_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12880674_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12880677_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12880678_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12880681_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12880682_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12880685_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12880686_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12880689_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12880700_1 | SINK | PIPE | SEWAGE
OutPort_12880691_1 | SOURCE | PIPE | SEWAGE
InPort_12880692_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 42
InPort_12880694_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 42
OutPort_12880692_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 42
InPort_12880693_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 41
InPort_12880696_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 41
OutPort_12880693_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 41
InPort_12880698_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 42
OutPort_12880694_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 42
InPort_12880698_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 41
OutPort_12880696_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 41
Port_12880700_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12880714_1 | SINK | PIPE | SEWAGE
OutPort_12880705_1 | SOURCE | PIPE | SEWAGE
InPort_12880706_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 44
InPort_12880708_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 44
OutPort_12880706_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 44
InPort_12880707_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 43
InPort_12880710_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 43
OutPort_12880707_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 43
InPort_12880712_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 44
OutPort_12880708_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 44
InPort_12880712_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 43
OutPort_12880710_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 43
Port_12880714_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12880742_1 | SINK | PIPE | SEWAGE
OutPort_12880733_1 | SOURCE | PIPE | SEWAGE
InPort_12880734_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 48
InPort_12880736_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 48
OutPort_12880734_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 48
InPort_12880735_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 47
InPort_12880738_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 47
OutPort_12880735_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 47
InPort_12880740_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 48
OutPort_12880736_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 48
InPort_12880740_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 47
OutPort_12880738_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 47
Port_12880742_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12880756_1 | SINK | PIPE | SEWAGE
OutPort_12880747_1 | SOURCE | PIPE | SEWAGE
InPort_12880748_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 50
InPort_12880750_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 50
OutPort_12880748_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 50
InPort_12880749_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 49
InPort_12880752_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 49
OutPort_12880749_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 49
InPort_12880754_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 50
OutPort_12880750_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 50
InPort_12880754_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 49
OutPort_12880752_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 49
Port_12880756_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12880770_1 | SINK | PIPE | SEWAGE
OutPort_12880761_1 | SOURCE | PIPE | SEWAGE
InPort_12880762_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 52
InPort_12880764_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 52
OutPort_12880762_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 52
InPort_12880763_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 51
InPort_12880766_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 51
OutPort_12880763_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 51
InPort_12880768_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 52
OutPort_12880764_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 52
InPort_12880768_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 51
OutPort_12880766_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 51
Port_12880770_2 | SOURCEANDSINK | PIPE | SEWAGE
OutPort_12880776_1 | SOURCE | PIPE | SEWAGE
InPort_12880777_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12880778_1 | SOURCE | PIPE | SEWAGE
Port_12880778_2 | SOURCEANDSINK | PIPE
OutPort_12880781_1 | SOURCE | PIPE | SEWAGE
InPort_12880782_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12880783_1 | SOURCE | PIPE | SEWAGE
Port_12880783_2 | SOURCEANDSINK | PIPE
OutPort_12880786_1 | SOURCE | PIPE | SEWAGE
InPort_12880787_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12880788_1 | SOURCE | PIPE | SEWAGE
Port_12880788_2 | SOURCEANDSINK | PIPE
Port_12880840_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12880843_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12880844_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12880847_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12880848_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12880851_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12880852_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12880855_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12880856_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12880859_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12880870_1 | SINK | PIPE | SEWAGE
OutPort_12880861_1 | SOURCE | PIPE | SEWAGE
InPort_12880862_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 43
InPort_12880864_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 43
OutPort_12880862_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 43
InPort_12880863_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 42
InPort_12880866_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 42
OutPort_12880863_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 42
InPort_12880868_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 43
OutPort_12880864_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 43
InPort_12880868_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 42
OutPort_12880866_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 42
Port_12880870_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12880884_1 | SINK | PIPE | SEWAGE
OutPort_12880875_1 | SOURCE | PIPE | SEWAGE
InPort_12880876_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 47
InPort_12880878_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 47
OutPort_12880876_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 47
InPort_12880877_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 46
InPort_12880880_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 46
OutPort_12880877_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 46
InPort_12880882_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 47
OutPort_12880878_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 47
InPort_12880882_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 46
OutPort_12880880_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 46
Port_12880884_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12880912_1 | SINK | PIPE | SEWAGE
OutPort_12880903_1 | SOURCE | PIPE | SEWAGE
InPort_12880904_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 54
InPort_12880906_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 54
OutPort_12880904_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 54
InPort_12880905_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 53
InPort_12880908_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 53
OutPort_12880905_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 53
InPort_12880910_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 54
OutPort_12880906_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 54
InPort_12880910_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 53
OutPort_12880908_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 53
Port_12880912_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12880926_1 | SINK | PIPE | SEWAGE
OutPort_12880917_1 | SOURCE | PIPE | SEWAGE
InPort_12880918_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 56
InPort_12880920_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 56
OutPort_12880918_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 56
InPort_12880919_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 55
InPort_12880922_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 55
OutPort_12880919_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 55
InPort_12880924_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 56
OutPort_12880920_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 56
InPort_12880924_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 55
OutPort_12880922_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 55
Port_12880926_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12880940_1 | SINK | PIPE | SEWAGE
OutPort_12880931_1 | SOURCE | PIPE | SEWAGE
InPort_12880932_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 58
InPort_12880934_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 58
OutPort_12880932_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 58
InPort_12880933_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 57
InPort_12880936_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 57
OutPort_12880933_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 57
InPort_12880938_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 58
OutPort_12880934_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 58
InPort_12880938_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 57
OutPort_12880936_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 57
Port_12880940_2 | SOURCEANDSINK | PIPE | SEWAGE
OutPort_12880946_1 | SOURCE | PIPE | SEWAGE
InPort_12880947_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12880948_1 | SOURCE | PIPE | SEWAGE
Port_12880948_2 | SOURCEANDSINK | PIPE
OutPort_12880951_1 | SOURCE | PIPE | SEWAGE
InPort_12880952_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12880953_1 | SOURCE | PIPE | SEWAGE
Port_12880953_2 | SOURCEANDSINK | PIPE
OutPort_12880956_1 | SOURCE | PIPE | SEWAGE
InPort_12880957_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12880958_1 | SOURCE | PIPE | SEWAGE
Port_12880958_2 | SOURCEANDSINK | PIPE
Port_12881010_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12881013_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12881014_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12881017_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12881018_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12881021_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12881022_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12881025_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12881026_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12881029_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12881040_1 | SINK | PIPE | SEWAGE
OutPort_12881031_1 | SOURCE | PIPE | SEWAGE
InPort_12881032_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 45
InPort_12881034_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 45
OutPort_12881032_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 45
InPort_12881033_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 44
InPort_12881036_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 44
OutPort_12881033_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 44
InPort_12881038_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 45
OutPort_12881034_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 45
InPort_12881038_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 44
OutPort_12881036_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 44
Port_12881040_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12881054_1 | SINK | PIPE | SEWAGE
OutPort_12881045_1 | SOURCE | PIPE | SEWAGE
InPort_12881046_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 53
InPort_12881048_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 53
OutPort_12881046_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 53
InPort_12881047_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 52
InPort_12881050_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 52
OutPort_12881047_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 52
InPort_12881052_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 53
OutPort_12881048_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 53
InPort_12881052_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 52
