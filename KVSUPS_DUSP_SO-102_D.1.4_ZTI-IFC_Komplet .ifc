Properties of the parts of a building model (IFC4), part 57 of 60

# IfcPipeSegment: Typy trubek:PVC-U_KG systém (166)
Name (Typy trubek:PVC-U_KG systém:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Instalační jednotky | Relativní drsnost | CCI Funkční systém | Referenční podlaží | Sklon | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Typ systému | Řez | Klasifikace systému | Název systému = Group | Obrátit výšku (mm) | Průměr (mm) = Vnější průměr (mm) | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa
13144478 | -1.PP_SO-102 | 2973.28 | 0.00950189 | 1.02749 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 2 | -3541.53 | -3596.52 | -3655.98 | -3710.97 | Fáze 1 | SW_Splašky vnitřní gravitační | 3 | Sanitární | SW_Splašky vnitřní gravitační 4 | -7707.77 | 110 | ø110 | 103.6 | TR06.05.0966 | 0966 | yes
13144486 | -1.PP_SO-102 | 5238.37 | 0.0201032 | 2.63309 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 2 | -2119.11 | -2303.84 | -2199.1 | -2383.83 | Fáze 1 | SW_Splašky vnitřní gravitační | 65 | Sanitární | SW_Splašky vnitřní gravitační 3 | -6379.83 | 160 | ø160 | 152 | TR06.05.0967 | 0967 | yes
13144545 | -1.PP_SO-102 | 340.802 | 0.0201032 | 0.171306 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 100 | -1870.89 | -1927.46 | -2168.45 | -2225.01 | Fáze 1 | SW_Splašky vnitřní gravitační | 65 | Sanitární | SW_Splašky vnitřní gravitační 3 | -6222.19 | 160 | ø160 | 152 | TR06.05.0968 | 0968 | yes
13144622 | -1.PP_SO-102 | 1761.86 | 0.0201032 | 0.885607 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 |  | -103.224 | -103.224 | -1865.08 | -1865.08 | Fáze 1 | SW_Splašky vnitřní gravitační | 65 | Sanitární | SW_Splašky vnitřní gravitační 3 | -5865.08 | 160 | ø160 | 152 | TR06.05.0969 | 0969 | yes
13144740 | -1.PP_SO-102 | 366.451 | 0.0201032 | 0.184199 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 2 | -2254.96 | -2334.95 | -2342.27 | -2422.26 | Fáze 1 | SW_Splašky vnitřní gravitační | 55 | Sanitární | SW_Splašky vnitřní gravitační 3 | -6418.26 | 160 | ø160 | 152 | TR06.05.0970 | 0970 | yes
13144754 | -1.PP_SO-102 | 13033.7 | 0.0201032 | 6.55144 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 2 | -1756.1 | -1836.08 | -2096.7 | -2176.69 | Fáze 1 | SW_Splašky vnitřní gravitační | 55 | Sanitární | SW_Splašky vnitřní gravitační 3 | -6172.69 | 160 | ø160 | 152 | TR06.05.0971 | 0971 | yes
13144999 | -1.PP_SO-102 | 311 | 0.0201032 | 0.156325 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 2 | -3333.65 | -3419.85 | -3413.63 | -3499.84 | Fáze 1 | SW_Splašky vnitřní gravitační | 51 | Sanitární | SW_Splašky vnitřní gravitační 3 | -7495.84 | 160 | ø160 | 152 | TR06.05.0972 | 0972 | yes
13145012 | -1.PP_SO-102 | 3289.11 | 0.0201032 | 1.65328 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 2 | -3346.73 | -3492.48 | -3426.71 | -3572.47 | Fáze 1 | SW_Splašky vnitřní gravitační | 24 | Sanitární | SW_Splašky vnitřní gravitační 3 | -7568.47 | 160 | ø160 | 152 | TR06.05.0973 | 0973 | yes
13145022 | -1.PP_SO-102 | 241.523 | 0.0201032 | 0.121403 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 2 | -3413.95 | -3498.77 | -3493.94 | -3578.75 | Fáze 1 | SW_Splašky vnitřní gravitační | 24 | Sanitární | SW_Splašky vnitřní gravitační 3 | -7574.75 | 160 | ø160 | 152 | TR06.05.0974 | 0974 | yes
13145032 | -1.PP_SO-102 | 3625.49 | 0.0201032 | 1.82237 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 2 | -3420.24 | -3572.72 | -3500.22 | -3652.7 | Fáze 1 | SW_Splašky vnitřní gravitační | 24 | Sanitární | SW_Splašky vnitřní gravitační 3 | -7648.7 | 160 | ø160 | 152 | TR06.05.0975 | 0975 | yes
13150416 | -1.PP_SO-102 | 88.7206 | 0.0201032 | 0.0445959 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 0 | -3550.56 | -3630.56 | -3630.56 | -3710.56 | Fáze 1 | SW_Splašky vnitřní gravitační | 24 | Sanitární | SW_Splašky vnitřní gravitační 3 | -7706.56 | 160 | ø160 | 152 | TR06.05.0976 | 0976 | yes
13150420 | -1.PP_SO-102 | 2218.62 | 0.00950189 | 0.766701 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 |  | -1162.94 | -1162.94 | -3381.56 | -3381.56 | Fáze 1 | SW_Splašky čerpání | 3 | Sanitární | SW_Splašky čerpání 2 | -7381.56 | 110 | ø110 | 103.6 | TR06.05.0977 | 0977 | yes
13150426 | -1.PP_SO-102 | 376.927 | 0.0201032 | 0.189464 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 15 | -3494.56 | -3629.59 | -3573.67 | -3708.7 | Fáze 1 | SW_Splašky vnitřní gravitační | 24 | Sanitární | SW_Splašky vnitřní gravitační 3 | -7704.75 | 160 | ø160 | 152 | TR06.05.0978 | 0978 | yes
13150532 | -1.PP_SO-102 | 138.397 | 0.00950189 | 0.0478265 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 27.1084 | -3605.07 | -3658.16 | -3694.37 | -3747.45 | Fáze 1 | SW_Splašky vnitřní gravitační | 3 | Sanitární | SW_Splašky vnitřní gravitační 4 | -7744.36 | 110 | ø110 | 103.6 | TR06.05.0979 | 0979 | yes
13150546 | -1.PP_SO-102 | 12.0665 | 0.00950189 | 0.00416987 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 0 | -3641.56 | -3696.56 | -3696.56 | -3751.56 | Fáze 1 | SW_Splašky vnitřní gravitační | 3 | Sanitární | SW_Splašky vnitřní gravitační 4 | -7748.36 | 110 | ø110 | 103.6 | TR06.05.0980 | 0980 | yes
13152161 | -1.PP_SO-102 | 139.314 | 0.0201032 | 0.070027 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 2 | -3336.06 | -3416.05 | -3418.83 | -3498.82 | Fáze 1 | SW_Splašky vnitřní gravitační | 28 | Sanitární | SW_Splašky vnitřní gravitační 3 | -7494.82 | 160 | ø160 | 152 | TR06.05.0983 | 0983 | yes
13152888 | -1.PP_SO-102 | 305.969 | 0.00950189 | 0.105735 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 100 | -3322.86 | -3578.1 | -3361.75 | -3616.99 | Fáze 1 | SW_Splašky vnitřní gravitační | 3 | Sanitární | SW_Splašky vnitřní gravitační 4 | -7614.73 | 110 | ø110 | 103.6 | TR06.05.0986 | 0986 | yes
13155543 | -1.PP_SO-102 | 6860.59 | 0.0201032 | 3.44851 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 2 | -3195.01 | -3412.18 | -3274.99 | -3492.16 | Fáze 1 | SW_Splašky vnitřní gravitační | 51 | Sanitární | SW_Splašky vnitřní gravitační 3 | -7488.16 | 160 | ø160 | 152 | TR06.05.1022 | 1022 | yes
13156174 | -1.PP_SO-102 | 2250.33 | 0.00950189 | 0.777658 | ø110 mm |  | 0 | G | -1.PP_SO-102 | 4893479 | -1162.94 | -1162.94 | -3413.27 | -3413.27 | Fáze 1 | SW_Odvětrání kanalizace | 132 | Průduch | SW_Odvětrání kanalizace 16 | -7413.27 | 110 | ø110 | 103.6 | TR06.05.1028 | 1028 | yes
13156488 | -1.PP_SO-102 | 5128.98 | 0.00950189 | 1.77245 | ø110 mm |  | 0.000140449 | G | -1.PP_SO-102 | 0 | -1045 | -1100 | -1100 | -1155 | Fáze 1 | SW_Odvětrání kanalizace | 38 | Průduch | SW_Odvětrání kanalizace 16 | -5151.8 | 110 | ø110 | 103.6 | TR06.05.1029 | 1029 | yes
13156665 | -1.PP_SO-102 | 5744.66 | 0.00950189 | 1.98521 | ø110 mm |  | 0.000100604 | G | -1.PP_SO-102 | 0 | 3055 | 3000 | 3000 | 2945 | Fáze 1 | SW_Odvětrání kanalizace | 142 | Průduch | SW_Odvětrání kanalizace 16 | -1051.8 | 110 | ø110 | 103.6 | TR06.05.1030 | 1030 | yes
13156801 | -1.PP_SO-102 | 5114.64 | 0.00950189 | 1.76749 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 0 | -1045 | -1100 | -1100 | -1155 | Fáze 1 | SW_Splašky čerpání | 3 | Sanitární | SW_Splašky čerpání 2 | -5151.8 | 110 | ø110 | 103.6 | TR06.05.1032 | 1032 | yes
13157381 | -1.PP_SO-102 | 115.11 | 0.0201032 | 0.0578606 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 2 | -2466 | -2545.98 | -2548.29 | -2628.27 | Fáze 1 | SW_Splašky vnitřní gravitační | 45 | Sanitární | SW_Splašky vnitřní gravitační 3 | -6624.27 | 160 | ø160 | 152 | TR06.05.1034 | 1034 | yes
13157390 | -1.PP_SO-102 | 2603.61 | 0.0201032 | 1.30872 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 2 | -2270.17 | -2350.15 | -2402.21 | -2482.2 | Fáze 1 | SW_Splašky vnitřní gravitační | 46 | Sanitární | SW_Splašky vnitřní gravitační 3 | -6478.2 | 160 | ø160 | 152 | TR06.05.1035 | 1035 | yes
13157393 | -1.PP_SO-102 | 660.161 | 0.0201032 | 0.331833 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 2 | -2451.34 | -2531.33 | -2544.53 | -2624.51 | Fáze 1 | SW_Splašky vnitřní gravitační | 45 | Sanitární | SW_Splašky vnitřní gravitační 3 | -6620.51 | 160 | ø160 | 152 | TR06.05.1036 | 1036 | yes
13157587 | -1.PP_SO-102 | 47.775 | 0.00950189 | 0.0165099 | ø110 mm |  | 0.00120656 | G | -1.PP_SO-102 |  | 2477.06 | 2477.06 | 2429.29 | 2429.29 | Fáze 1 | SW_Odvětrání kanalizace | 142 | Průduch | SW_Odvětrání kanalizace 16 | -1570.71 | 110 | ø110 | 103.6 | TR06.05.1048 | 1048 | yes
13161562 | -1.PP_SO-102 | 96.8473 | 0.0201032 | 0.0486808 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 2 | -3058.95 | -3138.93 | -3140.87 | -3220.85 | Fáze 1 | SW_Splašky vnitřní gravitační | 52 | Sanitární | SW_Splašky vnitřní gravitační 3 | -7216.86 | 160 | ø160 | 152 | TR06.05.1051 | 1051 | yes
13161571 | -1.PP_SO-102 | 4117.34 | 0.0201032 | 2.0696 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 2 | -2978.56 | -3140.87 | -3058.54 | -3220.85 | Fáze 1 | SW_Splašky vnitřní gravitační | 41 | Sanitární | SW_Splašky vnitřní gravitační 3 | -7216.86 | 160 | ø160 | 152 | TR06.05.1052 | 1052 | yes
13161603 | -1.PP_SO-102 | 2964.82 | 0.0201032 | 1.49028 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 |  | -86.196 | -86.1966 | -3051.01 | -3051.01 | Fáze 1 | SW_Splašky vnitřní gravitační | 52 | Sanitární | SW_Splašky vnitřní gravitační 3 | -7051.01 | 160 | ø160 | 152 | TR06.05.1053 | 1053 | yes
13165227 | -1.PP_SO-102 | 631.943 | 0.0201032 | 0.317649 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 2 | -1735.08 | -1815.07 | -1827.7 | -1907.69 | Fáze 1 | SW_Splašky vnitřní gravitační | 9 | Sanitární | SW_Splašky vnitřní gravitační 3 | -5903.69 | 160 | ø160 | 152 | TR06.05.1057 | 1057 | yes
13165260 | -1.PP_SO-102 | 2747.13 | 0.0201032 | 1.38086 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 2 | -1678.69 | -1758.68 | -1813.61 | -1893.59 | Fáze 1 | SW_Splašky vnitřní gravitační | 9 | Sanitární | SW_Splašky vnitřní gravitační 3 | -5889.59 | 160 | ø160 | 152 | TR06.05.1058 | 1058 | yes
13165321 | -1.PP_SO-102 | 651.033 | 0.0201032 | 0.327245 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 100 | -1216.02 | -1732.94 | -1272.59 | -1789.51 | Fáze 1 | SW_Splašky vnitřní gravitační | 9 | Sanitární | SW_Splašky vnitřní gravitační 3 | -5786.68 | 160 | ø160 | 152 | TR06.05.1059 | 1059 | yes
13370349 | -1.PP_SO-102 | 745.12 | 0.01227 | 0.292608 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 |  | -400.39 | -1145.51 | -400.39 | -1145.51 | Fáze 2 | SW_Splašky vnitřní gravitační | 129 | Sanitární | SW_Splašky vnitřní gravitační 3 | -5145.51 | 125 | ø125 | 118.6 | TR06.05.1313 | 1313 | yes
13414023 | -1.PP_SO-102 | 2904.16 | 0.0314112 | 1.82474 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 |  | 1963.4 | -940.763 | 1963.4 | -940.763 | Fáze 1 | SW_Splašky vnitřní gravitační | 738 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -4940.76 | 200 | ø200 | 190.2 | TR06.05.1348 | 1348 | yes
13418990 | -1.PP_SO-102 | 2206.68 | 0.04908 | 1.73312 | ø250 mm | 0 | 0.000526094 | G | -1.PP_SO-102 | 1 | -1295.25 | -1442.31 | -1420.25 | -1567.31 | Fáze 1 | SW_Splašky vnitřní gravitační | 733 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -5561.11 | 250 | ø250 | 237.6 | TR06.05.1349 | 1349 | yes
13419357 | -1.PP_SO-102 | 286.393 | 0.0201032 | 0.143957 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 100 | -891.988 | -1151.07 | -948.556 | -1207.64 | Fáze 1 | SW_Splašky vnitřní gravitační | 730 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -5204.81 | 160 | ø160 | 152 | TR06.05.1350 | 1350 | yes
13426696 | -1.PP_SO-102 | 505.226 | 0.00950189 | 0.174593 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 100 | 3181.74 | 2785.61 | 3142.85 | 2746.71 | Fáze 1 | SW_Splašky vnitřní gravitační | 219 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1251.02 | 110 | ø110 | 103.6 | TR06.05.1351 | 1351 | yes
13429070 | -1.PP_SO-102 | 1051.99 | 0.0314112 | 0.660983 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 1 | 2552.62 | 2442.1 | 2452.62 | 2342.11 | Fáze 1 | SW_Splašky vnitřní gravitační | 577 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1652.99 | 200 | ø200 | 190.2 | TR06.05.1356 | 1356 | yes
13429118 | -1.PP_SO-102 | 1931.79 | 0.0314112 | 1.21378 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 2 | 2640.33 | 2540.35 | 2501.72 | 2401.74 | Fáze 1 | SW_Splašky vnitřní gravitační | 271 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1593.36 | 200 | ø200 | 190.2 | TR06.05.1357 | 1357 | yes
13431874 | -1.PP_SO-102 | 1847.42 | 0.00950189 | 0.638424 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 2 | 2925.25 | 2833.32 | 2870.27 | 2778.34 | Fáze 2 | SW_Splašky vnitřní gravitační | 234 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1218.47 | 110 | ø110 | 103.6 | TR06.05.1359 | 1359 | yes | Identifikační data - Komentáře: S19
13432671 | -1.PP_SO-102 | 5750.97 | 0.01227 | 2.2584 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 2 | -1518.09 | -1695.58 | -1580.58 | -1758.06 | Fáze 2 | SW_Splašky vnitřní gravitační | 129 | Sanitární | SW_Splašky vnitřní gravitační 3 | -5754.86 | 125 | ø125 | 118.6 | TR06.05.1362 | 1362 | yes
13432693 | -1.PP_SO-102 | 1041.07 | 0.01227 | 0.408828 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 2 | -1496.09 | -1558.58 | -1579.4 | -1641.88 | Fáze 2 | SW_Splašky vnitřní gravitační | 129 | Sanitární | SW_Splašky vnitřní gravitační 3 | -5638.69 | 125 | ø125 | 118.6 | TR06.05.1363 | 1363 | yes
13432707 | -1.PP_SO-102 | 2641.38 | 0.01227 | 1.03727 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 2 | -1442.09 | -1504.58 | -1557.4 | -1619.88 | Fáze 2 | SW_Splašky vnitřní gravitační | 129 | Sanitární | SW_Splašky vnitřní gravitační 3 | -5616.68 | 125 | ø125 | 118.6 | TR06.05.1364 | 1364 | yes
13432717 | -1.PP_SO-102 | 815.173 | 0.01227 | 0.320118 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 2 | -1424.61 | -1487.1 | -1503.4 | -1565.88 | Fáze 2 | SW_Splašky vnitřní gravitační | 129 | Sanitární | SW_Splašky vnitřní gravitační 3 | -5562.68 | 125 | ø125 | 118.6 | TR06.05.1365 | 1365 | yes
13432736 | -1.PP_SO-102 | 3933.12 | 0.01227 | 1.54453 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 2 | -1344.78 | -1407.27 | -1485.91 | -1548.4 | Fáze 2 | SW_Splašky vnitřní gravitační | 129 | Sanitární | SW_Splašky vnitřní gravitační 3 | -5545.2 | 125 | ø125 | 118.6 | TR06.05.1366 | 1366 | yes
13432831 | -1.PP_SO-102 | 766.41 | 0.01227 | 0.300969 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 2 | -1749.57 | -1812.06 | -1827.39 | -1889.87 | Fáze 1 | SW_Splašky vnitřní gravitační | 129 | Sanitární | SW_Splašky vnitřní gravitační 3 | -5886.67 | 125 | ø125 | 118.6 | TR06.05.1367 | 1367 | yes
13432858 | -1.PP_SO-102 | 269.172 | 0.01227 | 0.105704 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 100 | -1151.83 | -1386.36 | -1196.02 | -1430.55 | Fáze 2 | SW_Splašky vnitřní gravitační | 129 | Sanitární | SW_Splašky vnitřní gravitační 3 | -5428.29 | 125 | ø125 | 118.6 | TR06.05.1368 | 1368 | yes
13436335 | -1.PP_SO-102 | 1109.55 | 0.0314112 | 0.697152 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 1 | 2537.12 | 2437.12 | 2426.03 | 2326.03 | Fáze 1 | SW_Splašky vnitřní gravitační | 738 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1669.07 | 200 | ø200 | 190.2 | TR06.05.1373 | 1373 | yes
13436492 | -1.PP_SO-102 | 421.105 | 0.0201032 | 0.21167 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 0.999864 | 2526.83 | 2446.83 | 2442.62 | 2362.63 | Fáze 1 | SW_Splašky vnitřní gravitační | 1 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1633.37 | 160 | ø160 | 152 | TR06.05.1374 | 1374 | yes
13436587 | -1.PP_SO-102 | 3246.73 | 0.0314112 | 2.03998 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 1.00419 | 2609.97 | 2477.37 | 2509.98 | 2377.38 | Fáze 1 | SW_Splašky vnitřní gravitační | 588 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1617.72 | 200 | ø200 | 190.2 | TR06.05.1375 | 1375 | yes
13437998 | -1.PP_SO-102 | 818.518 | 0.0314112 | 0.51429 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 1.00001 | 2809.23 | 2709.23 | 2701.05 | 2601.05 | Fáze 1 | SW_Splašky vnitřní gravitační | 536 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1394.05 | 200 | ø200 | 190.2 | TR06.05.1380 | 1380 | yes
13439196 | -1.PP_SO-102 | 2629.53 | 0.0314112 | 1.65218 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 2 | 2694.73 | 2542.17 | 2594.75 | 2442.19 | Fáze 1 | SW_Splašky vnitřní gravitační | 271 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1552.91 | 200 | ø200 | 190.2 | TR06.05.1383 | 1383 | yes
13439205 | -1.PP_SO-102 | 7199.31 | 0.00950189 | 2.4879 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 2 | 2800.35 | 2601.4 | 2745.36 | 2546.41 | Fáze 1 | SW_Splašky vnitřní gravitační | 280 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1450.39 | 110 | ø110 | 103.6 | TR06.05.1384 | 1384 | yes
13439373 | -1.PP_SO-102 | 268.1 | 0.0201032 | 0.134762 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 1.00036 | 2530.24 | 2450.24 | 2447.56 | 2367.57 | Fáze 1 | SW_Splašky vnitřní gravitační | 1 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1628.43 | 160 | ø160 | 152 | TR06.05.1385 | 1385 | yes
13439443 | -1.PP_SO-102 | 183.253 | 0.0314112 | 0.115141 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 100 | 2241.14 | 2040.85 | 2170.43 | 1970.14 | Fáze 1 | SW_Splašky vnitřní gravitační | 738 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -2026.39 | 200 | ø200 | 190.2 | TR06.05.1386 | 1386 | yes
13440193 | -1.PP_SO-102 | 300.259 | 0.0314112 | 0.188658 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 1 | 2929.29 | 2826.29 | 2829.29 | 2726.3 | Fáze 2 | SW_Splašky vnitřní gravitační | 284 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1268.8 | 200 | ø200 | 190.2 | TR06.05.1387 | 1387 | yes
13440196 | -1.PP_SO-102 | 121.548 | 0.00950189 | 0.042004 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 2 | 2887.23 | 2832.24 | 2829.81 | 2774.82 | Fáze 2 | SW_Splašky vnitřní gravitační | 234 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1221.98 | 110 | ø110 | 103.6 | TR06.05.1388 | 1388 | yes | Identifikační data - Komentáře: S19
13467076 | -1.PP_SO-102 | 1820.45 | 0.0201032 | 0.915057 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 2 | -2225.89 | -2342.27 | -2305.87 | -2422.26 | Fáze 1 | SW_Splašky vnitřní gravitační | 65 | Sanitární | SW_Splašky vnitřní gravitační 3 | -6418.26 | 160 | ø160 | 152 | TR06.05.1417 | 1417 | yes
13472575 | -1.PP_SO-102 | 621.497 | 0.0201032 | 0.312399 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 |  | -289.794 | -911.291 | -289.794 | -911.291 | Fáze 1 | SW_Deště vnitřní gravitační | 2 | Sanitární | SW_Deště vnitřní gravitační 2 | -4911.29 | 160 | ø160 | 152 | TR06.05.1418 | 1418 | yes
13472672 | -1.PP_SO-102 | 13639.1 | 0.01227 | 5.35608 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 1 | -1173.7 | -1236.19 | -1372.58 | -1435.08 | Fáze 1 | SW_Deště vnitřní gravitační | 3 | Sanitární | SW_Deště vnitřní gravitační 2 | -5431.88 | 125 | ø125 | 118.6 | TR06.05.1419 | 1419 | yes
13472680 | -1.PP_SO-102 | 1710.53 | 0.01227 | 0.671725 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 1 | -1310.67 | -1390.27 | -1373.17 | -1452.77 | Fáze 1 | SW_Deště vnitřní gravitační | 3 | Sanitární | SW_Deště vnitřní gravitační 2 | -5449.57 | 125 | ø125 | 118.6 | TR06.05.1420 | 1420 | yes
13472696 | -1.PP_SO-102 | 6450.05 | 0.01227 | 2.53293 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 1 | -2653.26 | -2780.26 | -2715.76 | -2842.75 | Fáze 1 | SW_Deště vnitřní gravitační | 4 | Sanitární | SW_Deště vnitřní gravitační 2 | -6839.55 | 125 | ø125 | 118.6 | TR06.05.1421 | 1421 | yes
13473475 | -1.PP_SO-102 | 300.768 | 0.01227 | 0.118111 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 100 | -958.405 | -1215.27 | -1002.6 | -1259.47 | Fáze 1 | SW_Deště vnitřní gravitační | 3 | Sanitární | SW_Deště vnitřní gravitační 2 | -5257.21 | 125 | ø125 | 118.6 | TR06.05.1422 | 1422 | yes
13473685 | -1.PP_SO-102 | 900.871 | 0.01227 | 0.353771 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 1 | -2718.35 | -2789.86 | -2780.85 | -2852.35 | Fáze 1 | SW_Deště vnitřní gravitační | 4 | Sanitární | SW_Deště vnitřní gravitační 2 | -6849.15 | 125 | ø125 | 118.6 | TR06.05.1423 | 1423 | yes
13473709 | -1.PP_SO-102 | 3461 | 0.01227 | 1.35913 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 1 | -2727.95 | -2825.06 | -2790.45 | -2887.55 | Fáze 1 | SW_Deště vnitřní gravitační | 4 | Sanitární | SW_Deště vnitřní gravitační 2 | -6884.35 | 125 | ø125 | 118.6 | TR06.05.1424 | 1424 | yes
13473719 | -1.PP_SO-102 | 500.851 | 0.01227 | 0.196684 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 1 | -2763.15 | -2830.66 | -2825.65 | -2893.15 | Fáze 1 | SW_Deště vnitřní gravitační | 4 | Sanitární | SW_Deště vnitřní gravitační 2 | -6889.95 | 125 | ø125 | 118.6 | TR06.05.1425 | 1425 | yes
13473732 | -1.PP_SO-102 | 1869.31 | 0.01227 | 0.734077 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 1 | -2768.75 | -2849.94 | -2831.25 | -2912.44 | Fáze 1 | SW_Deště vnitřní gravitační | 4 | Sanitární | SW_Deště vnitřní gravitační 2 | -6909.24 | 125 | ø125 | 118.6 | TR06.05.1426 | 1426 | yes
13485121 | -1.PP_SO-102 | 4947.86 | 0.00950189 | 1.70986 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 0 | -1045 | -1100 | -1100 | -1155 | Fáze 1 | SW_Splašky čerpání | 3 | Sanitární | SW_Splašky čerpání 2 | -5151.8 | 110 | ø110 | 103.6 | TR06.05.1471 | 1471 | yes
13485192 | 1.NP_SO-102 | 7883.17 | 0.00950189 | 2.72423 | ø110 mm | 0 | 0.00120656 | G | 1.NP_SO-102 |  | 2846.1 | 2846.1 | -5037.06 | -5037.06 | Fáze 1 | SW_Splašky čerpání | 3 | Sanitární | SW_Splašky čerpání 2 | -5037.06 | 110 | ø110 | 103.6 | TR06.05.1472 | 1472 | yes | Identifikační data - Komentáře: Č1
13485385 | 1.NP_SO-102 | 482.909 | 0.00950189 | 0.166881 | ø110 mm | 0 | 0.00120656 | G | 1.NP_SO-102 | 0 | 2964.04 | 2909.04 | 2909.04 | 2854.04 | Fáze 1 | SW_Splašky čerpání | 3 | Sanitární | SW_Splašky čerpání 2 | 2857.24 | 110 | ø110 | 103.6 | TR06.05.1473 | 1473 | yes
13486189 | -1.PP_SO-102 | 1988.99 | 0.0779194 | 1.9683 | ø315 mm | 0 | 0.000417223 | G | -1.PP_SO-102 | 1.5 | -1062.54 | -1249.85 | -1220.02 | -1407.33 | Fáze 1 | SW_Deště vnitřní gravitační | 1 | Sanitární | SW_Deště vnitřní gravitační 3 | -5399.63 | 315 | ø315 | 299.6 | TR06.05.1483 | 1483 | yes | Identifikační data - Komentáře: PŘEPADOVÉ POTRUBÍ
13514832 | -1.PP_SO-102 | 374.044 | 0.01227 | 0.146887 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 1 | -2544.22 | -2606.71 | -2610.45 | -2672.95 | Fáze 1 | SW_Deště vnitřní gravitační | 6 | Sanitární | SW_Deště vnitřní gravitační 2 | -6669.75 | 125 | ø125 | 118.6 | TR06.05.1523 | 1523 | yes
13514845 | -1.PP_SO-102 | 8819.88 | 0.01227 | 3.46356 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 1 | -1440.04 | -1590.73 | -1502.53 | -1653.23 | Fáze 1 | SW_Deště vnitřní gravitační | 3 | Sanitární | SW_Deště vnitřní gravitační 2 | -5650.03 | 125 | ø125 | 118.6 | TR06.05.1524 | 1524 | yes
13516419 | -1.PP_SO-102 | 4201.81 | 0.00950189 | 1.45204 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 2 | -2514.55 | -2569.54 | -2653.55 | -2708.54 | Fáze 1 | SW_Splašky vnitřní gravitační | 127 | Sanitární | SW_Splašky vnitřní gravitační 3 | -6705.34 | 110 | ø110 | 103.6 | TR06.05.1527 | 1527 | yes
13516793 | -1.PP_SO-102 | 333.93 | 0.00950189 | 0.115398 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 |  | -2092.95 | -2426.88 | -2092.95 | -2426.88 | Fáze 1 | SW_Splašky vnitřní gravitační | 112 | Sanitární | SW_Splašky vnitřní gravitační 3 | -6426.88 | 110 | ø110 | 103.6 | TR06.05.1529 | 1529 | yes
13517022 | -1.PP_SO-102 | 121.036 | 0.00950189 | 0.0418269 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 100 | -2432.49 | -2556.97 | -2471.38 | -2595.86 | Fáze 1 | SW_Splašky vnitřní gravitační | 112 | Sanitární | SW_Splašky vnitřní gravitační 3 | -6593.59 | 110 | ø110 | 103.6 | TR06.05.1530 | 1530 | yes
13517064 | -1.PP_SO-102 | 10344.9 | 0.00950155 | 3.57493 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 2 | -2756.66 | -3018.5 | -2811.65 | -3073.49 | Fáze 1 | SW_Splašky vnitřní gravitační | 111 | Sanitární | SW_Splašky vnitřní gravitační 3 | -7070.29 | 110 | ø110 | 103.6 | TR06.05.1531 | 1531 | yes
13538483 | -1.PP_SO-102 | 3788.55 | 0.0314112 | 2.38041 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 1 | 2848.14 | 2710.26 | 2748.15 | 2610.27 | Fáze 2 | SW_Splašky vnitřní gravitační | 536 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1384.83 | 200 | ø200 | 190.2 | TR06.05.1578 | 1578 | yes
13611680 | -1.PP_SO-102 | 10792.4 | 0.01227 | 4.23816 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 1 | -1328.37 | -1498.78 | -1390.87 | -1561.28 | Fáze 1 | SW_Deště vnitřní gravitační | 3 | Sanitární | SW_Deště vnitřní gravitační 2 | -5558.08 | 125 | ø125 | 118.6 | TR06.05.1596 | 1596 | yes
13612984 | -1.PP_SO-102 | 6179.79 | 0.0201032 | 3.1063 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 2 | -2331.83 | -2411.81 | -2535.38 | -2615.37 | Fáze 1 | SW_Splašky vnitřní gravitační | 46 | Sanitární | SW_Splašky vnitřní gravitační 3 | -6611.37 | 160 | ø160 | 152 | TR06.05.1597 | 1597 | yes
13613051 | -1.PP_SO-102 | 9841.71 | 0.01227 | 3.86483 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 1 | -2551.1 | -2712.01 | -2613.6 | -2774.51 | Fáze 1 | SW_Deště vnitřní gravitační | 4 | Sanitární | SW_Deště vnitřní gravitační 2 | -6771.31 | 125 | ø125 | 118.6 | TR06.05.1598 | 1598 | yes
13613066 | -1.PP_SO-102 | 5833.41 | 0.0201032 | 2.93219 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 2 | -3068.77 | -3265.39 | -3148.75 | -3345.38 | Fáze 1 | SW_Splašky vnitřní gravitační | 51 | Sanitární | SW_Splašky vnitřní gravitační 3 | -7341.38 | 160 | ø160 | 152 | TR06.05.1599 | 1599 | yes
13613081 | -1.PP_SO-102 | 9090.92 | 0.04908 | 7.13999 | ø250 mm | 0 | 0.000526094 | G | -1.PP_SO-102 | 1 | -1047.15 | -1172.14 | -1263.04 | -1388.04 | Fáze 1 | SW_Splašky vnitřní gravitační | 192 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -5381.84 | 250 | ø250 | 237.6 | TR06.05.1600 | 1600 | yes
13613135 | -1.PP_SO-102 | 11361.7 | 0.0201032 | 5.71104 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 2 | -2026.32 | -2106.3 | -2333.49 | -2413.47 | Fáze 1 | SW_Splašky vnitřní gravitační | 55 | Sanitární | SW_Splašky vnitřní gravitační 3 | -6409.47 | 160 | ø160 | 152 | TR06.05.1601 | 1601 | yes
13613538 | -1.PP_SO-102 | 11716.4 | 0.01227 | 4.60102 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 1 | -2426.47 | -2488.96 | -2606.12 | -2668.62 | Fáze 1 | SW_Deště vnitřní gravitační | 6 | Sanitární | SW_Deště vnitřní gravitační 2 | -6665.42 | 125 | ø125 | 118.6 | TR06.05.1602 | 1602 | yes
13613595 | -1.PP_SO-102 | 7295.12 | 0.00950155 | 2.52101 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 2 | -2604.19 | -2805.05 | -2659.18 | -2860.04 | Fáze 1 | SW_Splašky vnitřní gravitační | 111 | Sanitární | SW_Splašky vnitřní gravitační 3 | -6856.84 | 110 | ø110 | 103.6 | TR06.05.1603 | 1603 | yes
13616403 | -1.PP_SO-102 | 5385.25 | 0.01227 | 2.11478 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 2 | -1640.59 | -1703.08 | -1810.76 | -1873.25 | Fáze 2 | SW_Splašky vnitřní gravitační | 129 | Sanitární | SW_Splašky vnitřní gravitační 3 | -5870.05 | 125 | ø125 | 118.6 | TR06.05.1605 | 1605 | yes
13622195 | -1.PP_SO-102 | 1135.85 | 0.0201032 | 0.57094 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 1.9883 | -2476.18 | -2556.16 | -2578.74 | -2658.73 | Fáze 1 | SW_Splašky vnitřní gravitační | 130 | Sanitární | SW_Splašky vnitřní gravitační 3 | -6654.73 | 160 | ø160 | 152 | TR06.05.1609 | 1609 | yes
13624423 | -1.PP_SO-102 | 1267.74 | 0.01227 | 0.497839 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 115.893 | -1574.66 | -2575.31 | -1615.49 | -2616.14 | Fáze 1 | SW_Deště vnitřní gravitační | 3 | Sanitární | SW_Deště vnitřní gravitační 2 | -6614.05 | 125 | ø125 | 118.6 | TR06.05.1611 | 1611 | yes
13624441 | -1.PP_SO-102 | 1037.53 | 0.01227 | 0.407437 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 1 | -2537.58 | -2600.08 | -2610.45 | -2672.95 | Fáze 1 | SW_Deště vnitřní gravitační | 3 | Sanitární | SW_Deště vnitřní gravitační 2 | -6669.75 | 125 | ø125 | 118.6 | TR06.05.1612 | 1612 | yes
13624502 | -1.PP_SO-102 | 505.212 | 0.0201032 | 0.253947 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 118.304 | -2577.54 | -2629.18 | -3015.02 | -3066.67 | Fáze 1 | SW_Splašky vnitřní gravitační | 40 | Sanitární | SW_Splašky vnitřní gravitační 3 | -7064.08 | 160 | ø160 | 152 | TR06.05.1613 | 1613 | yes
13630995 | -1.PP_SO-102 | 2087.4 | 0.01227 | 0.819718 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 1 | -2401.84 | -2464.34 | -2485.21 | -2547.71 | Fáze 1 | SW_Deště vnitřní gravitační | 6 | Sanitární | SW_Deště vnitřní gravitační 2 | -6544.51 | 125 | ø125 | 118.6 | TR06.05.1618 | 1618 | yes
13631005 | -1.PP_SO-102 | 4887.59 | 0.01227 | 1.91935 | ø125 mm | 0 | 0.00105396 | G | -1.PP_SO-102 | 1 | -2352.38 | -2463.75 | -2414.88 | -2526.25 | Fáze 1 | SW_Deště vnitřní gravitační | 6 | Sanitární | SW_Deště vnitřní gravitační 2 | -6523.05 | 125 | ø125 | 118.6 | TR06.05.1619 | 1619 | yes
13658921 | -1.PP_SO-102 | 576.244 | 0.0201032 | 0.289652 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 1.9883 | -2506.59 | -2586.58 | -2598.03 | -2678.02 | Fáze 1 | SW_Splašky vnitřní gravitační | 40 | Sanitární | SW_Splašky vnitřní gravitační 3 | -6674.02 | 160 | ø160 | 152 | TR06.05.1723 | 1723 | yes
13659880 | -1.PP_SO-102 | 251.235 | 0.0201032 | 0.126284 | ø160 mm | 0 | 0.000822368 | G | -1.PP_SO-102 | 2 | -2463.28 | -2543.26 | -2548.29 | -2628.27 | Fáze 1 | SW_Splašky vnitřní gravitační | 132 | Sanitární | SW_Splašky vnitřní gravitační 3 | -6624.27 | 160 | ø160 | 152 | TR06.05.1729 | 1729 | yes
13669806 | -1.PP_SO-102 | 1720.97 | 0.0314112 | 1.08132 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 0.999999 | 2704.06 | 2604.06 | 2586.85 | 2486.86 | Fáze 1 | SW_Splašky vnitřní gravitační | 252 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1508.24 | 200 | ø200 | 190.2 | TR06.05.1737 | 1737 | yes
13671796 | -1.PP_SO-102 | 159.177 | 0.00950189 | 0.0550075 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 2 | 2696.81 | 2638.63 | 2641.82 | 2583.64 | Fáze 1 | SW_Splašky vnitřní gravitační | 264 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1413.16 | 110 | ø110 | 103.6 | TR06.05.1738 | 1738 | yes
13671812 | -1.PP_SO-102 | 1999.75 | 0.00950189 | 0.691064 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 2 | 2737.83 | 2682.85 | 2642.86 | 2587.87 | Fáze 1 | SW_Splašky vnitřní gravitační | 264 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1408.93 | 110 | ø110 | 103.6 | TR06.05.1739 | 1739 | yes
13671937 | -1.PP_SO-102 | 329.921 | 0.00950189 | 0.114013 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 2 | 2693.58 | 2638.59 | 2631.99 | 2577 | Fáze 1 | SW_Splašky vnitřní gravitační | 430 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1419.8 | 110 | ø110 | 103.6 | TR06.05.1740 | 1740 | yes
13671998 | -1.PP_SO-102 | 380.086 | 0.0314112 | 0.238815 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 1 | 2723.48 | 2623.49 | 2619.69 | 2519.69 | Fáze 1 | SW_Splašky vnitřní gravitační | 432 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1475.41 | 200 | ø200 | 190.2 | TR06.05.1741 | 1741 | yes
13672542 | -1.PP_SO-102 | 427.688 | 0.00950189 | 0.147798 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 2 | 2748.42 | 2693.43 | 2684.88 | 2629.89 | Fáze 1 | SW_Splašky vnitřní gravitační | 726 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1366.91 | 110 | ø110 | 103.6 | TR06.05.1742 | 1742 | yes
13672551 | -1.PP_SO-102 | 462.613 | 0.0314112 | 0.290668 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 1 | 2776.37 | 2676.38 | 2671.75 | 2571.76 | Fáze 1 | SW_Splašky vnitřní gravitační | 300 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1423.34 | 200 | ø200 | 190.2 | TR06.05.1743 | 1743 | yes
13672568 | -1.PP_SO-102 | 5757.63 | 0.00950189 | 1.98969 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 2 | 2864.6 | 2809.61 | 2694.48 | 2639.49 | Fáze 1 | SW_Splašky vnitřní gravitační | 726 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1357.31 | 110 | ø110 | 103.6 | TR06.05.1744 | 1744 | yes
13672682 | -1.PP_SO-102 | 97.6652 | 0.00950189 | 0.0337507 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 1.99995 | 2761.51 | 2706.52 | 2704.57 | 2649.58 | Fáze 1 | SW_Splašky vnitřní gravitační | 515 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1347.22 | 110 | ø110 | 103.6 | TR06.05.1745 | 1745 | yes
13672691 | -1.PP_SO-102 | 1470.44 | 0.0314112 | 0.923903 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 1.00001 | 2796.06 | 2696.06 | 2681.36 | 2581.37 | Fáze 1 | SW_Splašky vnitřní gravitační | 511 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1413.73 | 200 | ø200 | 190.2 | TR06.05.1746 | 1746 | yes
13672698 | -1.PP_SO-102 | 2075.68 | 0.00950189 | 0.717303 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 2 | 2804.06 | 2749.07 | 2707.56 | 2652.57 | Fáze 1 | SW_Splašky vnitřní gravitační | 515 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1344.23 | 110 | ø110 | 103.6 | TR06.05.1747 | 1747 | yes
13672964 | -1.PP_SO-102 | 71.8693 | 0.00950189 | 0.0248363 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 2 | 2731.7 | 2676.71 | 2675.27 | 2620.29 | Fáze 1 | SW_Splašky vnitřní gravitační | 534 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1376.52 | 110 | ø110 | 103.6 | TR06.05.1748 | 1748 | yes
13672973 | -1.PP_SO-102 | 3166 | 0.0314112 | 1.98925 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 1 | 2766.77 | 2666.77 | 2635.11 | 2535.12 | Fáze 1 | SW_Splašky vnitřní gravitační | 517 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1459.98 | 200 | ø200 | 190.2 | TR06.05.1749 | 1749 | yes
13672979 | -1.PP_SO-102 | 10240 | 0.00950155 | 3.53869 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 2.00001 | 2937.5 | 2677.75 | 2882.51 | 2622.76 | Fáze 1 | SW_Splašky vnitřní gravitační | 534 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1374.04 | 110 | ø110 | 103.6 | TR06.05.1750 | 1750 | yes
13675117 | -1.PP_SO-102 | 165.766 | 0.0314112 | 0.104154 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 1 | 2730.12 | 2630.13 | 2628.47 | 2528.48 | Fáze 1 | SW_Splašky vnitřní gravitační | 259 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1466.62 | 200 | ø200 | 190.2 | TR06.05.1755 | 1755 | yes
13675652 | -1.PP_SO-102 | 394.476 | 0.0314112 | 0.247857 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 1 | 2921.3 | 2817.36 | 2821.31 | 2717.37 | Fáze 2 | SW_Splašky vnitřní gravitační | 2 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1277.73 | 200 | ø200 | 190.2 | TR06.05.1757 | 1757 | yes
13675729 | -1.PP_SO-102 | 75.4309 | 0.00950189 | 0.026067 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 2 | 2813.15 | 2758.16 | 2756.65 | 2701.66 | Fáze 2 | SW_Splašky vnitřní gravitační | 626 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1295.14 | 110 | ø110 | 103.6 | TR06.05.1758 | 1758 | yes
13675740 | -1.PP_SO-102 | 5918.39 | 0.0314112 | 3.71863 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 1 | 2912.31 | 2753.13 | 2812.31 | 2653.13 | Fáze 2 | SW_Splašky vnitřní gravitační | 256 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1341.97 | 200 | ø200 | 190.2 | TR06.05.1759 | 1759 | yes
13675750 | -1.PP_SO-102 | 10623 | 0.00950189 | 3.67104 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 2 | 3026.61 | 2971.62 | 2759.2 | 2704.21 | Fáze 2 | SW_Splašky vnitřní gravitační | 626 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1292.59 | 110 | ø110 | 103.6 | TR06.05.1760 | 1760 | yes
13688923 | -1.PP_SO-102 | 966.623 | 0.0314112 | 0.607347 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 1 | 2714.63 | 2614.64 | 2604.97 | 2504.97 | Fáze 1 | SW_Splašky vnitřní gravitační | 252 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1490.13 | 200 | ø200 | 190.2 | TR06.05.1797 | 1797 | yes
13689226 | -1.PP_SO-102 | 671.353 | 0.0314112 | 0.421823 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 2 | 2575.99 | 2476.01 | 2462.59 | 2362.61 | Fáze 1 | SW_Splašky vnitřní gravitační | 588 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1632.49 | 200 | ø200 | 190.2 | TR06.05.1798 | 1798 | yes
13689241 | -1.PP_SO-102 | 1866.49 | 0.0314112 | 1.17275 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 2 | 2599.89 | 2462.59 | 2499.91 | 2362.61 | Fáze 1 | SW_Splašky vnitřní gravitační | 271 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1632.49 | 200 | ø200 | 190.2 | TR06.05.1799 | 1799 | yes
13689672 | -1.PP_SO-102 | 203.712 | 0.00950189 | 0.070398 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 0 | 2599.84 | 2544.84 | 2544.84 | 2489.84 | Fáze 1 | SW_Splašky vnitřní gravitační | 587 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1506.96 | 110 | ø110 | 103.6 | TR06.05.1800 | 1800 | yes
13689681 | -1.PP_SO-102 | 3844.58 | 0.0314112 | 2.41562 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 1.00419 | 2685.94 | 2547.34 | 2585.95 | 2447.35 | Fáze 1 | SW_Splašky vnitřní gravitační | 252 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1547.75 | 200 | ø200 | 190.2 | TR06.05.1801 | 1801 | yes
13689686 | -1.PP_SO-102 | 867.861 | 0.00950189 | 0.299911 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 0 | 2599.84 | 2544.84 | 2544.84 | 2489.84 | Fáze 1 | SW_Splašky vnitřní gravitační | 587 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1506.96 | 110 | ø110 | 103.6 | TR06.05.1802 | 1802 | yes
13689855 | -1.PP_SO-102 | 355.083 | 0.00950189 | 0.122708 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 100 | 2853.25 | 2563.27 | 2814.36 | 2524.38 | Fáze 1 | SW_Splašky vnitřní gravitační | 587 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1473.35 | 110 | ø110 | 103.6 | TR06.05.1803 | 1803 | yes
13689907 | -1.PP_SO-102 | 145.569 | 0.00950189 | 0.0503051 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 2 | 2576.39 | 2521.4 | 2518.49 | 2463.5 | Fáze 1 | SW_Splašky vnitřní gravitační | 574 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1533.3 | 110 | ø110 | 103.6 | TR06.05.1804 | 1804 | yes
13689917 | -1.PP_SO-102 | 2724.72 | 0.0314112 | 1.71199 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 1.00419 | 2642.33 | 2514.98 | 2542.34 | 2414.98 | Fáze 1 | SW_Splašky vnitřní gravitační | 582 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1580.12 | 200 | ø200 | 190.2 | TR06.05.1805 | 1805 | yes
13689928 | -1.PP_SO-102 | 968.077 | 0.00950189 | 0.334543 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 2 | 2596.79 | 2541.8 | 2522.44 | 2467.45 | Fáze 1 | SW_Splašky vnitřní gravitační | 574 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1529.35 | 110 | ø110 | 103.6 | TR06.05.1806 | 1806 | yes
13689963 | -1.PP_SO-102 | 271.953 | 0.00950189 | 0.0939802 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 1.99871 | 2603.27 | 2548.28 | 2542.84 | 2487.85 | Fáze 1 | SW_Splašky vnitřní gravitační | 574 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1508.95 | 110 | ø110 | 103.6 | TR06.05.1807 | 1807 | yes
13689980 | -1.PP_SO-102 | 335.055 | 0.00950189 | 0.115787 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 2 | 2611.01 | 2549.32 | 2556.02 | 2494.33 | Fáze 1 | SW_Splašky vnitřní gravitační | 574 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1502.47 | 110 | ø110 | 103.6 | TR06.05.1808 | 1808 | yes
13837801 | -1.PP_SO-102 | 288.409 | 0.00950189 | 0.0996669 | ø110 mm | 0 | 0.00120656 | F | -1.PP_SO-102 | 100 | 3232.87 | 3193.98 | 2990.04 | 2951.15 | Fáze 2 | SW_Splašky vnitřní gravitační | 626 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1046.59 | 110 | ø110 | 103.6 | TR06.05.2000 | 2000 | yes
13837852 | -1.PP_SO-102 | 216.633 | 0.00950189 | 0.0748631 | ø110 mm | 0 | 0.00120656 | F | -1.PP_SO-102 | 100 | 3881.67 | 3842.78 | 3689.59 | 3650.7 | Fáze 2 | SW_Splašky vnitřní gravitační | 626 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -347.034 | 110 | ø110 | 103.6 | TR06.05.2001 | 2001 | yes
13838147 | -1.PP_SO-102 | 187.774 | 0.00950189 | 0.06489 | ø110 mm | 0 | 0.00120656 | F | -1.PP_SO-102 |  | 3426.25 | 3426.25 | 3238.48 | 3238.48 | Fáze 2 | SW_Splašky vnitřní gravitační | 626 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -761.52 | 110 | ø110 | 103.6 | TR06.05.2002 | 2002 | yes
13838567 | -1.PP_SO-102 | 131.612 | 0.00950189 | 0.0454818 | ø110 mm | 0 | 0.00120656 | F | -1.PP_SO-102 | 2 | 3726.16 | 3668.54 | 3671.17 | 3613.55 | Fáze 2 | SW_Splašky vnitřní gravitační | 626 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -383.248 | 110 | ø110 | 103.6 | TR06.05.2003 | 2003 | yes
13838572 | -1.PP_SO-102 | 252.307 | 0.00950189 | 0.0871912 | ø110 mm | 0 | 0.00120656 | F | -1.PP_SO-102 | 100.861 | 3688.65 | 3649.93 | 3470.76 | 3432.03 | Fáze 2 | SW_Splašky vnitřní gravitační | 626 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -565.713 | 110 | ø110 | 103.6 | TR06.05.2004 | 2004 | yes
13980315 | -1.PP_SO-102 | 8740 | 0.0779194 | 8.64912 | ø315 mm | 0 | 0.000417223 | F | -1.PP_SO-102 | 1.5 | -1121.3 | -1409.87 | -1278.78 | -1567.35 | Fáze 1 | SW_Deště vnitřní gravitační | 1 | Sanitární | SW_Deště vnitřní gravitační 4 | -5559.65 | 315 | ø315 | 299.6 | TR06.05.2033 | 2033 | yes
13981069 | -1.PP_SO-102 | 1463.98 | 0.00950189 | 0.505915 | ø110 mm |  | 0 | F | -1.PP_SO-102 |  | -1169.29 | -1169.29 | -2633.27 | -2633.27 | Fáze 1 | SW_Odvětrání kanalizace | 133 | Průduch | SW_Odvětrání kanalizace 16 | -6633.27 | 110 | ø110 | 103.6 | TR06.05.2034 | 2034 | yes
13981216 | -1.PP_SO-102 | 2868.85 | 0.00950189 | 0.991402 | ø110 mm |  | 0.00120656 | G | -1.PP_SO-102 | 0 | -1045 | -1100 | -1100 | -1155 | Fáze 1 | SW_Odvětrání kanalizace | 38 | Průduch | SW_Odvětrání kanalizace 16 | -5151.8 | 110 | ø110 | 103.6 | TR06.05.2035 | 2035 | yes
13981228 | -1.PP_SO-102 | 1779.77 | 0.00950189 | 0.615046 | ø110 mm |  | 0.00120656 | G | -1.PP_SO-102 | 0 | -1045 | -1100 | -1100 | -1155 | Fáze 1 | SW_Odvětrání kanalizace | 132 | Průduch | SW_Odvětrání kanalizace 16 | -5151.8 | 110 | ø110 | 103.6 | TR06.05.2036 | 2036 | yes
13981843 | -1.PP_SO-102 | 1604.71 | 0.00950189 | 0.554547 | ø110 mm | 0 | 0.00120656 | F | -1.PP_SO-102 | 0 | -1249.18 | -1304.18 | -1304.18 | -1359.18 | Fáze 1 | SW_Deště čerpání | 1 | Sanitární | SW_Deště čerpání 1 | -5355.98 | 110 | ø110 | 103.6 | TR06.05.2037 | 2037 | yes
13981857 | -1.PP_SO-102 | 1234.44 | 0.00950189 | 0.426592 | ø110 mm | 0 | 0.00120656 | F | -1.PP_SO-102 |  | -1367.12 | -1367.12 | -2601.56 | -2601.56 | Fáze 1 | SW_Deště čerpání | 1 | Sanitární | SW_Deště čerpání 1 | -6601.56 | 110 | ø110 | 103.6 | TR06.05.2038 | 2038 | yes
13981942 | -1.PP_SO-102 | 3585.23 | 0.00950189 | 1.23897 | ø110 mm | 0 | 0.00120656 | F | -1.PP_SO-102 | 0 | -1249.18 | -1304.18 | -1304.18 | -1359.18 | Fáze 1 | SW_Deště čerpání | 1 | Sanitární | SW_Deště čerpání 1 | -5355.98 | 110 | ø110 | 103.6 | TR06.05.2039 | 2039 | yes
13982031 | -1.PP_SO-102 | 264.37 | 0.01227 | 0.103818 | ø125 mm | 0 | 0.00105396 | F | -1.PP_SO-102 | 0.0172485 | -2787.66 | -2850.2 | -2850.16 | -2912.7 | Fáze 1 | SW_Deště vnitřní gravitační | 4 | Sanitární | SW_Deště vnitřní gravitační 2 | -6909.5 | 125 | ø125 | 118.6 | TR06.05.2040 | 2040
13982050 | -1.PP_SO-102 | 65.1484 | 0.00950189 | 0.0225137 | ø110 mm | 0 | 0.00120656 | F | -1.PP_SO-102 | 0 | -2796.56 | -2851.56 | -2851.56 | -2906.56 | Fáze 1 | SW_Deště vnitřní gravitační | 5 | Sanitární | SW_Deště vnitřní gravitační 2 | -6903.36 | 110 | ø110 | 103.6 | TR06.05.2041 | 2041
13982177 | -1.PP_SO-102 | 287.094 | 0.00950189 | 0.0992126 | ø110 mm | 0 | 0.00120656 | F | -1.PP_SO-102 | 0 | 3035 | 2980 | 2980 | 2925 | Fáze 1 | SW_Deště čerpání | 1 | Sanitární | SW_Deště čerpání 1 | -1071.8 | 110 | ø110 | 103.6 | TR06.05.2042 | 2042 | yes
13982189 | -1.PP_SO-102 | 4158.31 | 0.00950189 | 1.43701 | ø110 mm | 0 | 0.00120656 | F | -1.PP_SO-102 |  | 2917.06 | 2917.06 | -1241.24 | -1241.24 | Fáze 1 | SW_Deště čerpání | 1 | Sanitární | SW_Deště čerpání 1 | -5241.24 | 110 | ø110 | 103.6 | TR06.05.2043 | 2043 | yes | Identifikační data - Komentáře: Č2
13982562 | -1.PP_SO-102 | 150.342 | 0.00950189 | 0.0519543 | ø110 mm | 0 | 0.00120656 | F | -1.PP_SO-102 | 0 | 3035 | 2980 | 2980 | 2925 | Fáze 1 | SW_Deště čerpání | 1 | Sanitární | SW_Deště čerpání 1 | -1071.8 | 110 | ø110 | 103.6 | TR06.05.2044 | 2044 | yes
13982574 | -1.PP_SO-102 | 223.202 | 0.00950189 | 0.0771332 | ø110 mm | 0 | 0.00120656 | F | -1.PP_SO-102 | 0 | 3035 | 2980 | 2980 | 2925 | Fáze 1 | SW_Deště čerpání | 1 | Sanitární | SW_Deště čerpání 1 | -1071.8 | 110 | ø110 | 103.6 | TR06.05.2045 | 2045 | yes
14014741 | -1.PP_SO-102 | 682.768 | 0.0201032 | 0.343197 | ø160 mm | 0 | 0.000822368 | F | -1.PP_SO-102 | 100 | -669.188 | -1208.55 | -725.756 | -1265.11 | Fáze 1 | SW_Deště vnitřní gravitační | 1 | Sanitární | SW_Deště vnitřní gravitační 5 | -5262.29 | 160 | ø160 | 152 | TR06.05.2152 | 2152 | yes
14014762 | 1.NP_SO-102 | 493.575 | 0.0201032 | 0.248098 | ø160 mm | 0 | 0.000822368 | F | 1.NP_SO-102 |  | -4170 | -4663.58 | -4170 | -4663.58 | Fáze 1 | SW_Deště vnitřní gravitační | 1 | Sanitární | SW_Deště vnitřní gravitační 5 | -4663.58 | 160 | ø160 | 152 | TR06.05.2153 | 2153 | yes
14014896 | -1.PP_SO-102 | 337.522 | 0.0201032 | 0.169657 | ø160 mm | 0 | 0.000822368 | F | -1.PP_SO-102 | 1 | -1331.39 | -1414.76 | -1411.39 | -1494.76 | Fáze 1 | SW_Deště vnitřní gravitační | 1 | Sanitární | SW_Deště vnitřní gravitační 5 | -5490.76 | 160 | ø160 | 152 | TR06.05.2154 | 2154 | yes
14014917 | -1.PP_SO-102 | 18163.6 | 0.0201032 | 9.13001 | ø160 mm | 0 | 0.000822368 | F | -1.PP_SO-102 | 1 | -1335.5 | -1597.12 | -1415.49 | -1677.11 | Fáze 1 | SW_Deště vnitřní gravitační | 1 | Sanitární | SW_Deště vnitřní gravitační 5 | -5673.11 | 160 | ø160 | 152 | TR06.05.2155 | 2155 | yes
14015273 | -2.PP_SO-102 | 983.858 | 0.0201032 | 0.494541 | ø160 mm | 0 | 0.000822368 | F | -2.PP_SO-102 | 1 | 2845.7 | 2755.86 | 2765.7 | 2675.87 | Fáze 1 | SW_Deště vnitřní gravitační | 1 | Sanitární | SW_Deště vnitřní gravitační 5 | -5320.13 | 160 | ø160 | 152 | TR06.05.2156 | 2156 | yes
14015281 | -2.PP_SO-102 | 16580.3 | 0.0201032 | 8.33418 | ø160 mm | 0 | 0.000822368 | F | -2.PP_SO-102 | 1 | 2835.13 | 2589.34 | 2755.14 | 2509.34 | Fáze 1 | SW_Deště vnitřní gravitační | 1 | Sanitární | SW_Deště vnitřní gravitační 5 | -5486.66 | 160 | ø160 | 152 | TR06.05.2157 | 2157 | yes | Identifikační data - Komentáře: TRASA NOVÉ DEŠŤOVÉ KANALIZACE OD ULIČNÍ VPUSTI UV1
14019152 | -1.PP_SO-102 | 1623.38 | 0.00950189 | 0.561001 | ø110 mm | 0 | 0.00120656 | G | -1.PP_SO-102 | 0 | -1045 | -1100 | -1100 | -1155 | Fáze 1 | SW_Splašky čerpání | 3 | Sanitární | SW_Splašky čerpání 2 | -5151.8 | 110 | ø110 | 103.6 | TR06.05.2185 | 2185 | yes
14019767 | -1.PP_SO-102 | 3327.78 | 0.00950189 | 1.15 | ø110 mm |  | 0.00120656 | G | -1.PP_SO-102 |  | 2290.71 | 2290.71 | -1037.06 | -1037.06 | Fáze 1 | SW_Odvětrání kanalizace | 38 | Průduch | SW_Odvětrání kanalizace 16 | -5037.06 | 110 | ø110 | 103.6 | TR06.05.2186 | 2186 | yes
14023276 | -1.PP_SO-102 | 1339.07 | 0.00950189 | 0.46275 | ø110 mm |  | 0.00120656 | F | -1.PP_SO-102 | 0 | 2595 | 2540 | 2540 | 2485 | Fáze 1 | SW_Odvětrání kanalizace | 142 | Průduch | SW_Odvětrání kanalizace 16 | -1511.8 | 110 | ø110 | 103.6 | TR06.05.2195 | 2195 | yes
14023354 | -1.PP_SO-102 | 334.125 | 0.00950189 | 0.115465 | ø110 mm |  | 0 | F | -1.PP_SO-102 |  | 2937.06 | 2602.94 | 2937.06 | 2602.94 | Fáze 1 | SW_Odvětrání kanalizace | 142 | Průduch | SW_Odvětrání kanalizace 16 | -1397.06 | 110 | ø110 | 103.6 | TR06.05.2196 | 2196 | yes
14026467 | -1.PP_SO-102 | 3143.03 | 0.04908 | 2.46853 | ø250 mm | 0 | 0.000526094 | G | -1.PP_SO-102 | 1 | -1014.99 | -1171.42 | -1139.99 | -1296.41 | Fáze 1 | SW_Splašky vnitřní gravitační | 192 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -5290.21 | 250 | ø250 | 237.6 | TR06.05.2209 | 2209 | yes
14027454 | -1.PP_SO-102 | 457.238 | 0.0201032 | 0.229833 | ø160 mm | 0 | 0.000822368 | F | -1.PP_SO-102 | 2 | -1096.82 | -1185.95 | -1176.81 | -1265.93 | Fáze 1 | SW_Splašky vnitřní gravitační | 730 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -5261.93 | 160 | ø160 | 152 | TR06.05.2210 | 2210 | yes
14027469 | -1.PP_SO-102 | 490.58 | 0.0201032 | 0.246592 | ø160 mm | 0 | 0.000822368 | F | -1.PP_SO-102 | 2 | -1107.42 | -1197.21 | -1187.4 | -1277.2 | Fáze 1 | SW_Splašky vnitřní gravitační | 730 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -5273.2 | 160 | ø160 | 152 | TR06.05.2211 | 2211 | yes
14027484 | -1.PP_SO-102 | 2293.27 | 0.0201032 | 1.15272 | ø160 mm | 0 | 0.000822368 | F | -1.PP_SO-102 | 2 | -1118.69 | -1244.53 | -1198.67 | -1324.51 | Fáze 1 | SW_Splašky vnitřní gravitační | 730 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -5320.51 | 160 | ø160 | 152 | TR06.05.2212 | 2212 | yes
14027494 | -1.PP_SO-102 | 633.674 | 0.0201032 | 0.318519 | ø160 mm | 0 | 0.000822368 | F | -1.PP_SO-102 | 2 | -1166 | -1258.65 | -1245.98 | -1338.64 | Fáze 1 | SW_Splašky vnitřní gravitační | 730 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -5334.64 | 160 | ø160 | 152 | TR06.05.2213 | 2213 | yes
14027576 | -1.PP_SO-102 | 438.383 | 0.04908 | 0.344305 | ø250 mm | 0 | 0.000526094 | G | -1.PP_SO-102 | 1 | -1144.26 | -1269.25 | -1273.64 | -1398.63 | Fáze 1 | SW_Splašky vnitřní gravitační | 733 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -5392.43 | 250 | ø250 | 237.6 | TR06.05.2214 | 2214 | yes
14028057 | -1.PP_SO-102 | 13783.2 | 0.04908 | 10.8253 | ø250 mm | 0 | 0.000526094 | G | -1.PP_SO-102 | 1 | -1156.14 | -1418.96 | -1281.14 | -1543.95 | Fáze 1 | SW_Splašky vnitřní gravitační | 733 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -5537.75 | 250 | ø250 | 237.6 | TR06.05.2215 | 2215 | yes
14028665 | -1.PP_SO-102 | 1620.32 | 0.0779194 | 1.60347 | ø315 mm | 0 | 0.000417223 | G | -1.PP_SO-102 | 1.5 | -1035.85 | -1217.63 | -1193.33 | -1375.11 | Fáze 1 | SW_Deště vnitřní gravitační | 1 | Sanitární | SW_Deště vnitřní gravitační 3 | -5367.42 | 315 | ø315 | 299.6 | TR06.05.2216 | 2216 | yes | Identifikační data - Komentáře: PŘEPADOVÉ POTRUBÍ
14035997 | -1.PP_SO-102 | 10921.4 | 0.0314112 | 6.86211 | ø200 mm | 0 | 0.000657203 | G | -1.PP_SO-102 | 1 | 2411.71 | 2311.72 | 2202.51 | 2102.52 | Fáze 1 | SW_Splašky vnitřní gravitační | 738 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1892.59 | 200 | ø200 | 190.2 | TR06.05.2220 | 2220 | yes
14036117 | -1.PP_SO-102 | 743.939 | 0.0314112 | 0.467431 | ø200 mm | 0 | 0.000657203 | F | -1.PP_SO-102 | 1 | 2525.73 | 2418.3 | 2425.74 | 2318.3 | Fáze 2 | SW_Splašky vnitřní gravitační | 738 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1676.8 | 200 | ø200 | 190.2 | TR06.05.2221 | 2221 | yes
14036406 | -1.PP_SO-102 | 743.939 | 0.0314112 | 0.467431 | ø200 mm | 0 | 0.000657203 | F | -1.PP_SO-102 | 1 | 2419.44 | 2319.45 | 2312.01 | 2212.01 | Fáze 2 | SW_Splašky vnitřní gravitační | 738 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1783.09 | 200 | ø200 | 190.2 | TR06.05.2222 | 2222 | yes
14036418 | -1.PP_SO-102 | 9828.11 | 0.0314112 | 6.17519 | ø200 mm | 0 | 0.000657203 | F | -1.PP_SO-102 | 1 | 2518.01 | 2418.01 | 2319.73 | 2219.74 | Fáze 2 | SW_Splašky vnitřní gravitační | 738 | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | -1775.36 | 200 | ø200 | 190.2 | TR06.05.2223 | 2223 | yes

# IfcSanitaryTerminal: PF_PE QS P+ Roofoutlet:QSP+ membrane (8)
In: 4.NP_SO-102
Type - Description: Siphonic roof outlet; PredefinedType: SINK; Classification: VP01 SNIM (SNIM); Material: PUR, Multicoloured, RAL0012 (2), PE, Black, RAL9200
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - CWFU: 0; HWFU: 0; WFU: 0.75
Type - Materiály a povrchové úpravy - groundplate_material: Stainless Steel; material: PUR, Multicoloured, RAL0012
Type - Kóty - Délka: 330 mm; Jmenovitá velikost výstupu: 40 mm; Šířka: 330 mm; Výška: 210 mm
Type - Identifikační data - Číslo OmniClass: 23.70.50.24; EAN_code: 4026294817731; GTIN_Code: 04026294817731; Kód sestavy: VP01; Komentáře k typům: STŘEŠNÍ VPUST; Model: Roof Outlet QS-P+; Nadpis OmniClass: Rainwater Removal; Název typu: QSP+ membrane; Označení typu: 31; Popis: Siphonic roof outlet; Popis sestavy: Střešní; product_series: Quickstream; Výrobce: Wavin
Type - Jiné - Kategorie: Instalační zařizovací předměty; bitumen_drain: no; LOD: LOD 400; membrane_drain: yes; Název rodiny: PF_PE QS P+ Roofoutlet; region_index: 8; workplane: 57 mm
Classification: VP01 SNIM (SNIM); VP01 Uniformat (Uniformat); Material: PUR, Multicoloured, RAL0012, PE, Black, RAL9200; Group: SW_Deště vnitřní podtlak 4
Text - CCI Funkční systém: F; CCI Komponenta: XKE; CCI Technický systém: JB
Vazby - Podlaží: STŘECHA_SO-102; bend: no; emergency ring: no; heating_element: no; Hostitel: Podlaží : STŘECHA_SO-102; Odsazení od hostitele: 370 mm; outlet_user_length: 425 mm; rotation_angle: 90 deg; shorten_outlet_connector: no; straigth connector: yes; vaporbarrier: no; vaporbarrier_position: 50 mm; Výška od podlaží: 370 mm
Mechanické - Typ systému: SW_Deště vnitřní podtlak; Klasifikace systému: Sanitární; Název systému: SW_Deště vnitřní podtlak 4
Kóty - connection_diameter1: 56 mm; DN1: 56 mm; Objem: 0.000227924 m3; Plocha: 0.423808 m2; Ro1: 0 mm; Rs1: 0 mm
Identifikační data - artnr_wcz: OF951910W; artnr_wtu: 4036540; desc_wcz: Střešní vtok QS-P+ fóliový typ; desc_wtu: WQS Süzgeç Qs-M-75 Ø 260 Bit; item_description: Střešní vtok QS-P+ fóliový typ; productcode: OF951910W
Jiné - Páteřní trasa: no; backwater_ring_check: no; bend_angle: 180 deg; bend_check: no; bend_position: 50 mm; bendleg_length: 185 mm; emergency outlet: no; heating_element_check: no; Id typu: 13236644; IsCustom: no; localisation: CZ; offset: 57 mm; outlet_connector_check: yes; outlet_connector_global_index: 536; outlet_connector_user_length: 370 mm; outlet_connector_Z1_length: 370 mm; outlet_length: 185 mm; product_check: 1; Rodina: PF_PE QS P+ Roofoutlet; Rodina a typ: PF_PE QS P+ Roofoutlet: QSP+ membrane; roofing plate: no; Typ: QSP+ membrane; vaporbarrier_check: no; vaporbarrier_Z: -107 mm
Name (PF_PE QS P+ Roofoutlet:QSP+ membrane:...) | Fáze vytvoření | Kód prvku | Označení
13236765 | Fáze 1 | VP01.31.0694 | 0694
13236942 | Fáze 1 | VP01.31.0695 | 0695
13237040 | Fáze 1 | VP01.31.0696 | 0696
13237043 | Fáze 1 | VP01.31.0697 | 0697
13238471 | Fáze 1 | VP01.31.0703 | 0703
13238524 | Fáze 1 | VP01.31.0704 | 0704
13242559 | Fáze 2 | VP01.31.0705 | 0705
13242573 | Fáze 2 | VP01.31.0706 | 0706

# IfcValve: Filtr závitový.LH:DN 15 (5)
Type - Classification: FI02 SNIM (SNIM); Material: 128-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - DÉLKA: 59 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; JMENOVITÝ PRŮMĚR: 15 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.14.17; Kód sestavy: FI02; Komentáře k typům: F DN15; Model: Model; Nadpis OmniClass: Adjusting/Controlling Valves for Liquid Services; Název typu: DN 15; Označení typu: 15; Popis: Filtr; Popis sestavy: Mechanický; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; DF: 26 mm; DFl: 26 mm; DN: 15 mm; Lookup Table Name: Závitový_Filtr; Název rodiny: Filtr závitový.LH; ODFl: 51.7 mm; OF: 14.75 mm; RN: 7.5 mm; Scale Factor: 15; SF: 15; TDFl: 5 mm; TF: 11 mm; V: 8.66667 mm; VS: 17.2333 mm; WDFl: 12 mm; WFl: 20 mm
Classification: FI02 SNIM (SNIM); FI02 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø20 mm-ø20 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Mechanické - Typ systému: WS_"ŠEDÁ" studená vnitřní; Klasifikace systému: Studená voda v domácnosti; PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 20 mm; Minimální velikost: 20 mm; Objem: 0.0000413131 m3; Průměr připojení: 20 mm; Velikost: ø20-ø20
Jiné - Páteřní trasa: no; Rodina: Filtr závitový.LH; Id typu: 13040049; Rodina a typ: Filtr závitový.LH: DN 15; Typ: DN 15
Name (Filtr závitový.LH:DN 15:...) | In | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Kód prvku | Označení
13046564 | 2.NP_SO-102 | 2.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní 23 | FI02.15.0386 | 0386
13070249 | 4.NP_SO-102 | 4.NP_SO-102 | 1426.66 | Fáze 1 | WS_"Jiný typ" studená vnitřní 1 | FI02.15.0409 | 0409
13070673 | 3.NP_SO-102 | 3.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní 3 | FI02.15.0413 | 0413
13070732 | 2.NP_SO-102 | 2.NP_SO-102 | 1426.66 | Fáze 1 | WS_"Jiný typ" studená vnitřní 1 | FI02.15.0414 | 0414
13071525 | 1.NP_SO-102 | 1.NP_SO-102 | 1426.66 | Fáze 1 | WS_"Jiný typ" studená vnitřní 1 | FI02.15.0419 | 0419

# IfcValve: Filtr závitový.LH:DN 20 (3)
Type - Classification: FI02 SNIM (SNIM); Material: 128-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - DÉLKA: 69 mm; JMENOVITÝ PRŮMĚR: 20 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.14.17; Kód sestavy: FI02; Komentáře k typům: Filtr, DN 20; Model: Model; Nadpis OmniClass: Adjusting/Controlling Valves for Liquid Services; Název typu: DN 20; Označení typu: 13; Popis: Filtr; Popis sestavy: Mechanický; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství trubek; DF: 32 mm; DFl: 32 mm; DN: 20 mm; Lookup Table Name: Závitový_Filtr; Název rodiny: Filtr závitový.LH; ODFl: 59.3 mm; OF: 17.25 mm; RN: 10 mm; Scale Factor: 17; SF: 17; TDFl: 5 mm; TF: 12 mm; V: 10.6667 mm; VS: 19.7667 mm; WDFl: 12 mm; WFl: 26 mm
Classification: FI02 SNIM (SNIM); FI02 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Vazby - Výška od podlaží: 1250 mm
Fázování - Fáze vytvoření: Fáze 2
Mechanické - Typ systému: WS_"ŠEDÁ" studená vnitřní; Klasifikace systému: Studená voda v domácnosti; PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Objem: 0.0000740691 m3
Jiné - Páteřní trasa: no; Id typu: 13040045; Rodina: Filtr závitový.LH; Rodina a typ: Filtr závitový.LH: DN 20; Typ: DN 20
Name (Filtr závitový.LH:DN 20:...) | In | Celková velikost | Podlaží | Název systému = Group | Maximální velikost (mm) = Minimální velikost (mm) = Průměr připojení (mm) | Velikost | Kód prvku | Označení
13046546 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | WS_"ŠEDÁ" studená vnitřní 2 | 25 | ø25-ø25 | FI02.13.0380 | 0380
13046555 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | WS_"ŠEDÁ" studená vnitřní 22 | 20 | ø20-ø20 | FI02.13.0383 | 0383
13046573 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | WS_"ŠEDÁ" studená vnitřní 24 | 20 | ø20-ø20 | FI02.13.0389 | 0389

# IfcValve: Kulový kohout závitový.LH:DN15 (9)
Type - Classification: VE01 SNIM (SNIM); Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Koeficient K: 0
Type - Kóty - DÉLKA: 54 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; JMENOVITÝ PRŮMĚR: 15 mm; VÝŠKA: 33.7 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.14.17; Kód sestavy: VE01; Komentáře k typům: KK DN15; Nadpis OmniClass: Adjusting/Controlling Valves for Liquid Services; Název typu: DN15; Označení typu: 10; Popis: Ventil; Popis sestavy: Kulový kohout
Type - Jiné - Kategorie: Příslušenství trubek; Body Diameter: 16.5 mm; Body Height: 24.3389 mm; Body Radius: 8.25 mm; Half Nut Height: 2.475 mm; Handle Width: 9.5 mm; Length 1: 26 mm; Length 2: 11.6 mm; Lookup Table Name: Závitový_Plnící a vypouštěcí kohout; Název rodiny: Kulový kohout závitový.LH; Nut Diameter: 4.5 mm; Nut Height: 4.95 mm; Nut Radius: 2.25 mm; Páka_Délka: 78 mm; Páka_Tloušťka: 4.95 mm; Příruba_Průměr: 23 mm; Příruba_Tloušťka: 14 mm; Radius: 23.2 mm; Seal Length: 15.4 mm; Stem Diameter: 3 mm; Stem Height: 9.36111 mm; Stem Radius: 1.5 mm; VS: 54 mm
Classification: VE01 SNIM (SNIM); VE01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø25 mm-ø25 mm
Text - CCI Funkční systém: F; CCI Komponenta: FMD; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Studená voda v domácnosti; PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 25 mm; Minimální velikost: 25 mm; Objem: 0.0000248726 m3; Průměr připojení: 25 mm; Velikost: ø25-ø25
Jiné - Páteřní trasa: no; Rodina: Kulový kohout závitový.LH; Id typu: 12958572; Rodina a typ: Kulový kohout závitový.LH: DN15; Typ: DN15
Name (Kulový kohout závitový.LH:DN15:...) | In | Podlaží | Výška od podlaží (mm) | Typ systému | Název systému = Group | Kód prvku | Označení
12963599 | 4.NP_SO-102 | 4.NP_SO-102 | 1669.1 | WS_Studená vnitřní | WS_Studená vnitřní 134 | VE01.10.0307 | 0307 | Identifikační data - Komentáře: (UMÍSTĚNO NA SVISLÉM POTRUBÍ, PŘÍSTUP REVIZNÍMI DVÍŘKY)
