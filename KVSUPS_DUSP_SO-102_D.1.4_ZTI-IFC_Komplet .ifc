Properties of the parts of a building model (IFC4), part 59 of 60

# IfcValve: Revizní šachta_světlé rozměry5:Revizní šachta_světlé rozměry, Revizní šachta_světlé rozměry5:Revizní šachta_světlé rozměry:13530231
Type - Identifikační data - Kód sestavy: AT01; Komentáře k typům: REVIZNÍ ŠACHTA; Název typu: Revizní šachta_světlé rozměry; Označení typu: 33; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Revizní šachta_světlé rozměry5
Classification: AT01 SNIM (SNIM); AT01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: EBB; CCI Technický systém: JB
Vazby - Přesunout s blízkými prvky: no; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 1.19278 m3; Plocha: 0.72 m2
Identifikační data - Kód prvku: AT01.33.0593; Označení: 0593
Jiné - Páteřní trasa: no; Typ: Revizní šachta_světlé rozměry; Id typu: 13530229; Rodina: Revizní šachta_světlé rozměry5; Rodina a typ: Revizní šachta_světlé rozměry5: Revizní šachta_světlé rozměry

# IfcValve: Revizní šachta_světlé rozměry6:Revizní šachta_světlé rozměry, Revizní šachta_světlé rozměry6:Revizní šachta_světlé rozměry:13613722
In: -2.PP_SO-102
Type - Classification: AT01 SNIM (SNIM); Material: <Unnamed>
Type - Identifikační data - Kód sestavy: AT01; Název typu: Revizní šachta_světlé rozměry; Označení typu: 37; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Revizní šachta_světlé rozměry6
Classification: AT01 SNIM (SNIM); AT01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: EBB; CCI Technický systém: JB
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 2
Kóty - Objem: 1.02312 m3; Plocha: 0.72 m2
Identifikační data - Kód prvku: AT01.37.0627; Označení: 0627
Jiné - Páteřní trasa: no; Typ: Revizní šachta_světlé rozměry; Id typu: 13613720; Rodina: Revizní šachta_světlé rozměry6; Rodina a typ: Revizní šachta_světlé rozměry6: Revizní šachta_světlé rozměry

# IfcValve: Revizní šachta_světlé rozměry:Revizní šachta_světlé rozměry, Revizní šachta_světlé rozměry:Revizní šachta_světlé rozměry:13471448
In: -2.PP_SO-102
Type - Classification: AT01 SNIM (SNIM); Material: <Unnamed>
Type - Identifikační data - Kód sestavy: AT01; Komentáře k typům: REVIZNÍ ŠACHTA; Název typu: Revizní šachta_světlé rozměry; Označení typu: 28; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Revizní šachta_světlé rozměry
Classification: AT01 SNIM (SNIM); AT01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: F; CCI Komponenta: EBB; CCI Technický systém: JB
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 1.83597 m3; Plocha: 0.72 m2
Identifikační data - Kód prvku: AT01.28.0543; Označení: 0543
Jiné - Páteřní trasa: no; Id typu: 13471446; Rodina: Revizní šachta_světlé rozměry; Rodina a typ: Revizní šachta_světlé rozměry: Revizní šachta_světlé rozměry; Typ: Revizní šachta_světlé rozměry

# IfcValve: Rohový ventil:G 1/2" × 3/8" (256)
Type - Classification: VE13 SNIM (SNIM); Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Kóty - Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; JMENOVITÝ PRŮMĚR: 15 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VE13; Název typu: G 1/2" × 3/8"; Označení typu: 02; Popis: Rohový ventil; Popis sestavy: Rohový; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Rohový ventil
Classification: VE13 SNIM (SNIM); VE13 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø15 mm-ø15 mm
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Vazby - Výška od podlaží: 580 mm
Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 15 mm; Minimální velikost: 15 mm; Objem: 0.0000388424 m3; Velikost: ø15-ø15
Jiné - Id typu: 12812713; Rodina: Rohový ventil; Rodina a typ: Rohový ventil: G 1/2" × 3/8"; Typ: G 1/2" × 3/8"
Name (Rohový ventil:G 1/2" × 3/8":...) | In | Tlaková ztráta (Pa) | Podlaží | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Kód prvku | Název sestavy | Označení
12825621 | -2.PP_SO-102 | 0 | -1.PP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 7 | VE13.02.0003 | Umyvadlo | 0003
12825622 | -2.PP_SO-102 | 0 | -1.PP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 5 | VE13.02.0004 | Umyvadlo | 0004
12865979 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 26 | VE13.02.0009 | Umyvadlo + modul | 0009
12865980 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 25 | VE13.02.0010 | Umyvadlo + modul | 0010
12871083 | -2.PP_SO-102 | 0 | -1.PP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 19 | VE13.02.0012 | Umyvadlo + modul | 0012
12871084 | -2.PP_SO-102 | 0 | -1.PP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 16 | VE13.02.0013 | Umyvadlo + modul | 0013
12871111 | -2.PP_SO-102 | 0 | -1.PP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 10 | VE13.02.0015 | Umyvadlo + modul | 0015
12871112 | -2.PP_SO-102 | 0 | -1.PP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 15 | VE13.02.0016 | Umyvadlo + modul | 0016
12871172 | -2.PP_SO-102 | 0 | -1.PP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 9 | VE13.02.0018 | Umyvadlo + modul | 0018
12871173 | -2.PP_SO-102 | 0 | -1.PP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 7 | VE13.02.0019 | Umyvadlo + modul | 0019
12879373 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 27 | VE13.02.0021 | Umyvadlo + modul | 0021
12879374 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 26 | VE13.02.0022 | Umyvadlo + modul | 0022
12879414 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 25 | VE13.02.0024 | Umyvadlo + modul | 0024
12879415 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 21 | VE13.02.0025 | Umyvadlo + modul | 0025
12879443 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 28 | VE13.02.0027 | Umyvadlo + modul | 0027
12879444 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 27 | VE13.02.0028 | Umyvadlo + modul | 0028
12879474 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 29 | VE13.02.0030 | Umyvadlo + modul | 0030
12879475 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 28 | VE13.02.0031 | Umyvadlo + modul | 0031
12879501 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 30 | VE13.02.0033 | Umyvadlo + modul | 0033
12879502 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 29 | VE13.02.0034 | Umyvadlo + modul | 0034
12879530 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 31 | VE13.02.0036 | Umyvadlo + modul | 0036
12879531 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 30 | VE13.02.0037 | Umyvadlo + modul | 0037
12880692 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 42 | VE13.02.0042 | Umyvadlo + modul | 0042
12880693 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 41 | VE13.02.0043 | Umyvadlo + modul | 0043
12880706 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 44 | VE13.02.0045 | Umyvadlo + modul | 0045
12880707 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 43 | VE13.02.0046 | Umyvadlo + modul | 0046
12880734 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 48 | VE13.02.0048 | Umyvadlo + modul | 0048
12880735 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 47 | VE13.02.0049 | Umyvadlo + modul | 0049
12880748 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 50 | VE13.02.0051 | Umyvadlo + modul | 0051
12880749 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 49 | VE13.02.0052 | Umyvadlo + modul | 0052
12880762 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 52 | VE13.02.0054 | Umyvadlo + modul | 0054
12880763 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 51 | VE13.02.0055 | Umyvadlo + modul | 0055
12880862 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 43 | VE13.02.0060 | Umyvadlo + modul | 0060
12880863 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 42 | VE13.02.0061 | Umyvadlo + modul | 0061
12880876 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 47 | VE13.02.0063 | Umyvadlo + modul | 0063
12880877 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 46 | VE13.02.0064 | Umyvadlo + modul | 0064
12880904 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 54 | VE13.02.0066 | Umyvadlo + modul | 0066
12880905 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 53 | VE13.02.0067 | Umyvadlo + modul | 0067
12880918 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 56 | VE13.02.0069 | Umyvadlo + modul | 0069
12880919 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 55 | VE13.02.0070 | Umyvadlo + modul | 0070
12880932 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 58 | VE13.02.0072 | Umyvadlo + modul | 0072
12880933 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 57 | VE13.02.0073 | Umyvadlo + modul | 0073
12881032 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 45 | VE13.02.0078 | Umyvadlo + modul | 0078
12881033 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 44 | VE13.02.0079 | Umyvadlo + modul | 0079
12881046 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 53 | VE13.02.0081 | Umyvadlo + modul | 0081
12881047 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 52 | VE13.02.0082 | Umyvadlo + modul | 0082
12881074 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 60 | VE13.02.0084 | Umyvadlo + modul | 0084
12881075 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 59 | VE13.02.0085 | Umyvadlo + modul | 0085
12881088 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 62 | VE13.02.0087 | Umyvadlo + modul | 0087
12881089 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 61 | VE13.02.0088 | Umyvadlo + modul | 0088
12881102 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 64 | VE13.02.0090 | Umyvadlo + modul | 0090
12881103 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 63 | VE13.02.0091 | Umyvadlo + modul | 0091
12881933 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 68 | VE13.02.0096 | Umyvadlo + modul | 0096
12881934 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 67 | VE13.02.0097 | Umyvadlo + modul | 0097
12884682 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 72 | VE13.02.0101 | Umyvadlo | 0101
12884683 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 71 | VE13.02.0102 | Umyvadlo | 0102
12884792 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 76 | VE13.02.0104 | Umyvadlo | 0104
12884793 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 75 | VE13.02.0105 | Umyvadlo | 0105
12886218 | -2.PP_SO-102 | 0 | -1.PP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 70 | VE13.02.0107 | Umyvadlo + modul | 0107
12886219 | -2.PP_SO-102 | 0 | -1.PP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 69 | VE13.02.0108 | Umyvadlo + modul | 0108
12888133 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 34 | VE13.02.0110 | Umyvadlo + modul | 0110
12888134 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 33 | VE13.02.0111 | Umyvadlo + modul | 0111
12888840 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 35 | VE13.02.0113 | Umyvadlo + modul | 0113
12888841 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 34 | VE13.02.0114 | Umyvadlo + modul | 0114
12888864 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 38 | VE13.02.0116 | Umyvadlo + modul | 0116
12888865 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 37 | VE13.02.0117 | Umyvadlo + modul | 0117
12889674 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 81 | VE13.02.0119 | Umyvadlo + modul | 0119
12889675 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 80 | VE13.02.0120 | Umyvadlo + modul | 0120
12890306 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | VE13.02.0122 | Umyvadlo + modul | 0122
12890307 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 82 | VE13.02.0123 | Umyvadlo + modul | 0123
12890333 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 84 | VE13.02.0125 | Umyvadlo + modul | 0125
12890334 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 83 | VE13.02.0126 | Umyvadlo + modul | 0126
12890444 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 82 | VE13.02.0128 | Umyvadlo + modul | 0128
12890445 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 81 | VE13.02.0129 | Umyvadlo + modul | 0129
12890829 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 85 | VE13.02.0134 | Umyvadlo + modul | 0134
12890830 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 84 | VE13.02.0135 | Umyvadlo + modul | 0135
12890853 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 86 | VE13.02.0137 | Umyvadlo + modul | 0137
12890854 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 85 | VE13.02.0138 | Umyvadlo + modul | 0138
12891274 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 32 | VE13.02.0140 | Umyvadlo + modul | 0140
12891275 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 31 | VE13.02.0141 | Umyvadlo + modul | 0141
12891685 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 49 | VE13.02.0143 | Umyvadlo + modul | 0143
12891686 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 48 | VE13.02.0144 | Umyvadlo + modul | 0144
12891776 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 55 | VE13.02.0146 | Umyvadlo + modul | 0146
12891777 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 54 | VE13.02.0147 | Umyvadlo + modul | 0147
12891849 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 59 | VE13.02.0149 | Umyvadlo + modul | 0149
12891850 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 58 | VE13.02.0150 | Umyvadlo + modul | 0150
12891921 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 61 | VE13.02.0152 | Umyvadlo + modul | 0152
12891922 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 60 | VE13.02.0153 | Umyvadlo + modul | 0153
12891996 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 63 | VE13.02.0155 | Umyvadlo + modul | 0155
12891997 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 62 | VE13.02.0156 | Umyvadlo + modul | 0156
12892062 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 65 | VE13.02.0158 | Umyvadlo + modul | 0158
12892063 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 64 | VE13.02.0159 | Umyvadlo + modul | 0159
12892279 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 67 | VE13.02.0161 | Umyvadlo + modul | 0161
12892280 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 66 | VE13.02.0162 | Umyvadlo + modul | 0162
12892346 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 69 | VE13.02.0164 | Umyvadlo + modul | 0164
12892347 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 68 | VE13.02.0165 | Umyvadlo + modul | 0165
12892412 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 71 | VE13.02.0167 | Umyvadlo + modul | 0167
12892413 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 70 | VE13.02.0168 | Umyvadlo + modul | 0168
12892478 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 73 | VE13.02.0170 | Umyvadlo + modul | 0170
12892479 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 72 | VE13.02.0171 | Umyvadlo + modul | 0171
12892543 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 75 | VE13.02.0173 | Umyvadlo + modul | 0173
12892544 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 74 | VE13.02.0174 | Umyvadlo + modul | 0174
12892796 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 87 | VE13.02.0176 | Umyvadlo + modul | 0176
12892797 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 86 | VE13.02.0177 | Umyvadlo + modul | 0177
12892899 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 89 | VE13.02.0179 | Umyvadlo + modul | 0179
12892900 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 88 | VE13.02.0180 | Umyvadlo + modul | 0180
12893030 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 91 | VE13.02.0182 | Umyvadlo + modul | 0182
12893031 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 90 | VE13.02.0183 | Umyvadlo + modul | 0183
12893155 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 93 | VE13.02.0185 | Umyvadlo + modul | 0185
12893156 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 92 | VE13.02.0186 | Umyvadlo + modul | 0186
12894056 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 98 | VE13.02.0191 | Umyvadlo + modul | 0191
12894057 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 94 | VE13.02.0192 | Umyvadlo + modul | 0192
12894122 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 99 | VE13.02.0194 | Umyvadlo + modul | 0194
12894123 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 95 | VE13.02.0195 | Umyvadlo + modul | 0195
12894201 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 100 | VE13.02.0197 | Umyvadlo + modul | 0197
12894202 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 96 | VE13.02.0198 | Umyvadlo + modul | 0198
12894265 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 101 | VE13.02.0200 | Umyvadlo + modul | 0200
12894266 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 97 | VE13.02.0201 | Umyvadlo + modul | 0201
12894326 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 102 | VE13.02.0203 | Umyvadlo + modul | 0203
12894327 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 98 | VE13.02.0204 | Umyvadlo + modul | 0204
12894671 | -2.PP_SO-102 | 0 | -1.PP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 103 | VE13.02.0206 | Umyvadlo + modul | 0206
12894672 | -2.PP_SO-102 | 0 | -1.PP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 99 | VE13.02.0207 | Umyvadlo + modul | 0207
12894785 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 104 | VE13.02.0209 | Umyvadlo + modul | 0209
12894786 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 100 | VE13.02.0210 | Umyvadlo + modul | 0210
12895095 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 105 | VE13.02.0213 | Umyvadlo + modul | 0213
12895096 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 101 | VE13.02.0214 | Umyvadlo + modul | 0214
12895278 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 106 | VE13.02.0216 | Umyvadlo + modul | 0216
12895279 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 102 | VE13.02.0217 | Umyvadlo + modul | 0217
12895302 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 107 | VE13.02.0219 | Umyvadlo + modul | 0219
12895303 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 103 | VE13.02.0220 | Umyvadlo + modul | 0220
12895433 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 110 | VE13.02.0222 | Umyvadlo + modul | 0222
12895434 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 106 | VE13.02.0223 | Umyvadlo + modul | 0223
12895779 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 113 | VE13.02.0225 | Umyvadlo + modul | 0225
12895780 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 109 | VE13.02.0226 | Umyvadlo + modul | 0226
12896133 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 114 | VE13.02.0229 | Umyvadlo + modul | 0229
12896134 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 110 | VE13.02.0230 | Umyvadlo + modul | 0230
12896333 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 115 | VE13.02.0232 | Umyvadlo + modul | 0232
12896334 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 111 | VE13.02.0233 | Umyvadlo + modul | 0233
12896401 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 116 | VE13.02.0235 | Umyvadlo + modul | 0235
12896402 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 112 | VE13.02.0236 | Umyvadlo + modul | 0236
12896714 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 120 | VE13.02.0238 | Umyvadlo + modul | 0238
12896715 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 116 | VE13.02.0239 | Umyvadlo + modul | 0239
12896774 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 121 | VE13.02.0241 | Umyvadlo + modul | 0241
12896775 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 117 | VE13.02.0242 | Umyvadlo + modul | 0242
12896890 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 122 | VE13.02.0244 | Umyvadlo + modul | 0244
12896891 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 118 | VE13.02.0245 | Umyvadlo + modul | 0245
12896914 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 123 | VE13.02.0247 | Umyvadlo + modul | 0247
12896915 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 119 | VE13.02.0248 | Umyvadlo + modul | 0248
12897287 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 124 | VE13.02.0251 | Umyvadlo + modul | 0251
12897288 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 120 | VE13.02.0252 | Umyvadlo + modul | 0252
12897360 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 125 | VE13.02.0254 | Umyvadlo + modul | 0254
12897361 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 121 | VE13.02.0255 | Umyvadlo + modul | 0255
12897411 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 127 | VE13.02.0257 | Umyvadlo + modul | 0257
12897412 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 123 | VE13.02.0258 | Umyvadlo + modul | 0258
12897442 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 128 | VE13.02.0260 | Umyvadlo + modul | 0260
12897443 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 124 | VE13.02.0261 | Umyvadlo + modul | 0261
12897749 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 130 | VE13.02.0263 | Umyvadlo + modul | 0263
12897750 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 126 | VE13.02.0264 | Umyvadlo + modul | 0264
12897773 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 131 | VE13.02.0266 | Umyvadlo + modul | 0266
12897774 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 127 | VE13.02.0267 | Umyvadlo + modul | 0267
12898197 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 132 | VE13.02.0270 | Umyvadlo + modul | 0270
12898198 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 128 | VE13.02.0271 | Umyvadlo + modul | 0271
12898221 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 133 | VE13.02.0273 | Umyvadlo + modul | 0273
12898222 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 129 | VE13.02.0274 | Umyvadlo + modul | 0274
12898543 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 135 | VE13.02.0276 | Umyvadlo + modul | 0276
12898544 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 131 | VE13.02.0277 | Umyvadlo + modul | 0277
12898594 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 137 | VE13.02.0279 | Umyvadlo + modul | 0279
12898595 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 133 | VE13.02.0280 | Umyvadlo + modul | 0280
12899099 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 79 | VE13.02.0282 | Umyvadlo + modul | 0282
12899100 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 50 | VE13.02.0283 | Umyvadlo + modul | 0283
12899470 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 57 | VE13.02.0287 | Umyvadlo + modul | 0287
12899471 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 56 | VE13.02.0288 | Umyvadlo + modul | 0288
12899620 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 139 | VE13.02.0292 | Umyvadlo + modul | 0292
12899621 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 135 | VE13.02.0293 | Umyvadlo + modul | 0293
12992012 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 183 | VE13.02.0329 | Umyvadlo + modul | 0329
12992013 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 76 | VE13.02.0330 | Umyvadlo + modul | 0330
12992030 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 78 | VE13.02.0332 | Umyvadlo + modul | 0332
12992031 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 77 | VE13.02.0333 | Umyvadlo + modul | 0333
13068776 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 199 | VE13.02.0399 | Umyvadlo + modul | 0399
13068777 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 200 | VE13.02.0400 | Umyvadlo + modul | 0400
13068914 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 200 | VE13.02.0402 | Umyvadlo + modul | 0402
13068915 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 201 | VE13.02.0403 | Umyvadlo + modul | 0403
13071945 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 37 | VE13.02.0420 | Umyvadlo + modul | 0420
13071946 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 36 | VE13.02.0421 | Umyvadlo + modul | 0421
13102565 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 12 | VE13.02.0437 | Umyvadlo + modul | 0437
13102566 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 4 | VE13.02.0438 | Umyvadlo + modul | 0438
13102680 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 14 | VE13.02.0440 | Umyvadlo + modul | 0440
13102681 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 9 | VE13.02.0441 | Umyvadlo + modul | 0441
13105035 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 15 | VE13.02.0443 | Umyvadlo + modul | 0443
13105036 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 10 | VE13.02.0444 | Umyvadlo + modul | 0444
13154251 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 13 | VE13.02.0446 | Umyvadlo + modul | 0446
13154252 | -1.PP_SO-102 | 0 | 1.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 8 | VE13.02.0447 | Umyvadlo + modul | 0447
13401570 | -1.PP_SO-102 | 0 | -1.PP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 21 | VE13.02.0505 | Výlevka nástěnné | 0505
13401571 | -1.PP_SO-102 | 0 | -1.PP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 19 | VE13.02.0506 | Výlevka nástěnné | 0506
13401597 | 1.NP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 17 | VE13.02.0508 | Výlevka nástěnné | 0508
13401598 | 1.NP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 18 | VE13.02.0509 | Výlevka nástěnné | 0509
13401718 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 33 | VE13.02.0511 | Výlevka nástěnnê | 0511
13401719 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 89 | VE13.02.0512 | Výlevka nástěnnê | 0512
13401872 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 36 | VE13.02.0514 | Umyvadlo | 0514
13401873 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 91 | VE13.02.0515 | Umyvadlo | 0515
13505812 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 90 | VE13.02.0561 | Umyvadlo + modul | 0561
13505813 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 138 | VE13.02.0562 | Umyvadlo + modul | 0562
13505920 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 117 | VE13.02.0564 | Umyvadlo + modul | 0564
13505921 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 114 | VE13.02.0565 | Umyvadlo + modul | 0565
13506562 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 92 | VE13.02.0568 | Umyvadlo + modul | 0568
13506563 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 122 | VE13.02.0569 | Umyvadlo + modul | 0569
13506635 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 94 | VE13.02.0571 | Umyvadlo + modul | 0571
13506636 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 113 | VE13.02.0572 | Umyvadlo + modul | 0572
13506745 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 97 | VE13.02.0574 | Umyvadlo + modul | 0574
13506746 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 93 | VE13.02.0575 | Umyvadlo + modul | 0575
13506813 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 96 | VE13.02.0577 | Umyvadlo + modul | 0577
13506814 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 78 | VE13.02.0578 | Umyvadlo + modul | 0578
13525884 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 118 | VE13.02.0581 | Umyvadlo + modul | 0581
13525885 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 130 | VE13.02.0582 | Umyvadlo + modul | 0582
13526117 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 126 | VE13.02.0584 | Umyvadlo + modul | 0584
13526118 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 140 | VE13.02.0585 | Umyvadlo + modul | 0585
13526368 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 119 | VE13.02.0587 | Umyvadlo + modul | 0587
13526369 | 1.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 125 | VE13.02.0588 | Umyvadlo + modul | 0588
13526785 | -2.PP_SO-102 | 0 | -1.PP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 88 | VE13.02.0590 | Umyvadlo + modul | 0590
13526786 | -2.PP_SO-102 | 0 | -1.PP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 115 | VE13.02.0591 | Umyvadlo + modul | 0591
13544045 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 80 | VE13.02.0596 | Umyvadlo + modul | 0596
13544046 | 3.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 73 | VE13.02.0597 | Umyvadlo + modul | 0597
13544814 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 134 | VE13.02.0599 | Umyvadlo | 0599
13544815 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 141 | VE13.02.0600 | Umyvadlo | 0600
13545125 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 136 | VE13.02.0603 | Výlevka nástěnnë | 0603
13545126 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 142 | VE13.02.0604 | Výlevka nástěnnë | 0604
13545323 | -2.PP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 74 | VE13.02.0606 | Výlevka nástěnnë | 0606
13545324 | -2.PP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 65 | VE13.02.0607 | Výlevka nástěnnë | 0607
13545421 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 138 | VE13.02.0608 | Umyvadlo + modul | 0608
13545422 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 144 | VE13.02.0609 | Umyvadlo + modul | 0609
13546118 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 140 | VE13.02.0611 | Umyvadlo | 0611
13546119 | 2.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 145 | VE13.02.0612 | Umyvadlo | 0612
13550205 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 141 | VE13.02.0614 | Výlevka nástěnnê | 0614
13550206 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 146 | VE13.02.0615 | Výlevka nástěnnê | 0615
13725003 | -1.PP_SO-102 |  | 1.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 18 | VE13.02.0660 | Výlevka nástěnnî | 0660
13725004 | -1.PP_SO-102 |  | 1.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 13 | VE13.02.0661 | Výlevka nástěnnî | 0661
13728591 | 1.NP_SO-102 |  | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 22 | VE13.02.0663 | Výlevka nástěnnñ | 0663
13728592 | 1.NP_SO-102 |  | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 14 | VE13.02.0664 | Výlevka nástěnnñ | 0664
13728667 | 1.NP_SO-102 |  | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 5 | VE13.02.0666 | Výlevka nástěnnñ | 0666
13728668 | 1.NP_SO-102 |  | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 11 | VE13.02.0667 | Výlevka nástěnnñ | 0667
13733480 | 2.NP_SO-102 |  | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 39 | VE13.02.0669 | Výlevka nástěnnî | 0669
13733481 | 2.NP_SO-102 |  | 3.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 17 | VE13.02.0670 | Výlevka nástěnnî | 0670
14005550 | -2.PP_SO-102 |  | -1.PP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 23 | VE13.02.0679 | Výlevka nástěnnò | 0679
14005551 | -2.PP_SO-102 |  | -1.PP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 1 | VE13.02.0680 | Výlevka nástěnnò | 0680
14005931 | -2.PP_SO-102 |  | -1.PP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 24 | VE13.02.0682 | Výlevka nástěnnô | 0682
14005932 | -2.PP_SO-102 |  | -1.PP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 20 | VE13.02.0683 | Výlevka nástěnnô | 0683
14007192 | 3.NP_SO-102 |  | 4.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 40 | VE13.02.0685 | Výlevka nástěnnö | 0685
14007193 | 3.NP_SO-102 |  | 4.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 22 | VE13.02.0686 | Výlevka nástěnnö | 0686
14007272 | 2.NP_SO-102 |  | 3.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 11 | VE13.02.0688 | Výlevka nástěnnö | 0688
14007273 | 2.NP_SO-102 |  | 3.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 12 | VE13.02.0689 | Výlevka nástěnnö | 0689
14007303 | 1.NP_SO-102 |  | 2.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 41 | VE13.02.0691 | Výlevka nástěnnö | 0691
14007304 | 1.NP_SO-102 |  | 2.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 32 | VE13.02.0692 | Výlevka nástěnnö | 0692
14007332 | -1.PP_SO-102 |  | 1.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 77 | VE13.02.0694 | Výlevka nástěnnö | 0694
14007333 | -1.PP_SO-102 |  | 1.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 35 | VE13.02.0695 | Výlevka nástěnnö | 0695
14030745 | -2.PP_SO-102 | 0 | -1.PP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 109 | VE13.02.0699 | Umyvadlo | 0699
14030746 | -2.PP_SO-102 | 0 | -1.PP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 39 | VE13.02.0700 | Umyvadlo | 0700

# IfcValve: Rohový ventil:Roháček.CC (8)
Type - Classification: VE13 SNIM (SNIM); Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Kóty - Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; JMENOVITÝ PRŮMĚR: 15 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VE13; Název typu: Roháček.CC; Označení typu: 06; Popis: Rohový ventil; Popis sestavy: Rohový; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Příslušenství trubek; Název rodiny: Rohový ventil
Classification: VE13 SNIM (SNIM); VE13 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø15 mm-ø15 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: QMA; CCI Technický systém: JB
Vazby - Výška od podlaží: 120 mm
Mechanické - PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 15 mm; Minimální velikost: 15 mm; Objem: 0.0000388424 m3; Velikost: ø15-ø15
Identifikační data - Název sestavy: Bidet + modul
Jiné - Rodina: Rohový ventil; Id typu: 12882059; Rodina a typ: Rohový ventil: Roháček.CC; Typ: Roháček.CC
Name (Rohový ventil:Roháček.CC:...) | In | Podlaží | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Kód prvku | Označení
12881998 | 1.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 2 | VE13.06.0099 | 0099
12881999 | 1.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 4 | VE13.06.0100 | 0100
12899367 | -1.PP_SO-102 | 1.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 23 | VE13.06.0285 | 0285
12899368 | -1.PP_SO-102 | 1.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 46 | VE13.06.0286 | 0286
12899558 | 2.NP_SO-102 | 3.NP_SO-102 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 45 | VE13.06.0290 | 0290
12899559 | 2.NP_SO-102 | 3.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 51 | VE13.06.0291 | 0291
13067069 | 3.NP_SO-102 | 4.NP_SO-102 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 178 | VE13.06.0397 | 0397
13067070 | 3.NP_SO-102 | 4.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 182 | VE13.06.0398 | 0398

# IfcValve: Sifon pisoárový:DN50 (20)
Type - Classification: ZU00 SNIM (SNIM); Material: Plactic - White, Plactic - Black
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK: 0 m3/s
Type - Materiály a povrchové úpravy - Materiál: Plactic - White; Materiál 2: Plactic - Black
Type - Kóty - Jmenovitá velikost vstupu: 50 mm; Jmenovitá velikost výstupu: 50 mm; JMENOVITÝ PRŮMĚR: 50 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.70.50.00; DIMENZE: DN50; EAN: 9003076314300; HMOTNOST: 0,185 kg; HYDRAULICKÁ KAPACITA: 0,7l/s, Spülwasservolumen 1,0l; Indexovaná poznámka: HL430/50; Kód sestavy: ZU00; Komentáře k typům: Odsávací zápachová uzávěrka DN50 pro pisoáry, s kloubem na odtoku; MATERIÁL: PP; Model: HL430/50; Nadpis OmniClass: Liquid Waste Handling Services; Název typu: DN50; NORMY: DIN1380, DIN19541; Označení typu: 05; Popis: Odsávací zápachová uzávěrka DN50 pro pisoáry; Popis sestavy: Obecný prvek; PRÁVNÍ OZNÁMENÍ: "Copyright (©), autorská a jiná práva spojená s duševním vlastnictvím, jsou výhradním vlastnictvím společnosti HL Hutterer & Lechner GmbH. Úpravy nejsou dovoleny. Rodina je opatřená vodoznakem."; URL: http://www.hutterer-lechner.com/cs/products/catalog/roof-drains/HL430/50.aspx; Výrobce: HL Hutterer & Lechner GmbH
Type - Jiné - Kategorie: Příslušenství trubek; b: 110.2 mm; n: 25 mm; Název rodiny: Sifon pisoárový
Classification: ZU00 SNIM (SNIM); ZU00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø50 mm-ø50 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Výška od podlaží: 450 mm
Mechanické - Klasifikace systému: Sanitární,Nedefinovaný
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 50 mm; Minimální velikost: 50 mm; Objem: 0.0008489 m3; Úhel instalace výstup: 0 deg; Velikost: ø50-ø50
Identifikační data - Název sestavy: Pisoár + modul
Jiné - a: 118.7 mm; c: 118.4 mm; d: 118.7 mm; Id typu: 12878471; Rodina: Sifon pisoárový; Rodina a typ: Sifon pisoárový: DN50; Typ: DN50; Úhel instalace výstup max: 0 deg; Úhel instalace výstup min: 0 deg; x: 25.5 mm
Name (Sifon pisoárový:DN50:...) | In | Podlaží | Fáze vytvoření | Kód prvku | Označení
12879587 | -1.PP_SO-102 | 1.NP_SO-102 | Fáze 1 | ZU00.05.0039 | 0039
12879629 | -1.PP_SO-102 | 1.NP_SO-102 | Fáze 1 | ZU00.05.0040 | 0040
12879641 | -1.PP_SO-102 | 1.NP_SO-102 | Fáze 1 | ZU00.05.0041 | 0041
12880778 | 1.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | ZU00.05.0057 | 0057
12880783 | 1.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | ZU00.05.0058 | 0058
12880788 | 1.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | ZU00.05.0059 | 0059
12880948 | 2.NP_SO-102 | 3.NP_SO-102 | Fáze 1 | ZU00.05.0075 | 0075
12880953 | 2.NP_SO-102 | 3.NP_SO-102 | Fáze 1 | ZU00.05.0076 | 0076
12880958 | 2.NP_SO-102 | 3.NP_SO-102 | Fáze 1 | ZU00.05.0077 | 0077
12881118 | 3.NP_SO-102 | 4.NP_SO-102 | Fáze 1 | ZU00.05.0093 | 0093
12881123 | 3.NP_SO-102 | 4.NP_SO-102 | Fáze 1 | ZU00.05.0094 | 0094
12881128 | 3.NP_SO-102 | 4.NP_SO-102 | Fáze 1 | ZU00.05.0095 | 0095
12890552 | 1.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | ZU00.05.0131 | 0131
12890561 | 1.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | ZU00.05.0132 | 0132
12890573 | 1.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | ZU00.05.0133 | 0133
12894936 | -1.PP_SO-102 | 1.NP_SO-102 | Fáze 2 | ZU00.05.0212 | 0212
12895866 | 1.NP_SO-102 | 2.NP_SO-102 | Fáze 2 | ZU00.05.0228 | 0228
12897022 | 2.NP_SO-102 | 3.NP_SO-102 | Fáze 2 | ZU00.05.0250 | 0250
12897905 | 3.NP_SO-102 | 4.NP_SO-102 | Fáze 2 | ZU00.05.0269 | 0269
13154276 | -1.PP_SO-102 | 1.NP_SO-102 | Fáze 2 | ZU00.05.0449 | 0449

# IfcValve: Sifon pro sprchové vaničky s nerez krytkou:Sifon pro sprchové vaničky s nerez krytkou (8)
Type - Classification: ZU00 SNIM (SNIM); Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Kóty - Jmenovitá velikost vstupu: 75 mm; Jmenovitá velikost výstupu: 75 mm; JMENOVITÝ PRŮMĚR: 40 mm; JMENOVITÝ PRŮMĚR 2: 50 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: ZÚ.01; Kód sestavy: ZU00; Komentáře k typům: sprchový Jika THEMA 50_40mm s nerez krytkou, logem JIKA, průtok 39 l/min; Model: 2.9482.4.000.000.1; Název typu: Sifon pro sprchové vaničky s nerez krytkou; Označení typu: 01; Popis: Sifon; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Jika
Type - Jiné - Kategorie: Příslušenství trubek; A: 20 mm; B: 25 mm; C: 20 mm; ID: 40 mm; Lookup Table Name: Trubky_Obecný typ; Název rodiny: Sifon pro sprchové vaničky s nerez krytkou; OD: 40.8 mm
Classification: ZU00 SNIM (SNIM); ZU00 Uniformat (Uniformat)
Izolace - Celková velikost: ø50 mm-ø40 mm; Tloušťka izolace: 0 mm
Text - CCI Funkční systém: G; CCI Komponenta: ABA; CCI Technický systém: JD
Vazby - Výška od podlaží: -52 mm
Mechanické - Klasifikace systému: Sanitární; PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 50 mm; Minimální velikost: 40 mm; Objem: 0.000583203 m3; Prodloužení 1: 52 mm; Prodloužení 2: 95 mm; Velikost: ø50-ø40; Výška odpadu: 100 mm
Identifikační data - ID pozice: 02; ID systému: 003; Název sestavy: Sprchový kout - vanička (nástěnná baterie)
Jiné - Id typu: 12798063; Rodina: Sifon pro sprchové vaničky s nerez krytkou; Rodina a typ: Sifon pro sprchové vaničky s nerez krytkou: Sifon pro sprchové vaničky s nerez krytkou; Typ: Sifon pro sprchové vaničky s nerez krytkou
Name (Sifon pro sprchové vaničky s nerez krytkou:Sifon pro sprchové vaničky s nerez krytkou:...) | In | Podlaží | Fáze vytvoření | Kód prvku | Označení
12797920 | -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | ZU00.01.0001 | 0001
12805480 | -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | ZU00.01.0002 | 0002 | Mechanické - Název systému: SW_Splašky přípojka 1; Typ systému: SW_Splašky přípojka; Group: SW_Splašky přípojka 1
12833680 | -2.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | ZU00.01.0006 | 0006 | Mechanické - Název systému: SW_Splašky přípojka 3; Typ systému: SW_Splašky přípojka; Group: SW_Splašky přípojka 3
12833744 | -2.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | ZU00.01.0007 | 0007 | Mechanické - Název systému: SW_Splašky přípojka 2; Typ systému: SW_Splašky přípojka; Group: SW_Splašky přípojka 2
12893439 | 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | ZU00.01.0188 | 0188
12893484 | 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | ZU00.01.0189 | 0189
12893963 | 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | ZU00.01.0190 | 0190
13325302 | -1.PP_SO-102 | -1.PP_SO-102 | Fáze 2 | ZU00.01.0474 | 0474

# IfcValve: Sifon umyvadlový:Sifon dřezový (6)
Type - Classification: ZU00 SNIM (SNIM); Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Kóty - Jmenovitá velikost vstupu: 50 mm; Jmenovitá velikost výstupu: 50 mm; JMENOVITÝ PRŮMĚR: 50 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZU00; Komentáře k typům: Zápachová uzávěrka pro umyvadlo; Název typu: Sifon dřezový; Označení typu: 27; Popis: ZU; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Příslušenství trubek; A: 25 mm; B: 30 mm; C: 25 mm; ID: 50 mm; Lookup Table Name: Trubky_Obecný typ; Název rodiny: Sifon umyvadlový; OD: 51 mm
Classification: ZU00 SNIM (SNIM); ZU00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø50 mm-ø50 mm
Text - CCI Funkční systém: G; CCI Komponenta: ABA; CCI Technický systém: JD
Vazby - Výška od podlaží: 0 mm
Mechanické - Klasifikace systému: Sanitární; PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 50 mm; Minimální velikost: 50 mm; Objem: 0.000816082 m3; Prodloužení 1: 110 mm; Prodloužení 2: 150 mm; Velikost: ø50-ø50; Výška odpadu: 530 mm
Jiné - Rodina: Sifon umyvadlový; Id typu: 13399818; Rodina a typ: Sifon umyvadlový: Sifon dřezový; Typ: Sifon dřezový
Name (Sifon umyvadlový:Sifon dřezový:...) | In | Podlaží | Fáze vytvoření | Kód prvku | Název sestavy | Označení
13401572 | -1.PP_SO-102 | -1.PP_SO-102 | Fáze 2 | ZU00.27.0507 | Výlevka nástěnné | 0507
13401599 | 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | ZU00.27.0510 | Výlevka nástěnné | 0510
13401720 | 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | ZU00.27.0513 | Výlevka nástěnnê | 0513
13545097 | 3.NP_SO-102 | 3.NP_SO-102 | Fáze 2 | ZU00.27.0602 | Výlevka nástěnnë | 0602
13545319 | -2.PP_SO-102 | 4.NP_SO-102 | Fáze 1 | ZU00.27.0605 | Výlevka nástěnnë | 0605
13550207 | 3.NP_SO-102 | 3.NP_SO-102 | Fáze 1 | ZU00.27.0616 | Výlevka nástěnnê | 0616

# IfcValve: Sifon umyvadlový:Sifon umyvadlový (122)
Type - Classification: ZU00 SNIM (SNIM); Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Kóty - Jmenovitá velikost vstupu: 50 mm; Jmenovitá velikost výstupu: 50 mm; JMENOVITÝ PRŮMĚR: 40 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZU00; Komentáře k typům: Zápachová uzávěrka pro umyvadlo; Název typu: Sifon umyvadlový; Označení typu: 03; Popis: ZU; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Příslušenství trubek; A: 20 mm; B: 25 mm; C: 20 mm; ID: 40 mm; Lookup Table Name: Trubky_Obecný typ; Název rodiny: Sifon umyvadlový; OD: 40.8 mm
Classification: ZU00 SNIM (SNIM); ZU00 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø40 mm-ø40 mm
Text - CCI Funkční systém: G; CCI Komponenta: ABA; CCI Technický systém: JD
Mechanické - Klasifikace systému: Sanitární; PRŮTOK_VODA: 0 m3/s; SPÁD TLAKU: 0 Pa
Grafika - Použít měřítko poznámky: no
Kóty - Maximální velikost: 40 mm; Minimální velikost: 40 mm; Velikost: ø40-ø40; Výška odpadu: 530 mm
Jiné - Id typu: 12812715; Rodina: Sifon umyvadlový; Rodina a typ: Sifon umyvadlový: Sifon umyvadlový; Typ: Sifon umyvadlový
Name (Sifon umyvadlový:Sifon umyvadlový:...) | In | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Objem (m3) | Prodloužení 1 (mm) | Prodloužení 2 (mm) | Kód prvku | Název sestavy | Označení
12825629 | -2.PP_SO-102 | -1.PP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0005 | Umyvadlo | 0005
12865987 | -1.PP_SO-102 | 1.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0011 | Umyvadlo + modul | 0011
12871091 | -2.PP_SO-102 | -1.PP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0014 | Umyvadlo + modul | 0014
12871119 | -2.PP_SO-102 | -1.PP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0017 | Umyvadlo + modul | 0017
12871180 | -2.PP_SO-102 | -1.PP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0020 | Umyvadlo + modul | 0020
12879381 | -1.PP_SO-102 | 1.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0023 | Umyvadlo + modul | 0023
12879422 | -1.PP_SO-102 | 1.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0026 | Umyvadlo + modul | 0026
12879451 | -1.PP_SO-102 | 1.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0029 | Umyvadlo + modul | 0029
12879482 | -1.PP_SO-102 | 1.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0032 | Umyvadlo + modul | 0032
12879509 | -1.PP_SO-102 | 1.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0035 | Umyvadlo + modul | 0035
12879538 | -1.PP_SO-102 | 1.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0038 | Umyvadlo + modul | 0038
12880700 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0044 | Umyvadlo + modul | 0044
12880714 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0047 | Umyvadlo + modul | 0047
12880742 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0050 | Umyvadlo + modul | 0050
12880756 | 1.NP_SO-102 | 2.NP_SO-102 | 0 | Fáze 1 | 0.000597412 | 110 | 205.675 | ZU00.03.0053 | Umyvadlo + modul | 0053
