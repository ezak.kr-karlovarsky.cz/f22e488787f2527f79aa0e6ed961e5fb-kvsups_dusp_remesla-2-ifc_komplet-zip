Properties of the parts of a building model (IFC4), part 11 of 60

# IfcDistributionPort (11856)
Name | FlowDirection | PredefinedType | SystemType | Group
OutPort_12881050_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 52
Port_12881054_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12881082_1 | SINK | PIPE | SEWAGE
OutPort_12881073_1 | SOURCE | PIPE | SEWAGE
InPort_12881074_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 60
InPort_12881076_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 60
OutPort_12881074_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 60
InPort_12881075_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 59
InPort_12881078_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 59
OutPort_12881075_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 59
InPort_12881080_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 60
OutPort_12881076_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 60
InPort_12881080_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 59
OutPort_12881078_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 59
Port_12881082_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12881096_1 | SINK | PIPE | SEWAGE
OutPort_12881087_1 | SOURCE | PIPE | SEWAGE
InPort_12881088_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 62
InPort_12881090_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 62
OutPort_12881088_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 62
InPort_12881089_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 61
InPort_12881092_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 61
OutPort_12881089_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 61
InPort_12881094_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 62
OutPort_12881090_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 62
InPort_12881094_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 61
OutPort_12881092_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 61
Port_12881096_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12881110_1 | SINK | PIPE | SEWAGE
OutPort_12881101_1 | SOURCE | PIPE | SEWAGE
InPort_12881102_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 64
InPort_12881104_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 64
OutPort_12881102_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 64
InPort_12881103_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 63
InPort_12881106_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 63
OutPort_12881103_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 63
InPort_12881108_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 64
OutPort_12881104_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 64
InPort_12881108_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 63
OutPort_12881106_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 63
Port_12881110_2 | SOURCEANDSINK | PIPE | SEWAGE
OutPort_12881116_1 | SOURCE | PIPE | SEWAGE
InPort_12881117_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12881118_1 | SOURCE | PIPE | SEWAGE
Port_12881118_2 | SOURCEANDSINK | PIPE
OutPort_12881121_1 | SOURCE | PIPE | SEWAGE
InPort_12881122_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12881123_1 | SOURCE | PIPE | SEWAGE
Port_12881123_2 | SOURCEANDSINK | PIPE
OutPort_12881126_1 | SOURCE | PIPE | SEWAGE
InPort_12881127_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12881128_1 | SOURCE | PIPE | SEWAGE
Port_12881128_2 | SOURCEANDSINK | PIPE
Port_12881911_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12881914_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12881941_1 | SINK | PIPE | SEWAGE
OutPort_12881932_1 | SOURCE | PIPE | SEWAGE
InPort_12881933_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 68
InPort_12881935_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 68
OutPort_12881933_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 68
InPort_12881934_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 67
InPort_12881937_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 67
OutPort_12881934_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 67
InPort_12881939_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 68
OutPort_12881935_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 68
InPort_12881939_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 67
OutPort_12881937_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 67
Port_12881941_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_12881994_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12881997_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 4
OutPort_12882000_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 4
InPort_12881997_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 2
OutPort_12882002_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 2
InPort_12881998_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 2
InPort_12882002_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 2
OutPort_12881998_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 2
InPort_12881999_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 4
InPort_12882000_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 4
OutPort_12881999_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 4
InPort_12884690_1 | SINK | PIPE | SEWAGE
OutPort_12884681_1 | SOURCE | PIPE | SEWAGE
InPort_12884682_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 72
InPort_12884684_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 72
OutPort_12884682_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 72
InPort_12884683_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 71
InPort_12884686_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 71
OutPort_12884683_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 71
InPort_12884688_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 72
OutPort_12884684_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 72
InPort_12884688_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 71
OutPort_12884686_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 71
Port_12884690_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12884800_1 | SINK | PIPE | SEWAGE
OutPort_12884791_1 | SOURCE | PIPE | SEWAGE
InPort_12884792_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 76
InPort_12884794_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 76
OutPort_12884792_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 76
InPort_12884793_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 75
InPort_12884796_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 75
OutPort_12884793_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 75
InPort_12884798_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 76
OutPort_12884794_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 76
InPort_12884798_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 75
OutPort_12884796_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 75
Port_12884800_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12886121_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12886121_2 | SINK | PIPE | DOMESTICHOTWATER
Port_12886121_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER
InPort_12886122_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_12886226_1 | SINK | PIPE | SEWAGE
OutPort_12886217_1 | SOURCE | PIPE | SEWAGE
InPort_12886218_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 70
InPort_12886220_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 70
OutPort_12886218_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 70
InPort_12886219_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 69
InPort_12886222_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 69
OutPort_12886219_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 69
InPort_12886224_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 70
OutPort_12886220_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 70
InPort_12886224_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 69
OutPort_12886222_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 69
Port_12886226_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12888141_1 | SINK | PIPE | SEWAGE
OutPort_12888132_1 | SOURCE | PIPE | SEWAGE
InPort_12888133_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 34
InPort_12888135_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 34
OutPort_12888133_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 34
InPort_12888134_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 33
InPort_12888137_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 33
OutPort_12888134_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 33
InPort_12888139_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 34
OutPort_12888135_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 34
InPort_12888139_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 33
OutPort_12888137_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 33
Port_12888141_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12888848_1 | SINK | PIPE | SEWAGE
OutPort_12888839_1 | SOURCE | PIPE | SEWAGE
InPort_12888840_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 35
InPort_12888842_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 35
OutPort_12888840_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 35
InPort_12888841_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 34
InPort_12888844_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 34
OutPort_12888841_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 34
InPort_12888846_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 35
OutPort_12888842_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 35
InPort_12888846_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 34
OutPort_12888844_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 34
Port_12888848_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12888872_1 | SINK | PIPE | SEWAGE
OutPort_12888863_1 | SOURCE | PIPE | SEWAGE
InPort_12888864_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 38
InPort_12888866_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 38
OutPort_12888864_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 38
InPort_12888865_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 37
InPort_12888868_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 37
OutPort_12888865_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 37
InPort_12888870_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 38
OutPort_12888866_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 38
InPort_12888870_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 37
OutPort_12888868_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 37
Port_12888872_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12889682_1 | SINK | PIPE | SEWAGE
OutPort_12889673_1 | SOURCE | PIPE | SEWAGE
InPort_12889674_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 81
InPort_12889676_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 81
OutPort_12889674_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 81
InPort_12889675_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 80
InPort_12889678_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 80
OutPort_12889675_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 80
InPort_12889680_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 81
OutPort_12889676_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 81
InPort_12889680_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 80
OutPort_12889678_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 80
Port_12889682_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_12889905_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12889908_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12889913_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12889916_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12889924_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12889927_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12889946_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 16
InPort_12889949_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12890314_1 | SINK | PIPE | SEWAGE
OutPort_12890305_1 | SOURCE | PIPE | SEWAGE
InPort_12890306_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_12999458_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_12890308_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_12890306_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_12890307_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 82
InPort_12890310_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 82
OutPort_12890307_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 82
InPort_12890312_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_12890308_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_12890312_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 82
OutPort_12890310_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 82
Port_12890314_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12890341_1 | SINK | PIPE | SEWAGE
OutPort_12890332_1 | SOURCE | PIPE | SEWAGE
InPort_12890333_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 84
InPort_12890335_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 84
OutPort_12890333_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 84
InPort_12890334_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 83
InPort_12890337_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 83
OutPort_12890334_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 83
InPort_12890339_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 84
OutPort_12890335_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 84
InPort_12890339_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 83
OutPort_12890337_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 83
Port_12890341_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12890452_1 | SINK | PIPE | SEWAGE
OutPort_12890443_1 | SOURCE | PIPE | SEWAGE
InPort_12890444_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 82
InPort_12890446_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 82
OutPort_12890444_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 82
InPort_12890445_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 81
InPort_12890448_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 81
OutPort_12890445_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 81
InPort_12890450_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 82
OutPort_12890446_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 82
InPort_12890450_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 81
OutPort_12890448_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 81
Port_12890452_2 | SOURCEANDSINK | PIPE | SEWAGE
OutPort_12890550_1 | SOURCE | PIPE | SEWAGE
InPort_12890551_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12890552_1 | SOURCE | PIPE | SEWAGE
Port_12890552_2 | SOURCEANDSINK | PIPE
OutPort_12890559_1 | SOURCE | PIPE | SEWAGE
InPort_12890560_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12890561_1 | SOURCE | PIPE | SEWAGE
Port_12890561_2 | SOURCEANDSINK | PIPE
OutPort_12890571_1 | SOURCE | PIPE | SEWAGE
InPort_12890572_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12890573_1 | SOURCE | PIPE | SEWAGE
Port_12890573_2 | SOURCEANDSINK | PIPE
InPort_12890837_1 | SINK | PIPE | SEWAGE
OutPort_12890828_1 | SOURCE | PIPE | SEWAGE
InPort_12890829_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 85
InPort_12890831_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 85
OutPort_12890829_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 85
InPort_12890830_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 84
InPort_12890833_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 84
OutPort_12890830_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 84
InPort_12890835_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 85
OutPort_12890831_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 85
InPort_12890835_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 84
OutPort_12890833_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 84
Port_12890837_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12890861_1 | SINK | PIPE | SEWAGE
OutPort_12890852_1 | SOURCE | PIPE | SEWAGE
InPort_12890853_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 86
InPort_12890855_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 86
OutPort_12890853_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 86
InPort_12890854_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 85
InPort_12890857_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 85
OutPort_12890854_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 85
InPort_12890859_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 86
OutPort_12890855_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 86
InPort_12890859_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 85
OutPort_12890857_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 85
Port_12890861_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12891282_1 | SINK | PIPE | SEWAGE
OutPort_12891273_1 | SOURCE | PIPE | SEWAGE
InPort_12891274_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 32
InPort_12891276_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 32
OutPort_12891274_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 32
InPort_12891275_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 31
InPort_12891278_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 31
OutPort_12891275_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 31
InPort_12891280_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 32
OutPort_12891276_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 32
InPort_12891280_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 31
OutPort_12891278_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 31
Port_12891282_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12891693_1 | SINK | PIPE | SEWAGE
OutPort_12891684_1 | SOURCE | PIPE | SEWAGE
InPort_12891685_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 49
InPort_12891687_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 49
OutPort_12891685_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 49
InPort_12891686_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 48
InPort_12891689_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 48
OutPort_12891686_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 48
InPort_12891691_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 49
OutPort_12891687_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 49
InPort_12891691_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 48
OutPort_12891689_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 48
Port_12891693_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12891784_1 | SINK | PIPE | SEWAGE
OutPort_12891775_1 | SOURCE | PIPE | SEWAGE
InPort_12891776_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 55
InPort_12891778_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 55
OutPort_12891776_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 55
InPort_12891777_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 54
InPort_12891780_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 54
OutPort_12891777_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 54
InPort_12891782_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 55
OutPort_12891778_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 55
InPort_12891782_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 54
OutPort_12891780_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 54
Port_12891784_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12891857_1 | SINK | PIPE | SEWAGE
OutPort_12891848_1 | SOURCE | PIPE | SEWAGE
InPort_12891849_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 59
InPort_12891851_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 59
OutPort_12891849_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 59
InPort_12891850_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 58
InPort_12891853_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 58
OutPort_12891850_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 58
InPort_12891855_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 59
OutPort_12891851_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 59
InPort_12891855_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 58
OutPort_12891853_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 58
Port_12891857_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12891929_1 | SINK | PIPE | SEWAGE
OutPort_12891920_1 | SOURCE | PIPE | SEWAGE
InPort_12891921_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 61
InPort_12891923_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 61
OutPort_12891921_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 61
InPort_12891922_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 60
InPort_12891925_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 60
OutPort_12891922_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 60
InPort_12891927_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 61
OutPort_12891923_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 61
InPort_12891927_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 60
OutPort_12891925_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 60
Port_12891929_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12892004_1 | SINK | PIPE | SEWAGE
OutPort_12891995_1 | SOURCE | PIPE | SEWAGE
InPort_12891996_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 63
InPort_12891998_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 63
OutPort_12891996_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 63
InPort_12891997_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 62
InPort_12892000_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 62
OutPort_12891997_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 62
InPort_12892002_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 63
OutPort_12891998_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 63
InPort_12892002_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 62
OutPort_12892000_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 62
Port_12892004_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12892070_1 | SINK | PIPE | SEWAGE
OutPort_12892061_1 | SOURCE | PIPE | SEWAGE
InPort_12892062_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 65
InPort_12892064_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 65
OutPort_12892062_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 65
InPort_12892063_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 64
InPort_12892066_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 64
OutPort_12892063_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 64
InPort_12892068_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 65
OutPort_12892064_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 65
InPort_12892068_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 64
OutPort_12892066_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 64
Port_12892070_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12892287_1 | SINK | PIPE | SEWAGE
OutPort_12892278_1 | SOURCE | PIPE | SEWAGE
InPort_12892279_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 67
InPort_12892281_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 67
OutPort_12892279_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 67
InPort_12892280_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 66
InPort_12892283_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 66
OutPort_12892280_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 66
InPort_12892285_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 67
OutPort_12892281_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 67
InPort_12892285_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 66
OutPort_12892283_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 66
Port_12892287_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12892354_1 | SINK | PIPE | SEWAGE
OutPort_12892345_1 | SOURCE | PIPE | SEWAGE
InPort_12892346_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 69
InPort_12892348_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 69
OutPort_12892346_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 69
InPort_12892347_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 68
InPort_12892350_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 68
OutPort_12892347_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 68
InPort_12892352_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 69
OutPort_12892348_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 69
InPort_12892352_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 68
OutPort_12892350_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 68
Port_12892354_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12892420_1 | SINK | PIPE | SEWAGE
OutPort_12892411_1 | SOURCE | PIPE | SEWAGE
InPort_12892412_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 71
InPort_12892414_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 71
OutPort_12892412_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 71
InPort_12892413_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 70
InPort_12892416_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 70
OutPort_12892413_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 70
InPort_12892418_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 71
OutPort_12892414_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 71
InPort_12892418_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 70
OutPort_12892416_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 70
Port_12892420_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12892486_1 | SINK | PIPE | SEWAGE
OutPort_12892477_1 | SOURCE | PIPE | SEWAGE
InPort_12892478_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 73
InPort_12892480_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 73
OutPort_12892478_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 73
InPort_12892479_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 72
InPort_12892482_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 72
OutPort_12892479_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 72
InPort_12892484_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 73
OutPort_12892480_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 73
InPort_12892484_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 72
OutPort_12892482_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 72
Port_12892486_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12892551_1 | SINK | PIPE | SEWAGE
OutPort_12892542_1 | SOURCE | PIPE | SEWAGE
InPort_12892543_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 75
InPort_12892545_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 75
OutPort_12892543_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 75
InPort_12892544_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 74
InPort_12892547_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 74
OutPort_12892544_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 74
InPort_12892549_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 75
OutPort_12892545_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 75
InPort_12892549_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 74
OutPort_12892547_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 74
Port_12892551_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_12892698_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12892701_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12892804_1 | SINK | PIPE | SEWAGE
OutPort_12892795_1 | SOURCE | PIPE | SEWAGE
InPort_12892796_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 87
InPort_12892798_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 87
OutPort_12892796_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 87
InPort_12892797_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 86
InPort_12892800_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 86
OutPort_12892797_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 86
InPort_12892802_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 87
OutPort_12892798_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 87
InPort_12892802_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 86
OutPort_12892800_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 86
Port_12892804_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12892907_1 | SINK | PIPE | SEWAGE
OutPort_12892898_1 | SOURCE | PIPE | SEWAGE
InPort_12892899_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 89
InPort_12892901_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 89
OutPort_12892899_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 89
InPort_12892900_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 88
InPort_12892903_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 88
OutPort_12892900_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 88
InPort_12892905_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 89
OutPort_12892901_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 89
InPort_12892905_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 88
OutPort_12892903_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 88
Port_12892907_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12893038_1 | SINK | PIPE | SEWAGE
OutPort_12893029_1 | SOURCE | PIPE | SEWAGE
InPort_12893030_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 91
InPort_12893032_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 91
OutPort_12893030_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 91
InPort_12893031_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 90
InPort_12893034_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 90
OutPort_12893031_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 90
InPort_12893036_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 91
OutPort_12893032_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 91
InPort_12893036_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 90
OutPort_12893034_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 90
Port_12893038_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12893163_1 | SINK | PIPE | SEWAGE
OutPort_12893154_1 | SOURCE | PIPE | SEWAGE
InPort_12893155_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 93
InPort_12893157_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 93
OutPort_12893155_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 93
InPort_12893156_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 92
InPort_12893159_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 92
OutPort_12893156_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 92
InPort_12893161_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 93
OutPort_12893157_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 93
InPort_12893161_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 92
OutPort_12893159_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 92
Port_12893163_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12893439_1 | SINK | PIPE | SEWAGE
OutPort_12893438_1 | SOURCE | PIPE | SEWAGE
Port_12893439_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12893444_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 20
OutPort_12893446_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 20
InPort_12893445_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_12893445_2 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12893446_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 20
OutPort_12893445_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 20
InPort_12893484_1 | SINK | PIPE | SEWAGE
OutPort_12893483_1 | SOURCE | PIPE | SEWAGE
Port_12893484_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12893489_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 95
OutPort_12893491_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 95
InPort_12893490_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_12893490_2 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12893491_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 95
OutPort_12893490_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 95
InPort_12893963_1 | SINK | PIPE | SEWAGE
OutPort_12893962_1 | SOURCE | PIPE | SEWAGE
Port_12893963_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12893968_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 66
OutPort_12893970_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 66
InPort_12893969_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_12893969_2 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12893970_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 66
OutPort_12893969_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 66
InPort_12894064_1 | SINK | PIPE | SEWAGE
OutPort_12894055_1 | SOURCE | PIPE | SEWAGE
InPort_12894056_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 98
InPort_12894058_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 98
OutPort_12894056_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 98
InPort_12894057_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 94
InPort_12894060_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 94
OutPort_12894057_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 94
InPort_12894062_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 98
OutPort_12894058_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 98
InPort_12894062_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 94
OutPort_12894060_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 94
Port_12894064_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12894130_1 | SINK | PIPE | SEWAGE
OutPort_12894121_1 | SOURCE | PIPE | SEWAGE
InPort_12894122_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 99
InPort_12894124_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 99
OutPort_12894122_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 99
InPort_12894123_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 95
InPort_12894126_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 95
OutPort_12894123_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 95
InPort_12894128_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 99
OutPort_12894124_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 99
InPort_12894128_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 95
OutPort_12894126_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 95
Port_12894130_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12894209_1 | SINK | PIPE | SEWAGE
OutPort_12894200_1 | SOURCE | PIPE | SEWAGE
InPort_12894201_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 100
InPort_12894203_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 100
OutPort_12894201_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 100
InPort_12894202_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 96
InPort_12894205_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 96
OutPort_12894202_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 96
InPort_12894207_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 100
OutPort_12894203_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 100
InPort_12894207_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 96
OutPort_12894205_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 96
Port_12894209_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12894273_1 | SINK | PIPE | SEWAGE
OutPort_12894264_1 | SOURCE | PIPE | SEWAGE
InPort_12894265_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 101
InPort_12894267_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 101
OutPort_12894265_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 101
InPort_12894266_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 97
InPort_12894269_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 97
OutPort_12894266_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 97
InPort_12894271_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 101
OutPort_12894267_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 101
InPort_12894271_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 97
OutPort_12894269_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 97
Port_12894273_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12894334_1 | SINK | PIPE | SEWAGE
OutPort_12894325_1 | SOURCE | PIPE | SEWAGE
InPort_12894326_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 102
InPort_12894328_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 102
OutPort_12894326_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 102
InPort_12894327_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 98
InPort_12894330_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 98
OutPort_12894327_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 98
InPort_12894332_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 102
OutPort_12894328_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 102
InPort_12894332_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 98
OutPort_12894330_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 98
Port_12894334_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_12894598_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12894601_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12894679_1 | SINK | PIPE | SEWAGE
OutPort_12894670_1 | SOURCE | PIPE | SEWAGE
InPort_12894671_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 103
InPort_12894673_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 103
OutPort_12894671_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 103
InPort_12894672_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 99
InPort_12894675_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 99
OutPort_12894672_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 99
InPort_12894677_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 103
OutPort_12894673_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 103
InPort_12894677_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 99
OutPort_12894675_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 99
Port_12894679_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12894793_1 | SINK | PIPE | SEWAGE
OutPort_12894784_1 | SOURCE | PIPE | SEWAGE
InPort_12894785_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 104
InPort_12894787_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 104
OutPort_12894785_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 104
InPort_12894786_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 100
InPort_12894789_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 100
OutPort_12894786_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 100
InPort_12894791_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 104
OutPort_12894787_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 104
InPort_12894791_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 100
OutPort_12894789_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 100
Port_12894793_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_12894888_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12894891_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12894934_1 | SOURCE | PIPE | SEWAGE
InPort_12894935_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12894936_1 | SOURCE | PIPE | SEWAGE
Port_12894936_2 | SOURCEANDSINK | PIPE
Port_12894981_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12894984_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12894989_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12894992_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12895103_1 | SINK | PIPE | SEWAGE
OutPort_12895094_1 | SOURCE | PIPE | SEWAGE
InPort_12895095_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 105
InPort_12895097_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 105
OutPort_12895095_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 105
InPort_12895096_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 101
InPort_12895099_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 101
OutPort_12895096_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 101
InPort_12895101_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 105
OutPort_12895097_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 105
InPort_12895101_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 101
OutPort_12895099_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 101
Port_12895103_2 | SOURCEANDSINK | PIPE | SEWAGE
OutPort_12895160_1 | SOURCE | PIPE | SEWAGE
InPort_12895162_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_12895162_2 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12895286_1 | SINK | PIPE | SEWAGE
OutPort_12895277_1 | SOURCE | PIPE | SEWAGE
InPort_12895278_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 106
InPort_12895280_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 106
OutPort_12895278_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 106
InPort_12895279_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 102
InPort_12895282_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 102
OutPort_12895279_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 102
InPort_12895284_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 106
OutPort_12895280_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 106
InPort_12895284_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 102
OutPort_12895282_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 102
Port_12895286_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12895310_1 | SINK | PIPE | SEWAGE
OutPort_12895301_1 | SOURCE | PIPE | SEWAGE
InPort_12895302_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 107
InPort_12895304_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 107
OutPort_12895302_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 107
InPort_12895303_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 103
InPort_12895306_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 103
OutPort_12895303_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 103
InPort_12895308_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 107
OutPort_12895304_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 107
InPort_12895308_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 103
OutPort_12895306_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 103
Port_12895310_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12895441_1 | SINK | PIPE | SEWAGE
OutPort_12895432_1 | SOURCE | PIPE | SEWAGE
InPort_12895433_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 110
InPort_12895435_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 110
OutPort_12895433_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 110
InPort_12895434_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 106
InPort_12895437_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 106
OutPort_12895434_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 106
InPort_12895439_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 110
OutPort_12895435_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 110
InPort_12895439_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 106
OutPort_12895437_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 106
Port_12895441_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12895787_1 | SINK | PIPE | SEWAGE
OutPort_12895778_1 | SOURCE | PIPE | SEWAGE
InPort_12895779_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 113
InPort_12895781_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 113
OutPort_12895779_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 113
InPort_12895780_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 109
InPort_12895783_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 109
OutPort_12895780_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 109
InPort_12895785_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 113
OutPort_12895781_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 113
InPort_12895785_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 109
OutPort_12895783_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 109
Port_12895787_2 | SOURCEANDSINK | PIPE | SEWAGE
OutPort_12895864_1 | SOURCE | PIPE | SEWAGE
InPort_12895865_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12895866_1 | SOURCE | PIPE | SEWAGE
Port_12895866_2 | SOURCEANDSINK | PIPE
Port_12895976_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12895979_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12896031_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12896034_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12896039_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12896042_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12896141_1 | SINK | PIPE | SEWAGE
OutPort_12896132_1 | SOURCE | PIPE | SEWAGE
InPort_12896133_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 114
InPort_12896135_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 114
OutPort_12896133_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 114
InPort_12896134_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 110
InPort_12896137_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 110
OutPort_12896134_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 110
InPort_12896139_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 114
OutPort_12896135_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 114
InPort_12896139_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 110
OutPort_12896137_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 110
Port_12896141_2 | SOURCEANDSINK | PIPE | SEWAGE
OutPort_12896221_1 | SOURCE | PIPE | SEWAGE
InPort_12896223_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_12896223_2 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12896341_1 | SINK | PIPE | SEWAGE
OutPort_12896332_1 | SOURCE | PIPE | SEWAGE
InPort_12896333_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 115
InPort_12896335_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 115
OutPort_12896333_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 115
InPort_12896334_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 111
InPort_12896337_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 111
OutPort_12896334_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 111
InPort_12896339_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 115
OutPort_12896335_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 115
InPort_12896339_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 111
OutPort_12896337_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 111
Port_12896341_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12896409_1 | SINK | PIPE | SEWAGE
OutPort_12896400_1 | SOURCE | PIPE | SEWAGE
InPort_12896401_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 116
InPort_12896403_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 116
OutPort_12896401_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 116
InPort_12896402_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 112
InPort_12896405_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 112
OutPort_12896402_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 112
InPort_12896407_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 116
OutPort_12896403_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 116
InPort_12896407_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 112
OutPort_12896405_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 112
Port_12896409_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12896722_1 | SINK | PIPE | SEWAGE
OutPort_12896713_1 | SOURCE | PIPE | SEWAGE
InPort_12896714_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 120
InPort_12896716_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 120
OutPort_12896714_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 120
InPort_12896715_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 116
InPort_12896718_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 116
OutPort_12896715_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 116
InPort_12896720_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 120
OutPort_12896716_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 120
InPort_12896720_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 116
OutPort_12896718_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 116
Port_12896722_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12896782_1 | SINK | PIPE | SEWAGE
OutPort_12896773_1 | SOURCE | PIPE | SEWAGE
InPort_12896774_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 121
InPort_12896776_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 121
OutPort_12896774_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 121
InPort_12896775_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 117
InPort_12896778_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 117
OutPort_12896775_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 117
InPort_12896780_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 121
OutPort_12896776_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 121
InPort_12896780_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 117
OutPort_12896778_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 117
Port_12896782_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12896898_1 | SINK | PIPE | SEWAGE
OutPort_12896889_1 | SOURCE | PIPE | SEWAGE
InPort_12896890_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 122
InPort_12896892_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 122
OutPort_12896890_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 122
InPort_12896891_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 118
InPort_12896894_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 118
OutPort_12896891_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 118
InPort_12896896_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 122
OutPort_12896892_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 122
InPort_12896896_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 118
OutPort_12896894_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 118
Port_12896898_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12896922_1 | SINK | PIPE | SEWAGE
OutPort_12896913_1 | SOURCE | PIPE | SEWAGE
InPort_12896914_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 123
InPort_12896916_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 123
OutPort_12896914_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 123
InPort_12896915_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 119
InPort_12896918_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 119
OutPort_12896915_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 119
InPort_12896920_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 123
OutPort_12896916_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 123
InPort_12896920_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 119
OutPort_12896918_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 119
Port_12896922_2 | SOURCEANDSINK | PIPE | SEWAGE
OutPort_12897020_1 | SOURCE | PIPE | SEWAGE
InPort_12897021_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12897022_1 | SOURCE | PIPE | SEWAGE
Port_12897022_2 | SOURCEANDSINK | PIPE
Port_12897073_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12897076_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12897081_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12897084_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12897092_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12897095_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12897198_1 | SOURCE | PIPE | SEWAGE
InPort_12897200_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_12897200_2 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12897295_1 | SINK | PIPE | SEWAGE
OutPort_12897286_1 | SOURCE | PIPE | SEWAGE
InPort_12897287_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 124
InPort_12897289_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 124
OutPort_12897287_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 124
InPort_12897288_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 120
InPort_12897291_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 120
OutPort_12897288_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 120
InPort_12897293_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 124
OutPort_12897289_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 124
InPort_12897293_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 120
OutPort_12897291_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 120
Port_12897295_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12897368_1 | SINK | PIPE | SEWAGE
OutPort_12897359_1 | SOURCE | PIPE | SEWAGE
InPort_12897360_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 125
InPort_12897362_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 125
OutPort_12897360_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 125
InPort_12897361_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 121
InPort_12897364_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 121
OutPort_12897361_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 121
InPort_12897366_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 125
OutPort_12897362_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 125
InPort_12897366_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 121
OutPort_12897364_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 121
Port_12897368_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12897419_1 | SINK | PIPE | SEWAGE
OutPort_12897410_1 | SOURCE | PIPE | SEWAGE
InPort_12897411_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 127
InPort_12897413_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 127
OutPort_12897411_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 127
InPort_12897412_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 123
InPort_12897415_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 123
OutPort_12897412_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 123
InPort_12897417_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 127
OutPort_12897413_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 127
InPort_12897417_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 123
OutPort_12897415_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 123
Port_12897419_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12897450_1 | SINK | PIPE | SEWAGE
OutPort_12897441_1 | SOURCE | PIPE | SEWAGE
InPort_12897442_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 128
InPort_12897444_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 128
OutPort_12897442_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 128
InPort_12897443_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 124
InPort_12897446_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 124
OutPort_12897443_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 124
InPort_12897448_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 128
OutPort_12897444_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 128
InPort_12897448_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 124
OutPort_12897446_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 124
Port_12897450_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12897757_1 | SINK | PIPE | SEWAGE
OutPort_12897748_1 | SOURCE | PIPE | SEWAGE
InPort_12897749_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 130
InPort_12897751_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 130
OutPort_12897749_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 130
InPort_12897750_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 126
InPort_12897753_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 126
OutPort_12897750_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 126
InPort_12897755_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 130
OutPort_12897751_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 130
InPort_12897755_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 126
OutPort_12897753_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 126
Port_12897757_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12897781_1 | SINK | PIPE | SEWAGE
OutPort_12897772_1 | SOURCE | PIPE | SEWAGE
InPort_12897773_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 131
InPort_12897775_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 131
OutPort_12897773_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 131
InPort_12897774_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 127
InPort_12897777_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 127
OutPort_12897774_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 127
InPort_12897779_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 131
OutPort_12897775_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 131
InPort_12897779_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 127
OutPort_12897777_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 127
Port_12897781_2 | SOURCEANDSINK | PIPE | SEWAGE
OutPort_12897903_1 | SOURCE | PIPE | SEWAGE
InPort_12897904_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12897905_1 | SOURCE | PIPE | SEWAGE
Port_12897905_2 | SOURCEANDSINK | PIPE
Port_12897988_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12897991_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12897996_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12897999_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_12898007_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12898010_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_12898141_1 | SOURCE | PIPE | SEWAGE
InPort_12898143_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_12898143_2 | SINK | PIPE | DOMESTICCOLDWATER
InPort_12898205_1 | SINK | PIPE | SEWAGE
OutPort_12898196_1 | SOURCE | PIPE | SEWAGE
InPort_12898197_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 132
InPort_12898199_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 132
OutPort_12898197_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 132
InPort_12898198_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 128
InPort_12898201_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 128
OutPort_12898198_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 128
InPort_12898203_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 132
OutPort_12898199_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 132
InPort_12898203_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 128
OutPort_12898201_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 128
Port_12898205_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12898229_1 | SINK | PIPE | SEWAGE
OutPort_12898220_1 | SOURCE | PIPE | SEWAGE
InPort_12898221_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 133
InPort_12898223_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 133
OutPort_12898221_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 133
InPort_12898222_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 129
InPort_12898225_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 129
OutPort_12898222_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 129
InPort_12898227_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 133
OutPort_12898223_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 133
InPort_12898227_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 129
OutPort_12898225_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 129
Port_12898229_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_12898551_1 | SINK | PIPE | SEWAGE
