Properties of the parts of a building model (IFC4), part 22 of 60

# IfcDistributionPort (11856)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_13517809_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13518314_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13517920_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13517920_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13518310_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13518297_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13518310_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13518297_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13518314_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13519784_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13519799_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13519784_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13533363_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13519799_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13533210_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13519799_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13519807_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13999317_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13520035_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13522749_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13524416_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13522749_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13522750_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13522749_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13522757_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13523082_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525238_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13523082_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525279_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13523505_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13523641_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13523505_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13829353_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13523641_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13641521_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13523982_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524043_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13523982_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524053_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524045_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524046_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524045_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524363_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524045_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524053_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524046_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524081_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524067_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524089_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524067_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524091_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524081_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524082_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524081_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524089_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524082_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13640844_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524144_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524372_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524144_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524382_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524221_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524335_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524221_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524345_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524337_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524375_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524337_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524338_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524337_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524345_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524363_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524374_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524374_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524375_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524374_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524382_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524400_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13524415_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13524415_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13524416_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13524415_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13524423_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13524451_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524452_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524451_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525239_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524677_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13645928_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524677_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13645930_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524865_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525272_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13524865_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525002_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525000_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525273_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525191_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525236_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525191_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525246_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525238_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525239_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525238_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525246_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525260_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525276_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525260_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525279_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525272_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525273_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525272_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525276_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13525892_1 | SINK | PIPE | SEWAGE
OutPort_13525883_1 | SOURCE | PIPE | SEWAGE
InPort_13525884_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 118
InPort_13525886_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 118
OutPort_13525884_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 118
InPort_13525885_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 130
InPort_13525888_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 130
OutPort_13525885_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 130
InPort_13525890_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 118
OutPort_13525886_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 118
InPort_13525890_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 130
OutPort_13525888_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 130
Port_13525892_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13526125_1 | SINK | PIPE | SEWAGE
OutPort_13526116_1 | SOURCE | PIPE | SEWAGE
InPort_13526117_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 126
InPort_13526119_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 126
OutPort_13526117_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 126
InPort_13526118_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 140
InPort_13526121_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 140
OutPort_13526118_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 140
InPort_13526123_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 126
OutPort_13526119_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 126
InPort_13526123_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 140
OutPort_13526121_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 140
Port_13526125_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13526376_1 | SINK | PIPE | SEWAGE
OutPort_13526367_1 | SOURCE | PIPE | SEWAGE
InPort_13526368_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 119
InPort_13526370_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 119
OutPort_13526368_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 119
InPort_13526369_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 125
InPort_13526372_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 125
OutPort_13526369_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 125
InPort_13526374_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 119
OutPort_13526370_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 119
InPort_13526374_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 125
OutPort_13526372_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 125
Port_13526376_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13526793_1 | SINK | PIPE | SEWAGE
OutPort_13526784_1 | SOURCE | PIPE | SEWAGE
InPort_13526785_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 88
InPort_13526787_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 88
OutPort_13526785_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 88
InPort_13526786_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 115
InPort_13526789_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 115
OutPort_13526786_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 115
InPort_13526791_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 88
OutPort_13526787_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 88
InPort_13526791_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 115
OutPort_13526789_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 115
Port_13526793_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_13527507_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13528001_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13527988_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13528007_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13527988_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13528010_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13528000_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13528001_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13528000_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13528007_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13528607_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13624170_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13528607_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13528830_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13528844_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13528830_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13624180_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13528848_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13624170_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13528848_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13624176_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13531471_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13531479_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13531555_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13531471_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13671995_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13531530_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13531530_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13531555_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13533210_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13533225_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13533225_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13534537_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13533225_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13533233_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13533277_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13533279_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13533359_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13533894_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13533390_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13533392_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13533522_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13533524_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13533619_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13533621_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13533892_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13533894_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13534537_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13534548_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13534548_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13534549_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13534548_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13534556_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13536225_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13828697_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13536227_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13536480_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13536480_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13807614_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13536603_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13828696_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13536603_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13807511_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13536650_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13536652_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13536650_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13641180_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13536652_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13828715_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13537043_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13807023_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13537079_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13986232_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13538002_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13838019_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13538002_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13538483_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675739_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13538483_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13639135_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14000540_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13543651_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13544053_1 | SINK | PIPE | SEWAGE
OutPort_13544044_1 | SOURCE | PIPE | SEWAGE
InPort_13544045_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 80
InPort_13544047_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 80
OutPort_13544045_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 80
InPort_13544046_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 73
InPort_13544049_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 73
OutPort_13544046_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 73
InPort_13544051_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 80
OutPort_13544047_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 80
InPort_13544051_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 73
OutPort_13544049_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 73
Port_13544053_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_13544159_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13544161_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
InPort_13544822_1 | SINK | PIPE | SEWAGE
OutPort_13544813_1 | SOURCE | PIPE | SEWAGE
InPort_13544814_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 134
InPort_13544816_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 134
OutPort_13544814_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 134
InPort_13544815_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 141
InPort_13544818_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 141
OutPort_13544815_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 141
InPort_13544820_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 134
OutPort_13544816_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 134
InPort_13544820_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 141
OutPort_13544818_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 141
Port_13544822_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_13544830_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13544832_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13544830_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13544855_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13544863_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13544855_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13545097_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13545098_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13545097_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13545125_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 136
InPort_13545130_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 136
OutPort_13545125_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 136
InPort_13545126_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 142
InPort_13545128_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 142
OutPort_13545126_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 142
InPort_13545165_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 142
OutPort_13545128_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 142
InPort_13545165_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 136
OutPort_13545130_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 136
Port_13545319_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13545320_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13545319_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13545323_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 74
InPort_13545327_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 74
OutPort_13545323_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 74
InPort_13545324_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 65
InPort_13545325_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 65
OutPort_13545324_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 65
InPort_13545329_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 65
OutPort_13545325_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 65
InPort_13545329_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 74
OutPort_13545327_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 74
InPort_13545429_1 | SINK | PIPE | SEWAGE
OutPort_13545420_1 | SOURCE | PIPE | SEWAGE
InPort_13545421_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 138
InPort_13545423_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 138
OutPort_13545421_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 138
InPort_13545422_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 144
InPort_13545425_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 144
OutPort_13545422_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 144
InPort_13545427_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 138
OutPort_13545423_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 138
InPort_13545427_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 144
OutPort_13545425_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 144
Port_13545429_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_13545668_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13545678_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13545668_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13546045_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13545682_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13546045_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13545682_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13546053_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13546050_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13545760_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13545764_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13681213_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13546049_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13681276_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13546049_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13546050_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13546049_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13546053_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13546126_1 | SINK | PIPE | SEWAGE
OutPort_13546117_1 | SOURCE | PIPE | SEWAGE
InPort_13546118_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 140
InPort_13546120_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 140
OutPort_13546118_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 140
InPort_13546119_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 145
InPort_13546122_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 145
OutPort_13546119_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 145
InPort_13546124_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 140
OutPort_13546120_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 140
InPort_13546124_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 145
OutPort_13546122_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 145
Port_13546126_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_13546164_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13546841_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13546164_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13546177_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13547300_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13546177_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13546441_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13546843_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13546441_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13546853_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13546841_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13546843_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13546845_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13546846_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13546845_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13546853_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13547277_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13547297_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13547277_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13547300_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13547290_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13817238_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13547290_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13547297_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13550205_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 141
InPort_13550214_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 141
OutPort_13550205_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 141
InPort_13550206_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 146
InPort_13550212_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 146
OutPort_13550206_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 146
Port_13550207_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13550208_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_13550207_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13550210_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 141
OutPort_13550214_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 141
InPort_13550210_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 146
OutPort_13550212_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 146
Port_13550252_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13550595_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13550252_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13550320_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13550328_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13550320_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13550725_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13550328_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13550595_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13550347_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13550725_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13550347_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13550729_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13550629_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13817652_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13550629_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13550729_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13573387_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13573400_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13573400_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13573401_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13573400_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13573408_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13573434_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13645149_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13573434_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14017273_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13573454_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14017337_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_13611676_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13611680_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
Port_13612981_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13612984_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13612984_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13659879_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13613048_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13613051_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
Port_13613063_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13613066_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13613077_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14028057_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13613077_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027576_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13613081_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027575_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13613081_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14026649_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13613132_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13613135_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13613535_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13630995_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13613538_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13613535_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
Port_13613591_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13613595_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13614065_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13621213_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13614065_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13614068_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13614102_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13616403_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13621213_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13621329_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13621291_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13621325_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13621291_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13621329_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13621396_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13621396_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13621412_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13622195_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13658920_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13624091_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13624176_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13624091_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13624180_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13624423_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13624461_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13624465_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13624423_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13624441_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13624465_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
Port_13624502_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13624522_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13624502_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13658165_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13624518_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13624522_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13630558_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13630574_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13630687_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13630558_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13630685_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13630687_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13630835_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13630685_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13630772_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13630835_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13631062_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13630772_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13630995_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13631066_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13631005_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13631062_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13631066_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13631005_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
Port_13640730_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13641029_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_13640824_2 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
OutPort_13641588_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13640844_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13641311_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13640878_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13640915_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13640896_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13641188_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13641107_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13640896_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13640915_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13641179_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13640939_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13641528_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13641540_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13640939_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13641014_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_13641425_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_13641442_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Teplá vnitřní 83
OutPort_13641014_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13641029_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13641417_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13641179_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13641180_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13641188_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13641179_3 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13641311_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13641520_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13641417_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13641418_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_13641425_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_13641417_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13641520_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13641521_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13641528_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13641520_3 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13641588_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
OutPort_13641661_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
InPort_13641661_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
OutPort_13641662_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
InPort_13641669_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
OutPort_13641661_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
InPort_13641754_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
OutPort_13641669_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
InPort_13641789_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Cirkulace vnitřní 9
OutPort_13641754_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
InPort_13641864_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
OutPort_13641880_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
InPort_13641999_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Cirkulace vnitřní 9
OutPort_13641864_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
InPort_13641872_2 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
OutPort_13831110_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
InPort_13641880_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
OutPort_13641872_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
InPort_13641933_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13641949_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13642035_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13641933_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13641941_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13831133_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13641949_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13641941_3 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13641967_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13641983_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13642025_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13641967_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13641975_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13831156_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13641983_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13641975_3 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13642178_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13642194_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13642390_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13642178_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13642186_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13642187_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13642194_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13642186_3 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13642211_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
OutPort_13642227_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
InPort_13642406_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Cirkulace vnitřní 9
OutPort_13642211_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13642219_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_13642220_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
InPort_13642227_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
OutPort_13642219_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
InPort_13642246_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_13642273_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_13642374_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Teplá vnitřní 83
OutPort_13642246_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13642256_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13642257_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_13642273_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
OutPort_13642256_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
InPort_13642289_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13642311_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13642358_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13642289_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13642303_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13642304_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13642311_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
OutPort_13642303_3 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13642489_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
OutPort_13642505_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
InPort_13642817_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
OutPort_13642489_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13642497_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13642650_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13642497_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13642498_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
InPort_13642505_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
OutPort_13642497_3 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
InPort_13642521_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
OutPort_13642537_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
InPort_13642829_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
OutPort_13642521_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13642529_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13642671_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13642529_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13642530_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
InPort_13642537_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
OutPort_13642529_3 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
InPort_13642553_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 3
OutPort_13642571_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 3
InPort_13642849_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Cirkulace vnitřní 3
OutPort_13642553_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 3
InPort_13642563_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 3
OutPort_13642564_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 3
InPort_13642571_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 3
OutPort_13642563_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 3
InPort_13642564_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 3
OutPort_13642687_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 3
InPort_13642587_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
OutPort_13642603_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
InPort_13642863_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Teplá vnitřní 8
OutPort_13642587_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13642595_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13642706_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13642595_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13642596_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
InPort_13642603_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
OutPort_13642595_3 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13642648_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13642650_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"ŠEDÁ" studená vnitřní 2
Port_13642668_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13642671_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
InPort_13642687_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 3
OutPort_13642690_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 3
Port_13642704_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13642706_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
InPort_13644956_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13643546_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13644857_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13644780_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13644780_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13644782_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13644782_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13644954_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13644880_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13644857_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13644954_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13644956_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645138_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645148_3 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645161_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645138_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13645148_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13645149_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645153_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645221_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645243_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645153_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645192_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645161_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645190_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645192_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645223_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645190_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645221_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645223_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645307_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645315_3 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645328_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645307_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13645315_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13645316_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645320_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645386_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645406_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645320_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645361_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645328_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645359_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645361_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645388_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645359_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645386_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645388_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645537_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645507_0 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645507_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645539_3 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645509_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645516_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645519_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645509_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645513_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645514_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645517_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645513_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645514_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645537_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13645516_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
OutPort_13645517_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13645534_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13645539_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13645539_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13645540_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13645695_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645709_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645695_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645715_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645706_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645709_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645706_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645709_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645710_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645713_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645715_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645713_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645719_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645717_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645719_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645717_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645725_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645725_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645742_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645730_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645752_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645742_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645756_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645752_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13645756_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13646007_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13646057_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13646320_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646333_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646333_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13646334_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
