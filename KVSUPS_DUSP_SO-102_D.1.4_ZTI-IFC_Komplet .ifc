Properties of the parts of a building model (IFC4), part 29 of 60

# IfcFlowTerminal: Výpusť umyvadlová:Výpusť umyvadlová (123)
Name (Výpusť umyvadlová:Výpusť umyvadlová:...) | In | Podlaží = Vztažné podlaží | Pracovní rovina | Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Název sestavy | Označení
12881112 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0235 | Umyvadlo + modul | 0235
12881943 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0251 | Umyvadlo + modul | 0251
12884692 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0257 | Umyvadlo | 0257
12884802 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0260 | Umyvadlo | 0260
12886228 | -2.PP_SO-102 | -1.PP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0267 | Umyvadlo + modul | 0267
12888143 | -1.PP_SO-102 | 1.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0271 | Umyvadlo + modul | 0271
12888850 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0275 | Umyvadlo + modul | 0275
12888874 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0279 | Umyvadlo + modul | 0279
12889684 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0283 | Umyvadlo + modul | 0283
12890316 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0299 | Umyvadlo + modul | 0299
12890343 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0303 | Umyvadlo + modul | 0303
12890454 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0307 | Umyvadlo + modul | 0307
12890839 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0320 | Umyvadlo + modul | 0320
12890863 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0324 | Umyvadlo + modul | 0324
12891284 | -1.PP_SO-102 | 1.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0328 | Umyvadlo + modul | 0328
12891695 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0332 | Umyvadlo + modul | 0332
12891786 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0336 | Umyvadlo + modul | 0336
12891859 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0340 | Umyvadlo + modul | 0340
12891931 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0344 | Umyvadlo + modul | 0344
12892006 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0348 | Umyvadlo + modul | 0348
12892072 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0352 | Umyvadlo + modul | 0352
12892289 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0356 | Umyvadlo + modul | 0356
12892356 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0360 | Umyvadlo + modul | 0360
12892422 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0364 | Umyvadlo + modul | 0364
12892488 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0368 | Umyvadlo + modul | 0368
12892553 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0372 | Umyvadlo + modul | 0372
12892806 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0379 | Umyvadlo + modul | 0379
12892909 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0383 | Umyvadlo + modul | 0383
12893040 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0387 | Umyvadlo + modul | 0387
12893165 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0391 | Umyvadlo + modul | 0391
12894066 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0410 | Umyvadlo + modul | 0410
12894132 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0414 | Umyvadlo + modul | 0414
12894211 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0418 | Umyvadlo + modul | 0418
12894275 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0422 | Umyvadlo + modul | 0422
12894336 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0426 | Umyvadlo + modul | 0426
12894681 | -2.PP_SO-102 | -1.PP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0433 | Umyvadlo + modul | 0433
12894795 | -1.PP_SO-102 | 1.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0437 | Umyvadlo + modul | 0437
12895105 | -1.PP_SO-102 | 1.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0453 | Umyvadlo + modul | 0453
12895288 | -1.PP_SO-102 | 1.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0460 | Umyvadlo + modul | 0460
12895312 | -1.PP_SO-102 | 1.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0464 | Umyvadlo + modul | 0464
12895443 | -1.PP_SO-102 | 1.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0468 | Umyvadlo + modul | 0468
12895789 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0472 | Umyvadlo + modul | 0472
12896143 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0488 | Umyvadlo + modul | 0488
12896343 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0495 | Umyvadlo + modul | 0495
12896411 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0499 | Umyvadlo + modul | 0499
12896724 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0503 | Umyvadlo + modul | 0503
12896784 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0507 | Umyvadlo + modul | 0507
12896900 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0511 | Umyvadlo + modul | 0511
12896924 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0515 | Umyvadlo + modul | 0515
12897297 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0534 | Umyvadlo + modul | 0534
12897370 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0538 | Umyvadlo + modul | 0538
12897421 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0542 | Umyvadlo + modul | 0542
12897452 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0546 | Umyvadlo + modul | 0546
12897759 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0550 | Umyvadlo + modul | 0550
12897783 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0554 | Umyvadlo + modul | 0554
12898207 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0573 | Umyvadlo + modul | 0573
12898231 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0577 | Umyvadlo + modul | 0577
12898553 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0581 | Umyvadlo + modul | 0581
12898604 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0585 | Umyvadlo + modul | 0585
12899109 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0589 | Umyvadlo + modul | 0589
12899480 | -1.PP_SO-102 | 1.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0599 | Umyvadlo + modul | 0599
12899630 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0609 | Umyvadlo + modul | 0609
12992022 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0625 | Umyvadlo + modul | 0625
12992040 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0629 | Umyvadlo + modul | 0629
13003547 | 2.NP_SO-102 | 2.NP_SO-102 | <nepřiřazeno> | 723 | Fáze 1 | ZT00.21.0639 |  | 0639 | Jiné - Páteřní trasa: no
13068786 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0646 | Umyvadlo + modul | 0646
13068924 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0650 | Umyvadlo + modul | 0650
13071955 | -1.PP_SO-102 | 1.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0654 | Umyvadlo + modul | 0654
13102575 | -1.PP_SO-102 | 1.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0658 | Umyvadlo + modul | 0658
13102690 | -1.PP_SO-102 | 1.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0662 | Umyvadlo + modul | 0662
13105045 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0666 | Umyvadlo + modul | 0666
13154261 | -1.PP_SO-102 | 1.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0687 | Umyvadlo + modul | 0687
13401882 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0738 | Umyvadlo | 0738
13505822 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0747 | Umyvadlo + modul | 0747
13505930 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0751 | Umyvadlo + modul | 0751
13506572 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0755 | Umyvadlo + modul | 0755
13506645 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0759 | Umyvadlo + modul | 0759
13506755 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0763 | Umyvadlo + modul | 0763
13506823 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0767 | Umyvadlo + modul | 0767
13525894 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0772 | Umyvadlo + modul | 0772
13526127 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0776 | Umyvadlo + modul | 0776
13526378 | 1.NP_SO-102 | 2.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0780 | Umyvadlo + modul | 0780
13526795 | -2.PP_SO-102 | -1.PP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0784 | Umyvadlo + modul | 0784
13544055 | 3.NP_SO-102 | 4.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 2 | ZT00.21.0788 | Umyvadlo + modul | 0788
13544824 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0791 | Umyvadlo | 0791
13545431 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0801 | Umyvadlo + modul | 0801
13546128 | 2.NP_SO-102 | 3.NP_SO-102 | Umyvadlo : Umyvadlo | 723 | Fáze 1 | ZT00.21.0804 | Umyvadlo | 0804
13725012 | -1.PP_SO-102 | 1.NP_SO-102 | <nepřiřazeno> | 712.372 | Fáze 1 | ZT00.21.0816 | Výlevka nástěnnî | 0816
13728600 | 1.NP_SO-102 | 2.NP_SO-102 | <nepřiřazeno> | 712.372 | Fáze 1 | ZT00.21.0829 | Výlevka nástěnnñ | 0829
13728676 | 1.NP_SO-102 | 2.NP_SO-102 | <nepřiřazeno> | 712.372 | Fáze 1 | ZT00.21.0833 | Výlevka nástěnnñ | 0833
13733489 | 2.NP_SO-102 | 3.NP_SO-102 | <nepřiřazeno> | 712.372 | Fáze 1 | ZT00.21.0837 | Výlevka nástěnnî | 0837
14005559 | -2.PP_SO-102 |  | <nepřiřazeno> | 0 | Fáze 1 | ZT00.21.0856 | Výlevka nástěnnò | 0856
14005940 | -2.PP_SO-102 |  | <nepřiřazeno> | 0 | Fáze 1 | ZT00.21.0863 | Výlevka nástěnnô | 0863
14007201 | 3.NP_SO-102 |  | <nepřiřazeno> | 0 | Fáze 2 | ZT00.21.0874 | Výlevka nástěnnö | 0874
14007281 | 2.NP_SO-102 |  | <nepřiřazeno> | 0 | Fáze 2 | ZT00.21.0881 | Výlevka nástěnnö | 0881
14007312 | 1.NP_SO-102 |  | <nepřiřazeno> | 0 | Fáze 2 | ZT00.21.0888 | Výlevka nástěnnö | 0888
14007341 | -1.PP_SO-102 |  | <nepřiřazeno> | 0 | Fáze 2 | ZT00.21.0895 | Výlevka nástěnnö | 0895
14030755 | -2.PP_SO-102 |  | Umyvadlo : Umyvadlo | 0 | Fáze 2 | ZT00.21.0903 | Umyvadlo | 0903

# IfcFlowTerminal: Výpusť umyvadlová:Výpusť výlevková (3)
In: 3.NP_SO-102
Type - Classification: ZT00 SNIM (SNIM); Material: CHROM
Type - Vazby - Výchozí výška: 850 mm
Type - Materiály a povrchové úpravy - Materiál: CHROM
Type - Identifikační data - Kód sestavy: ZT00; Komentáře k typům: click clack; Název typu: Výpusť výlevková; Označení typu: 29; Popis: Dřezová výpusť; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Výpusť umyvadlová
Classification: ZT00 SNIM (SNIM); ZT00 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 0 mm; Podlaží: 4.NP_SO-102; Vztažné podlaží: 4.NP_SO-102; Pracovní rovina: Výlevka nástěnná_malá : Výlevka nástěnná_malá; Výška od podlaží: 678.517 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.00000865422 m3
Identifikační data - Název sestavy: Výlevka DN50_modul+nástěnná baterie
Jiné - Rodina: Výpusť umyvadlová; Id typu: 12932547; Rodina a typ: Výpusť umyvadlová: Výpusť výlevková; Typ: Výpusť výlevková
Name (Výpusť umyvadlová:Výpusť výlevková:...) | Kód prvku | Označení
12932545 | ZT00.29.0613 | 0613
12937672 | ZT00.29.0617 | 0617
12937715 | ZT00.29.0621 | 0621

# IfcFlowTerminal: WC závěsné:WC závěsné (50)
Type - Classification: ZT01 SNIM (SNIM); Material: ZDRAVOTNÍ KERAMIKA, PLAST_BÍLÝ
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s
Type - Materiály a povrchové úpravy - Materiál: ZDRAVOTNÍ KERAMIKA; WC prkénko: PLAST_BÍLÝ
Type - Kóty - JMENOVITÝ PRŮMĚR: 110 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: ZT01; Komentáře k typům: Závěsné WC pro předstěnu; Název typu: WC závěsné; Označení typu: 13; Popis: WC; Popis sestavy: Záchodová mísa; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: WC závěsné
Classification: ZT01 SNIM (SNIM); ZT01 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: XKB; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Mechanické - Klasifikace systému: Sanitární
Kóty - Objem: 0.032307 m3; Tloušťka stěny: 20 mm
Identifikační data - Název sestavy: Toaleta + modul
Jiné - Id typu: 12818277; Rodina: WC závěsné; Rodina a typ: WC závěsné: WC závěsné; Typ: WC závěsné
Name (WC závěsné:WC závěsné:...) | In | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
12833554 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZT01.13.0021 | 0021
12833579 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZT01.13.0024 | 0024
12866033 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT01.13.0044 | 0044
12879216 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT01.13.0062 | 0062
12879265 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT01.13.0065 | 0065
12879276 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT01.13.0068 | 0068
12879291 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT01.13.0071 | 0071
12879304 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT01.13.0074 | 0074
12880184 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT01.13.0110 | 0110
12880670 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT01.13.0113 | 0113
12880674 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT01.13.0116 | 0116
12880678 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT01.13.0119 | 0119
12880682 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT01.13.0122 | 0122
12880686 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT01.13.0125 | 0125
12880840 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT01.13.0157 | 0157
12880844 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT01.13.0160 | 0160
12880848 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT01.13.0163 | 0163
12880852 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT01.13.0166 | 0166
12880856 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT01.13.0169 | 0169
12881010 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT01.13.0201 | 0201
12881014 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT01.13.0204 | 0204
12881018 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT01.13.0207 | 0207
12881022 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT01.13.0210 | 0210
12881026 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT01.13.0213 | 0213
12881911 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT01.13.0245 | 0245
12889905 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT01.13.0284 | 0284
12889913 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT01.13.0287 | 0287
12889924 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT01.13.0290 | 0290
12889946 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT01.13.0293 | 0293 | Mechanické - Název systému: SW_Splašky vnitřní gravitační 16; Typ systému: SW_Splašky vnitřní gravitační; Group: SW_Splašky vnitřní gravitační 16
12892698 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | ZT01.13.0373 | 0373
12894598 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | ZT01.13.0427 | 0427
12894888 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZT01.13.0438 | 0438
12894981 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZT01.13.0444 | 0444
12894989 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZT01.13.0447 | 0447
12895976 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZT01.13.0476 | 0476
12896031 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZT01.13.0479 | 0479
12896039 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZT01.13.0482 | 0482
12897073 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZT01.13.0519 | 0519
12897081 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZT01.13.0522 | 0522
12897092 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZT01.13.0525 | 0525
12897988 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZT01.13.0558 | 0558
12897996 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZT01.13.0561 | 0561
12898007 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZT01.13.0564 | 0564
12899417 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZT01.13.0593 | 0593
12899599 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZT01.13.0603 | 0603
12992046 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT01.13.0630 | 0630
12992050 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT01.13.0633 | 0633
13154281 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZT01.13.0691 | 0691
13691412 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT01.13.0811 | 0811
14005366 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZT01.13.0843 | 0843

# IfcFlowTerminal: WC závěsné_invalida:WC závěsné_invalida (10)
Type - Classification: ZT01 SNIM (SNIM); Material: ZDRAVOTNÍ KERAMIKA, PLAST_BÍLÝ
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s
Type - Materiály a povrchové úpravy - Rámeček tlačítka: NEREZOVÁ OCEL; Sanitární keramika: ZDRAVOTNÍ KERAMIKA; Sedátko: PLAST_BÍLÝ; Tlačítko: PLAST_BÍLÝ
Type - Kóty - JMENOVITÝ PRŮMĚR: 110 mm; Výška odpadu: 230 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: WCi; Kód sestavy: ZT01; Komentáře k typům: Zavěšené WC pro předstěnu, invalida; Název typu: WC závěsné_invalida; Označení typu: 46; Popis: WC závěsné; Popis sestavy: Záchodová mísa; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: WC závěsné_invalida
Classification: ZT01 SNIM (SNIM); ZT01 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: XKB; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Mechanické - Klasifikace systému: Sanitární
Kóty - Objem: 0.0450623 m3; Tloušťka obkladu: 20 mm
Jiné - Id typu: 13717413; Rodina: WC závěsné_invalida; Rodina a typ: WC závěsné_invalida: WC závěsné_invalida; Typ: WC závěsné_invalida
Name (WC závěsné_invalida:WC závěsné_invalida:...) | In | Podlaží = Vztažné podlaží | Pracovní rovina | Fáze vytvoření | Kód prvku | Název sestavy | Označení
13725113 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | ZT01.46.0820 | Toaleta + modul (madla, lehká kce)_invalida | 0820
13728409 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT01.46.0824 | Výlevka nástěnnï | 0824
13728476 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | ZT01.46.0827 | Výlevka nástěnnð | 0827
13733494 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | ZT01.46.0841 | Toaleta + modul (madla, lehká kce)_invalida | 0841
14005726 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZT01.46.0861 | Výlevka nástěnnó | 0861
14006046 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | ZT01.46.0868 | Výlevka nástěnnõ | 0868
14007101 | 3.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | ZT01.46.0871 | Toaleta + modul (madla, lehká kce)_invalida | 0871
14007266 | 2.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | ZT01.46.0878 | Toaleta + modul (madla, lehká kce)_invalida | 0878
14007297 | 1.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | ZT01.46.0885 | Toaleta + modul (madla, lehká kce)_invalida | 0885
14007326 | -1.PP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | ZT01.46.0892 | Toaleta + modul (madla, lehká kce)_invalida | 0892

# IfcGroup, Pronajmutelné
Jiné - Kategorie: Schémata ploch; Název: Pronajmutelné

# IfcPipeFitting: M_Koleno, obecné:Standardní (1248)
Type - Classification: TT01 SNIM (SNIM); Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: K; Kód sestavy: TT01; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 02; Popis: Koleno; Popis sestavy: Koleno
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Koleno, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT01 SNIM (SNIM); TT01 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: G; CCI Komponenta: QMA; CCI Technický systém: JB
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3326550; Rodina: M_Koleno, obecné; Rodina a typ: M_Koleno, obecné: Standardní
Name (M_Koleno, obecné:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm) | Group
12918188 | 3.NP_SO-102 | ø110 mm-ø110 mm | 3.NP_SO-102 | 2754.66 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.0004 | 0004 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
12918203 | 3.NP_SO-102 | ø110 mm-ø110 mm | 3.NP_SO-102 | 2721.57 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000484586 | 25.3353 | 43.8542 | ø110-ø110 | 18.2233 | 113.175 | TT01.02.0005 | 0005 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
12918251 | 3.NP_SO-102 | ø110 mm-ø110 mm | 3.NP_SO-102 | 2540.11 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000497246 | 26.0696 | 45 | ø110-ø110 | 18.7514 | 113.175 | TT01.02.0006 | 0006 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
12919424 | 3.NP_SO-102 | ø110 mm-ø110 mm | 3.NP_SO-102 | 2928.11 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 55 | 110 | 0.000981844 | 61.6913 | 88.8542 | ø110-ø110 | 44.3737 | 113.175 | TT01.02.0007 | 0007 | yes | 62.9375 | 56.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
12919749 | -1.PP_SO-102 | ø160 mm-ø160 mm | -1.PP_SO-102 | 2612.06 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 3 | 80 | 160 | 0.00288854 | 87.9375 | 90 | ø160-ø160 | 65.27 | 163.175 | TT01.02.0008 | 0008 | yes | 87.9375 | 81.5875 | SW_Splašky vnitřní gravitační 3; SW_Odvětrání kanalizace 6
12939190 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 3361.14 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0010 | 0010 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
12939194 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 3366.14 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0011 | 0011 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
12939226 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 3349.73 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0012 | 0012 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
12939260 | 1.NP_SO-102 | ø78 mm-ø78 mm | 1.NP_SO-102 | 3308.78 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0013 | 0013 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
12940880 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 3319.65 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0014 | 0014 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
12941147 | 3.NP_SO-102 | ø78 mm-ø78 mm | 3.NP_SO-102 | 2993.74 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0015 | 0015 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
12941174 | 2.NP_SO-102 | ø78 mm-ø78 mm | 2.NP_SO-102 | 3324.65 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0016 | 0016 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
12941178 | 3.NP_SO-102 | ø78 mm-ø78 mm | 3.NP_SO-102 | 2947.74 | Fáze 1 | SW_Splašky vnitřní gravitační | Sanitární | SW_Splašky vnitřní gravitační 35 (1) | 39 | 78 | 0.000376701 | 46.0081 | 88.8542 | ø78-ø78 | 31.8271 | 81.175 | TT01.02.0017 | 0017 | yes | 46.9375 | 40.5875 | SW_Splašky vnitřní gravitační 35 (1) | Mechanické – tok - Tlaková ztráta: 0 Pa
12945482 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0019 | 0019 | yes | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
12946365 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0020 | 0020 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
12948346 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0023 | 0023 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12948616 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0025 | 0025 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12948765 | 4.NP_SO-102 | ø32 mm-ø32 mm | 4.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0027 | 0027 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 83
12948810 | 4.NP_SO-102 | ø32 mm-ø32 mm | 4.NP_SO-102 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0028 | 0028 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 83
12949139 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0030 | 0030 | no | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
12949149 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0031 | 0031 | no | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
12949371 | 4.NP_SO-102 | ø32 mm-ø32 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0032 | 0032 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 134
12949782 | 4.NP_SO-102 | ø32 mm-ø32 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0033 | 0033 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 134
12949983 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0034 | 0034 | yes | 20.6375 | 14.2875 | WS_Studená vnitřní 134
12949991 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0035 | 0035 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
12950262 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0037 | 0037 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12950402 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0038 | 0038 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12950410 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0039 | 0039 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12950936 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0040 | 0040 | yes | 20.6375 | 14.2875 | WS_Studená vnitřní 134
12952125 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0042 | 0042 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
12952127 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0043 | 0043 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
12952634 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0044 | 0044 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
12953761 | 4.NP_SO-102 | ø32 mm-ø32 mm | 4.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0045 | 0045 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 83
12953771 | 4.NP_SO-102 | ø32 mm-ø32 mm | 4.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0046 | 0046 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 83
12954052 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0047 | 0047 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
12954198 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0048 | 0048 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
12954285 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0050 | 0050 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12954355 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0051 | 0051 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12954357 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0052 | 0052 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12954608 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 580 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0054 | 0054 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12955067 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0058 | 0058 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12955115 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0059 | 0059 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12955230 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0060 | 0060 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12955328 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0061 | 0061 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12956200 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0062 | 0062 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
12956222 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0064 | 0064 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12956228 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0066 | 0066 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
12956248 | 3.NP_SO-102 | ø32 mm-ø32 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0068 | 0068 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 83
12956278 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0070 | 0070 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12956282 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0071 | 0071 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12956460 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0072 | 0072 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
12956482 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0074 | 0074 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12956528 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0076 | 0076 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
12965164 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0081 | 0081 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12965216 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0082 | 0082 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12965434 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0083 | 0083 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12965484 | 1.NP_SO-102 | ø20 mm-ø20 mm | 1.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0084 | 0084 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12965903 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0085 | 0085 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12965933 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0086 | 0086 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12965998 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0087 | 0087 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12966232 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000103942 | 8.54834 | 45.0001 | ø25-ø25 | 4.73447 | 28.575 | TT01.02.0090 | 0090 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
12966238 | 3.NP_SO-102 | ø32 mm-ø32 mm | 3.NP_SO-102 | 3320 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000179159 | 9.86347 | 45.0001 | ø32-ø32 | 5.78657 | 34.925 | TT01.02.0092 | 0092 | no | 23.8125 | 17.4625 | WS_Studená vnitřní 134
12966424 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 3320 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0093 | 0093 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12966619 | 4.NP_SO-102 | ø25 mm-ø25 mm | 4.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0094 | 0094 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
12967611 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0103 | 0103 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12968115 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0114 | 0114 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
12968200 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0116 | 0116 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
12969016 | 3.NP_SO-102 | ø32 mm-ø32 mm | 3.NP_SO-102 | 3200 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0130 | 0130 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 83
12971218 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0132 | 0132 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
12971226 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0134 | 0134 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12971232 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0136 | 0136 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
12971246 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0138 | 0138 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 83
12971258 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0139 | 0139 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12971262 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0140 | 0140 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12971268 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0141 | 0141 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12971272 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0142 | 0142 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12971280 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0143 | 0143 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12971284 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0144 | 0144 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12971288 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0145 | 0145 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12971296 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0146 | 0146 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12971312 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000103942 | 8.54834 | 45.0001 | ø25-ø25 | 4.73447 | 28.575 | TT01.02.0149 | 0149 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
12971316 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 3320 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000179159 | 9.86347 | 45.0001 | ø32-ø32 | 5.78657 | 34.925 | TT01.02.0151 | 0151 | no | 23.8125 | 17.4625 | WS_Studená vnitřní 134
12971320 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 3320 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0152 | 0152 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12971354 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0160 | 0160 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12984058 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0172 | 0172 | yes | 20.6375 | 14.2875 | WS_Studená vnitřní 134
12984182 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0173 | 0173 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
12984257 | 1.NP_SO-102 | ø25 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0174 | 0174 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
12992587 | 2.NP_SO-102 | ø40 mm-ø40 mm | 2.NP_SO-102 | 2003.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0176 | 0176 | no | 26.9875 | 20.6375 | WS_Studená vnitřní 134
12993168 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0177 | 0177 | no | 20.6375 | 14.2875 | WS_Cirkulace vnitřní 9
12993202 | 2.NP_SO-102 | ø40 mm-ø40 mm | 2.NP_SO-102 | 2000 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.02.0178 | 0178 | no | 26.9875 | 20.6375 | WS_Teplá vnitřní 83
12994270 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0179 | 0179 | no | 17.4625 | 11.1125 | WS_Cirkulace vnitřní 9
12994675 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0180 | 0180 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
12994946 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0181 | 0181 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
12994981 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0182 | 0182 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
12995087 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0184 | 0184 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12995227 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 2404.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0185 | 0185 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12995405 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0187 | 0187 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12995429 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0188 | 0188 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12995775 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0193 | 0193 | no | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
12996037 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0198 | 0198 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
12996061 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 2000 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0199 | 0199 | no | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
12996561 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 1250 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0200 | 0200 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
12996569 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0201 | 0201 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
12996644 | 2.NP_SO-102 | ø50 mm-ø50 mm | 2.NP_SO-102 | 1227.29 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0203 | 0203 | no | 33.3375 | 26.9875 | WS_Studená vnitřní 134
12996675 | 2.NP_SO-102 | ø50 mm-ø50 mm | 2.NP_SO-102 | 1224.15 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.02.0205 | 0205 | no | 33.3375 | 26.9875 | WS_Teplá vnitřní 83
12996762 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0207 | 0207 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12996764 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0208 | 0208 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12996795 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0210 | 0210 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12996797 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0211 | 0211 | no | 20.6375 | 14.2875 | WS_Studená vnitřní 134
12997245 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0212 | 0212 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
12997645 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0215 | 0215 | no | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
12997979 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0218 | 0218 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
12998001 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0219 | 0219 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
12998075 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 1235.78 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0221 | 0221 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
12998315 | 2.NP_SO-102 | ø25 mm-ø25 mm | 2.NP_SO-102 | 2000 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0222 | 0222 | no | 20.6375 | 14.2875 | WS_"Jiný typ" studená vnitřní 1
12998815 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0223 | 0223 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12998848 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0225 | 0225 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
12999193 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 783.001 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0229 | 0229 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
12999454 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 580 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0230 | 0230 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83 | Mechanické – tok - Tlaková ztráta: 0 Pa
13000006 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 580 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0245 | 0245 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
13000078 | 2.NP_SO-102 | ø20 mm-ø20 mm | 2.NP_SO-102 | 580 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0247 | 0247 | no | 17.4625 | 11.1125 | WS_Teplá vnitřní 83
13001028 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 2000 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0266 | 0266 | no | 23.8125 | 17.4625 | WS_Cirkulace vnitřní 9
13001622 | 4.NP_SO-102 | ø20 mm-ø20 mm | 4.NP_SO-102 | 1170 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0273 | 0273 | no | 17.4625 | 11.1125 | WS_"Jiný typ" studená vnitřní 1
13003339 | 3.NP_SO-102 | ø32 mm-ø32 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0274 | 0274 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13003375 | 3.NP_SO-102 | ø20 mm-ø20 mm | 3.NP_SO-102 | 580 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.02.0275 | 0275 | no | 17.4625 | 11.1125 | WS_Studená vnitřní 134
13003427 | 3.NP_SO-102 | ø25 mm-ø25 mm | 3.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.02.0277 | 0277 | yes | 20.6375 | 14.2875 | WS_Teplá vnitřní 83
13003465 | 3.NP_SO-102 | ø32 mm-ø32 mm | 3.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0279 | 0279 | yes | 23.8125 | 17.4625 | WS_Teplá vnitřní 83
13003559 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0280 | 0280 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 134
13003569 | 2.NP_SO-102 | ø32 mm-ø32 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.02.0281 | 0281 | yes | 23.8125 | 17.4625 | WS_Studená vnitřní 134
