Properties of the parts of a building model (IFC4), part 36 of 60

# IfcPipeFitting: M_Přechod, obecný:Standardní (211)
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Délka (mm) | Jmenovitý poloměr 1 (mm) = Odskok – šířka | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Odskok – výška | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Viditelnost 1 | Výškové odsazení (mm) | Max. vnější průměr tvarovky 12 (mm) | Viditelnost 2 | Viditelnost 3 | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm)
12968566 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0119 | 0119 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
12968607 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0120 | 0120 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
12968688 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0123 | 0123 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
12968843 | 4.NP_SO-102 | ø32 mm-ø20 mm | 4.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0128 | 0128 | no | no | 3048 | 34.925 | yes | no | 11.1125 | 17.4625
12968852 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0129 | 0129 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
12971314 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 3343.96 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 12.5 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.05.0150 | 0150 | no | no | 3048 | 34.925 | no | yes | 17.4625 | 14.2875
12971342 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 3320 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0158 | 0158 | no | no | 3048 | 34.925 | yes | no | 11.1125 | 17.4625
12971360 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 3293.01 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0162 | 0162 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
12971368 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 1250 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0163 | 0163 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
12971370 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 3323.01 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0164 | 0164 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
12971372 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 1557.16 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0165 | 0165 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
12971376 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 1250 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0167 | 0167 | no | no | 3048 | 34.925 | yes | no | 11.1125 | 17.4625
12971378 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0168 | 0168 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
12971382 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 12.5 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.05.0169 | 0169 | yes | no | 3048 | 34.925 | no | yes | 17.4625 | 14.2875
12971390 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0170 | 0170 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
12971392 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0171 | 0171 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
12999731 | 2.NP_SO-102 | ø50 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.05.0232 | 0232 | no | no | 3048 | 53.975 | yes | no | 17.4625 | 26.9875
12999741 | 2.NP_SO-102 | ø50 mm-ø32 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.05.0233 | 0233 | no | no | 3048 | 53.975 | yes | no | 17.4625 | 26.9875
12999768 | 2.NP_SO-102 | ø50 mm-ø32 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.05.0235 | 0235 | no | no | 3048 | 53.975 | yes | no | 17.4625 | 26.9875
12999777 | 2.NP_SO-102 | ø50 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 13.4938 | 25 | 16 | 50 | 32 | 50 | 32 | 0.0000212161 | 25 | 0.00315461 | ø50-ø32 | 21.59 | 13.97 | 53.975 | 34.925 | TT00.05.0237 | 0237 | no | no | 3048 | 53.975 | yes | no | 17.4625 | 26.9875
12999786 | 2.NP_SO-102 | ø50 mm-ø20 mm | 2.NP_SO-102 | 1227.29 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT00.05.0238 | 0238 | no | no | 3048 | 53.975 | yes | no | 11.1125 | 26.9875
12999796 | 2.NP_SO-102 | ø50 mm-ø20 mm | 2.NP_SO-102 | 1224.15 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT00.05.0239 | 0239 | no | no | 3048 | 53.975 | yes | no | 11.1125 | 26.9875
12999807 | 2.NP_SO-102 | ø50 mm-ø20 mm | 2.NP_SO-102 | 2364.05 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT00.05.0240 | 0240 | no | no | 3048 | 53.975 | yes | no | 11.1125 | 26.9875
12999809 | 2.NP_SO-102 | ø50 mm-ø20 mm | 2.NP_SO-102 | 1260.62 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT00.05.0241 | 0241 | no | no | 3048 | 53.975 | yes | no | 11.1125 | 26.9875
12999816 | 2.NP_SO-102 | ø50 mm-ø20 mm | 2.NP_SO-102 | 2360.31 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT00.05.0242 | 0242 | no | no | 3048 | 53.975 | yes | no | 11.1125 | 26.9875
12999818 | 2.NP_SO-102 | ø50 mm-ø20 mm | 2.NP_SO-102 | 1257.49 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT00.05.0243 | 0243 | no | no | 3048 | 53.975 | yes | no | 11.1125 | 26.9875
13000215 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0248 | 0248 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13000226 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0249 | 0249 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13000250 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0250 | 0250 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13000258 | 2.NP_SO-102 | ø50 mm-ø20 mm | 2.NP_SO-102 | 2360.31 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT00.05.0251 | 0251 | no | no | 3048 | 53.975 | yes | no | 11.1125 | 26.9875
13000265 | 2.NP_SO-102 | ø50 mm-ø20 mm | 2.NP_SO-102 | 2364.05 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT00.05.0252 | 0252 | no | no | 3048 | 53.975 | yes | no | 11.1125 | 26.9875
13000267 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 1420.64 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0253 | 0253 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13000328 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0254 | 0254 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13000458 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 1273.81 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0255 | 0255 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13000475 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 1273.81 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0256 | 0256 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13000594 | 2.NP_SO-102 | ø40 mm-ø32 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT00.05.0261 | 0261 | no | no | 3048 | 41.275 | no | yes | 20.6375 | 17.4625
13000603 | 2.NP_SO-102 | ø40 mm-ø32 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT00.05.0262 | 0262 | no | no | 3048 | 41.275 | no | yes | 20.6375 | 17.4625
13000982 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0264 | 0264 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13000984 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0265 | 0265 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13001320 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0269 | 0269 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13001620 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 1399.67 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0272 | 0272 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13005409 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0317 | 0317 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13005411 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0318 | 0318 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13005417 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0319 | 0319 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13005419 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0320 | 0320 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13005655 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 1399.67 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 3 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0322 | 0322 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13005659 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 3 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0324 | 0324 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13005690 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 1399.67 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0326 | 0326 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13005723 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 1399.67 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0329 | 0329 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13008171 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0338 | 0338 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13008282 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0341 | 0341 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13008569 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0348 | 0348 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13008571 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0349 | 0349 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13010161 | 1.NP_SO-102 | ø32 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 12.5 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.05.0359 | 0359 | yes | no | 3048 | 34.925 | no | yes | 17.4625 | 14.2875
13010220 | 1.NP_SO-102 | ø32 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 12.5 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.05.0362 | 0362 | yes | no | 3048 | 34.925 | no | yes | 17.4625 | 14.2875
13011810 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0375 | 0375 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13011813 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0376 | 0376 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13012753 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 3293.01 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0382 | 0382 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13013020 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 3320 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 12.5 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.05.0383 | 0383 | yes | no | 3048 | 34.925 | no | yes | 17.4625 | 14.2875
13014616 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 1176.19 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0400 | 0400 | yes | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13014628 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0401 | 0401 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13014814 | 4.NP_SO-102 | ø32 mm-ø25 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 12.5 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.05.0403 | 0403 | yes | no | 3048 | 34.925 | no | yes | 17.4625 | 14.2875
13027836 | 4.NP_SO-102 | ø50 mm-ø20 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT00.05.0477 | 0477 | no | no | 3048 | 53.975 | yes | no | 11.1125 | 26.9875
13027843 | 4.NP_SO-102 | ø50 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT00.05.0478 | 0478 | no | no | 3048 | 53.975 | yes | no | 11.1125 | 26.9875
13028716 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0491 | 0491 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13028718 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0492 | 0492 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13028729 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0493 | 0493 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13028731 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0494 | 0494 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13030612 | 3.NP_SO-102 | ø50 mm-ø20 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT00.05.0526 | 0526 | no | no | 3048 | 53.975 | yes | no | 11.1125 | 26.9875
13030614 | 3.NP_SO-102 | ø50 mm-ø20 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT00.05.0527 | 0527 | no | no | 3048 | 53.975 | yes | no | 11.1125 | 26.9875
13030678 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0535 | 0535 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13030680 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0536 | 0536 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13030682 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0537 | 0537 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13030684 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0538 | 0538 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13031085 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0581 | 0581 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13031087 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0582 | 0582 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13031089 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0583 | 0583 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13031091 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0584 | 0584 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13031494 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0611 | 0611 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13031496 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0612 | 0612 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13031498 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0613 | 0613 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13031500 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0614 | 0614 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13032708 | 3.NP_SO-102 | ø50 mm-ø25 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 25 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.05.0630 | 0630 | yes | no | 3048 | 53.975 | yes | no | 14.2875 | 26.9875
13032723 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0632 | 0632 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13032856 | 3.NP_SO-102 | ø50 mm-ø25 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 25 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.05.0633 | 0633 | yes | no | 3048 | 53.975 | yes | no | 14.2875 | 26.9875
13032858 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0634 | 0634 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13033074 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0639 | 0639 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13033088 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0641 | 0641 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13033090 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0642 | 0642 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13033228 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0643 | 0643 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13033239 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0644 | 0644 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13033833 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0649 | 0649 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13034122 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3284.92 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0653 | 0653 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13034152 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0654 | 0654 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13034192 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0656 | 0656 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13034261 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0657 | 0657 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13034297 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0659 | 0659 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13034738 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0667 | 0667 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13035574 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0675 | 0675 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13035580 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0676 | 0676 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13035647 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0679 | 0679 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13035694 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0682 | 0682 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13036983 | -1.PP_SO-102 | ø50 mm-ø25 mm | -1.PP_SO-102 | 2649.8 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 25 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.05.0689 | 0689 | yes | no | 3048 | 53.975 | yes | no | 14.2875 | 26.9875
13036994 | -1.PP_SO-102 | ø50 mm-ø25 mm | -1.PP_SO-102 | 2649.95 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 25 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.05.0690 | 0690 | yes | no | 3048 | 53.975 | yes | no | 14.2875 | 26.9875
13037155 | 3.NP_SO-102 | ø40 mm-ø32 mm | 3.NP_SO-102 | 3254.76 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT00.05.0691 | 0691 | yes | no | 3048 | 41.275 | no | yes | 20.6375 | 17.4625
13037164 | 3.NP_SO-102 | ø40 mm-ø32 mm | 3.NP_SO-102 | 3314.76 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT00.05.0692 | 0692 | yes | no | 3048 | 41.275 | no | yes | 20.6375 | 17.4625
13037757 | 1.NP_SO-102 | ø32 mm-ø20 mm | 1.NP_SO-102 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.0703 | 0703 | no | no | 3048 | 34.925 | yes | no | 11.1125 | 17.4625
13048245 | -1.PP_SO-102 | ø63 mm-ø25 mm | -1.PP_SO-102 | 3179.45 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 16.5437 | 31.5 | 12.5 | 63 | 25 | 63 | 25 | 0.0000306546 | 31.5 | 0.00420842 | ø63-ø25 | 26.47 | 11.43 | 66.175 | 28.575 | TT00.05.0713 | 0713 | yes | no | 3048 | 66.175 | yes | no | 14.2875 | 33.0875
13068014 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0718 | 0718 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125 | Mechanické – tok - Tlaková ztráta: 0 Pa
13068029 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 1273.81 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0719 | 0719 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13068031 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0720 | 0720 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13068124 | -1.PP_SO-102 | ø40 mm-ø32 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT00.05.0725 | 0725 | yes | no | 3048 | 41.275 | no | yes | 20.6375 | 17.4625
13068131 | -1.PP_SO-102 | ø40 mm-ø32 mm | -1.PP_SO-102 | 2650 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT00.05.0726 | 0726 | yes | no | 3048 | 41.275 | no | yes | 20.6375 | 17.4625
13068145 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 3271.91 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 12.5 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.05.0728 | 0728 | yes | no | 3048 | 34.925 | no | yes | 17.4625 | 14.2875
13068169 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0730 | 0730 | yes | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13068171 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0731 | 0731 | yes | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13068176 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0732 | 0732 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13068181 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 1273.81 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0733 | 0733 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13068183 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0734 | 0734 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13068192 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0735 | 0735 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13068261 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0736 | 0736 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125 | Mechanické – tok - Tlaková ztráta: 0 Pa
13068297 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0737 | 0737 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13068339 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0738 | 0738 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13068347 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 1273.81 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0739 | 0739 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13068349 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0740 | 0740 | yes | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13068363 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 12.5 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.05.0741 | 0741 | yes | no | 3048 | 34.925 | no | yes | 17.4625 | 14.2875
13068424 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0743 | 0743 | yes | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13068459 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0744 | 0744 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13068535 | -1.PP_SO-102 | ø40 mm-ø32 mm | -1.PP_SO-102 | 2600 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT00.05.0746 | 0746 | yes | no | 3048 | 41.275 | no | yes | 20.6375 | 17.4625
13068629 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 1223.81 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0748 | 0748 | yes | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13070191 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0750 | 0750 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13071131 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0751 | 0751 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13071375 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0752 | 0752 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13074306 | -1.PP_SO-102 | ø40 mm-ø32 mm | -1.PP_SO-102 | 3400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT00.05.0760 | 0760 | yes | no | 3048 | 41.275 | no | yes | 20.6375 | 17.4625
13078602 | -1.PP_SO-102 | ø40 mm-ø32 mm | -1.PP_SO-102 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | WS_Cirkulace vnitřní 9 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT00.05.0772 | 0772 | yes | no | 3048 | 41.275 | no | yes | 20.6375 | 17.4625
13083370 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0783 | 0783 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13083372 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 2373.01 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0784 | 0784 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13083374 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0785 | 0785 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13083376 | 2.NP_SO-102 | ø25 mm-ø20 mm | 2.NP_SO-102 | 2374.42 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0786 | 0786 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13144309 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.0814 | 0814 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13154384 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0857 | 0857 | yes | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13154408 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 1273.81 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"ŠEDÁ" studená vnitřní 2 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT00.05.0858 | 0858 | no | no | 3048 | 28.575 | no | yes | 14.2875 | 11.1125
13335594 | 4.NP_SO-102 | ø25 mm-ø20 mm | 4.NP_SO-102 | 1226.99 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | WS_"Jiný typ" studená vnitřní 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.1068 | 1068 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13336461 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.1070 | 1070 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13336484 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.1071 | 1071 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13357435 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 15.6736 | 0.00129552 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1098 | 1098 | no | no | 3047.67 | 34.925 | yes | no | 11.1125 | 17.4625
13361431 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.1131 | 1131 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13361485 | 3.NP_SO-102 | ø25 mm-ø20 mm | 3.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.1134 | 1134 | no | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13473806 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1238 | 1238 | no | no | 3048 | 34.925 | yes | no | 11.1125 | 17.4625
13473821 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 1400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1242 | 1242 | no | no | 3048 | 34.925 | yes | no | 11.1125 | 17.4625
13473907 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 1978.51 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1252 | 1252 | no | no | 3048 | 34.925 | yes | no | 11.1125 | 17.4625
13474083 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 12.8435 | 0.00128381 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1272 | 1272 | no | no | 3044.84 | 34.925 | yes | no | 11.1125 | 17.4625
13474443 | 2.NP_SO-102 | ø32 mm-ø20 mm | 2.NP_SO-102 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 12.8435 | 0.00128381 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT00.05.1276 | 1276 | no | no | 3044.84 | 34.925 | yes | no | 11.1125 | 17.4625
13523781 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 12.5 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.05.1337 | 1337 | yes | no | 3048 | 34.925 | no | yes | 17.4625 | 14.2875
13525276 | 4.NP_SO-102 | ø32 mm-ø32 mm | 4.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 16 | 16 | 32 | 32 | 32 | 32 | 0.00000833521 | 6.1625 | 0.00188869 | ø32-ø32 | 13.97 | 13.97 | 34.925 | 34.925 | TT00.05.1361 | 1361 | yes | yes | 3038.16 | 34.925 | no | no | 17.4625 | 17.4625
13525731 | 4.NP_SO-102 | ø50 mm-ø25 mm | 4.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 25 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.05.1367 | 1367 | yes | no | 3048 | 53.975 | yes | no | 14.2875 | 26.9875
13525799 | 4.NP_SO-102 | ø50 mm-ø25 mm | 4.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 25 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.05.1371 | 1371 | yes | no | 3048 | 53.975 | yes | no | 14.2875 | 26.9875
13525977 | 3.NP_SO-102 | ø50 mm-ø25 mm | 3.NP_SO-102 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 8 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 25 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.05.1373 | 1373 | yes | no | 3048 | 53.975 | yes | no | 14.2875 | 26.9875
13526031 | 3.NP_SO-102 | ø50 mm-ø25 mm | 3.NP_SO-102 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 6 | 13.4938 | 25 | 12.5 | 50 | 25 | 50 | 25 | 0.0000185809 | 25 | 0.00290744 | ø50-ø25 | 21.59 | 11.43 | 53.975 | 28.575 | TT00.05.1376 | 1376 | yes | no | 3048 | 53.975 | yes | no | 14.2875 | 26.9875
13533258 | 1.NP_SO-102 | ø40 mm-ø32 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT00.05.1403 | 1403 | yes | no | 3048 | 41.275 | no | yes | 20.6375 | 17.4625
13533279 | 1.NP_SO-102 | ø32 mm-ø25 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 12.5 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.05.1405 | 1405 | yes | no | 3048 | 34.925 | no | yes | 17.4625 | 14.2875
13533281 | 1.NP_SO-102 | ø40 mm-ø32 mm | 1.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT00.05.1406 | 1406 | yes | no | 3048 | 41.275 | no | yes | 20.6375 | 17.4625
13533392 | 1.NP_SO-102 | ø50 mm-ø40 mm | 1.NP_SO-102 | 3277.77 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 13.4938 | 20 | 25 | 40 | 50 | 50 | 40 | 0.0000241169 | 20 | 0.00346833 | ø50-ø40 | 16.51 | 21.59 | 41.275 | 53.975 | TT00.05.1409 | 1409 | yes | no | 3048 | 53.975 | no | yes | 26.9875 | 20.6375
13533524 | 1.NP_SO-102 | ø50 mm-ø40 mm | 1.NP_SO-102 | 3127.77 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 13.4938 | 20 | 25 | 40 | 50 | 50 | 40 | 0.0000241169 | 20 | 0.00346833 | ø50-ø40 | 16.51 | 21.59 | 41.275 | 53.975 | TT00.05.1414 | 1414 | yes | no | 3048 | 53.975 | no | yes | 26.9875 | 20.6375
13533568 | 3.NP_SO-102 | ø40 mm-ø32 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT00.05.1417 | 1417 | yes | no | 3048 | 41.275 | no | yes | 20.6375 | 17.4625
13533621 | 2.NP_SO-102 | ø32 mm-ø25 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 12.5 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.05.1419 | 1419 | yes | no | 3048 | 34.925 | no | yes | 17.4625 | 14.2875
13533623 | 2.NP_SO-102 | ø40 mm-ø32 mm | 2.NP_SO-102 | 3340 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT00.05.1420 | 1420 | yes | no | 3048 | 41.275 | no | yes | 20.6375 | 17.4625
13533764 | 1.NP_SO-102 | ø25 mm-ø20 mm | 1.NP_SO-102 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT00.05.1421 | 1421 | yes | no | 3048 | 28.575 | yes | no | 11.1125 | 14.2875
13535104 | 3.NP_SO-102 | ø32 mm-ø25 mm | 3.NP_SO-102 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 134 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 12.5 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.05.1426 | 1426 | no | no | 3048 | 34.925 | no | yes | 17.4625 | 14.2875
13535120 | 3.NP_SO-102 | ø32 mm-ø25 mm | 3.NP_SO-102 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 83 | 8.73125 | 12.5 | 16 | 25 | 32 | 32 | 25 | 0.00000691625 | 12.5 | 0.00146184 | ø32-ø25 | 11.43 | 13.97 | 28.575 | 34.925 | TT00.05.1427 | 1427 | no | no | 3048 | 34.925 | no | yes | 17.4625 | 14.2875
