Properties of the parts of a building model (IFC4), part 54 of 60

# IfcPipeSegment: Typy trubek:PP-RCT (1338)
Name (Typy trubek:PP-RCT:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Instalační jednotky = Reynoldsovo číslo = Třecí faktor = Tření = Průtok (m3/s) = Rychlost (m/s) = Tlaková ztráta (Pa) | Stav průtoku | Doplňkový průtok (m3/s) | Relativní drsnost | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) | Spodní výška (mm) | Střední výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Délka (mm) | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
14037132 | 3.NP_SO-102 | 1009.04 | 0.000314112 | 0.0633999 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11342.3 | PP–RCT S4 | 20 | 389 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1009.04 | ø20 | 15.4 | TR10.03.2227 | 2227 | no | WS_Studená vnitřní 134 | 0
14037147 | 3.NP_SO-102 | 342.538 | 0.000314112 | 0.0215223 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JD | 3.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11342.3 | PP–RCT S4 | 20 | 366 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 342.538 | ø20 | 15.4 | TR10.03.2228 | 2228 |  | WS_Teplá vnitřní 83 | 0
14037156 | 3.NP_SO-102 | 1321.58 | 0.000314112 | 0.0830372 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11342.3 | PP–RCT S4 | 20 | 366 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1321.58 | ø20 | 15.4 | TR10.03.2229 | 2229 | no | WS_Teplá vnitřní 83 | 0

# IfcPipeSegment: Typy trubek:PP_Skolan SAFE dB (426)
Type - Material: 255-0-255
Type - Požární ochrana - Požární odolnost: –
Type - Identifikační data - Cena: 0; ID kategorie: TR; Kód sestavy: TR08; Název typu: PP_Skolan SAFE dB; Označení typu: 01; Popis: PP; Popis sestavy: Polypropylen (PP); Výrobce: Ostendorf - OSMA
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR08 SNIM (SNIM); TR08 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Komponenta: WPA; CCI Technický systém: JD
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Mechanické - Typ přípoje: Obecné
Jiné - Id typu: 9442253; Rodina: Typy trubek; Rodina a typ: Typy trubek: PP_Skolan SAFE dB; Typ: PP_Skolan SAFE dB
Name (Typy trubek:PP_Skolan SAFE dB:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Relativní drsnost | CCI Funkční systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) | Spodní výška (mm) | Střední výška (mm) | Fáze vytvoření | Drsnost (mm) | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Typ systému | Úsek potrubí | Výkaz/typ | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Instalační jednotky | Sklon
12903605 | 4.NP_SO-102 | 460.978 | 0.0201032 | 0.231713 | ø160 mm | 0.0000669344 | G | 4.NP_SO-102 | 2501.77 | 2501.77 | 2040.79 | 2040.79 | 2040.79 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 1 | 14040.8 | PP–SKEM | 160 | 3 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.0001 | 0001 | yes | SW_Odvětrání kanalizace 1 | Identifikační data - Komentáře: S4
12904856 | 3.NP_SO-102 | 12060.9 | 0.00950189 | 4.16793 | ø110 mm | 0.000100604 | G | 3.NP_SO-102 | 2866.42 | -9194.44 | 2866.42 | -9194.44 | 2866.42 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1194.44 | PP–SKEM | 110 | 574 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0003 | 0003 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S8
12904871 | 1.NP_SO-102 | 4375.61 | 0.00950189 | 1.5121 | ø110 mm | 0.000100604 | G | 1.NP_SO-102 | 3234.47 | -1141.14 | 3234.47 | -1141.14 | 3234.47 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1141.14 | PP–SKEM | 110 | 587 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0004 | 0004 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S9
12904886 | 2.NP_SO-102 | 8066.2 | 0.00477764 | 1.97657 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3273.65 | -4792.55 | 3273.65 | -4792.55 | 3273.65 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -792.55 | PP–SKEM | 78 | 505 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0005 | 0005 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S11
12912135 | 1.NP_SO-102 | 3260.81 | 0.00950189 | 1.12686 | ø110 mm | 0.000100604 | G | 1.NP_SO-102 | 2069.76 | -1191.05 | 2069.76 | -1191.05 | 2069.76 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1191.05 | PP–SKEM | 110 | 6 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0007 | 0007 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S6
12912181 | 3.NP_SO-102 | 1968.8 | 0.00477764 | 0.482444 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 1380.96 | -587.848 | 1380.96 | -587.848 | 1380.96 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7412.15 | PP–SKEM | 78 | 502 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0008 | 0008 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S9
12912653 | 3.NP_SO-102 | 3826.9 | 0.00477764 | 0.93776 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 3244.97 | 3244.97 | -581.929 | -581.929 | -581.929 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7418.07 | PP–SKEM | 78 | 305 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0009 | 0009 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S13
12912668 | 3.NP_SO-102 | 2033.85 | 0.00477764 | 0.498384 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 1172.09 | 1172.06 | -861.792 | -861.818 | -861.792 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7138.19 | PP–SKEM | 78 | 553 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0010 | 0010 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 151351
12912681 | 3.NP_SO-102 | 4150.56 | 0.00477764 | 1.01707 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 3199.62 | 3199.62 | -950.942 | -950.942 | -950.942 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7049.06 | PP–SKEM | 78 | 15 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0011 | 0011 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S15
12912964 | 2.NP_SO-102 | 1457.46 | 0.0143117 | 0.618131 | ø135 mm | 0.0000669344 | G | 2.NP_SO-102 | 3034.56 | 3034.56 | 1577.1 | 1577.1 | 1577.1 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 5577.1 | PP–SKEM | 135 | 77 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.0012 | 0012 | yes | SW_Odvětrání kanalizace 16
12913030 | 2.NP_SO-102 | 515.219 | 0.0143117 | 0.218512 | ø135 mm | 0.0000669344 | G | 2.NP_SO-102 | 2049.76 | 2049.76 | 1534.54 | 1534.54 | 1534.54 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 5534.54 | PP–SKEM | 135 | 137 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.0013 | 0013 | yes | SW_Odvětrání kanalizace 16
12913041 | 1.NP_SO-102 | 946.437 | 0.0143117 | 0.401398 | ø135 mm | 0.0000803859 | G | 1.NP_SO-102 | 4365 | 4365 | 3418.56 | 3418.56 | 3418.56 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3418.56 | PP–SKEM | 135 | 600 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.0014 | 0014 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1583517
12913117 | 2.NP_SO-102 | 1483.67 | 0.0143117 | 0.629246 | ø135 mm | 0.0000669344 | G | 2.NP_SO-102 | 3018.22 | 3018.21 | 1534.54 | 1534.54 | 1534.54 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 5534.54 | PP–SKEM | 135 | 117 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.0015 | 0015 | yes | SW_Odvětrání kanalizace 16 |  | 1908572
12913132 | 2.NP_SO-102 | 869.58 | 0.0143117 | 0.368802 | ø135 mm | 0.0000669344 | G | 2.NP_SO-102 | 2404.12 | 2404.12 | 1534.54 | 1534.54 | 1534.54 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 5534.54 | PP–SKEM | 135 | 122 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.0016 | 0016 | yes | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 16
12913493 | -1.PP_SO-102 | 332.245 | 0.00950189 | 0.114816 | ø110 mm | 0.0000669344 | G | -1.PP_SO-102 | 2297.06 | 2297.06 | 1964.82 | 1964.82 | 1964.82 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | -2035.18 | PP–SKEM | 110 | 139 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0017 | 0017 | yes | SW_Odvětrání kanalizace 16
12913504 | -1.PP_SO-102 | 2216.79 | 0.0201032 | 1.11428 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | 0 | 0 | -2216.79 | -2216.79 | -2216.79 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6216.79 | PP–SKEM | 160 | 30 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.0018 | 0018 | yes | SW_Splašky vnitřní gravitační 3 | 0
12913515 | -1.PP_SO-102 | 2133.58 | 0.0201032 | 1.07245 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | 56.7881 | 56.7881 | -2076.79 | -2076.79 | -2076.79 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6076.79 | PP–SKEM | 160 | 27 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.0019 | 0019 | yes | SW_Splašky vnitřní gravitační 3 | 0
12913552 | -1.PP_SO-102 | 1248.2 | 0.00950189 | 0.431346 | ø110 mm | 0.0000669344 | G | -1.PP_SO-102 | 2937.06 | 2937.06 | 1688.87 | 1688.87 | 1688.87 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | -2311.13 | PP–SKEM | 110 | 142 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0020 | 0020 | yes | SW_Odvětrání kanalizace 16; SW_Splašky vnitřní gravitační 4
12913565 | -1.PP_SO-102 | 609.477 | 0.00950189 | 0.21062 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -1280.65 | -1280.65 | -1890.13 | -1890.13 | -1890.13 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 4 | -5890.13 | PP–SKEM | 110 | 1 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0021 | 0021 | yes | SW_Splašky vnitřní gravitační 4 | 0
12913578 | -1.PP_SO-102 | 620.111 | 0.00950189 | 0.214295 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -1271.58 | -1271.58 | -1891.69 | -1891.69 | -1891.69 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 4 | -5891.69 | PP–SKEM | 110 | 5 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0022 | 0022 | yes | SW_Splašky vnitřní gravitační 4 | 0
12913610 | -1.PP_SO-102 | 3734.53 | 0.0201032 | 1.87718 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | 2524.13 | 2524.13 | -1210.41 | -1210.41 | -1210.41 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -5210.41 | PP–SKEM | 160 | 9 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.0023 | 0023 | yes | SW_Splašky vnitřní gravitační 3 | 0
12913862 | 4.NP_SO-102 | 1545.31 | 0.0201032 | 0.776759 | ø160 mm | 0.0000669344 | G | STŘECHA_SO-102 | 1650 | 1650 | 104.686 | 104.686 | 104.686 | Fáze 2 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 15 | 15954.7 | PP–SKEM | 160 | 288 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.0025 | 0025 | yes | SW_Odvětrání kanalizace 15 | Identifikační data - Komentáře: S20
12913903 | 1.NP_SO-102 | 4266.53 | 0.00477764 | 1.04549 | ø78 mm | 0.000144928 | G | 1.NP_SO-102 | 3200.45 | -1066.08 | 3200.45 | -1066.08 | 3200.45 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1066.08 | PP–SKEM | 78 | 456 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0026 | 0026 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S19
12913931 | 4.NP_SO-102 | 1839.71 | 0.00477764 | 0.450809 | ø78 mm | 0.000144928 | G | 4.NP_SO-102 | 3351.46 | 1511.75 | 3351.46 | 1511.75 | 3351.46 | Fáze 2 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 10 | 13511.8 | PP–SKEM | 78 | 2 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0027 | 0027 | yes | SW_Odvětrání kanalizace 10 | Identifikační data - Komentáře: S18
12913944 | 1.NP_SO-102 | 4052.68 | 0.00477764 | 0.993086 | ø78 mm | 0.000144928 | G | 1.NP_SO-102 | 3321.28 | -731.402 | 3321.28 | -731.402 | 3321.28 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -731.402 | PP–SKEM | 78 | 593 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0028 | 0028 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S17
12913983 | 3.NP_SO-102 | 7987.56 | 0.00477764 | 1.95731 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 3320.44 | 3320.44 | -4667.12 | -4667.12 | -4667.12 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3332.88 | PP–SKEM | 78 | 456 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0029 | 0029 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S19
12914032 | 4.NP_SO-102 | 1680.61 | 0.00477764 | 0.411823 | ø78 mm | 0.000144928 | G | 4.NP_SO-102 | 3312.96 | 1632.36 | 3312.96 | 1632.36 | 3312.96 | Fáze 2 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 17 | 13632.4 | PP–SKEM | 78 | 2 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0030 | 0030 | yes | SW_Odvětrání kanalizace 17 | Identifikační data - Komentáře: S16
12914082 | 3.NP_SO-102 | 4254.14 | 0.00477764 | 1.04245 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 3277.03 | -977.101 | 3277.03 | -977.101 | 3277.03 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7022.9 | PP–SKEM | 78 | 242 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0031 | 0031 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S16
12914171 | 4.NP_SO-102 | 3873.99 | 0.00477764 | 0.949299 | ø78 mm | 0.000144928 | G | 4.NP_SO-102 | 3198.04 | 3198.04 | -675.956 | -675.956 | -675.956 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11324 | PP–SKEM | 78 | 4 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0032 | 0032 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S22
12915131 | -1.PP_SO-102 | 1289.3 | 0.00477764 | 0.315935 | ø78 mm | 0.000144928 | G | -1.PP_SO-102 | 0 | 0 | -1289.3 | -1289.3 | -1289.3 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -5289.3 | PP–SKEM | 78 | 73 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0034 | 0034 | yes | SW_Splašky vnitřní gravitační 3 | 0
12915142 | -1.PP_SO-102 | 979.566 | 0.00477764 | 0.240037 | ø78 mm | 0.000144928 | G | -1.PP_SO-102 | 0 | 0 | -979.566 | -979.566 | -979.566 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -4979.57 | PP–SKEM | 78 | 43 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0035 | 0035 | yes | SW_Splašky vnitřní gravitační 3 | 0
12917852 | 4.NP_SO-102 | 3471.71 | 0.00950189 | 1.19974 | ø110 mm | 0.0000669344 | G | STŘECHA_SO-102 | 1650 | 1650 | -1821.71 | -1821.71 | -1821.71 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 2 | 14028.3 | PP–SKEM | 110 | 2 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0036 | 0036 | yes | SW_Odvětrání kanalizace 2 | Identifikační data - Komentáře: S6
12917854 | 4.NP_SO-102 | 2866.5 | 0.00950189 | 0.990593 | ø110 mm | 0.000100604 | G | 4.NP_SO-102 | 1971.71 | -894.799 | 1971.71 | -894.799 | 1971.71 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11105.2 | PP–SKEM | 110 | 8 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0037 | 0037 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S6
12917986 | 4.NP_SO-102 | 3471.71 | 0.00950189 | 1.19974 | ø110 mm | 0.0000669344 | G | STŘECHA_SO-102 | 1650 | 1650 | -1821.71 | -1821.71 | -1821.71 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 3 | 14028.3 | PP–SKEM | 110 | 2 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0038 | 0038 | yes | SW_Odvětrání kanalizace 3 | Identifikační data - Komentáře: S8
12918154 | 3.NP_SO-102 | 140.592 | 0.00950189 | 0.0485852 | ø110 mm | 0.000100604 | G | 3.NP_SO-102 | 2910.88 | 2772.57 | 2871.99 | 2733.68 | 2871.99 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 10737.4 | PP–SKEM | 110 | 6 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0039 | 0039 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
12918178 | 3.NP_SO-102 | 1604.28 | 0.00950189 | 0.554398 | ø110 mm | 0.000100604 | G | 3.NP_SO-102 | 2809.14 | 2722.07 | 2754.15 | 2667.08 | 2754.15 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 10672.4 | PP–SKEM | 110 | 6 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0040 | 0040 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
12918193 | 3.NP_SO-102 | 205.209 | 0.00950189 | 0.0709151 | ø110 mm | 0.000100604 | G | 3.NP_SO-102 | 2742.54 | 2558.55 | 2703.65 | 2519.65 | 2703.65 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 10523.4 | PP–SKEM | 110 | 6 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0041 | 0041 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
12919200 | 3.NP_SO-102 | 1927.03 | 0.00950189 | 0.665933 | ø110 mm | 0.000100604 | G | 3.NP_SO-102 | 3022.87 | 2967.88 | 2929.34 | 2874.36 | 2929.34 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 10879.7 | PP–SKEM | 110 | 574 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0042 | 0042 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
12919739 | -1.PP_SO-102 | 2162.13 | 0.0201032 | 1.08681 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | 2692.06 | 2612.06 | 2612.06 | 2532.06 | 2612.06 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 6 | -1462.64 | PP–SKEM | 160 | 1 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.0043 | 0043 | yes | SW_Odvětrání kanalizace 6 |  | 0
12924274 | 4.NP_SO-102 | 2822.35 | 0.0201032 | 1.41867 | ø160 mm | 0.0000669344 | G | STŘECHA_SO-102 | 1650 | 1650 | -1172.35 | -1172.35 | -1172.35 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 7 | 14677.6 | PP–SKEM | 160 | 2 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.0044 | 0044 | yes | SW_Odvětrání kanalizace 7 | Identifikační data - Komentáře: S6
12924337 | 4.NP_SO-102 | 2619.71 | 0.00477764 | 0.641944 | ø78 mm | 0.000144928 | G | 4.NP_SO-102 | 1955.71 | -663.992 | 1955.71 | -663.992 | 1955.71 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11336 | PP–SKEM | 78 | 15 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0045 | 0045 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S15
12934796 | -1.PP_SO-102 | 540.293 | 0.00950189 | 0.186712 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 3593.05 | 3052.76 | 3593.05 | 3052.76 | 3593.05 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -947.242 | PP–SKEM | 110 | 280 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0046 | 0046 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S5
12936312 | 3.NP_SO-102 | 4153.54 | 0.00950189 | 1.43536 | ø110 mm | 0.000100604 | G | 3.NP_SO-102 | 1754.57 | -2398.97 | 1754.57 | -2398.97 | 1754.57 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 5601.03 | PP–SKEM | 110 | 280 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0047 | 0047 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S5
12939102 | 2.NP_SO-102 | 3919.4 | 0.00477764 | 0.960427 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3315.14 | -604.265 | 3315.14 | -604.265 | 3315.14 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3395.74 | PP–SKEM | 78 | 502 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0048 | 0048 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
12939171 | 2.NP_SO-102 | 158.034 | 0.00477764 | 0.0387253 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3404.22 | 3365.22 | 3362.06 | 3323.07 | 3362.06 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7327.57 | PP–SKEM | 78 | 502 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0049 | 0049 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
12939218 | 1.NP_SO-102 | 1955.99 | 0.00477764 | 0.479304 | ø78 mm | 0.000144928 | G | 1.NP_SO-102 | 3387.8 | 3309.7 | 3348.81 | 3270.7 | 3348.81 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3275.2 | PP–SKEM | 78 | 502 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0050 | 0050 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
12940644 | 3.NP_SO-102 | 3531.07 | 0.00477764 | 0.865269 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 2901.74 | 2901.74 | -629.337 | -629.337 | -629.337 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7370.66 | PP–SKEM | 78 | 505 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0051 | 0051 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S11
12940852 | 2.NP_SO-102 | 159.237 | 0.00477764 | 0.03902 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3362.73 | 3320.57 | 3323.73 | 3281.58 | 3323.73 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7286.08 | PP–SKEM | 78 | 505 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0052 | 0052 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1.98488
12941139 | 3.NP_SO-102 | 2208.44 | 0.00477764 | 0.541166 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 3031.82 | 2948.66 | 2992.82 | 2909.67 | 2992.82 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 10914.2 | PP–SKEM | 78 | 505 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0053 | 0053 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
12941323 | 4.NP_SO-102 | 3479.29 | 0.00477764 | 0.852579 | ø78 mm | 0.000144928 | G | STŘECHA_SO-102 | 1650 | 1650 | -1829.29 | -1829.29 | -1829.29 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 4 | 14020.7 | PP–SKEM | 78 | 4 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0054 | 0054 | yes | SW_Odvětrání kanalizace 4 | Identifikační data - Komentáře: S12
13095079 | 1.NP_SO-102 | 1928.93 | 0.00477764 | 0.472674 | ø78 mm | 0.000144928 | G | 1.NP_SO-102 | 3324.94 | 3285.95 | 3247.38 | 3208.38 | 3247.38 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3212.88 | PP–SKEM | 78 | 456 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0928 | 0928 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2 | Identifikační data - Komentáře: S19
13095166 | 4.NP_SO-102 | 2330.83 | 0.00477764 | 0.571156 | ø78 mm | 0.000144928 | G | 4.NP_SO-102 | 3307.54 | 976.71 | 3307.54 | 976.71 | 3307.54 | Fáze 2 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 11 | 12976.7 | PP–SKEM | 78 | 1 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0929 | 0929 | yes | SW_Odvětrání kanalizace 11 | Identifikační data - Komentáře: S19
13095230 | 3.NP_SO-102 | 106.207 | 0.00477764 | 0.0260254 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 3408.48 | 3369.49 | 3367.36 | 3328.37 | 3367.36 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11332.9 | PP–SKEM | 78 | 456 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0930 | 0930 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2.00001 | Identifikační data - Komentáře: S19
13095290 | 4.NP_SO-102 | 2085.48 | 0.00477764 | 0.511034 | ø78 mm | 0.000144928 | G | STŘECHA_SO-102 | 1650 | 1650 | -435.479 | -435.479 | -435.479 | Fáze 2 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 11 | 15414.5 | PP–SKEM | 78 | 1 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0931 | 0931 | yes | SW_Odvětrání kanalizace 11 | Identifikační data - Komentáře: S19
13095443 | 4.NP_SO-102 | 656.449 | 0.00477764 | 0.160859 | ø78 mm | 0.000144928 | G | 4.NP_SO-102 | 3406.59 | 3367.59 | 3354.47 | 3315.47 | 3354.47 | Fáze 2 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 11 | 15320 | PP–SKEM | 78 | 1 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0932 | 0932 | yes | SW_Odvětrání kanalizace 11 |  | 2 | Identifikační data - Komentáře: S19
13095688 | 4.NP_SO-102 | 1519.71 | 0.00477764 | 0.372395 | ø78 mm | 0.000144928 | G | 4.NP_SO-102 | 936.122 | 936.122 | -583.584 | -583.584 | -583.584 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11416.4 | PP–SKEM | 78 | 456 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0933 | 0933 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S19
13096172 | 4.NP_SO-102 | 2037.65 | 0.00477764 | 0.499313 | ø78 mm | 0.000144928 | G | STŘECHA_SO-102 | 1650 | 1650 | -387.646 | -387.646 | -387.646 | Fáze 2 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 10 | 15462.4 | PP–SKEM | 78 | 2 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0934 | 0934 | yes | SW_Odvětrání kanalizace 10 | Identifikační data - Komentáře: S18
13096217 | 4.NP_SO-102 | 852.172 | 0.00477764 | 0.20882 | ø78 mm | 0.000144928 | G | 4.NP_SO-102 | 3454.42 | 3415.43 | 3398.39 | 3359.39 | 3398.39 | Fáze 2 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 10 | 15363.9 | PP–SKEM | 78 | 2 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0935 | 0935 | yes | SW_Odvětrání kanalizace 10 |  | 2 | Identifikační data - Komentáře: S18
13096382 | 4.NP_SO-102 | 2515.62 | 0.00477764 | 0.616437 | ø78 mm | 0.000144928 | G | 4.NP_SO-102 | 1471.16 | 1471.16 | -1044.45 | -1044.45 | -1044.45 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 10955.5 | PP–SKEM | 78 | 401 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0936 | 0936 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S18
13096969 | 1.NP_SO-102 | 3891.73 | 0.00950189 | 1.34488 | ø110 mm | 0.000100604 | G | 1.NP_SO-102 | 3123.03 | 3123.03 | -768.699 | -768.699 | -768.699 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -768.699 | PP–SKEM | 110 | 592 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0937 | 0937 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S18
13098728 | 3.NP_SO-102 | 1965.9 | 0.00477764 | 0.481731 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 3402.26 | 3363.27 | 3323.96 | 3284.97 | 3323.96 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11289.5 | PP–SKEM | 78 | 242 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0938 | 0938 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2 | Identifikační data - Komentáře: S16
13098789 | 2.NP_SO-102 | 7753.82 | 0.00477764 | 1.90003 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 2889.73 | -4864.09 | 2889.73 | -4864.09 | 2889.73 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -864.091 | PP–SKEM | 78 | 242 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0939 | 0939 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S16
13098991 | 2.NP_SO-102 | 1965.9 | 0.00477764 | 0.481731 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3014.96 | 2975.97 | 2936.66 | 2897.67 | 2936.66 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 6902.17 | PP–SKEM | 78 | 242 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0940 | 0940 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2 | Identifikační data - Komentáře: S16
13099215 | 4.NP_SO-102 | 2081.41 | 0.00477764 | 0.510036 | ø78 mm | 0.000144928 | G | STŘECHA_SO-102 | 1650 | 1650 | -431.405 | -431.405 | -431.405 | Fáze 2 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 17 | 15418.6 | PP–SKEM | 78 | 2 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0941 | 0941 | yes | SW_Odvětrání kanalizace 17 | Identifikační data - Komentáře: S16
13099713 | 4.NP_SO-102 | 2181.57 | 0.00477764 | 0.534581 | ø78 mm | 0.000144928 | G | 4.NP_SO-102 | 1591.77 | 1591.77 | -589.799 | -589.799 | -589.799 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11410.2 | PP–SKEM | 78 | 242 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0942 | 0942 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S16
13099749 | 4.NP_SO-102 | 588.821 | 0.00477764 | 0.144287 | ø78 mm | 0.000144928 | G | 4.NP_SO-102 | 3410.66 | 3371.67 | 3359.89 | 3320.9 | 3359.89 | Fáze 2 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 17 | 15325.4 | PP–SKEM | 78 | 2 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0943 | 0943 | yes | SW_Odvětrání kanalizace 17 |  | 2 | Identifikační data - Komentáře: S16
13099952 | 3.NP_SO-102 | 3894.14 | 0.00477764 | 0.954236 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 3316.11 | 3199.25 | 3277.12 | 3160.26 | 3277.12 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11164.8 | PP–SKEM | 78 | 4 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0944 | 0944 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13099967 | 4.NP_SO-102 | 3967.13 | 0.00477764 | 0.972122 | ø78 mm | 0.000144928 | G | 4.NP_SO-102 | 3118.04 | 3118.04 | -849.091 | -849.091 | -849.091 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11150.9 | PP–SKEM | 78 | 455 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0945 | 0945 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S17
13100043 | 1.NP_SO-102 | 838.557 | 0.00477764 | 0.205484 | ø78 mm | 0.000144928 | G | 1.NP_SO-102 | 3424.92 | 3385.92 | 3369.16 | 3330.16 | 3369.16 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3334.66 | PP–SKEM | 78 | 593 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0946 | 0946 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2 | Identifikační data - Komentáře: S17
13100056 | 1.NP_SO-102 | 371.503 | 0.00477764 | 0.0910347 | ø78 mm | 0.000144928 | G | 1.NP_SO-102 | 3407.22 | 3368.22 | 3368.22 | 3329.22 | 3368.22 | Fáze 2 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3333.72 | PP–SKEM | 78 | 593 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0947 | 0947 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 0 | Identifikační data - Komentáře: S17
13100421 | 3.NP_SO-102 | 2127.26 | 0.00477764 | 0.521272 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 3328.07 | 3289.08 | 3246.54 | 3207.55 | 3246.54 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11212.1 | PP–SKEM | 78 | 15 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0948 | 0948 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13100831 | 1.NP_SO-102 | 3560.09 | 0.00950189 | 1.23028 | ø110 mm | 0.000100604 | G | 1.NP_SO-102 | 3391.71 | -168.384 | 3391.71 | -168.384 | 3391.71 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -168.384 | PP–SKEM | 110 | 726 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0949 | 0949 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S13
13100927 | 2.NP_SO-102 | 1953.32 | 0.00477764 | 0.47865 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 3410.13 | 3371.14 | 3332.08 | 3293.09 | 3332.08 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7297.59 | PP–SKEM | 78 | 305 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0950 | 0950 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13101490 | 4.NP_SO-102 | 1300.12 | 0.00477764 | 0.318587 | ø78 mm | 0.000144928 | G | 4.NP_SO-102 | 3296.42 | 3296.42 | 1996.3 | 1996.3 | 1996.3 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 9 | 13996.3 | PP–SKEM | 78 | 4 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0951 | 0951 | yes | SW_Odvětrání kanalizace 9 | Identifikační data - Komentáře: S15
13101582 | 4.NP_SO-102 | 2095.16 | 0.00477764 | 0.513407 | ø78 mm | 0.000144928 | G | STŘECHA_SO-102 | 1650 | 1650 | -445.162 | -445.162 | -445.162 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 9 | 15404.8 | PP–SKEM | 78 | 4 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0952 | 0952 | yes | SW_Odvětrání kanalizace 9 | Identifikační data - Komentáře: S15
13101928 | 4.NP_SO-102 | 728.148 | 0.00477764 | 0.178428 | ø78 mm | 0.000144928 | G | 4.NP_SO-102 | 3396.9 | 3357.91 | 3343.35 | 3304.36 | 3343.35 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 9 | 15308.9 | PP–SKEM | 78 | 4 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0953 | 0953 | yes | SW_Odvětrání kanalizace 9 |  | 2
13101981 | 4.NP_SO-102 | 1791.82 | 0.00477764 | 0.439075 | ø78 mm | 0.000144928 | G | 4.NP_SO-102 | 1169.71 | -622.114 | 1169.71 | -622.114 | 1169.71 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11377.9 | PP–SKEM | 78 | 305 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0954 | 0954 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S13
13102087 | 4.NP_SO-102 | 2153.7 | 0.00477764 | 0.527751 | ø78 mm | 0.000144928 | G | STŘECHA_SO-102 | 1650 | 1650 | -503.698 | -503.698 | -503.698 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 8 | 15346.3 | PP–SKEM | 78 | 2 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0955 | 0955 | yes | SW_Odvětrání kanalizace 8 | Identifikační data - Komentáře: S13
13102247 | 4.NP_SO-102 | 2028.79 | 0.00477764 | 0.497144 | ø78 mm | 0.000144928 | G | 4.NP_SO-102 | 3239.09 | 3239.09 | 1210.29 | 1210.29 | 1210.29 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 8 | 13210.3 | PP–SKEM | 78 | 2 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0956 | 0956 | yes | SW_Odvětrání kanalizace 8 | Identifikační data - Komentáře: S13
13102400 | 4.NP_SO-102 | 668.136 | 0.00477764 | 0.163723 | ø78 mm | 0.000144928 | G | 4.NP_SO-102 | 3338.37 | 3299.37 | 3286.01 | 3247.02 | 3286.01 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 8 | 15251.5 | PP–SKEM | 78 | 2 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.0957 | 0957 | yes | SW_Odvětrání kanalizace 8 |  | 2
13152106 | -1.PP_SO-102 | 337.373 | 0.0201032 | 0.169582 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | -3076.51 | -3371.63 | -3133.08 | -3428.2 | -3133.08 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -7424.46 | PP–SKEM | 160 | 28 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.0981 | 0981 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 100
13152118 | -1.PP_SO-102 | 852.357 | 0.0201032 | 0.428441 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | -3317.39 | -3414.42 | -3397.37 | -3494.4 | -3397.37 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -7489.1 | PP–SKEM | 160 | 28 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.0982 | 0982 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 2
13152532 | -1.PP_SO-102 | 4508.84 | 0.00950189 | 1.55814 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 1908.23 | 1908.23 | -2600.61 | -2600.61 | -2600.61 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6600.61 | PP–SKEM | 110 | 39 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0984 | 0984 | yes | SW_Splašky vnitřní gravitační 3 | 0
13152736 | -1.PP_SO-102 | 3877.28 | 0.00950189 | 1.33989 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 1632.28 | 1632.28 | -2245.01 | -2245.01 | -2245.01 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 4 | -6245.01 | PP–SKEM | 110 | 2 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0985 | 0985 | yes | SW_Splašky vnitřní gravitační 4 | 0
13153097 | -1.PP_SO-102 | 1831.07 | 0.00950189 | 0.632774 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -2058.99 | -2150.6 | -2113.98 | -2205.59 | -2113.98 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 4 | -6200.29 | PP–SKEM | 110 | 5 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0987 | 0987 | yes | SW_Splašky vnitřní gravitační 4 | 0 | 2
13153126 | -1.PP_SO-102 | 1359.39 | 0.00950189 | 0.469771 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -2058.87 | -2141.04 | -2113.86 | -2196.03 | -2113.86 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 4 | -6190.73 | PP–SKEM | 110 | 1 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0988 | 0988 | yes | SW_Splašky vnitřní gravitační 4 | 0 | 2
13153193 | -1.PP_SO-102 | 164.049 | 0.00950189 | 0.0566914 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -2130.13 | -2285.02 | -2169.02 | -2323.91 | -2169.02 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 4 | -6320.16 | PP–SKEM | 110 | 5 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0989 | 0989 | yes | SW_Splašky vnitřní gravitační 4 | 0 | 100
13153225 | -1.PP_SO-102 | 693.122 | 0.00950189 | 0.239526 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -2120.57 | -2649.57 | -2159.46 | -2688.46 | -2159.46 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 4 | -6684.71 | PP–SKEM | 110 | 1 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0990 | 0990 | yes | SW_Splašky vnitřní gravitační 4 | 0 | 100
13153283 | -1.PP_SO-102 | 91.3231 | 0.00950189 | 0.031559 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -2518.23 | -2518.23 | -2609.56 | -2609.56 | -2609.56 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 4 | -6609.56 | PP–SKEM | 110 | 4 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0991 | 0991 | yes | SW_Splašky vnitřní gravitační 4 | 0
13153316 | -1.PP_SO-102 | 434.459 | 0.00950189 | 0.150138 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -2882.79 | -2882.79 | -3317.25 | -3317.25 | -3317.25 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 4 | -7317.25 | PP–SKEM | 110 | 3 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0992 | 0992 | yes | SW_Splašky vnitřní gravitační 4 | 0
13153421 | -1.PP_SO-102 | 225.378 | 0.00950189 | 0.0778849 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -1897.31 | -2095.56 | -1936.2 | -2134.45 | -1936.2 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 4 | -6130.71 | PP–SKEM | 110 | 5 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0993 | 0993 | yes | SW_Splašky vnitřní gravitační 4 | 0 | 100
13153457 | -1.PP_SO-102 | 227.406 | 0.00950189 | 0.0785857 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -1895.74 | -2095.43 | -1934.63 | -2134.33 | -1934.63 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 4 | -6130.58 | PP–SKEM | 110 | 1 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0994 | 0994 | yes | SW_Splašky vnitřní gravitační 4 | 0 | 100
13153594 | -1.PP_SO-102 | 544.913 | 0.00950189 | 0.188308 | ø110 mm | 0.0000669344 | G | -1.PP_SO-102 | 1957.06 | 1957.06 | 1412.15 | 1412.15 | 1412.15 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | -2587.85 | PP–SKEM | 110 | 91 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.0995 | 0995 | yes | SW_Odvětrání kanalizace 16; SW_Splašky vnitřní gravitační 3
13153752 | -1.PP_SO-102 | 298.298 | 0.0201032 | 0.149941 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | -2082.4 | -2349.9 | -2138.97 | -2406.47 | -2138.97 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6402.72 | PP–SKEM | 160 | 27 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.0996 | 0996 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 100
13153818 | -1.PP_SO-102 | 124.552 | 0.0201032 | 0.0626067 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | -2222.4 | -2367.04 | -2278.97 | -2423.61 | -2278.97 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6419.86 | PP–SKEM | 160 | 30 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.0997 | 0997 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 100
13153875 | -1.PP_SO-102 | 464.701 | 0.0201032 | 0.233584 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | -2399.88 | -2479.87 | -2489.16 | -2569.14 | -2489.16 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6563.84 | PP–SKEM | 160 | 29 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.0998 | 0998 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 2
13153937 | -1.PP_SO-102 | 217.869 | 0.0201032 | 0.109513 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | -2488.2 | -2544.5 | -2699.29 | -2755.58 | -2699.29 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6751.85 | PP–SKEM | 160 | 139 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.0999 | 0999 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 100.961
13153986 | -1.PP_SO-102 | 49.9909 | 0.0201032 | 0.0251282 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | -3020.88 | -3020.9 | -3070.89 | -3070.91 | -3070.89 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -7070.91 | PP–SKEM | 160 | 28 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.1000 | 1000 | yes | SW_Splašky vnitřní gravitační 3 | 0
13154009 | -1.PP_SO-102 | 227.644 | 0.0201032 | 0.114426 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | -2434.42 | -2518.96 | -2514.41 | -2598.94 | -2514.41 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6593.64 | PP–SKEM | 160 | 139 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.1001 | 1001 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 2
13154017 | -1.PP_SO-102 | 451.958 | 0.0201032 | 0.227179 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | -2417.28 | -2506.3 | -2497.26 | -2586.29 | -2497.26 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6580.99 | PP–SKEM | 160 | 26 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.1002 | 1002 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 2
13154090 | -1.PP_SO-102 | 606.999 | 0.0201032 | 0.305111 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | -1968.35 | -2024.92 | -2454.13 | -2510.7 | -2454.13 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6506.95 | PP–SKEM | 160 | 29 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.1003 | 1003 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 100
13154173 | -1.PP_SO-102 | 1962.73 | 0.0201032 | 0.986578 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | 0 | 0 | -1962.73 | -1962.73 | -1962.73 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -5962.73 | PP–SKEM | 160 | 29 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.1004 | 1004 | yes | SW_Splašky vnitřní gravitační 3 | 0
13155534 | -1.PP_SO-102 | 356.693 | 0.00950189 | 0.123264 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -2987.23 | -3042.22 | -3049.35 | -3104.33 | -3049.35 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -7099.04 | PP–SKEM | 110 | 117 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1021 | 1021 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 1.9988
13155598 | -1.PP_SO-102 | 214.45 | 0.00477764 | 0.0525496 | ø78 mm | 0.000144928 | G | -1.PP_SO-102 | 690.064 | 690.064 | 475.615 | 475.615 | 475.615 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -3524.39 | PP–SKEM | 78 | 58 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1023 | 1023 | yes | SW_Splašky vnitřní gravitační 3 | 0
13155686 | -1.PP_SO-102 | 2555.83 | 0.00477764 | 0.626291 | ø78 mm | 0.000144928 | G | -1.PP_SO-102 | 467.681 | 352.058 | 428.698 | 313.075 | 428.698 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -3682.43 | PP–SKEM | 78 | 58 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1024 | 1024 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 3
13155772 | -1.PP_SO-102 | 304.225 | 0.00477764 | 0.0745485 | ø78 mm | 0.000144928 | G | -1.PP_SO-102 | 365.908 | 123.212 | 338.331 | 95.6347 | 338.331 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -3901.18 | PP–SKEM | 78 | 58 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1025 | 1025 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 100
13155839 | -1.PP_SO-102 | 2091.78 | 0.00950189 | 0.722869 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | -130.01 | -130.01 | -2221.79 | -2221.79 | -2221.79 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6221.79 | PP–SKEM | 110 | 142 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1026 | 1026 | yes | SW_Splašky vnitřní gravitační 3 | 0
13156047 | -1.PP_SO-102 | 4859.2 | 0.00950189 | 1.67922 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 3055 | 3000 | 3000 | 2945 | 3000 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | -1049.7 | PP–SKEM | 110 | 142 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1027 | 1027 | yes | SW_Odvětrání kanalizace 16 |  | 0
13156740 | -1.PP_SO-102 | 1808.77 | 0.00950189 | 0.625066 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 3055 | 3000 | 3000 | 2945 | 3000 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | -1049.7 | PP–SKEM | 110 | 142 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1031 | 1031 | yes | SW_Odvětrání kanalizace 16 |  | 0
13157016 | -1.PP_SO-102 | 255.716 | 0.0201032 | 0.128537 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | -2268.2 | -2324.77 | -2505.59 | -2562.16 | -2505.59 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 3 | -6558.41 | PP–SKEM | 160 | 45 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.1033 | 1033 | yes | SW_Splašky vnitřní gravitační 3 | 0 | 100
13160031 | 2.NP_SO-102 | 654.647 | 0.00950189 | 0.22623 | ø110 mm | 0.000100604 | G | 2.NP_SO-102 | -147.769 | -147.769 | -802.416 | -802.416 | -802.416 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3197.58 | PP–SKEM | 110 | 647 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1049 | 1049 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
13160042 | 2.NP_SO-102 | 343.748 | 0.00950189 | 0.118791 | ø110 mm | 0.000100604 | G | 2.NP_SO-102 | -162.946 | -162.946 | -506.694 | -506.694 | -506.694 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3493.31 | PP–SKEM | 110 | 633 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1050 | 1050 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
13163625 | 2.NP_SO-102 | 1476.33 | 0.0143117 | 0.626134 | ø135 mm | 0.0000669344 | G | 2.NP_SO-102 | 3024.56 | 1548.23 | 3024.56 | 1548.23 | 3024.56 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 5548.23 | PP–SKEM | 135 | 116 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1054 | 1054 | yes | SW_Odvětrání kanalizace 16
13163886 | 2.NP_SO-102 | 1908.75 | 0.0143117 | 0.809531 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 1465.46 | -443.297 | 1465.46 | -443.297 | 1465.46 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3556.7 | PP–SKEM | 135 | 131 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1055 | 1055 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
13163908 | 2.NP_SO-102 | 2701.85 | 0.0143117 | 1.14589 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 1465.46 | 1465.46 | -1236.39 | -1236.39 | -1236.39 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2763.61 | PP–SKEM | 135 | 379 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1056 | 1056 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
13170641 | -1.PP_SO-102 | 2097.55 | 0.00950189 | 0.72486 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 2865 | 2810 | 2810 | 2755 | 2810 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | -1239.7 | PP–SKEM | 110 | 127 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1092 | 1092 | yes | SW_Odvětrání kanalizace 16 |  | 0
13170647 | 4.NP_SO-102 | 10518.2 | 0.0143117 | 4.46093 | ø135 mm | 0 | G | STŘECHA_SO-102 | 1650 | 1650 | -8868.21 | -8868.21 | -8868.21 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 6981.79 | PP–SKEM | 135 | 130 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1093 | 1093 | yes | SW_Odvětrání kanalizace 16 | Identifikační data - Komentáře: S14
13170668 | 2.NP_SO-102 | 901.63 | 0.0143117 | 0.382395 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 1086.51 | 184.881 | 1086.51 | 184.881 | 1086.51 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 4184.88 | PP–SKEM | 135 | 619 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1094 | 1094 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
13170674 | 2.NP_SO-102 | 272.114 | 0.0143117 | 0.115407 | ø135 mm | 0.0000669344 | G | 2.NP_SO-102 | 3177.5 | 3110 | 3110 | 3042.5 | 3110 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 7047.8 | PP–SKEM | 135 | 77 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1095 | 1095 | yes | SW_Odvětrání kanalizace 16 |  | 0
13170681 | 2.NP_SO-102 | 720.156 | 0.0143117 | 0.305429 | ø135 mm | 0.0000669344 | G | 2.NP_SO-102 | 3167.5 | 3100 | 3100 | 3032.5 | 3100 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 16 | 7037.8 | PP–SKEM | 135 | 62 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1096 | 1096 | yes | SW_Odvětrání kanalizace 16 |  | 0
13173758 | 2.NP_SO-102 | 1903.02 | 0.00477764 | 0.466325 | ø78 mm | 0.000144928 | G | 2.NP_SO-102 | 1205.02 | 1205.02 | -698.002 | -698.002 | -698.002 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3302 | PP–SKEM | 78 | 644 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1097 | 1097 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
13174410 | -1.PP_SO-102 | 540.3 | 0.00950189 | 0.186714 | ø110 mm | 0.000100604 | G | -1.PP_SO-102 | 7847.17 | 7847.17 | 7306.87 | 7306.87 | 7306.87 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3306.87 | PP–SKEM | 110 | 91 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1098 | 1098 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
13262066 | 2.NP_SO-102 | 2972.66 | 0.0143117 | 1.26075 | ø135 mm | 0.0000803859 | G | 2.NP_SO-102 | 2418.04 | 2418.04 | -554.627 | -554.628 | -554.627 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3445.37 | PP–SKEM | 135 | 114 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1174 | 1174 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
13262334 | 1.NP_SO-102 | 1181.24 | 0.0143117 | 0.50098 | ø135 mm | 0.0000803859 | G | 1.NP_SO-102 | 3126.6 | 3059.11 | 3035.62 | 2968.13 | 3035.62 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2973.43 | PP–SKEM | 135 | 114 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1175 | 1175 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 1.98939
13264838 | 1.NP_SO-102 | 229.786 | 0.0143117 | 0.0974555 | ø135 mm | 0.0000803859 | G | 1.NP_SO-102 | 2528.86 | 2461.36 | 2461.36 | 2393.86 | 2461.36 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 2399.16 | PP–SKEM | 135 | 714 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø135 | 124.4 | TR08.01.1176 | 1176 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 0
13264851 | 1.NP_SO-102 | 1761.12 | 0.00477747 | 0.431553 | ø78 mm | 0.000144928 | G | 1.NP_SO-102 | 3168.59 | 3094.38 | 3129.6 | 3055.39 | 3094.38 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3059.89 | PP–SKEM | 78 | 707 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1177 | 1177 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 2
13268437 | -1.PP_SO-102 | 332.962 | 0.0201032 | 0.167365 | ø160 mm | 0.0000669344 | G | -1.PP_SO-102 | 2768 | 2476 | 2711.44 | 2419.43 | 2711.44 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -1576.83 | PP–SKEM | 160 | 1 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.1178 | 1178 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 100
13271040 | 1.NP_SO-102 | 557.317 | 0.00477764 | 0.136567 | ø78 mm | 0.000144928 | G | 1.NP_SO-102 | 3372.99 | 3333.99 | 3333.99 | 3294.99 | 3333.99 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 3299.49 | PP–SKEM | 78 | 220 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1182 | 1182 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 0
13271058 | 1.NP_SO-102 | 4091.01 | 0.00477764 | 1.00248 | ø78 mm | 0.000144928 | G | 1.NP_SO-102 | 3287.06 | -803.949 | 3287.06 | -803.949 | 3287.06 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -803.949 | PP–SKEM | 78 | 220 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1183 | 1183 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S12
13271156 | 1.NP_SO-102 | 2034.87 | 0.00950189 | 0.703199 | ø110 mm | 0.000100604 | G | 1.NP_SO-102 | 1233.98 | 1233.94 | -800.928 | -800.971 | -800.928 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | -800.966 | PP–SKEM | 110 | 534 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1184 | 1184 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | 129220
13362690 | 4.NP_SO-102 | 2822.35 | 0.0201032 | 1.41867 | ø160 mm | 0.0000669344 | G | STŘECHA_SO-102 | 1650 | -1172.35 | 1650 | -1172.35 | 1650 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 1 | 14677.6 | PP–SKEM | 160 | 3 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.1305 | 1305 | yes | SW_Odvětrání kanalizace 1 | Identifikační data - Komentáře: S4
13362692 | 4.NP_SO-102 | 1424.12 | 0.0201032 | 0.715843 | ø160 mm | 0.0000669344 | G | 4.NP_SO-102 | 2669.71 | 2589.71 | 2589.71 | 2509.71 | 2589.71 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 1 | 14515 | PP–SKEM | 160 | 3 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø160 | 149.4 | TR08.01.1306 | 1306 | yes | SW_Odvětrání kanalizace 1 |  | 0
13362977 | 3.NP_SO-102 | 3641.02 | 0.00477764 | 0.892211 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 3401.4 | 3362.4 | 3362.4 | 3323.4 | 3362.4 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 20 | 11327.9 | PP–SKEM | 78 | 1 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1307 | 1307 | yes | SW_Odvětrání kanalizace 20 |  | 0
13363259 | 3.NP_SO-102 | 1893.92 | 0.00477764 | 0.464093 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 3315.46 | 1421.54 | 3315.46 | 1421.54 | 3315.46 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 20 | 9421.54 | PP–SKEM | 78 | 1 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1308 | 1308 | yes | SW_Odvětrání kanalizace 20 | Identifikační data - Komentáře: S9
13363342 | 3.NP_SO-102 | 17.3144 | 0.00477764 | 0.0042428 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 3376.23 | 3336.41 | 3348.65 | 3308.83 | 3348.65 | Fáze 1 | 0.01 | Průduch | PP_SKOLAN dB | SW_Odvětrání kanalizace 20 | 11312 | PP–SKEM | 78 | 1 | SW_Odvětrání kanalizace | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1309 | 1309 | yes | SW_Splašky vnitřní gravitační 35 (1); SW_Odvětrání kanalizace 20 |  | 100
13363545 | 3.NP_SO-102 | 52.383 | 0.00950189 | 0.0181023 | ø110 mm | 0.000100604 | G | 3.NP_SO-102 | 3083.19 | 3030.8 | 3083.19 | 3030.8 | 3083.19 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11030.8 | PP–SKEM | 110 | 574 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1310 | 1310 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
13363559 | 4.NP_SO-102 | 2615.29 | 0.00950189 | 0.90378 | ø110 mm | 0.000100604 | G | 4.NP_SO-102 | 1971.71 | -643.586 | 1971.71 | -643.586 | 1971.71 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 11356.4 | PP–SKEM | 110 | 274 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø110 | 99.4 | TR08.01.1311 | 1311 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0 | Identifikační data - Komentáře: S8
13370207 | 3.NP_SO-102 | 1428.47 | 0.00477764 | 0.350037 | ø78 mm | 0.000144928 | G | 3.NP_SO-102 | 559.478 | 559.478 | -868.987 | -868.987 | -868.987 | Fáze 1 | 0.01 | Sanitární | PP_SKOLAN dB | SW_Splašky vnitřní gravitační 35 (1) | 7131.01 | PP–SKEM | 78 | 436 | SW_Splašky vnitřní gravitační | PP_SKOLAN dB - – | – | ø78 | 69 | TR08.01.1312 | 1312 | yes | SW_Splašky vnitřní gravitační 35 (1) | 0
