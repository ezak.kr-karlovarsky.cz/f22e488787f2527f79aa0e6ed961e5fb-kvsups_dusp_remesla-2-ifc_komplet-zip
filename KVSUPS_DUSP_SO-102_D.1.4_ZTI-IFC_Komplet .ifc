Properties of the parts of a building model (IFC4), part 51 of 60

# IfcPipeSegment: Typy trubek:PP-RCT (1338)
Name (Typy trubek:PP-RCT:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Instalační jednotky = Reynoldsovo číslo = Třecí faktor = Tření = Průtok (m3/s) = Rychlost (m/s) = Tlaková ztráta (Pa) | Stav průtoku | Doplňkový průtok (m3/s) | Relativní drsnost | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) | Spodní výška (mm) | Střední výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Délka (mm) | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
13336054 | -1.PP_SO-102 | 431.516 | 0.0004908 | 0.0338912 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 1012.5 | 1000 | 1000 | 987.5 | 1000 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -3009.7 | PP–RCT S4 | 25 | 363 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 431.516 | ø25 | 19.4 | TR10.03.1239 | 1239 | no | WS_Studená vnitřní 134 | 0
13336136 | -1.PP_SO-102 | 331.582 | 0.0004908 | 0.0260424 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 1012.5 | 1000 | 1000 | 987.5 | 1000 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -3009.7 | PP–RCT S4 | 25 | 378 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 331.582 | ø25 | 19.4 | TR10.03.1240 | 1240 | no | WS_Teplá vnitřní 83 | 0 | Identifikační data - Komentáře: Vana ( voda+ odpad)
13347265 | 1.NP_SO-102 | 225.134 | 0.000314112 | 0.0141456 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3364.85 | 3354.85 | 3350.35 | 3340.35 | 3350.35 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3342.65 | PP–RCT S4 | 20 | 408 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 225.134 | ø20 | 15.4 | TR10.03.1241 | 1241 | no | WS_Studená vnitřní 134 | 2
13347269 | 1.NP_SO-102 | 462.64 | 0.000314112 | 0.0290686 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3374.8 | 3364.8 | 3355.55 | 3345.55 | 3355.55 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3347.85 | PP–RCT S4 | 20 | 408 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 462.64 | ø20 | 15.4 | TR10.03.1242 | 1242 | no | WS_Studená vnitřní 134 | 2
13347273 | 1.NP_SO-102 | 242.821 | 0.000314112 | 0.0152569 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3381.86 | 3371.86 | 3367.01 | 3357.01 | 3367.01 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3359.31 | PP–RCT S4 | 20 | 371 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 242.821 | ø20 | 15.4 | TR10.03.1243 | 1243 | no | WS_Teplá vnitřní 83 | 2
13347277 | 1.NP_SO-102 | 340.317 | 0.000314112 | 0.0213827 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3389.37 | 3379.37 | 3372.56 | 3362.56 | 3372.56 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3364.86 | PP–RCT S4 | 20 | 371 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 340.317 | ø20 | 15.4 | TR10.03.1244 | 1244 | no | WS_Teplá vnitřní 83 | 2
13347305 | 2.NP_SO-102 | 296.067 | 0.000804127 | 0.0297639 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2461.93 | 2445.93 | 2440.01 | 2424.01 | 2440.01 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6427.61 | PP–RCT S4 | 32 | 346 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 296.067 | ø32 | 24.8 | TR10.03.1245 | 1245 | no | WS_Studená vnitřní 134 | 2
13356053 | 3.NP_SO-102 | 4753.01 | 0.000804127 | 0.477825 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11337.6 | PP–RCT S4 | 32 | 190 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4753.01 | ø32 | 24.8 | TR10.03.1254 | 1254 | yes | WS_Studená vnitřní 134 | 0
13356061 | 3.NP_SO-102 | 4552.38 | 0.000804127 | 0.457655 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3406.19 | 3390.19 | 3390.19 | 3374.19 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11377.8 | PP–RCT S4 | 32 | 137 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4552.38 | ø32 | 24.8 | TR10.03.1255 | 1255 | yes | WS_Teplá vnitřní 83 | 0
13356995 | 1.NP_SO-102 | 119.823 | 0.0004908 | 0.0094109 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 359.404 | 346.904 | 346.904 | 334.404 | 346.904 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 337.204 | PP–RCT S4 | 25 | 347 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 119.823 | ø25 | 19.4 | TR10.03.1263 | 1263 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13356996 | 1.NP_SO-102 | 931.21 | 0.0004908 | 0.073137 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 326.267 | -604.943 | 326.267 | -604.943 | 326.267 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -604.943 | PP–RCT S4 | 25 | 347 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 931.21 | ø25 | 19.4 | TR10.03.1264 | 1264 | no | WS_"Jiný typ" studená vnitřní 1
13357396 | 2.NP_SO-102 | 2673.83 | 0.000804127 | 0.268803 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2416 | 2400 | 2400 | 2384 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6387.6 | PP–RCT S4 | 32 | 207 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2673.83 | ø32 | 24.8 | TR10.03.1265 | 1265 | no | WS_Teplá vnitřní 83 | 0
13357712 | 4.NP_SO-102 | 2273.48 | 0.000314112 | 0.142847 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3290.89 | 1017.4 | 3290.89 | 1017.4 | 3290.89 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 13017.4 | PP–RCT S4 | 20 | 226 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2273.48 | ø20 | 15.4 | TR10.03.1266 | 1266 | no | WS_"Jiný typ" studená vnitřní 1
13358353 | 1.NP_SO-102 | 760.957 | 0.0019632 | 0.119531 | ø50 mm |  |  | 0 | 0.000257732 | JB | 1.NP_SO-102 | 1325 | 1300 | 1300 | 1275 | 1300 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | Trubka Evo, S4 | WS_Požární nezavodněný 1 | 1280.6 | PP–RCT S4 | 50 | 1 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 760.957 | ø50 | 38.8 | TR10.03.1267 | 1267 | yes | WS_Požární nezavodněný 1 | 0
13358482 | 2.NP_SO-102 | 506.663 | 0.0019632 | 0.0795864 | ø50 mm |  |  | 0 | 0.000257732 | JB | 2.NP_SO-102 | 1325 | 1300 | 1300 | 1275 | 1300 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | Trubka Evo, S4 | WS_Požární nezavodněný 1 | 5280.6 | PP–RCT S4 | 50 | 317 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 506.663 | ø50 | 38.8 | TR10.03.1270 | 1270 | yes | WS_Požární nezavodněný 1 | 0
13358492 | 2.NP_SO-102 | 133.325 | 0.0019632 | 0.0209426 | ø50 mm |  |  | 0 | 0.000257732 | JB | 2.NP_SO-102 | 1325 | 1300 | 1300 | 1275 | 1300 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | Trubka Evo, S4 | WS_Požární nezavodněný 1 | 5280.6 | PP–RCT S4 | 50 | 317 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 133.325 | ø50 | 38.8 | TR10.03.1271 | 1271 | yes | WS_Požární nezavodněný 1 | 0
13358502 | 2.NP_SO-102 | 236.113 | 0.0019632 | 0.0370885 | ø50 mm |  |  | 0 | 0.000257732 | JB | 2.NP_SO-102 | 1325 | 1300 | 1300 | 1275 | 1300 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | Trubka Evo, S4 | WS_Požární nezavodněný 1 | 5280.6 | PP–RCT S4 | 50 | 317 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 236.113 | ø50 | 38.8 | TR10.03.1272 | 1272 | yes | WS_Požární nezavodněný 1 | 0
13358511 | 2.NP_SO-102 | 584.831 | 0.0019632 | 0.0918651 | ø50 mm |  |  | 0 | 0 | JB | 2.NP_SO-102 | 1918.17 | 1333.34 | 1918.17 | 1333.34 | 1918.17 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | Trubka Evo, S4 | WS_Požární nezavodněný 1 | 5333.34 | PP–RCT S4 | 50 | 317 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 584.831 | ø50 | 38.8 | TR10.03.1273 | 1273 | yes | WS_Požární nezavodněný 1
13361184 | 3.NP_SO-102 | 812.375 | 0.000804127 | 0.0816688 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11337.6 | PP–RCT S4 | 32 | 190 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 812.375 | ø32 | 24.8 | TR10.03.1297 | 1297 | yes | WS_Studená vnitřní 134 | 0
13361214 | 3.NP_SO-102 | 1650.78 | 0.000314112 | 0.103722 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11342.3 | PP–RCT S4 | 20 | 106 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1650.78 | ø20 | 15.4 | TR10.03.1298 | 1298 | no | WS_Studená vnitřní 134 | 0
13361309 | 3.NP_SO-102 | 872.375 | 0.000804127 | 0.0877007 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3406.19 | 3390.19 | 3390.19 | 3374.19 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11377.8 | PP–RCT S4 | 32 | 137 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 872.375 | ø32 | 24.8 | TR10.03.1299 | 1299 | yes | WS_Teplá vnitřní 83 | 0
13361336 | 3.NP_SO-102 | 1440.3 | 0.000314112 | 0.0904966 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3400.19 | 3390.19 | 3390.19 | 3380.19 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11382.5 | PP–RCT S4 | 20 | 139 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1440.3 | ø20 | 15.4 | TR10.03.1300 | 1300 | no | WS_Teplá vnitřní 83 | 0
13361412 | 3.NP_SO-102 | 672.521 | 0.000804127 | 0.0676092 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11337.6 | PP–RCT S4 | 32 | 190 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 672.521 | ø32 | 24.8 | TR10.03.1301 | 1301 | no | WS_Studená vnitřní 134 | 0
13361466 | 3.NP_SO-102 | 742.579 | 0.000804127 | 0.0746521 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3406.19 | 3390.19 | 3390.19 | 3374.19 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11377.8 | PP–RCT S4 | 32 | 137 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 742.579 | ø32 | 24.8 | TR10.03.1302 | 1302 | no | WS_Teplá vnitřní 83 | 0
13361478 | 3.NP_SO-102 | 4157.65 | 0.0004908 | 0.326541 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3402.69 | 3390.19 | 3390.19 | 3377.69 | 3390.19 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11380.5 | PP–RCT S4 | 25 | 316 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4157.65 | ø25 | 19.4 | TR10.03.1303 | 1303 | no | WS_Teplá vnitřní 83 | 0
13361598 | 3.NP_SO-102 | 400.677 | 0.0004908 | 0.0314691 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11340.3 | PP–RCT S4 | 25 | 113 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 400.677 | ø25 | 19.4 | TR10.03.1304 | 1304 | no | WS_Studená vnitřní 134 | 0
13370507 | -1.PP_SO-102 | 805.075 | 0.000314112 | 0.0505844 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3235.94 | 3225.94 | 3225.94 | 3215.94 | 3225.94 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | -781.762 | PP–RCT S4 | 20 | 91 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 805.075 | ø20 | 15.4 | TR10.03.1314 | 1314 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13370523 | -1.PP_SO-102 | 692.054 | 0.000314112 | 0.043483 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3235.94 | 3225.94 | 3225.94 | 3215.94 | 3225.94 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | -781.762 | PP–RCT S4 | 20 | 91 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 692.054 | ø20 | 15.4 | TR10.03.1315 | 1315 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13370562 | -1.PP_SO-102 | 678.725 | 0.0004908 | 0.0533069 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3238.44 | 3225.94 | 3225.94 | 3213.44 | 3225.94 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | -783.762 | PP–RCT S4 | 25 | 202 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 678.725 | ø25 | 19.4 | TR10.03.1316 | 1316 | no | WS_Studená vnitřní 6 | 0
13370578 | -1.PP_SO-102 | 4559.36 | 0.0004908 | 0.358091 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3238.44 | 3225.94 | 3225.94 | 3213.44 | 3225.94 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | -783.762 | PP–RCT S4 | 25 | 202 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4559.36 | ø25 | 19.4 | TR10.03.1317 | 1317 | no | WS_Studená vnitřní 6 | 0
13370615 | -1.PP_SO-102 | 558.725 | 0.0004908 | 0.0438822 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3238.09 | 3225.59 | 3225.59 | 3213.09 | 3225.59 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | -784.112 | PP–RCT S4 | 25 | 202 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 558.725 | ø25 | 19.4 | TR10.03.1318 | 1318 | no | WS_Teplá vnitřní 8 | 0
13370629 | -1.PP_SO-102 | 4799.36 | 0.0004908 | 0.376941 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3238.09 | 3225.59 | 3225.59 | 3213.09 | 3225.59 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | -784.112 | PP–RCT S4 | 25 | 202 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4799.36 | ø25 | 19.4 | TR10.03.1319 | 1319 | no | WS_Teplá vnitřní 8 | 0
13401657 | -1.PP_SO-102 | 3328.85 | 0.0004908 | 0.261447 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3312.5 | 3300 | 3300 | 3287.5 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -709.7 | PP–RCT S4 | 25 | 427 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3328.85 | ø25 | 19.4 | TR10.03.1323 | 1323 | no | WS_Teplá vnitřní 83 | 0
13401665 | -1.PP_SO-102 | 3372.38 | 0.0004908 | 0.264866 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3312.5 | 3300 | 3300 | 3287.5 | 3300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -709.7 | PP–RCT S4 | 25 | 487 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3372.38 | ø25 | 19.4 | TR10.03.1324 | 1324 | no | WS_Studená vnitřní 134 | 0
13401936 | 2.NP_SO-102 | 351.689 | 0.0004908 | 0.0276216 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2416.24 | 2403.74 | 2403.74 | 2391.24 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6394.04 | PP–RCT S4 | 25 | 168 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 351.689 | ø25 | 19.4 | TR10.03.1325 | 1325 | no | WS_Studená vnitřní 134 | 0
13401981 | 2.NP_SO-102 | 1495.36 | 0.0004908 | 0.117445 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 1312.5 | 1300 | 1300 | 1287.5 | 1300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5290.3 | PP–RCT S4 | 25 | 436 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1495.36 | ø25 | 19.4 | TR10.03.1326 | 1326 | no | WS_Studená vnitřní 134 | 0
13401996 | 2.NP_SO-102 | 1044.21 | 0.0004908 | 0.0820119 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2364.85 | 1320.64 | 2364.85 | 1320.64 | 2364.85 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5320.64 | PP–RCT S4 | 25 | 436 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1044.21 | ø25 | 19.4 | TR10.03.1327 | 1327 | no | WS_Studená vnitřní 134
13401999 | 2.NP_SO-102 | 2710.13 | 0.000804127 | 0.272452 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 52 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2710.13 | ø32 | 24.8 | TR10.03.1328 | 1328 | no | WS_Studená vnitřní 134 | 0
13402053 | 2.NP_SO-102 | 1431.9 | 0.0004908 | 0.112461 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 1312.5 | 1300 | 1300 | 1287.5 | 1300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5290.3 | PP–RCT S4 | 25 | 304 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1431.9 | ø25 | 19.4 | TR10.03.1329 | 1329 | no | WS_Teplá vnitřní 83 | 0
13402066 | 2.NP_SO-102 | 1040.47 | 0.0004908 | 0.0817182 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2361.11 | 1320.64 | 2361.11 | 1320.64 | 2361.11 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5320.64 | PP–RCT S4 | 25 | 304 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1040.47 | ø25 | 19.4 | TR10.03.1330 | 1330 | no | WS_Teplá vnitřní 83
13402069 | 2.NP_SO-102 | 1860.78 | 0.000804127 | 0.187066 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2416 | 2400 | 2400 | 2384 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6387.6 | PP–RCT S4 | 32 | 302 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1860.78 | ø32 | 24.8 | TR10.03.1331 | 1331 | no | WS_Teplá vnitřní 83 | 0
13402112 | 2.NP_SO-102 | 461.366 | 0.0004908 | 0.0362356 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 1312.5 | 1300 | 1300 | 1287.5 | 1300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5290.3 | PP–RCT S4 | 25 | 436 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 461.366 | ø25 | 19.4 | TR10.03.1332 | 1332 | no | WS_Studená vnitřní 134 | 0
13402128 | 2.NP_SO-102 | 385.46 | 0.0004908 | 0.030274 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 1312.5 | 1300 | 1300 | 1287.5 | 1300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5290.3 | PP–RCT S4 | 25 | 304 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 385.46 | ø25 | 19.4 | TR10.03.1333 | 1333 | no | WS_Teplá vnitřní 83 | 0
13402163 | 2.NP_SO-102 | 363.446 | 0.000314112 | 0.022836 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2413.41 | 2403.41 | 2403.41 | 2393.41 | 2403.41 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6395.71 | PP–RCT S4 | 20 | 349 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 363.446 | ø20 | 15.4 | TR10.03.1334 | 1334 | no | WS_Studená vnitřní 134 | 0
13402183 | 2.NP_SO-102 | 413.634 | 0.000314112 | 0.0259894 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2409.64 | 2399.64 | 2399.64 | 2389.64 | 2399.64 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6391.94 | PP–RCT S4 | 20 | 301 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 413.634 | ø20 | 15.4 | TR10.03.1335 | 1335 | no | WS_Teplá vnitřní 83 | 0
13402207 | 2.NP_SO-102 | 230.317 | 0.000314112 | 0.0144712 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2410 | 2400 | 2400 | 2390 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6392.3 | PP–RCT S4 | 20 | 225 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 230.317 | ø20 | 15.4 | TR10.03.1336 | 1336 | no | WS_Teplá vnitřní 83 | 0
13402293 | 2.NP_SO-102 | 339.852 | 0.000804127 | 0.0341656 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2416 | 2400 | 2400 | 2384 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6387.6 | PP–RCT S4 | 32 | 342 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 339.852 | ø32 | 24.8 | TR10.03.1337 | 1337 | no | WS_Teplá vnitřní 83 | 0
13402491 | 2.NP_SO-102 | 419.925 | 0.000804127 | 0.0422155 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2416 | 2400 | 2400 | 2384 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6387.6 | PP–RCT S4 | 32 | 299 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 419.925 | ø32 | 24.8 | TR10.03.1338 | 1338 | no | WS_Teplá vnitřní 83 | 0
13402507 | 2.NP_SO-102 | 373.444 | 0.000804127 | 0.0375427 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 416 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 373.444 | ø32 | 24.8 | TR10.03.1339 | 1339 | no | WS_Studená vnitřní 134 | 0
13402542 | 2.NP_SO-102 | 1709.21 | 0.000314112 | 0.107393 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2410 | 2400 | 2400 | 2390 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | 6392.3 | PP–RCT S4 | 20 | 2 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1709.21 | ø20 | 15.4 | TR10.03.1340 | 1340 | no | WS_Cirkulace vnitřní 9 | 0
13464830 | 2.NP_SO-102 | 357.807 | 0.0004908 | 0.0281021 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2412.5 | 2400 | 2400 | 2387.5 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6390.3 | PP–RCT S4 | 25 | 233 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 357.807 | ø25 | 19.4 | TR10.03.1415 | 1415 | no | WS_Teplá vnitřní 83 | 0
13464892 | 2.NP_SO-102 | 1593.26 | 0.000314112 | 0.100107 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2413.74 | 2403.74 | 2403.74 | 2393.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6396.04 | PP–RCT S4 | 20 | 164 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1593.26 | ø20 | 15.4 | TR10.03.1416 | 1416 | no | WS_Studená vnitřní 134 | 0
13473797 | 2.NP_SO-102 | 276.188 | 0.000804127 | 0.0277654 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2074.79 | 2058.79 | 2058.79 | 2042.79 | 2058.79 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6046.39 | PP–RCT S4 | 32 | 428 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 276.188 | ø32 | 24.8 | TR10.03.1427 | 1427 | no | WS_Studená vnitřní 134 | 0
13473800 | 2.NP_SO-102 | 604.813 | 0.000804127 | 0.0608025 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2034.98 | 2034.98 | 1430.16 | 1430.16 | 1430.16 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5430.16 | PP–RCT S4 | 32 | 428 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 604.813 | ø32 | 24.8 | TR10.03.1428 | 1428 | no | WS_Studená vnitřní 134
13473803 | 2.NP_SO-102 | 2213.55 | 0.000314112 | 0.139081 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1410 | 1400 | 1400 | 1390 | 1400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5392.3 | PP–RCT S4 | 20 | 427 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2213.55 | ø20 | 15.4 | TR10.03.1429 | 1429 | no | WS_Studená vnitřní 134 | 0
13473813 | 2.NP_SO-102 | 322.669 | 0.000804127 | 0.0324382 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2074.79 | 2058.79 | 2058.79 | 2042.79 | 2058.79 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6046.39 | PP–RCT S4 | 32 | 310 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 322.669 | ø32 | 24.8 | TR10.03.1430 | 1430 | no | WS_Teplá vnitřní 83 | 0
13473815 | 2.NP_SO-102 | 604.813 | 0.000804127 | 0.0608025 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2034.98 | 2034.98 | 1430.16 | 1430.16 | 1430.16 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5430.16 | PP–RCT S4 | 32 | 310 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 604.813 | ø32 | 24.8 | TR10.03.1431 | 1431 | no | WS_Teplá vnitřní 83
13473818 | 2.NP_SO-102 | 2037.96 | 0.000314112 | 0.128049 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1410 | 1400 | 1400 | 1390 | 1400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5392.3 | PP–RCT S4 | 20 | 307 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2037.96 | ø20 | 15.4 | TR10.03.1432 | 1432 | no | WS_Teplá vnitřní 83 | 0
13473837 | 2.NP_SO-102 | 1675.17 | 0.000314112 | 0.105254 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2413.74 | 2403.74 | 2403.74 | 2393.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6396.04 | PP–RCT S4 | 20 | 430 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1675.17 | ø20 | 15.4 | TR10.03.1433 | 1433 | no | WS_Studená vnitřní 134 | 0 | Identifikační data - Komentáře: Vyhřívaný výdejní pult
13473841 | 2.NP_SO-102 | 3411.79 | 0.000804127 | 0.342991 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 414 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3411.79 | ø32 | 24.8 | TR10.03.1434 | 1434 | no | WS_Studená vnitřní 134 | 0
13473855 | 2.NP_SO-102 | 1283.44 | 0.000314112 | 0.0806409 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2413.74 | 2403.74 | 2403.74 | 2393.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6396.04 | PP–RCT S4 | 20 | 432 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1283.44 | ø20 | 15.4 | TR10.03.1435 | 1435 | no | WS_Studená vnitřní 134 | 0 | Identifikační data - Komentáře: Konvektomat
13473874 | 2.NP_SO-102 | 742.987 | 0.000804127 | 0.0746932 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 359 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 742.987 | ø32 | 24.8 | TR10.03.1436 | 1436 | no | WS_Studená vnitřní 134 | 0
13473888 | 2.NP_SO-102 | 5077.14 | 0.000804127 | 0.51041 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2416 | 2400 | 2400 | 2384 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6387.6 | PP–RCT S4 | 32 | 335 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5077.14 | ø32 | 24.8 | TR10.03.1437 | 1437 | no | WS_Teplá vnitřní 83 | 0
13473891 | 2.NP_SO-102 | 267.456 | 0.000314112 | 0.0168048 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2012.33 | 2002.33 | 2002.33 | 1992.33 | 2002.33 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5994.63 | PP–RCT S4 | 20 | 326 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 267.456 | ø20 | 15.4 | TR10.03.1438 | 1438 | no | WS_Teplá vnitřní 83 | 0
13473893 | 2.NP_SO-102 | 530.889 | 0.000314112 | 0.0333568 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1969.78 | 1969.78 | 1438.89 | 1438.89 | 1438.89 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5438.89 | PP–RCT S4 | 20 | 324 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 530.889 | ø20 | 15.4 | TR10.03.1439 | 1439 | no | WS_Teplá vnitřní 83
13473896 | 2.NP_SO-102 | 1984.14 | 0.0004908 | 0.155834 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 1412.5 | 1400 | 1400 | 1387.5 | 1400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5390.3 | PP–RCT S4 | 25 | 221 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1984.14 | ø25 | 19.4 | TR10.03.1440 | 1440 | no | WS_Teplá vnitřní 83 | 0
13473911 | 2.NP_SO-102 | 229.706 | 0.000804127 | 0.0230926 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2018.33 | 2002.33 | 2002.33 | 1986.33 | 2002.33 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5989.93 | PP–RCT S4 | 32 | 366 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 229.706 | ø32 | 24.8 | TR10.03.1441 | 1441 | no | WS_Studená vnitřní 134 | 0
13473914 | 2.NP_SO-102 | 548.352 | 0.000804127 | 0.0551263 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 1978.51 | 1978.51 | 1430.16 | 1430.16 | 1430.16 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5430.16 | PP–RCT S4 | 32 | 366 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 548.352 | ø32 | 24.8 | TR10.03.1442 | 1442 | no | WS_Studená vnitřní 134
13473917 | 2.NP_SO-102 | 1955.7 | 0.0004908 | 0.1536 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 1412.5 | 1400 | 1400 | 1387.5 | 1400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5390.3 | PP–RCT S4 | 25 | 77 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1955.7 | ø25 | 19.4 | TR10.03.1443 | 1443 | no | WS_Studená vnitřní 134 | 0
13473935 | 2.NP_SO-102 | 884.15 | 0.000804127 | 0.0888845 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 518 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 884.15 | ø32 | 24.8 | TR10.03.1444 | 1444 | no | WS_Studená vnitřní 134 | 0
13473955 | 2.NP_SO-102 | 17.8585 | 0.000804127 | 0.00179533 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2420.7 | 2404.7 | 2404.34 | 2388.35 | 2404.34 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.94 | PP–RCT S4 | 32 | 346 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 17.8585 | ø32 | 24.8 | TR10.03.1445 | 1445 | no | WS_Studená vnitřní 134 | 2
13473956 | 2.NP_SO-102 | 29.4517 | 0.000804127 | 0.00296081 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2444.07 | 2432.87 | 2411.84 | 2400.64 | 2411.84 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6403.16 | PP–RCT S4 | 32 | 346 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 29.4517 | ø32 | 24.8 | TR10.03.1446 | 1446 | no | WS_Studená vnitřní 134 | 102.02
13473960 | 2.NP_SO-102 | 1210.24 | 0.000804127 | 0.121667 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 516 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1210.24 | ø32 | 24.8 | TR10.03.1447 | 1447 | no | WS_Studená vnitřní 134 | 0
13473973 | 2.NP_SO-102 | 2861.62 | 0.000804127 | 0.287682 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2416 | 2400 | 2400 | 2384 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6387.6 | PP–RCT S4 | 32 | 338 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2861.62 | ø32 | 24.8 | TR10.03.1448 | 1448 | no | WS_Teplá vnitřní 83 | 0 | Identifikační data - Komentáře: Myčka
13473980 | 2.NP_SO-102 | 336.188 | 0.000804127 | 0.0337973 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 518 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 336.188 | ø32 | 24.8 | TR10.03.1449 | 1449 | no | WS_Studená vnitřní 134 | 0 | Identifikační data - Komentáře: Nerez stůl s dřezem
13473984 | 2.NP_SO-102 | 230.905 | 0.000804127 | 0.0232131 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2416 | 2400 | 2400 | 2384 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6387.6 | PP–RCT S4 | 32 | 338 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 230.905 | ø32 | 24.8 | TR10.03.1450 | 1450 | no | WS_Teplá vnitřní 83 | 0
13473988 | 2.NP_SO-102 | 3507.56 | 0.000804127 | 0.352619 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 410 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3507.56 | ø32 | 24.8 | TR10.03.1451 | 1451 | no | WS_Studená vnitřní 134 | 0
13473993 | 2.NP_SO-102 | 1010.86 | 0.000804127 | 0.101623 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 34 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1010.86 | ø32 | 24.8 | TR10.03.1452 | 1452 | no | WS_Studená vnitřní 134 | 0
13474010 | 2.NP_SO-102 | 342.945 | 0.000314112 | 0.0215479 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2411.44 | 2399.94 | 2401.44 | 2389.94 | 2401.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6392.24 | PP–RCT S4 | 20 | 330 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 342.945 | ø20 | 15.4 | TR10.03.1453 | 1453 | no | WS_Studená vnitřní 134 | 0.439142
13474013 | 2.NP_SO-102 | 1328.85 | 0.000804127 | 0.13359 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 413 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1328.85 | ø32 | 24.8 | TR10.03.1454 | 1454 | no | WS_Studená vnitřní 134 | 0
13474031 | 2.NP_SO-102 | 2843.29 | 0.000804127 | 0.285839 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 412 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2843.29 | ø32 | 24.8 | TR10.03.1455 | 1455 | no | WS_Studená vnitřní 134 | 0
13474036 | 2.NP_SO-102 | 162.537 | 0.000314112 | 0.0102125 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2409.86 | 2399.86 | 2399.86 | 2389.86 | 2399.86 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6392.16 | PP–RCT S4 | 20 | 330 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 162.537 | ø20 | 15.4 | TR10.03.1456 | 1456 | no | WS_Studená vnitřní 134 | 0
13474040 | 2.NP_SO-102 | 435.062 | 0.000314112 | 0.0273358 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2409.87 | 2399.87 | 2399.87 | 2389.87 | 2399.87 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6392.17 | PP–RCT S4 | 20 | 334 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 435.062 | ø20 | 15.4 | TR10.03.1457 | 1457 | no | WS_Teplá vnitřní 83 | 0
13474044 | 2.NP_SO-102 | 5350.23 | 0.000804127 | 0.537864 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2416 | 2400 | 2400 | 2384 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6387.6 | PP–RCT S4 | 32 | 297 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5350.23 | ø32 | 24.8 | TR10.03.1458 | 1458 | no | WS_Teplá vnitřní 83 | 0
13474051 | 2.NP_SO-102 | 257.681 | 0.000314112 | 0.0161906 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2409.87 | 2399.87 | 2399.87 | 2389.87 | 2399.87 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6392.17 | PP–RCT S4 | 20 | 334 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 257.681 | ø20 | 15.4 | TR10.03.1459 | 1459 | no | WS_Teplá vnitřní 83 | 0
13474061 | 2.NP_SO-102 | 807.267 | 0.000314112 | 0.0507221 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2410.58 | 2400.58 | 2400.58 | 2390.58 | 2400.58 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6392.88 | PP–RCT S4 | 20 | 435 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 807.267 | ø20 | 15.4 | TR10.03.1460 | 1460 | no | WS_Studená vnitřní 134 | 0
13474076 | 2.NP_SO-102 | 4912.03 | 0.000804127 | 0.493811 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 411 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4912.03 | ø32 | 24.8 | TR10.03.1461 | 1461 | no | WS_Studená vnitřní 134 | 0
13474096 | 2.NP_SO-102 | 841.426 | 0.000314112 | 0.0528683 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2409.87 | 2399.87 | 2399.87 | 2389.87 | 2399.87 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6392.17 | PP–RCT S4 | 20 | 337 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 841.426 | ø20 | 15.4 | TR10.03.1462 | 1462 | no | WS_Teplá vnitřní 83 | 0 | Identifikační data - Komentáře: Dřez
13474105 | 2.NP_SO-102 | 2860.64 | 0.000804127 | 0.287583 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2416 | 2400 | 2400 | 2384 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6387.6 | PP–RCT S4 | 32 | 329 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2860.64 | ø32 | 24.8 | TR10.03.1463 | 1463 | no | WS_Teplá vnitřní 83 | 0
13474427 | 2.NP_SO-102 | 406.389 | 0.000314112 | 0.0255342 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2410.58 | 2400.58 | 2400.58 | 2390.58 | 2400.58 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6392.88 | PP–RCT S4 | 20 | 519 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 406.389 | ø20 | 15.4 | TR10.03.1464 | 1464 | no | WS_Studená vnitřní 134 | 0 | Identifikační data - Komentáře: Změkčovač
13474436 | 2.NP_SO-102 | 626.595 | 0.000804127 | 0.0629922 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 517 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 626.595 | ø32 | 24.8 | TR10.03.1465 | 1465 | no | WS_Studená vnitřní 134 | 0
13483680 | 2.NP_SO-102 | 2776.19 | 0.000804127 | 0.279093 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 515 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2776.19 | ø32 | 24.8 | TR10.03.1466 | 1466 | no | WS_Studená vnitřní 134 | 0
13483683 | 2.NP_SO-102 | 1689.89 | 0.000804127 | 0.169886 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 520 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1689.89 | ø32 | 24.8 | TR10.03.1467 | 1467 | no | WS_Studená vnitřní 134 | 0
13483686 | 2.NP_SO-102 | 2756.19 | 0.000804127 | 0.277082 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2416 | 2400 | 2400 | 2384 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6387.6 | PP–RCT S4 | 32 | 344 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2756.19 | ø32 | 24.8 | TR10.03.1468 | 1468 | no | WS_Teplá vnitřní 83 | 0
13483691 | 2.NP_SO-102 | 1795.17 | 0.000804127 | 0.18047 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2416 | 2400 | 2400 | 2384 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6387.6 | PP–RCT S4 | 32 | 342 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1795.17 | ø32 | 24.8 | TR10.03.1469 | 1469 | no | WS_Teplá vnitřní 83 | 0
13484700 | 2.NP_SO-102 | 1550.4 | 0.0004908 | 0.121768 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 2412.5 | 2400 | 2400 | 2387.5 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 6390.3 | PP–RCT S4 | 25 | 35 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1550.4 | ø25 | 19.4 | TR10.03.1470 | 1470 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13485420 | 2.NP_SO-102 | 1736.19 | 0.000804127 | 0.174541 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 515 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1736.19 | ø32 | 24.8 | TR10.03.1474 | 1474 | no | WS_Studená vnitřní 134 | 0 | Identifikační data - Komentáře: Dřez, umyvadlo, myčka, změkčovač, výrobník ledu, kávovar
13485424 | 2.NP_SO-102 | 860 | 0.000804127 | 0.0864566 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2416 | 2400 | 2400 | 2384 | 2400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6387.6 | PP–RCT S4 | 32 | 344 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 860 | ø32 | 24.8 | TR10.03.1475 | 1475 | no | WS_Teplá vnitřní 83 | 0
13485433 | 2.NP_SO-102 | 132.375 | 0.000804127 | 0.0133078 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 515 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 132.375 | ø32 | 24.8 | TR10.03.1476 | 1476 | no | WS_Studená vnitřní 134 | 0
13485437 | 2.NP_SO-102 | 732.375 | 0.000804127 | 0.0736264 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 515 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 732.375 | ø32 | 24.8 | TR10.03.1477 | 1477 | no | WS_Studená vnitřní 134 | 0
13485441 | 2.NP_SO-102 | 47.0921 | 0.000804127 | 0.00473422 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 515 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 47.0921 | ø32 | 24.8 | TR10.03.1478 | 1478 | no | WS_Studená vnitřní 134 | 0
13485445 | 2.NP_SO-102 | 816.187 | 0.000804127 | 0.0820521 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 515 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 816.187 | ø32 | 24.8 | TR10.03.1479 | 1479 | no | WS_Studená vnitřní 134 | 0
13485716 | 4.NP_SO-102 | 2552.38 | 0.000804127 | 0.256593 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15337.6 | PP–RCT S4 | 32 | 386 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2552.38 | ø32 | 24.8 | TR10.03.1480 | 1480 | no | WS_Studená vnitřní 134 | 0
13485754 | 4.NP_SO-102 | 476.188 | 0.000804127 | 0.0478716 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15337.6 | PP–RCT S4 | 32 | 386 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 476.188 | ø32 | 24.8 | TR10.03.1481 | 1481 | no | WS_Studená vnitřní 134 | 0 | Identifikační data - Komentáře: Mobilní pracovní stůl s dřezem
13486136 | 4.NP_SO-102 | 58.7693 | 0.000314112 | 0.00369258 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1010 | 999.94 | 1000 | 989.94 | 1000 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 12992.2 | PP–RCT S4 | 20 | 226 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 58.7693 | ø20 | 15.4 | TR10.03.1482 | 1482 | no | WS_"Jiný typ" studená vnitřní 1 | 0.101346
13486208 | 2.NP_SO-102 | 217.965 | 0.000804127 | 0.0219123 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 2419.74 | 2403.74 | 2403.74 | 2387.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6391.34 | PP–RCT S4 | 32 | 520 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 217.965 | ø32 | 24.8 | TR10.03.1484 | 1484 | no | WS_Studená vnitřní 134 | 0
13486274 | 2.NP_SO-102 | 245.73 | 0.000314112 | 0.0154397 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2409.87 | 2399.87 | 2399.87 | 2389.87 | 2399.87 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6392.17 | PP–RCT S4 | 20 | 337 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 245.73 | ø20 | 15.4 | TR10.03.1485 | 1485 | no | WS_Teplá vnitřní 83 | 0 | Identifikační data - Komentáře: Dřez
13502303 | 2.NP_SO-102 | 571.99 | 0.000314112 | 0.0359392 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2413.74 | 2403.74 | 2403.74 | 2393.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6396.04 | PP–RCT S4 | 20 | 430 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 571.99 | ø20 | 15.4 | TR10.03.1506 | 1506 | no | WS_Studená vnitřní 134 | 0 | Identifikační data - Komentáře: Vyhřívaný výdejní pult
13502430 | 2.NP_SO-102 | 723.661 | 0.000314112 | 0.045469 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2413.74 | 2403.74 | 2403.74 | 2393.74 | 2403.74 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6396.04 | PP–RCT S4 | 20 | 432 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 723.661 | ø20 | 15.4 | TR10.03.1507 | 1507 | no | WS_Studená vnitřní 134 | 0 | Identifikační data - Komentáře: Konvektomat
13502483 | 2.NP_SO-102 | 272.271 | 0.000314112 | 0.0171073 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2409.87 | 2399.87 | 2399.87 | 2389.87 | 2399.87 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 6392.17 | PP–RCT S4 | 20 | 334 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 272.271 | ø20 | 15.4 | TR10.03.1508 | 1508 | no | WS_Teplá vnitřní 83 | 0
13502706 | 2.NP_SO-102 | 430.038 | 0.000314112 | 0.0270201 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2413.57 | 2401.68 | 2403.57 | 2391.68 | 2403.57 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6393.98 | PP–RCT S4 | 20 | 330 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 430.038 | ø20 | 15.4 | TR10.03.1509 | 1509 | no | WS_Studená vnitřní 134 | 0.439142
13502737 | 2.NP_SO-102 | 439.836 | 0.000314112 | 0.0276357 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2410.58 | 2400.58 | 2400.58 | 2390.58 | 2400.58 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 6392.88 | PP–RCT S4 | 20 | 435 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 439.836 | ø20 | 15.4 | TR10.03.1510 | 1510 | no | WS_Studená vnitřní 134 | 0
13507136 | 3.NP_SO-102 | 8.08305 | 0.0004908 | 0.000634841 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3379.16 | 3366.66 | 3366.66 | 3354.16 | 3366.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11357 | PP–RCT S4 | 25 | 158 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 8.08305 | ø25 | 19.4 | TR10.03.1518 | 1518 | no | WS_Teplá vnitřní 83 | 0
13507137 | 3.NP_SO-102 | 9.09793 | 0.0004908 | 0.00071455 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 3370.39 | 3355.11 | 3361.55 | 3346.28 | 3361.55 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 11348.3 | PP–RCT S4 | 25 | 158 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 9.09793 | ø25 | 19.4 | TR10.03.1519 | 1519 | no | WS_Teplá vnitřní 83 | 100
13513876 | -1.PP_SO-102 | 1037.19 | 0.00311678 | 0.205282 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2857.19 | 1820 | 2857.19 | 1820 | 2857.19 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -2180 | PP–RCT S4 | 63 | 368 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1037.19 | ø63 | 48.8 | TR10.03.1520 | 1520 | yes | WS_"Jiný typ" studená vnitřní 1
13513880 | -1.PP_SO-102 | 924.329 | 0.0044172 | 0.21779 | ø75 mm | 0 | Laminární | 0 | 0.000171821 | JB | -1.PP_SO-102 | 1469.77 | 545.438 | 1469.77 | 545.438 | 1469.77 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -3454.56 | PP–RCT S4 | 75 | 510 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 924.329 | ø75 | 58.2 | TR10.03.1521 | 1521 | yes | WS_Studená vnitřní 134
13519784 | 1.NP_SO-102 | 2066.34 | 0.00125645 | 0.259664 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 1.NP_SO-102 | 1393.33 | -673.013 | 1393.33 | -673.013 | 1393.33 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -673.012 | PP–RCT S4 | 40 | 325 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2066.34 | ø40 | 31 | TR10.03.1538 | 1538 | yes | WS_"Jiný typ" studená vnitřní 1
13522750 | 3.NP_SO-102 | 1983.32 | 0.00125645 | 0.249232 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 3.NP_SO-102 | 1216.66 | -766.662 | 1216.66 | -766.662 | 1216.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 7233.34 | PP–RCT S4 | 40 | 350 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1983.32 | ø40 | 31 | TR10.03.1540 | 1540 | yes | WS_Teplá vnitřní 83
13523082 | 4.NP_SO-102 | 1786.19 | 0.000804127 | 0.179567 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3316.35 | 3316.35 | 1530.16 | 1530.16 | 1530.16 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 13530.2 | PP–RCT S4 | 32 | 367 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1786.19 | ø32 | 24.8 | TR10.03.1541 | 1541 | yes | WS_Studená vnitřní 134 | Identifikační data - Komentáře: V2
13523505 | -1.PP_SO-102 | 443.675 | 0.00125645 | 0.0557538 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 3320 | 3300 | 3300 | 3280 | 3300 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -715.5 | PP–RCT S4 | 40 | 484 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 443.675 | ø40 | 31 | TR10.03.1542 | 1542 | yes | WS_Studená vnitřní 134 | 0
13523982 | 1.NP_SO-102 | 363.833 | 0.000804127 | 0.0365765 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 1.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3337.6 | PP–RCT S4 | 32 | 392 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 363.833 | ø32 | 24.8 | TR10.03.1543 | 1543 | yes | WS_Studená vnitřní 134 | 0
13524046 | 1.NP_SO-102 | 1783.32 | 0.00125645 | 0.224099 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 1.NP_SO-102 | 3316.66 | 3316.66 | 1533.34 | 1533.34 | 1533.34 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 1533.34 | PP–RCT S4 | 40 | 365 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1783.32 | ø40 | 31 | TR10.03.1544 | 1544 | yes | WS_Studená vnitřní 134
13524067 | 1.NP_SO-102 | 200.354 | 0.0004908 | 0.0157357 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 1512.5 | 1500 | 1500 | 1487.5 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 1490.3 | PP–RCT S4 | 25 | 394 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 200.354 | ø25 | 19.4 | TR10.03.1545 | 1545 | no | WS_Studená vnitřní 134 | 0
13524082 | 1.NP_SO-102 | 2139.68 | 0.00125645 | 0.268879 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 1.NP_SO-102 | 1466.66 | 1466.66 | -673.013 | -673.013 | -673.013 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -673.012 | PP–RCT S4 | 40 | 131 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2139.68 | ø40 | 31 | TR10.03.1546 | 1546 | yes | WS_Studená vnitřní 134 | Identifikační data - Komentáře: V2
13524144 | 2.NP_SO-102 | 184.341 | 0.0004908 | 0.0144781 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 2.NP_SO-102 | 1512.5 | 1500 | 1500 | 1487.5 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5490.3 | PP–RCT S4 | 25 | 390 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 184.341 | ø25 | 19.4 | TR10.03.1547 | 1547 | no | WS_Studená vnitřní 134 | 0
13524221 | 2.NP_SO-102 | 363.833 | 0.000804127 | 0.0365765 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7337.6 | PP–RCT S4 | 32 | 373 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 363.833 | ø32 | 24.8 | TR10.03.1548 | 1548 | yes | WS_Studená vnitřní 134 | 0
13524338 | 3.NP_SO-102 | 2083.33 | 0.00125645 | 0.261798 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 3.NP_SO-102 | 1466.66 | -616.663 | 1466.66 | -616.663 | 1466.66 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 7383.34 | PP–RCT S4 | 40 | 121 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2083.33 | ø40 | 31 | TR10.03.1549 | 1549 | yes | WS_Studená vnitřní 134 | Identifikační data - Komentáře: V2
13524363 | 2.NP_SO-102 | 2083.33 | 0.00125645 | 0.261798 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 2.NP_SO-102 | 1466.66 | -616.663 | 1466.66 | -616.663 | 1466.66 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 3383.34 | PP–RCT S4 | 40 | 122 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2083.33 | ø40 | 31 | TR10.03.1550 | 1550 | yes | WS_Studená vnitřní 134 | Identifikační data - Komentáře: V2
13524375 | 2.NP_SO-102 | 1783.32 | 0.00125645 | 0.224099 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 2.NP_SO-102 | 3316.66 | 1533.34 | 3316.66 | 1533.34 | 3316.66 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 5533.34 | PP–RCT S4 | 40 | 371 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1783.32 | ø40 | 31 | TR10.03.1551 | 1551 | yes | WS_Studená vnitřní 134
13524400 | 2.NP_SO-102 | 1983.33 | 0.00125645 | 0.249232 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 2.NP_SO-102 | 1216.66 | -766.662 | 1216.66 | -766.662 | 1216.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 3233.34 | PP–RCT S4 | 40 | 351 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1983.33 | ø40 | 31 | TR10.03.1552 | 1552 | yes | WS_Teplá vnitřní 83
13524416 | 2.NP_SO-102 | 1883.33 | 0.00125645 | 0.236666 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | 2.NP_SO-102 | 3166.66 | 1283.34 | 3166.66 | 1283.34 | 3166.66 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | 5283.34 | PP–RCT S4 | 40 | 91 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1883.33 | ø40 | 31 | TR10.03.1553 | 1553 | yes | WS_Teplá vnitřní 83
13524452 | 3.NP_SO-102 | 1776.18 | 0.000804127 | 0.178561 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 3.NP_SO-102 | 3319.84 | 3319.84 | 1543.66 | 1543.66 | 1543.66 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 9543.66 | PP–RCT S4 | 32 | 116 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1776.18 | ø32 | 24.8 | TR10.03.1554 | 1554 | yes | WS_Studená vnitřní 134
13524677 | 3.NP_SO-102 | 35.0752 | 0.0004908 | 0.0027548 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 3.NP_SO-102 | 1512.5 | 1500 | 1500 | 1487.5 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 9490.3 | PP–RCT S4 | 25 | 444 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 35.0752 | ø25 | 19.4 | TR10.03.1555 | 1555 | no | WS_Studená vnitřní 134 | 0
13524865 | 4.NP_SO-102 | 118.03 | 0.000804127 | 0.0118657 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15337.6 | PP–RCT S4 | 32 | 94 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 118.03 | ø32 | 24.8 | TR10.03.1556 | 1556 | yes | WS_Studená vnitřní 134 | 0
13525191 | 4.NP_SO-102 | 104.216 | 0.0004908 | 0.00818511 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 1512.5 | 1500 | 1500 | 1487.5 | 1500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 13490.3 | PP–RCT S4 | 25 | 387 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 104.216 | ø25 | 19.4 | TR10.03.1557 | 1557 | no | WS_Studená vnitřní 134 | 0
13525239 | 4.NP_SO-102 | 2089.68 | 0.000804127 | 0.210077 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 1469.84 | 1469.84 | -619.838 | -619.838 | -619.838 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 11380.2 | PP–RCT S4 | 32 | 384 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2089.68 | ø32 | 24.8 | TR10.03.1558 | 1558 | yes | WS_Studená vnitřní 134 | Identifikační data - Komentáře: V2
13525260 | 4.NP_SO-102 | 368.596 | 0.000804127 | 0.0370553 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3356.16 | 3340.16 | 3340.16 | 3324.16 | 3340.16 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15327.8 | PP–RCT S4 | 32 | 367 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 368.596 | ø32 | 24.8 | TR10.03.1559 | 1559 | yes | WS_Studená vnitřní 134 | 0
13525273 | 4.NP_SO-102 | 13909.2 | 0.000804127 | 1.39831 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3366 | 3350 | 3350 | 3334 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | 15337.6 | PP–RCT S4 | 32 | 386 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 13909.2 | ø32 | 24.8 | TR10.03.1560 | 1560 | yes | WS_Studená vnitřní 134 | 0
