Properties of the parts of a building model (IFC4), part 50 of 60

# IfcPipeSegment: Typy trubek:PP-RCT (1338)
Name (Typy trubek:PP-RCT:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Instalační jednotky = Reynoldsovo číslo = Třecí faktor = Tření = Průtok (m3/s) = Rychlost (m/s) = Tlaková ztráta (Pa) | Stav průtoku | Doplňkový průtok (m3/s) | Relativní drsnost | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) | Spodní výška (mm) | Střední výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Délka (mm) | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
13035976 | -1.PP_SO-102 | 2606.97 | 0.0019632 | 0.409502 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 2674.95 | 2649.95 | 2649.95 | 2624.95 | 2649.95 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | -1369.45 | PP–RCT S4 | 50 | 8 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2606.97 | ø50 | 38.8 | TR10.03.0834 | 0834 | yes | WS_Teplá vnitřní 8 | 0
13036005 | -1.PP_SO-102 | 2612.34 | 0.000804127 | 0.262621 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 2666 | 2650 | 2650 | 2634 | 2650 | Fáze 2 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 3 | -1362.4 | PP–RCT S4 | 32 | 2 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2612.34 | ø32 | 24.8 | TR10.03.0835 | 0835 | yes | WS_Cirkulace vnitřní 3 | 0
13036024 | -1.PP_SO-102 | 2645.66 | 0.0004908 | 0.20779 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3238.44 | 3225.94 | 3225.94 | 3213.44 | 3225.94 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | -783.762 | PP–RCT S4 | 25 | 205 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2645.66 | ø25 | 19.4 | TR10.03.0836 | 0836 | yes | WS_Studená vnitřní 6 | 0
13036032 | -1.PP_SO-102 | 2557.47 | 0.0019632 | 0.401726 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 2674.8 | 2649.8 | 2649.8 | 2624.8 | 2649.8 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | -1369.6 | PP–RCT S4 | 50 | 170 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2557.47 | ø50 | 38.8 | TR10.03.0837 | 0837 | yes | WS_Studená vnitřní 6 | 0
13036051 | -1.PP_SO-102 | 2542.5 | 0.000314112 | 0.15975 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3235.94 | 3225.94 | 3225.94 | 3215.94 | 3225.94 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | -781.762 | PP–RCT S4 | 20 | 91 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2542.5 | ø20 | 15.4 | TR10.03.0838 | 0838 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 0
13036061 | -1.PP_SO-102 | 2552.54 | 0.00125645 | 0.320761 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 2670 | 2650 | 2650 | 2630 | 2650 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | -1365.5 | PP–RCT S4 | 40 | 49 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2552.54 | ø40 | 31 | TR10.03.0839 | 0839 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 0
13036130 | -1.PP_SO-102 | 11245.2 | 0.0004908 | 0.883196 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3238.09 | 3225.59 | 3225.59 | 3213.09 | 3225.59 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | -784.112 | PP–RCT S4 | 25 | 205 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 11245.2 | ø25 | 19.4 | TR10.03.0840 | 0840 | yes | WS_Teplá vnitřní 8 | 0
13036226 | -1.PP_SO-102 | 10854.3 | 0.0004908 | 0.852496 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3238.44 | 3225.94 | 3225.94 | 3213.44 | 3225.94 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | -783.762 | PP–RCT S4 | 25 | 205 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 10854.3 | ø25 | 19.4 | TR10.03.0841 | 0841 | yes | WS_Studená vnitřní 6 | 0
13036272 | -1.PP_SO-102 | 10601.6 | 0.000314112 | 0.666119 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3235.94 | 3225.94 | 3225.94 | 3215.94 | 3225.94 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | -781.762 | PP–RCT S4 | 20 | 91 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 10601.6 | ø20 | 15.4 | TR10.03.0842 | 0842 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 0
13036771 | 4.NP_SO-102 | 548.036 | 0.000804127 | 0.0550945 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 4.NP_SO-102 | 3260.93 | 3244.93 | 3244.93 | 3228.93 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 15232.5 | PP–RCT S4 | 32 | 56 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 548.036 | ø32 | 24.8 | TR10.03.0843 | 0843 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 0
13036822 | 3.NP_SO-102 | 179.458 | 0.000314112 | 0.0112757 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 3254.93 | 3244.93 | 3244.93 | 3234.93 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 11237.2 | PP–RCT S4 | 20 | 67 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 179.458 | ø20 | 15.4 | TR10.03.0844 | 0844 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 0
13036864 | 2.NP_SO-102 | 162.227 | 0.000804127 | 0.0163088 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | 2.NP_SO-102 | 3260.93 | 3244.93 | 3244.93 | 3228.93 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 7232.53 | PP–RCT S4 | 32 | 77 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 162.227 | ø32 | 24.8 | TR10.03.0845 | 0845 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 0
13036904 | 1.NP_SO-102 | 163.814 | 0.0004908 | 0.012866 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3257.43 | 3244.93 | 3244.93 | 3232.43 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 3235.23 | PP–RCT S4 | 25 | 80 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 163.814 | ø25 | 19.4 | TR10.03.0846 | 0846 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 0
13040166 | 4.NP_SO-102 | 1776.76 | 0.000314112 | 0.111637 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1436.66 | 1426.66 | 1426.66 | 1416.66 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 13419 | PP–RCT S4 | 20 | 47 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1776.76 | ø20 | 15.4 | TR10.03.0847 | 0847 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13046547 | 4.NP_SO-102 | 23.721 | 0.000314112 | 0.00149043 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 13242.3 | PP–RCT S4 | 20 | 8 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 23.721 | ø20 | 15.4 | TR10.03.0848 | 0848 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13046550 | 4.NP_SO-102 | 2312.61 | 0.0004908 | 0.181632 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 1262.5 | 1250 | 1250 | 1237.5 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 13240.3 | PP–RCT S4 | 25 | 52 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2312.61 | ø25 | 19.4 | TR10.03.0849 | 0849 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13046553 | 4.NP_SO-102 | 29.5333 | 0.000314112 | 0.00185563 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 13242.3 | PP–RCT S4 | 20 | 8 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 29.5333 | ø20 | 15.4 | TR10.03.0850 | 0850 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13046556 | 3.NP_SO-102 | 30.8647 | 0.000314112 | 0.00193929 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 22 | 9242.3 | PP–RCT S4 | 20 | 8 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 30.8647 | ø20 | 15.4 | TR10.03.0851 | 0851 | no | WS_"ŠEDÁ" studená vnitřní 22 | 0
13046560 | 3.NP_SO-102 | 29.5333 | 0.000314112 | 0.00185563 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 22 | 9242.3 | PP–RCT S4 | 20 | 8 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 29.5333 | ø20 | 15.4 | TR10.03.0852 | 0852 | no | WS_"ŠEDÁ" studená vnitřní 22 | 0
13046565 | 2.NP_SO-102 | 40.8647 | 0.000314112 | 0.00256761 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 23 | 5242.3 | PP–RCT S4 | 20 | 8 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 40.8647 | ø20 | 15.4 | TR10.03.0853 | 0853 | no | WS_"ŠEDÁ" studená vnitřní 23 | 0
13046569 | 2.NP_SO-102 | 36.0333 | 0.000314112 | 0.00226404 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 23 | 5242.3 | PP–RCT S4 | 20 | 8 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 36.0333 | ø20 | 15.4 | TR10.03.0854 | 0854 | no | WS_"ŠEDÁ" studená vnitřní 23 | 0
13046574 | 1.NP_SO-102 | 30.8647 | 0.000314112 | 0.00193929 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 24 | 1242.3 | PP–RCT S4 | 20 | 8 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 30.8647 | ø20 | 15.4 | TR10.03.0855 | 0855 | no | WS_"ŠEDÁ" studená vnitřní 24 | 0
13046578 | 1.NP_SO-102 | 29.5333 | 0.000314112 | 0.00185563 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 1260 | 1250 | 1250 | 1240 | 1250 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 24 | 1242.3 | PP–RCT S4 | 20 | 8 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 29.5333 | ø20 | 15.4 | TR10.03.0856 | 0856 | no | WS_"ŠEDÁ" studená vnitřní 24 | 0
13046712 | -1.PP_SO-102 | 2451.55 | 0.00311678 | 0.485211 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2928.13 | 2896.63 | 2896.63 | 2865.13 | 2896.63 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1127.77 | PP–RCT S4 | 63 | 368 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2451.55 | ø63 | 48.8 | TR10.03.0857 | 0857 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13046757 | -1.PP_SO-102 | 1244.55 | 0.000314112 | 0.0781977 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 2610 | 2600 | 2600 | 2590 | 2600 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1407.7 | PP–RCT S4 | 20 | 354 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1244.55 | ø20 | 15.4 | TR10.03.0858 | 0858 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13046787 | -1.PP_SO-102 | 752.58 | 0.000314112 | 0.047286 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 2610 | 2600 | 2600 | 2590 | 2600 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1407.7 | PP–RCT S4 | 20 | 354 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 752.58 | ø20 | 15.4 | TR10.03.0859 | 0859 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13047019 | -1.PP_SO-102 | 1086.55 | 0.000314112 | 0.06827 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3110 | 3100 | 3100 | 3090 | 3100 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -907.7 | PP–RCT S4 | 20 | 64 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1086.55 | ø20 | 15.4 | TR10.03.0860 | 0860 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13047045 | -1.PP_SO-102 | 277.988 | 0.000314112 | 0.0174665 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3110 | 3100 | 3100 | 3090 | 3100 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -907.7 | PP–RCT S4 | 20 | 64 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 277.988 | ø20 | 15.4 | TR10.03.0861 | 0861 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13047254 | -1.PP_SO-102 | 1871.9 | 0.0019632 | 0.294037 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 2625 | 2600 | 2600 | 2575 | 2600 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1419.4 | PP–RCT S4 | 50 | 237 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1871.9 | ø50 | 38.8 | TR10.03.0862 | 0862 | yes | WS_Studená vnitřní 134 | 0
13047270 | -1.PP_SO-102 | 1871.9 | 0.0019632 | 0.294037 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 2625 | 2600 | 2600 | 2575 | 2600 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1419.4 | PP–RCT S4 | 50 | 264 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1871.9 | ø50 | 38.8 | TR10.03.0863 | 0863 | yes | WS_Teplá vnitřní 83 | 0
13047314 | -1.PP_SO-102 | 1892.42 | 0.000804127 | 0.190247 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 2616 | 2600 | 2600 | 2584 | 2600 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1412.4 | PP–RCT S4 | 32 | 204 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1892.42 | ø32 | 24.8 | TR10.03.0864 | 0864 | yes | WS_Cirkulace vnitřní 9 | 0
13047348 | -1.PP_SO-102 | 146.113 | 0.00125645 | 0.0183612 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 2620 | 2600 | 2600 | 2580 | 2600 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1415.5 | PP–RCT S4 | 40 | 151 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 146.113 | ø40 | 31 | TR10.03.0865 | 0865 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13047371 | -1.PP_SO-102 | 136.856 | 0.0019632 | 0.0214973 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 2625 | 2600 | 2600 | 2575 | 2600 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1419.4 | PP–RCT S4 | 50 | 237 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 136.856 | ø50 | 38.8 | TR10.03.0866 | 0866 | yes | WS_Studená vnitřní 134 | 0
13047397 | -1.PP_SO-102 | 152.618 | 0.000804127 | 0.0153429 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 2616 | 2600 | 2600 | 2584 | 2600 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1412.4 | PP–RCT S4 | 32 | 204 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 152.618 | ø32 | 24.8 | TR10.03.0867 | 0867 | yes | WS_Cirkulace vnitřní 9 | 0
13047440 | -1.PP_SO-102 | 136.856 | 0.0019632 | 0.0214973 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 2625 | 2600 | 2600 | 2575 | 2600 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1419.4 | PP–RCT S4 | 50 | 264 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 136.856 | ø50 | 38.8 | TR10.03.0868 | 0868 | yes | WS_Teplá vnitřní 83 | 0
13047825 | -1.PP_SO-102 | 919.866 | 0.0004908 | 0.0722461 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 2512.5 | 2500 | 2500 | 2487.5 | 2500 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1509.7 | PP–RCT S4 | 25 | 479 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 919.866 | ø25 | 19.4 | TR10.03.0869 | 0869 | no | WS_Studená vnitřní 134 | 0
13048110 | -1.PP_SO-102 | 158.725 | 0.0004908 | 0.0124662 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3279.36 | 3120.64 | 3279.36 | 3120.64 | 3279.36 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -879.363 | PP–RCT S4 | 25 | 401 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 158.725 | ø25 | 19.4 | TR10.03.0870 | 0870 | yes | WS_Teplá vnitřní 83
13048158 | -1.PP_SO-102 | 152.375 | 0.000804127 | 0.0153184 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3276.19 | 3123.81 | 3276.19 | 3123.81 | 3276.19 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 4 | -876.188 | PP–RCT S4 | 32 | 52 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 152.375 | ø32 | 24.8 | TR10.03.0871 | 0871 | yes | WS_Cirkulace vnitřní 4
13048235 | -1.PP_SO-102 | 42.2693 | 0.0004908 | 0.00331982 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3162.91 | 3120.64 | 3162.91 | 3120.64 | 3162.91 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -879.363 | PP–RCT S4 | 25 | 249 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 42.2693 | ø25 | 19.4 | TR10.03.0872 | 0872 | yes | WS_Studená vnitřní 134
13048363 | -1.PP_SO-102 | 120.206 | 0.000314112 | 0.00755278 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3237.67 | 3117.46 | 3237.67 | 3117.46 | 3237.67 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -882.538 | PP–RCT S4 | 20 | 64 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 120.206 | ø20 | 15.4 | TR10.03.0873 | 0873 | yes | WS_"Jiný typ" studená vnitřní 1
13048593 | -1.PP_SO-102 | 3298.63 | 0.0044172 | 0.777221 | ø75 mm | 0 | Laminární | 0 | 0.000171821 | JB | -1.PP_SO-102 | 2934.13 | 2896.63 | 2896.63 | 2859.13 | 2896.63 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1132.47 | PP–RCT S4 | 75 | 316 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3298.63 | ø75 | 58.2 | TR10.03.0874 | 0874 | yes | WS_Studená vnitřní 134 | 0
13048622 | -1.PP_SO-102 | 13185 | 0.0019632 | 2.0711 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3251.44 | 3226.44 | 3226.44 | 3201.44 | 3226.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -792.963 | PP–RCT S4 | 50 | 357 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 13185 | ø50 | 38.8 | TR10.03.0875 | 0875 | yes | WS_Studená vnitřní 134 | 0
13048702 | -1.PP_SO-102 | 14061.2 | 0.0019632 | 2.20873 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3325 | 3300 | 3300 | 3275 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -719.4 | PP–RCT S4 | 50 | 215 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 14061.2 | ø50 | 38.8 | TR10.03.0876 | 0876 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13049018 | -1.PP_SO-102 | 13304.1 | 0.0019632 | 2.0898 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3325 | 3300 | 3300 | 3275 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -719.4 | PP–RCT S4 | 50 | 402 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 13304.1 | ø50 | 38.8 | TR10.03.0877 | 0877 | yes | WS_Teplá vnitřní 83 | 0
13069471 | -1.PP_SO-102 | 282.295 | 0.000314112 | 0.0177371 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -657.7 | PP–RCT S4 | 20 | 261 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 282.295 | ø20 | 15.4 | TR10.03.0878 | 0878 | no | WS_Teplá vnitřní 83 | 0
13069677 | -1.PP_SO-102 | 1845.56 | 0.0004908 | 0.14495 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 1012.5 | 1000 | 1000 | 987.5 | 1000 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -3009.7 | PP–RCT S4 | 25 | 436 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1845.56 | ø25 | 19.4 | TR10.03.0879 | 0879 | no | WS_Teplá vnitřní 83 | 0
13069705 | -1.PP_SO-102 | 4539.09 | 0.0004908 | 0.356499 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 2912.5 | 2900 | 2900 | 2887.5 | 2900 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1109.7 | PP–RCT S4 | 25 | 499 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4539.09 | ø25 | 19.4 | TR10.03.0880 | 0880 | no | WS_Studená vnitřní 134 | 0
13070212 | 4.NP_SO-102 | 226.352 | 0.000314112 | 0.0142221 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1436.66 | 1426.66 | 1426.66 | 1416.66 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 13419 | PP–RCT S4 | 20 | 47 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 226.352 | ø20 | 15.4 | TR10.03.0881 | 0881 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13070251 | 4.NP_SO-102 | 78.4058 | 0.000314112 | 0.00492638 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1436.66 | 1426.66 | 1426.66 | 1416.66 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 13419 | PP–RCT S4 | 20 | 47 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 78.4058 | ø20 | 15.4 | TR10.03.0882 | 0882 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13070299 | 4.NP_SO-102 | 109.358 | 0.000314112 | 0.00687114 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 1436.66 | 1426.66 | 1426.66 | 1416.66 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 13419 | PP–RCT S4 | 20 | 47 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 109.358 | ø20 | 15.4 | TR10.03.0883 | 0883 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13070618 | 3.NP_SO-102 | 87.7241 | 0.000314112 | 0.00551186 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1436.66 | 1426.66 | 1426.66 | 1416.66 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 3 | 9418.96 | PP–RCT S4 | 20 | 7 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 87.7241 | ø20 | 15.4 | TR10.03.0884 | 0884 | no | WS_"ŠEDÁ" studená vnitřní 3 | 0
13070640 | 3.NP_SO-102 | 253.352 | 0.000314112 | 0.0159186 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1436.66 | 1426.66 | 1426.66 | 1416.66 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 3 | 9418.96 | PP–RCT S4 | 20 | 7 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 253.352 | ø20 | 15.4 | TR10.03.0885 | 0885 | no | WS_"ŠEDÁ" studená vnitřní 3 | 0
13070675 | 3.NP_SO-102 | 37.3811 | 0.000314112 | 0.00234872 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 3.NP_SO-102 | 1436.66 | 1426.66 | 1426.66 | 1416.66 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 3 | 9418.96 | PP–RCT S4 | 20 | 7 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 37.3811 | ø20 | 15.4 | TR10.03.0886 | 0886 | no | WS_"ŠEDÁ" studená vnitřní 3 | 0
13070844 | 2.NP_SO-102 | 70.5254 | 0.000314112 | 0.00443124 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1436.66 | 1426.66 | 1426.66 | 1416.66 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5418.96 | PP–RCT S4 | 20 | 10 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 70.5254 | ø20 | 15.4 | TR10.03.0887 | 0887 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13071007 | 1.NP_SO-102 | 1775.6 | 0.000314112 | 0.111564 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 1436.66 | 1426.66 | 1426.66 | 1416.66 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 1418.96 | PP–RCT S4 | 20 | 15 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1775.6 | ø20 | 15.4 | TR10.03.0888 | 0888 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13071154 | 2.NP_SO-102 | 235.368 | 0.000314112 | 0.0147886 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1436.66 | 1426.66 | 1426.66 | 1416.66 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5418.96 | PP–RCT S4 | 20 | 10 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 235.368 | ø20 | 15.4 | TR10.03.0889 | 0889 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13071178 | 2.NP_SO-102 | 114.842 | 0.000314112 | 0.00721575 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1436.66 | 1426.66 | 1426.66 | 1416.66 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5418.96 | PP–RCT S4 | 20 | 10 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 114.842 | ø20 | 15.4 | TR10.03.0890 | 0890 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13071397 | 1.NP_SO-102 | 82.3576 | 0.000314112 | 0.00517468 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 1436.66 | 1426.66 | 1426.66 | 1416.66 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 1418.96 | PP–RCT S4 | 20 | 15 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 82.3576 | ø20 | 15.4 | TR10.03.0891 | 0891 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13071429 | 1.NP_SO-102 | 253.352 | 0.000314112 | 0.0159186 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 1436.66 | 1426.66 | 1426.66 | 1416.66 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 1418.96 | PP–RCT S4 | 20 | 15 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 253.352 | ø20 | 15.4 | TR10.03.0892 | 0892 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13071527 | 1.NP_SO-102 | 79.5683 | 0.000314112 | 0.00499943 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 1436.66 | 1426.66 | 1426.66 | 1416.66 | 1426.66 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 1418.96 | PP–RCT S4 | 20 | 15 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 79.5683 | ø20 | 15.4 | TR10.03.0893 | 0893 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13071615 | 1.NP_SO-102 | 8858.73 | 0.0004908 | 0.695763 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3340.3 | PP–RCT S4 | 25 | 332 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 8858.73 | ø25 | 19.4 | TR10.03.0894 | 0894 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13074609 | -1.PP_SO-102 | 164.377 | 0.00311678 | 0.0325335 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3331.5 | 3300 | 3300 | 3268.5 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -724.4 | PP–RCT S4 | 63 | 168 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 164.377 | ø63 | 48.8 | TR10.03.0895 | 0895 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13074655 | -1.PP_SO-102 | 6064.4 | 0.00311678 | 1.20027 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3331.5 | 3300 | 3300 | 3268.5 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -724.4 | PP–RCT S4 | 63 | 395 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6064.4 | ø63 | 48.8 | TR10.03.0896 | 0896 | yes | WS_Teplá vnitřní 83 | 0
13074770 | -1.PP_SO-102 | 6102.33 | 0.000804127 | 0.613473 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3316 | 3300 | 3300 | 3284 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -712.4 | PP–RCT S4 | 32 | 247 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6102.33 | ø32 | 24.8 | TR10.03.0897 | 0897 | yes | WS_Cirkulace vnitřní 9 | 0
13074780 | -1.PP_SO-102 | 459.54 | 0.000804127 | 0.046198 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3316 | 3300 | 3300 | 3284 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -712.4 | PP–RCT S4 | 32 | 211 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 459.54 | ø32 | 24.8 | TR10.03.0898 | 0898 | yes | WS_Cirkulace vnitřní 9 | 0
13075475 | -1.PP_SO-102 | 2381.91 | 0.0019632 | 0.374149 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 2625 | 2600 | 2600 | 2575 | 2600 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1419.4 | PP–RCT S4 | 50 | 392 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2381.91 | ø50 | 38.8 | TR10.03.0899 | 0899 | yes | WS_Teplá vnitřní 83 | 0
13075622 | -1.PP_SO-102 | 698.547 | 0.00311678 | 0.138257 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2441.5 | 2410 | 2410 | 2378.5 | 2410 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1614.4 | PP–RCT S4 | 63 | 395 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 698.547 | ø63 | 48.8 | TR10.03.0900 | 0900 | yes | WS_Teplá vnitřní 83 | 0
13075648 | -1.PP_SO-102 | 699.026 | 0.000804127 | 0.0702738 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 2416 | 2400 | 2400 | 2384 | 2400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1612.4 | PP–RCT S4 | 32 | 247 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 699.026 | ø32 | 24.8 | TR10.03.0901 | 0901 | yes | WS_Cirkulace vnitřní 9 | 0
13075689 | -1.PP_SO-102 | 2288.12 | 0.000804127 | 0.230027 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 2616 | 2600 | 2600 | 2584 | 2600 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -1412.4 | PP–RCT S4 | 32 | 261 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2288.12 | ø32 | 24.8 | TR10.03.0902 | 0902 | yes | WS_Cirkulace vnitřní 9 | 0
13075758 | -1.PP_SO-102 | 612.687 | 0.00311678 | 0.121263 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2431.5 | 2400 | 2400 | 2368.5 | 2400 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1624.4 | PP–RCT S4 | 63 | 468 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 612.687 | ø63 | 48.8 | TR10.03.0903 | 0903 | yes | WS_Studená vnitřní 134 | 0
13075804 | -1.PP_SO-102 | 2111.3 | 0.00311678 | 0.417869 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2631.5 | 2600 | 2600 | 2568.5 | 2600 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -1424.4 | PP–RCT S4 | 63 | 344 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2111.3 | ø63 | 48.8 | TR10.03.0904 | 0904 | yes | WS_Studená vnitřní 134 | 0
13075876 | -1.PP_SO-102 | 583.217 | 0.00311678 | 0.115431 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2431.5 | 2400 | 2400 | 2368.5 | 2400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1624.4 | PP–RCT S4 | 63 | 366 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 583.217 | ø63 | 48.8 | TR10.03.0905 | 0905 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13076289 | -1.PP_SO-102 | 6464.4 | 0.00311678 | 1.27944 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3331.5 | 3300 | 3300 | 3268.5 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -724.4 | PP–RCT S4 | 63 | 366 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6464.4 | ø63 | 48.8 | TR10.03.0906 | 0906 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13076445 | -1.PP_SO-102 | 6073.18 | 0.00311678 | 1.20201 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3257.94 | 3226.44 | 3226.44 | 3194.94 | 3226.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -797.963 | PP–RCT S4 | 63 | 468 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 6073.18 | ø63 | 48.8 | TR10.03.0907 | 0907 | yes | WS_Studená vnitřní 134 | 0
13076512 | -1.PP_SO-102 | 357.366 | 0.00125645 | 0.044908 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 3120 | 3100 | 3100 | 3080 | 3100 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -915.5 | PP–RCT S4 | 40 | 481 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 357.366 | ø40 | 31 | TR10.03.0908 | 0908 | yes | WS_Studená vnitřní 134 | 0
13076534 | -1.PP_SO-102 | 439.956 | 0.00125645 | 0.0552865 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 3120 | 3100 | 3100 | 3080 | 3100 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -915.5 | PP–RCT S4 | 40 | 418 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 439.956 | ø40 | 31 | TR10.03.0909 | 0909 | yes | WS_Teplá vnitřní 83 | 0
13076554 | -1.PP_SO-102 | 304.058 | 0.0004908 | 0.0238807 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3112.5 | 3100 | 3100 | 3087.5 | 3100 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -909.7 | PP–RCT S4 | 25 | 359 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 304.058 | ø25 | 19.4 | TR10.03.0910 | 0910 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13076571 | -1.PP_SO-102 | 404.282 | 0.000804127 | 0.0406429 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3116 | 3100 | 3100 | 3084 | 3100 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -912.4 | PP–RCT S4 | 32 | 9 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 404.282 | ø32 | 24.8 | TR10.03.0911 | 0911 | yes | WS_Cirkulace vnitřní 9 | 0
13077343 | -1.PP_SO-102 | 20190.3 | 0.00311678 | 3.99607 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2631.5 | 2600 | 2600 | 2568.5 | 2600 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1424.4 | PP–RCT S4 | 63 | 366 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 20190.3 | ø63 | 48.8 | TR10.03.0912 | 0912 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13077916 | -1.PP_SO-102 | 18425.6 | 0.0019632 | 2.89428 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 2825 | 2800 | 2800 | 2775 | 2800 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -1219.4 | PP–RCT S4 | 50 | 444 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 18425.6 | ø50 | 38.8 | TR10.03.0913 | 0913 | yes | WS_Teplá vnitřní 83 | 0
13078288 | -1.PP_SO-102 | 1245.38 | 0.00311678 | 0.246486 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3331.5 | 3300 | 3300 | 3268.5 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -724.4 | PP–RCT S4 | 63 | 411 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1245.38 | ø63 | 48.8 | TR10.03.0914 | 0914 | yes | WS_Teplá vnitřní 83 | 0
13079140 | -1.PP_SO-102 | 1486.75 | 0.00311678 | 0.294258 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3431.5 | 3400 | 3400 | 3368.5 | 3400 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -624.4 | PP–RCT S4 | 63 | 411 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1486.75 | ø63 | 48.8 | TR10.03.0915 | 0915 | yes | WS_Teplá vnitřní 83 | 0
13079342 | -1.PP_SO-102 | 300.044 | 0.000804127 | 0.0301637 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3316 | 3300 | 3300 | 3284 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -712.4 | PP–RCT S4 | 32 | 258 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 300.044 | ø32 | 24.8 | TR10.03.0916 | 0916 | yes | WS_Cirkulace vnitřní 9 | 0
13079427 | -1.PP_SO-102 | 169.34 | 0.00125645 | 0.0212799 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 3320 | 3300 | 3300 | 3280 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -715.5 | PP–RCT S4 | 40 | 423 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 169.34 | ø40 | 31 | TR10.03.0917 | 0917 | yes | WS_Teplá vnitřní 83 | 0
13079628 | -1.PP_SO-102 | 2574.68 | 0.00125645 | 0.323543 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 3420 | 3400 | 3400 | 3380 | 3400 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 9 | -615.5 | PP–RCT S4 | 40 | 224 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2574.68 | ø40 | 31 | TR10.03.0918 | 0918 | yes | WS_Cirkulace vnitřní 9 | 0
13080084 | -1.PP_SO-102 | 150.519 | 0.000314112 | 0.0094574 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 2610 | 2600 | 2600 | 2590 | 2600 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1407.7 | PP–RCT S4 | 20 | 354 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 150.519 | ø20 | 15.4 | TR10.03.0919 | 0919 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13080145 | 2.NP_SO-102 | 490.815 | 0.000314112 | 0.0308388 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 2376.19 | 1885.37 | 2376.19 | 1885.37 | 2376.19 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5885.37 | PP–RCT S4 | 20 | 44 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 490.815 | ø20 | 15.4 | TR10.03.0920 | 0920 | no | WS_"Jiný typ" studená vnitřní 1
13080175 | 2.NP_SO-102 | 407.56 | 0.000314112 | 0.0256077 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1831.37 | 1423.81 | 1831.37 | 1423.81 | 1831.37 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5423.81 | PP–RCT S4 | 20 | 44 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 407.56 | ø20 | 15.4 | TR10.03.0921 | 0921 | no | WS_"Jiný typ" studená vnitřní 1
13080211 | 2.NP_SO-102 | 891.949 | 0.000314112 | 0.0560428 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 2.NP_SO-102 | 1410 | 1400 | 1400 | 1390 | 1400 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 5392.3 | PP–RCT S4 | 20 | 191 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 891.949 | ø20 | 15.4 | TR10.03.0922 | 0922 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13080830 | -1.PP_SO-102 | 23.8187 | 0.000201032 | 0.00119726 | ø16 mm | 0 | Laminární | 0 | 0.000862069 | JB | -1.PP_SO-102 | 3308 | 3300 | 3300 | 3292 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S3.2 | WS_Teplá vnitřní 83 | -705.8 | PP–RCT S3,2 | 16 | 306 | Trubka Evo, S3.2 - ø16 | ø16 | 23.8187 | ø16 | 11.6 | TR10.03.0923 | 0923 | yes | WS_Teplá vnitřní 83 | 0
13080847 | -1.PP_SO-102 | 1862.92 | 0.0019632 | 0.292627 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3325 | 3300 | 3300 | 3275 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -719.4 | PP–RCT S4 | 50 | 425 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1862.92 | ø50 | 38.8 | TR10.03.0924 | 0924 | yes | WS_Teplá vnitřní 83 | 0
13081064 | -1.PP_SO-102 | 924.677 | 0.00311678 | 0.183012 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3381.5 | 3350 | 3350 | 3318.5 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -674.4 | PP–RCT S4 | 63 | 507 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 924.677 | ø63 | 48.8 | TR10.03.0925 | 0925 | yes | WS_Studená vnitřní 134 | 0
13081096 | -1.PP_SO-102 | 129.078 | 0.000314112 | 0.0081102 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -657.7 | PP–RCT S4 | 20 | 353 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 129.078 | ø20 | 15.4 | TR10.03.0926 | 0926 | no | WS_Studená vnitřní 134 | 0
13083002 | -1.PP_SO-102 | 1863.43 | 0.00125645 | 0.234166 | ø40 mm | 0 | Laminární | 0 | 0.000322581 | JB | -1.PP_SO-102 | 2620 | 2600 | 2600 | 2580 | 2600 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1415.5 | PP–RCT S4 | 40 | 151 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1863.43 | ø40 | 31 | TR10.03.0927 | 0927 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13102789 | -1.PP_SO-102 | 9309.13 | 0.0044172 | 2.19341 | ø75 mm |  |  |  | 0.000204918 | JB | -1.PP_SO-102 | 842.55 | 805.05 | 805.05 | 767.55 | 805.05 | Fáze 1 | WS_Požární nezavodněný | Požární ochrana – suché prostředky | Trubka Evo, S4 | WS_Požární nezavodněný 1 | -3224.05 | PP–RCT S4 | 75 | 388 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 9309.13 | ø75 | 58.2 | TR10.03.0958 | 0958 | yes | WS_Požární nezavodněný 1 | 0 | Identifikační data - Komentáře: PŘÍPOJNÉ MÍSTO SUCHOVODU
13103544 | -1.PP_SO-102 | 1975.04 | 0.00311678 | 0.3909 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2631.5 | 2600 | 2600 | 2568.5 | 2600 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1424.4 | PP–RCT S4 | 63 | 212 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1975.04 | ø63 | 48.8 | TR10.03.0959 | 0959 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13103556 | -1.PP_SO-102 | 603.879 | 0.00311678 | 0.11952 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 2531.5 | 2500 | 2500 | 2468.5 | 2500 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -1524.4 | PP–RCT S4 | 63 | 366 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 603.879 | ø63 | 48.8 | TR10.03.0960 | 0960 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13144264 | 1.NP_SO-102 | 467.283 | 0.0004908 | 0.0367003 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3340.3 | PP–RCT S4 | 25 | 332 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 467.283 | ø25 | 19.4 | TR10.03.0964 | 0964 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13144278 | 1.NP_SO-102 | 379.363 | 0.0004908 | 0.0297951 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3362.5 | 3350 | 3350 | 3337.5 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3340.3 | PP–RCT S4 | 25 | 332 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 379.363 | ø25 | 19.4 | TR10.03.0965 | 0965 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13154289 | 1.NP_SO-102 | 5605.07 | 0.000314112 | 0.352177 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3337.23 | PP–RCT S4 | 20 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5605.07 | ø20 | 15.4 | TR10.03.1005 | 1005 | no | WS_Teplá vnitřní 8 | 0
13154293 | 1.NP_SO-102 | 325.075 | 0.000314112 | 0.0204251 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3337.23 | PP–RCT S4 | 20 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 325.075 | ø20 | 15.4 | TR10.03.1006 | 1006 | no | WS_Teplá vnitřní 8 | 0
13154297 | 1.NP_SO-102 | 442.538 | 0.000314112 | 0.0278055 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3354.93 | 3344.93 | 3344.93 | 3334.93 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3337.23 | PP–RCT S4 | 20 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 442.538 | ø20 | 15.4 | TR10.03.1007 | 1007 | no | WS_Teplá vnitřní 8 | 0
13154301 | 1.NP_SO-102 | 5825.07 | 0.000314112 | 0.366 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3277.23 | PP–RCT S4 | 20 | 209 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5825.07 | ø20 | 15.4 | TR10.03.1008 | 1008 | no | WS_Studená vnitřní 6 | 0
13154305 | 1.NP_SO-102 | 385.075 | 0.000314112 | 0.024195 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3277.23 | PP–RCT S4 | 20 | 209 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 385.075 | ø20 | 15.4 | TR10.03.1009 | 1009 | no | WS_Studená vnitřní 6 | 0
13154309 | 1.NP_SO-102 | 302.538 | 0.000314112 | 0.019009 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3294.93 | 3284.93 | 3284.93 | 3274.93 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3277.23 | PP–RCT S4 | 20 | 209 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 302.538 | ø20 | 15.4 | TR10.03.1010 | 1010 | no | WS_Studená vnitřní 6 | 0
13154313 | 1.NP_SO-102 | 1331.49 | 0.000314112 | 0.0836602 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 2810 | 2800 | 2800 | 2790 | 2800 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 2792.3 | PP–RCT S4 | 20 | 209 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1331.49 | ø20 | 15.4 | TR10.03.1011 | 1011 | yes | WS_Studená vnitřní 6 | 0
13154318 | 1.NP_SO-102 | 1406.59 | 0.0004908 | 0.110474 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3297.43 | 3284.93 | 3284.93 | 3272.43 | 3284.93 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 3275.23 | PP–RCT S4 | 25 | 188 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1406.59 | ø25 | 19.4 | TR10.03.1012 | 1012 | yes | WS_Studená vnitřní 6 | 0
13154321 | 1.NP_SO-102 | 1189.88 | 0.000314112 | 0.0747621 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 2810 | 2800 | 2800 | 2790 | 2800 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 2792.3 | PP–RCT S4 | 20 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1189.88 | ø20 | 15.4 | TR10.03.1013 | 1013 | yes | WS_Teplá vnitřní 8 | 0
13154326 | 1.NP_SO-102 | 1625.67 | 0.0004908 | 0.12768 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3357.43 | 3344.93 | 3344.93 | 3332.43 | 3344.93 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 3335.23 | PP–RCT S4 | 25 | 188 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1625.67 | ø25 | 19.4 | TR10.03.1014 | 1014 | yes | WS_Teplá vnitřní 8 | 0
13154401 | 1.NP_SO-102 | 2336.99 | 0.0004908 | 0.183547 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3257.43 | 3244.93 | 3244.93 | 3232.43 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 3235.23 | PP–RCT S4 | 25 | 86 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2336.99 | ø25 | 19.4 | TR10.03.1015 | 1015 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 0
13154411 | 1.NP_SO-102 | 76.9517 | 0.0004908 | 0.00604378 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3257.43 | 3244.93 | 3244.93 | 3232.43 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 3235.23 | PP–RCT S4 | 25 | 81 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 76.9517 | ø25 | 19.4 | TR10.03.1016 | 1016 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 0
13154461 | 1.NP_SO-102 | 1478.73 | 0.0004908 | 0.116139 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 2812.5 | 2800 | 2800 | 2787.5 | 2800 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 2790.3 | PP–RCT S4 | 25 | 86 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1478.73 | ø25 | 19.4 | TR10.03.1017 | 1017 | yes | WS_"ŠEDÁ" studená vnitřní 2 | 0
13154481 | 1.NP_SO-102 | 7561.1 | 0.0004908 | 0.593847 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3257.43 | 3244.93 | 3244.93 | 3232.43 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 3235.23 | PP–RCT S4 | 25 | 86 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 7561.1 | ø25 | 19.4 | TR10.03.1018 | 1018 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13154491 | 1.NP_SO-102 | 598.725 | 0.0004908 | 0.0470238 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3257.43 | 3244.93 | 3244.93 | 3232.43 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 3235.23 | PP–RCT S4 | 25 | 86 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 598.725 | ø25 | 19.4 | TR10.03.1019 | 1019 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13154499 | 1.NP_SO-102 | 1499.36 | 0.0004908 | 0.11776 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 1.NP_SO-102 | 3257.43 | 3244.93 | 3244.93 | 3232.43 | 3244.93 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | 3235.23 | PP–RCT S4 | 25 | 86 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1499.36 | ø25 | 19.4 | TR10.03.1020 | 1020 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13175799 | -1.PP_SO-102 | 280 | 0.00311678 | 0.0554177 | ø63 mm | 0 | Laminární | 0 | 0.000204918 | JB | -1.PP_SO-102 | 3331.5 | 3300 | 3300 | 3268.5 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -724.4 | PP–RCT S4 | 63 | 367 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 280 | ø63 | 48.8 | TR10.03.1099 | 1099 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13271405 | -1.PP_SO-102 | 1847.5 | 0.0019632 | 0.290204 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3325 | 3300 | 3300 | 3275 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -719.4 | PP–RCT S4 | 50 | 215 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1847.5 | ø50 | 38.8 | TR10.03.1185 | 1185 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13271653 | -1.PP_SO-102 | 4004.27 | 0.0019632 | 0.62899 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3251.44 | 3226.44 | 3226.44 | 3201.44 | 3226.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -792.963 | PP–RCT S4 | 50 | 357 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4004.27 | ø50 | 38.8 | TR10.03.1186 | 1186 | yes | WS_Studená vnitřní 134 | 0
13271665 | -1.PP_SO-102 | 4026.66 | 0.0019632 | 0.632507 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3251.44 | 3226.44 | 3226.44 | 3201.44 | 3226.44 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 134 | -792.963 | PP–RCT S4 | 50 | 357 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4026.66 | ø50 | 38.8 | TR10.03.1187 | 1187 | yes | WS_Studená vnitřní 134 | 0
13271701 | -1.PP_SO-102 | 4283.15 | 0.000804127 | 0.430589 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3316 | 3300 | 3300 | 3284 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 4 | -712.4 | PP–RCT S4 | 32 | 52 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4283.15 | ø32 | 24.8 | TR10.03.1188 | 1188 | yes | WS_Cirkulace vnitřní 4 | 0
13271715 | -1.PP_SO-102 | 4076.19 | 0.000804127 | 0.409783 | ø32 mm | 0 | Laminární | 0 | 0.000403226 | JB | -1.PP_SO-102 | 3316 | 3300 | 3300 | 3284 | 3300 | Fáze 1 | WS_Cirkulace vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Cirkulace vnitřní 4 | -712.4 | PP–RCT S4 | 32 | 52 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4076.19 | ø32 | 24.8 | TR10.03.1189 | 1189 | yes | WS_Cirkulace vnitřní 4 | 0
13271739 | -1.PP_SO-102 | 4550.56 | 0.0019632 | 0.7148 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3325 | 3300 | 3300 | 3275 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -719.4 | PP–RCT S4 | 50 | 402 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4550.56 | ø50 | 38.8 | TR10.03.1190 | 1190 | yes | WS_Teplá vnitřní 83 | 0
13271749 | -1.PP_SO-102 | 4106.66 | 0.0019632 | 0.645073 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3325 | 3300 | 3300 | 3275 | 3300 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 83 | -719.4 | PP–RCT S4 | 50 | 402 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4106.66 | ø50 | 38.8 | TR10.03.1191 | 1191 | yes | WS_Teplá vnitřní 83 | 0
13271773 | -1.PP_SO-102 | 5217.03 | 0.0019632 | 0.819489 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3325 | 3300 | 3300 | 3275 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -719.4 | PP–RCT S4 | 50 | 215 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5217.03 | ø50 | 38.8 | TR10.03.1192 | 1192 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13271783 | -1.PP_SO-102 | 4294.55 | 0.0019632 | 0.674586 | ø50 mm | 0 | Laminární | 0 | 0.000257732 | JB | -1.PP_SO-102 | 3325 | 3300 | 3300 | 3275 | 3300 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -719.4 | PP–RCT S4 | 50 | 215 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 4294.55 | ø50 | 38.8 | TR10.03.1193 | 1193 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13272230 | 1.NP_SO-102 | 38.3302 | 0.000314112 | 0.00240836 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 510 | 500 | 500 | 490 | 500 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | 492.3 | PP–RCT S4 | 20 | 207 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 38.3302 | ø20 | 15.4 | TR10.03.1196 | 1196 | no | WS_Studená vnitřní 6 | 0
13272271 | 1.NP_SO-102 | 38.3302 | 0.000314112 | 0.00240836 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 510 | 500 | 500 | 490 | 500 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | 492.3 | PP–RCT S4 | 20 | 207 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 38.3302 | ø20 | 15.4 | TR10.03.1197 | 1197 | no | WS_Teplá vnitřní 8 | 0
13325900 | -1.PP_SO-102 | 2065.07 | 0.000314112 | 0.129752 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | -1.PP_SO-102 | 3235.94 | 3225.94 | 3225.94 | 3215.94 | 3225.94 | Fáze 2 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"ŠEDÁ" studená vnitřní 2 | -781.762 | PP–RCT S4 | 20 | 91 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2065.07 | ø20 | 15.4 | TR10.03.1228 | 1228 | no | WS_"ŠEDÁ" studená vnitřní 2 | 0
13325992 | -1.PP_SO-102 | 1812.37 | 0.0004908 | 0.142344 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3238.44 | 3225.94 | 3225.94 | 3213.44 | 3225.94 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_Studená vnitřní 6 | -783.762 | PP–RCT S4 | 25 | 202 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1812.37 | ø25 | 19.4 | TR10.03.1229 | 1229 | no | WS_Studená vnitřní 6 | 0
13326042 | -1.PP_SO-102 | 1512.37 | 0.0004908 | 0.118782 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3238.09 | 3225.59 | 3225.59 | 3213.09 | 3225.59 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | Trubka Evo, S4 | WS_Teplá vnitřní 8 | -784.112 | PP–RCT S4 | 25 | 202 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 1512.37 | ø25 | 19.4 | TR10.03.1230 | 1230 | no | WS_Teplá vnitřní 8 | 0
13335173 | -1.PP_SO-102 | 2949.99 | 0.0004908 | 0.231691 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3386.92 | 3374.42 | 3374.42 | 3361.92 | 3374.42 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -635.281 | PP–RCT S4 | 25 | 347 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2949.99 | ø25 | 19.4 | TR10.03.1231 | 1231 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13335181 | -1.PP_SO-102 | 3927.8 | 0.0004908 | 0.308489 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | -1.PP_SO-102 | 3386.92 | 3374.42 | 3374.42 | 3361.92 | 3374.42 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | -635.281 | PP–RCT S4 | 25 | 347 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 3927.8 | ø25 | 19.4 | TR10.03.1232 | 1232 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13335332 | 1.NP_SO-102 | 5385.08 | 0.000314112 | 0.338354 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 1.NP_SO-102 | 3360 | 3350 | 3350 | 3340 | 3350 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 3342.3 | PP–RCT S4 | 20 | 210 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 5385.08 | ø20 | 15.4 | TR10.03.1233 | 1233 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13335567 | 4.NP_SO-102 | 13567.6 | 0.000314112 | 0.852478 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3318.35 | 3308.35 | 3308.35 | 3298.35 | 3308.35 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 15300.6 | PP–RCT S4 | 20 | 226 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 13567.6 | ø20 | 15.4 | TR10.03.1234 | 1234 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13335584 | 4.NP_SO-102 | 2056.75 | 0.000314112 | 0.12923 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3290.89 | 3290.89 | 1234.13 | 1234.13 | 1234.13 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 13234.1 | PP–RCT S4 | 20 | 226 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 2056.75 | ø20 | 15.4 | TR10.03.1235 | 1235 | no | WS_"Jiný typ" studená vnitřní 1
13335587 | 4.NP_SO-102 | 678.328 | 0.0004908 | 0.0532758 | ø25 mm | 0 | Laminární | 0 | 0.000515464 | JB | 4.NP_SO-102 | 1212.5 | 1200 | 1200 | 1187.5 | 1200 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 13190.3 | PP–RCT S4 | 25 | 22 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 678.328 | ø25 | 19.4 | TR10.03.1236 | 1236 | no | WS_"Jiný typ" studená vnitřní 1 | 0
13335712 | 4.NP_SO-102 | 695.453 | 0.000314112 | 0.0436966 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3318.35 | 3308.35 | 3308.35 | 3298.35 | 3308.35 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 15300.6 | PP–RCT S4 | 20 | 226 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 695.453 | ø20 | 15.4 | TR10.03.1237 | 1237 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
13335758 | 4.NP_SO-102 | 310.684 | 0.000314112 | 0.0195208 | ø20 mm | 0 | Laminární | 0 | 0.000649351 | JB | 4.NP_SO-102 | 3318.35 | 3308.35 | 3308.35 | 3298.35 | 3308.35 | Fáze 1 | WS_"ŠEDÁ" studená vnitřní | Studená voda v domácnosti | Trubka Evo, S4 | WS_"Jiný typ" studená vnitřní 1 | 15300.6 | PP–RCT S4 | 20 | 226 | Trubka Evo, S4 - ø20 - ø 125 | ø20 - ø 125 | 310.684 | ø20 | 15.4 | TR10.03.1238 | 1238 | yes | WS_"Jiný typ" studená vnitřní 1 | 0
