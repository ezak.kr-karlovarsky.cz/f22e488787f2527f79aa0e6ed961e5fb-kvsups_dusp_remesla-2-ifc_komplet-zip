Properties of the parts of a building model (IFC4), part 25 of 60

# IfcDistributionPort (11856)
Name | FlowDirection | PredefinedType | SystemType | Group
OutPort_13981921_1 | SOURCE | PIPE | SEWAGE | SW_Deště čerpání 1
InPort_13981953_2 | SINK | PIPE | SEWAGE | SW_Deště čerpání 1
OutPort_13981942_0 | SOURCE | PIPE | SEWAGE | SW_Deště čerpání 1
InPort_13981942_1 | SINK | PIPE | SEWAGE | SW_Deště čerpání 1
OutPort_13982191_1 | SOURCE | PIPE | SEWAGE | SW_Deště čerpání 1
InPort_13982055_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13982031_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13982031_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13982061_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13982050_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13982052_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13982052_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13982055_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13982195_2 | SINK | PIPE | SEWAGE | SW_Deště čerpání 1
OutPort_13982177_0 | SOURCE | PIPE | SEWAGE | SW_Deště čerpání 1
InPort_13982177_1 | SINK | PIPE | SEWAGE | SW_Deště čerpání 1
OutPort_13982572_2 | SOURCE | PIPE | SEWAGE | SW_Deště čerpání 1
InPort_13982191_2 | SINK | PIPE | SEWAGE | SW_Deště čerpání 1
OutPort_13982189_0 | SOURCE | PIPE | SEWAGE | SW_Deště čerpání 1
InPort_13982189_1 | SINK | PIPE | SEWAGE | SW_Deště čerpání 1
OutPort_13982195_1 | SOURCE | PIPE | SEWAGE | SW_Deště čerpání 1
InPort_13982572_1 | SINK | PIPE | SEWAGE | SW_Deště čerpání 1
OutPort_13982562_0 | SOURCE | PIPE | SEWAGE | SW_Deště čerpání 1
InPort_13982562_1 | SINK | PIPE | SEWAGE | SW_Deště čerpání 1
OutPort_13982636_1 | SOURCE | PIPE | SEWAGE | SW_Deště čerpání 1
InPort_13982636_2 | SINK | PIPE | SEWAGE | SW_Deště čerpání 1
OutPort_13982574_0 | SOURCE | PIPE | SEWAGE | SW_Deště čerpání 1
InPort_13982574_1 | SINK | PIPE | SEWAGE | SW_Deště čerpání 1
OutPort_13982638_3 | SOURCE | PIPE | SEWAGE | SW_Deště čerpání 1
Port_13982628_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13982638_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13982638_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13982639_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13986232_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13986502_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13986287_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13986471_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13986344_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13986532_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13986431_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13986530_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13986431_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13986532_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13986460_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13986471_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13986460_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13986520_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13986489_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13986502_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13986489_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13986513_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13986524_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13987623_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13986603_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13986609_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13986603_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13987614_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13991925_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13987614_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13987622_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13987623_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13987622_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13987723_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13987714_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13987723_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13987714_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13991936_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13991925_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13991936_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13993128_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993144_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993128_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993160_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993148_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993160_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993148_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993274_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993407_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993466_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993407_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993478_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993470_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993571_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993470_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993478_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13993513_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13993525_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13993641_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13993513_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13993606_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13993561_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13993561_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13993637_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993570_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993940_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993570_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993571_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13993570_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13993606_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13993637_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13993575_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13993575_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13993641_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993771_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993934_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993771_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993947_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993939_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14004504_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993939_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993940_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993939_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993947_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13994063_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13994072_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14004673_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13994063_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13994144_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14004676_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14004679_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13994144_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13994340_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13994933_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13994340_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14004638_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13994721_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13994947_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13994721_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13994756_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13994909_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13995018_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13994909_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13994947_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13994930_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13995018_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13994930_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13995030_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13994933_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13995022_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13995022_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13995230_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13995022_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13995030_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13995057_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13995073_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13995761_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13995057_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13995230_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13995698_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13995736_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13995689_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13995689_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13995757_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13995698_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996157_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13995698_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13995736_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13995757_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13995705_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13995705_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13995761_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996038_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996049_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996038_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996061_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996054_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996061_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996054_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996688_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996065_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996688_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996065_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996700_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13996087_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13996099_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13996773_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13996087_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996103_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996813_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996103_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996777_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996157_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996568_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996477_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996487_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996477_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996564_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996487_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996625_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996491_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996564_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996491_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996576_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996568_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13997588_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996568_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996576_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996625_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996740_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996692_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996741_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996692_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996693_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996692_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996700_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996731_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996740_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996731_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996777_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996740_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996741_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13996814_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13996773_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996802_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996840_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996802_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996887_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13996813_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13996814_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996813_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996840_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996817_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996887_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996817_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996891_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14018287_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13997319_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13997319_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13997321_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13997346_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13997357_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13998618_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13997346_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13997521_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13998548_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13997521_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999021_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13997588_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13998912_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13997873_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999279_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13997873_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13998548_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13998403_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13998413_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13998583_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13998403_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13998581_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999280_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13998581_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999563_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13998581_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13998583_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13999589_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13998618_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13998904_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13998912_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13998904_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999072_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13998912_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999670_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13998938_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999072_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13998938_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999021_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13999072_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13999084_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13999084_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13999102_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13999102_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13999095_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13999095_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13999183_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13999183_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14001802_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13999288_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13999270_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13999270_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13999352_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999279_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999280_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13999279_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13999288_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13999290_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13999349_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13999352_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13999290_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13999300_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13999317_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13999347_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13999300_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13999349_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13999347_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999388_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999401_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999388_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999584_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999405_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999584_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999405_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999588_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999563_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999588_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13999588_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13999589_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999660_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999677_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999660_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999686_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999669_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14000765_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999669_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999670_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999669_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999677_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999679_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999686_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999679_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999737_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999733_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14002104_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999737_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14002090_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999902_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999992_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999992_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14000754_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14000408_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14000900_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14000408_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14000912_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14000688_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14000540_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14000905_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14000688_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14000754_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14000796_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14000765_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14000796_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14000889_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14000904_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14000889_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027448_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14000904_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14000905_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14000904_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14000912_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14001037_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14001046_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14001057_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14001037_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14001050_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14001057_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14001123_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14001050_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14001114_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14001123_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14001383_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14001114_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14001381_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14001383_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14001583_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14001381_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14001543_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14001583_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14001587_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14001543_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14001587_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14001588_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14001802_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14001845_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14001813_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14001841_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14001845_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14001813_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14001885_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14001894_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14001885_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14001904_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14001898_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14001904_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14001898_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14001914_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14001914_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14002033_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14002033_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14002099_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14002041_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14002099_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14002041_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14002103_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14002090_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14002103_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14002103_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14002104_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14002289_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14002302_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14002312_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14002289_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14002394_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14002312_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14002408_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14002394_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14002402_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14002408_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14002418_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14002402_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14002412_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14002418_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14002432_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14002412_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14002505_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14002516_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14002530_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14002505_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14002520_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14002530_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14002675_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14002520_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14002534_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14002675_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14002679_3 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14002534_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14004215_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14002679_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14002679_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14002680_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14003704_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14003356_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14015988_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14003704_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14004123_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016664_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14004141_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14004123_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14004135_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14004141_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14004210_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14004135_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14004145_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14004210_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14004214_3 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14004145_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14004206_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14004214_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14004214_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14004215_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_14004504_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14004637_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14004646_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14004629_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14004629_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14004679_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14004637_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14004638_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14004637_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14004646_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14004676_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_14004673_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14005366_1 | SOURCEANDSINK | PIPE | SEWAGE
InPort_14005369_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_14005434_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_14005434_2 | SINK | PIPE | DOMESTICHOTWATER
Port_14005434_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER
InPort_14005435_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_14005464_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_14005464_2 | SINK | PIPE | DOMESTICHOTWATER
Port_14005464_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER
InPort_14005465_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_14005516_1 | SINK | PIPE | DOMESTICCOLDWATER
InPort_14005516_2 | SINK | PIPE | DOMESTICHOTWATER
Port_14005516_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER
InPort_14005517_1 | SINK | PIPE | DOMESTICHOTWATER
Port_14005550_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 23
Port_14005550_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 23
Port_14005552_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 23
Port_14005551_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 1
Port_14005551_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 1
Port_14005554_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 1
Port_14005552_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 23
Port_14005554_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 1
Port_14005556_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_14005556_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_14005561_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_14005561_2 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_14005580_1 | SOURCE | PIPE | SEWAGE
InPort_14005661_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_14005726_1 | SOURCE | PIPE | SEWAGE
Port_14005931_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 24
Port_14005931_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 24
Port_14005933_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 24
Port_14005932_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 20
Port_14005932_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 20
Port_14005935_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 20
Port_14005933_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 24
Port_14005935_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 20
Port_14005937_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_14005937_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_14005941_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_14005941_2 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_14005961_1 | SOURCE | PIPE | SEWAGE
InPort_14006030_1 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_14006046_1 | SOURCE | PIPE | SEWAGE
OutPort_14006964_1 | SOURCE | PIPE | SEWAGE
OutPort_14007101_1 | SOURCE | PIPE | SEWAGE
InPort_14007103_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_14007192_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 40
Port_14007192_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 40
Port_14007194_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 40
Port_14007193_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 22
Port_14007193_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 22
Port_14007196_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 22
Port_14007194_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 40
Port_14007196_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 22
Port_14007198_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_14007198_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_14007202_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_14007202_2 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_14007222_1 | SOURCE | PIPE | SEWAGE
OutPort_14007266_1 | SOURCE | PIPE | SEWAGE
InPort_14007268_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_14007272_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 11
Port_14007272_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 11
Port_14007274_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 11
Port_14007273_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 12
Port_14007273_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 12
Port_14007276_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 12
Port_14007274_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 11
Port_14007276_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 12
Port_14007278_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_14007278_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_14007282_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_14007282_2 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_14007283_1 | SOURCE | PIPE | SEWAGE
OutPort_14007297_1 | SOURCE | PIPE | SEWAGE
InPort_14007299_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_14007303_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 41
Port_14007303_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 41
Port_14007305_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 41
Port_14007304_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 32
Port_14007304_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 32
Port_14007307_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 32
Port_14007305_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 41
Port_14007307_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 32
Port_14007309_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_14007309_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_14007313_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_14007313_2 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_14007314_1 | SOURCE | PIPE | SEWAGE
OutPort_14007326_1 | SOURCE | PIPE | SEWAGE
InPort_14007328_1 | SINK | PIPE | DOMESTICCOLDWATER
Port_14007332_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 77
Port_14007332_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 77
Port_14007334_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 77
Port_14007333_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 35
Port_14007333_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 35
Port_14007336_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 35
Port_14007334_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 77
Port_14007336_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 35
Port_14007338_1 | SOURCEANDSINK | PIPE | SEWAGE
Port_14007338_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_14007342_1 | SINK | PIPE | DOMESTICHOTWATER
InPort_14007342_2 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_14007343_1 | SOURCE | PIPE | SEWAGE
OutPort_14007358_1 | SOURCE | PIPE | SEWAGE
OutPort_14007360_1 | SOURCE | PIPE | SEWAGE
InPort_14014762_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
OutPort_14014592_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
InPort_14014741_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
OutPort_14014764_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
InPort_14015243_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
OutPort_14014741_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
InPort_14014764_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
OutPort_14014762_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
InPort_14014896_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
OutPort_14015317_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
InPort_14014928_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
OutPort_14014896_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
InPort_14014917_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
OutPort_14014928_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
OutPort_14014917_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
InPort_14015273_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
OutPort_14015243_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
InPort_14015313_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
OutPort_14015273_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
InPort_14015281_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
OutPort_14015313_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
InPort_14015317_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
OutPort_14015281_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 5
InPort_14015955_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14015988_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016014_3 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14015955_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016451_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016014_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016014_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016134_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016042_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016056_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016068_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016042_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016060_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016068_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016079_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016060_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016072_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016079_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016162_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016072_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016134_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016162_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016364_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016378_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016388_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016364_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016382_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016388_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016446_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016382_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016408_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016446_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016450_3 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016408_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016443_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016450_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016495_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016443_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016450_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016451_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016470_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016495_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016595_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016470_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016675_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016583_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016583_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016748_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016593_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016595_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016748_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016593_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016664_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016651_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016651_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016675_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016855_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016857_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_14017273_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14017485_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14017337_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14017514_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14017383_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14017553_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14017383_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14017557_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14017429_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14017588_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14017429_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14017592_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14017483_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14017485_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14017483_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14017588_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14017512_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14017514_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14017512_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14017553_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14017543_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14017545_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14017543_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14017557_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14017578_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14017580_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14017578_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14017592_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_14018457_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14018204_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14018204_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14018462_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14018287_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14018325_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14018344_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14018312_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14018312_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14018379_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14018325_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14018344_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14018379_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14018377_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14018377_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14018457_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14019152_0 | SINK | PIPE | SEWAGE | SW_Splašky čerpání 2
OutPort_14019199_2 | SOURCE | PIPE | SEWAGE | SW_Splašky čerpání 2
InPort_14026133_2 | SINK | PIPE | SEWAGE | SW_Splašky čerpání 2
OutPort_14019152_1 | SOURCE | PIPE | SEWAGE | SW_Splašky čerpání 2
Port_14019756_2 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_14019767_0 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_14019767_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_14019771_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_14019769_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_14019771_4 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_14019908_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14020057_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14020024_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14020057_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14020024_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14020059_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14036752_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14020349_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14020974_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 7
OutPort_14020874_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 7
InPort_14020970_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 7
OutPort_14020947_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 7
InPort_14020947_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 7
OutPort_14020974_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 7
InPort_14022620_1 | SINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 2
OutPort_14022625_1 | SOURCE | PIPE | FIREPROTECTION | WS_Požární nezavodněný 2
Port_14022621_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 2
Port_14022625_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 2
Port_14022621_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 2
Port_14022623_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární nezavodněný 2
OutPort_14022623_2 | SOURCE | PIPE | FIREPROTECTION | WS_Požární nezavodněný 2
Port_14022793_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14022858_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14022793_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14022860_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14023328_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14023276_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14023276_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14023409_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14023354_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14023405_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14023409_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14023354_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_14024838_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14024947_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14024857_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_14024992_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_14024857_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_14024994_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_14024869_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14025028_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14024869_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14025030_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14024895_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_14025058_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_14024945_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14024947_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14024945_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14024957_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14024982_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_14024984_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_14024982_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_14024994_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 9
Port_14025018_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14025020_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14025018_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14025030_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14025056_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_14025058_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_14025056_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_14025074_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_14025283_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14025335_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14025289_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14035052_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14035054_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14025289_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14025335_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
