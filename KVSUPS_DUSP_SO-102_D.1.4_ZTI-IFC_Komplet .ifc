Properties of the parts of a building model (IFC4), part 21 of 60

# IfcDistributionPort (11856)
Name | FlowDirection | PredefinedType | SystemType | Group
OutPort_13434505_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13437491_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13434462_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13436335_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14036076_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13436335_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13438554_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689399_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13436492_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13436492_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13436524_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13436524_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13439373_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13436587_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13689916_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13436587_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13689362_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13690285_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13436845_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13436845_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13673256_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13673256_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13436855_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13436855_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13673260_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13436875_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13437491_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13437496_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13436875_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13673738_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13437431_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13437431_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13690234_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13673210_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13437496_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13437680_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13675646_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13675660_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13437680_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13437998_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672690_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13437998_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13639135_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13438298_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13438309_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13438323_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13438298_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13438309_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13671373_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13671812_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13438323_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13438554_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13689399_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689241_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13438665_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13439080_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13439200_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13439204_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13439080_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13439196_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13689217_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689217_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13439204_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13439204_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13439205_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13439373_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13689381_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13439443_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13439490_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13439443_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13483695_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13439490_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14035997_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13440192_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675652_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13440192_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13440193_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13440192_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13673041_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13440193_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13673500_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13673041_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13440196_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13440196_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13673135_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13440265_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13673737_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13440265_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13673500_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13675438_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13444201_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13444201_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13444203_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13456536_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13456548_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13456536_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13456562_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13456562_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13456629_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13456629_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13675321_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13461353_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 18
OutPort_13680912_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 18
InPort_13461518_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 18
OutPort_13461353_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 18
InPort_13680912_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 18
OutPort_13461355_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 18
InPort_13461355_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 18
OutPort_13461548_2 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 18
InPort_13461357_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 18
OutPort_13461518_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 18
InPort_13461522_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13461357_1 | SOURCE | PIPE | VENT | SW_Splašky vnitřní gravitační 35 (1)
InPort_13461506_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13461522_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13461522_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13461523_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13461546_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13461548_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13461884_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13461910_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13461884_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14020059_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13461899_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14019908_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13461903_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13461910_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13461903_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13462185_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13461914_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13672621_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13461914_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13462185_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13462678_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13462267_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13462271_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13462668_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13462308_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13462326_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13462330_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13462308_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13462585_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13545764_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13462585_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13462677_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13462668_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13462677_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13462677_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13462678_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13463581_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13463920_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13680737_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13463581_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13463920_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13463595_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13531479_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13463723_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13463734_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13463882_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13680866_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13463734_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13463882_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13463736_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13463740_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13680866_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13680879_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13463740_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13463747_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13463864_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13680811_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13463747_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13463864_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13463749_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13463753_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13680811_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13680824_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13463753_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13464828_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13464830_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13464890_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13464892_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13467076_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13467115_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13472575_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13472605_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13473522_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13472575_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13472691_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13472672_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13472672_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13473524_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13472680_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13472691_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13472702_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13472680_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13472696_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13613048_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13473705_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13472696_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13611680_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13472702_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13473475_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13473520_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13473524_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13473475_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13473520_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13473522_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13473685_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13473705_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13473715_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13473685_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13473709_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13473715_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13473728_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13473709_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13473719_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13473728_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13473738_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13473719_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13473732_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13473738_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13982061_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13473732_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
Port_13473797_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473810_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473797_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473800_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473802_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473800_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473810_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473802_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473806_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473802_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473808_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473803_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473808_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473813_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473825_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473813_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473815_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473817_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473815_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473825_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473817_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473821_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473817_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473823_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473818_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473823_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473837_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13502301_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473837_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473841_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473845_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473845_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473874_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473845_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13486231_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473855_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13502428_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473855_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473874_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473883_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473883_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474013_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473883_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13486240_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473888_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474104_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473891_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473909_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473891_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473893_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473905_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473893_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473907_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473895_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473899_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473895_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473901_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473895_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473905_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473896_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473901_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473903_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473907_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473903_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473909_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473911_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473924_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473911_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473914_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473916_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473914_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473924_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473916_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473920_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473916_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473922_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473917_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473922_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473935_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473959_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473935_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473982_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473955_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473959_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473955_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473963_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473956_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473963_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473956_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473966_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473959_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474436_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473960_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474435_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473960_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13483682_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473973_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13483688_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473973_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13483690_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473980_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473982_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473980_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473984_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13483688_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473984_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13473988_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473992_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473992_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473993_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473992_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13473996_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474010_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13502704_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474010_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474038_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474013_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474030_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474030_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474031_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474030_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474034_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474031_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474075_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474034_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13502706_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474036_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474038_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474036_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474040_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13502481_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474040_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474053_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474043_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474105_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474043_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474044_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474043_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474047_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474047_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13502483_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474051_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474053_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474051_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474061_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13502735_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474061_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474075_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474076_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474075_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474083_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474083_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13502737_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474096_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13486272_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474096_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474104_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474105_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474104_3 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474112_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474112_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13486274_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13474427_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474443_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474427_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474435_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474436_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474435_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13474443_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13483680_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13483682_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13483680_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485488_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13483682_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13483683_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13483683_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13486206_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13483686_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13483690_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13483686_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13485526_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13483690_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13483691_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13483697_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14026467_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13483697_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13624579_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13484698_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13484700_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
InPort_13485121_0 | SINK | PIPE | SEWAGE | SW_Splašky čerpání 2
OutPort_14026133_1 | SOURCE | PIPE | SEWAGE | SW_Splašky čerpání 2
InPort_14026135_1 | SINK | PIPE | SEWAGE | SW_Splašky čerpání 2
OutPort_13485121_1 | SOURCE | PIPE | SEWAGE | SW_Splašky čerpání 2
InPort_14019199_1 | SINK | PIPE | SEWAGE | SW_Splašky čerpání 2
OutPort_13485192_0 | SOURCE | PIPE | SEWAGE | SW_Splašky čerpání 2
InPort_13485192_1 | SINK | PIPE | SEWAGE | SW_Splašky čerpání 2
OutPort_13485196_1 | SOURCE | PIPE | SEWAGE | SW_Splašky čerpání 2
InPort_13485196_2 | SINK | PIPE | SEWAGE | SW_Splašky čerpání 2
OutPort_13485385_0 | SOURCE | PIPE | SEWAGE | SW_Splašky čerpání 2
InPort_13485385_1 | SINK | PIPE | SEWAGE | SW_Splašky čerpání 2
OutPort_13543651_1 | SOURCE | PIPE | SEWAGE | SW_Splašky čerpání 2
Port_13485420_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485486_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485420_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485488_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485424_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13485526_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13485424_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13485433_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485486_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485433_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485439_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485437_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485439_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485437_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485443_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485441_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485443_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485441_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485447_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485445_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485447_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485445_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485716_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13525000_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485716_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485764_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485754_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485764_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13485754_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13486119_3 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13486136_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13486136_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13486144_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13486189_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 3
Port_14028667_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 3
Port_13486189_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 3
Port_13486206_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13486208_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13486231_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13502303_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13486240_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13502430_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13486272_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13486274_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13487358_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996049_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13487358_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13817238_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13487369_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13995923_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13487369_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13487384_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13520459_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13487384_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13487395_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13818869_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13487395_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13487452_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13817648_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13487452_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13817652_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13488238_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13489255_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13488238_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14022858_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13489247_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13489255_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13489247_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13489281_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13489273_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13489281_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13489273_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13491031_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14001588_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13491158_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13818872_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13491158_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999733_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13493925_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13494013_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13493925_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13494017_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13493941_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13494406_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13493941_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13494017_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13494013_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13520459_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13494406_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996693_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13495539_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13817596_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13495539_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13817623_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13495683_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13817596_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13495683_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13496782_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13496692_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13496680_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13496680_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13496698_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13496692_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13496693_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13496692_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13999902_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13496693_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14001587_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13496811_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13497447_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13496811_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13496977_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13497049_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13496977_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13994756_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13497049_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13497447_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13996099_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13497917_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13499771_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13995923_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13499771_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13996891_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13500526_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13500526_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13517199_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13502301_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13502303_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13502428_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13502430_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13502481_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13502483_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13502704_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13502706_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13502735_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13502737_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13503089_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13528010_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13503089_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13504003_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13504005_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13504003_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13505173_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13528000_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13505173_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13527545_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13505820_1 | SINK | PIPE | SEWAGE
OutPort_13505811_1 | SOURCE | PIPE | SEWAGE
InPort_13505812_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 90
InPort_13505814_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 90
OutPort_13505812_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 90
InPort_13505813_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 138
InPort_13505816_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 138
OutPort_13505813_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 138
InPort_13505818_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 90
OutPort_13505814_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 90
InPort_13505818_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 138
OutPort_13505816_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 138
Port_13505820_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13505928_1 | SINK | PIPE | SEWAGE
OutPort_13505919_1 | SOURCE | PIPE | SEWAGE
InPort_13505920_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 117
InPort_13505922_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 117
OutPort_13505920_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 117
InPort_13505921_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 114
InPort_13505924_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 114
OutPort_13505921_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 114
InPort_13505926_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 117
OutPort_13505922_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 117
InPort_13505926_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 114
OutPort_13505924_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 114
Port_13505928_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13506046_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 19
OutPort_13506056_2 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 19
InPort_13506497_1 | SINK | PIPE | SEWAGE | SW_Odvětrání kanalizace 19
OutPort_13506046_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 19
InPort_13506054_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13506056_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13506145_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13506054_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13506139_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13506116_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13506116_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13506145_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13506140_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13506139_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13645843_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13506140_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13506570_1 | SINK | PIPE | SEWAGE
OutPort_13506561_1 | SOURCE | PIPE | SEWAGE
InPort_13506562_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 92
InPort_13506564_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 92
OutPort_13506562_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 92
InPort_13506563_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 122
InPort_13506566_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 122
OutPort_13506563_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 122
InPort_13506568_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 92
OutPort_13506564_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 92
InPort_13506568_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 122
OutPort_13506566_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 122
Port_13506570_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13506643_1 | SINK | PIPE | SEWAGE
OutPort_13506634_1 | SOURCE | PIPE | SEWAGE
InPort_13506635_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 94
InPort_13506637_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 94
OutPort_13506635_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 94
InPort_13506636_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 113
InPort_13506639_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 113
OutPort_13506636_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 113
InPort_13506641_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 94
OutPort_13506637_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 94
InPort_13506641_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 113
OutPort_13506639_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 113
Port_13506643_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13506753_1 | SINK | PIPE | SEWAGE
OutPort_13506744_1 | SOURCE | PIPE | SEWAGE
InPort_13506745_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 97
InPort_13506747_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 97
OutPort_13506745_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 97
InPort_13506746_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 93
InPort_13506749_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 93
OutPort_13506746_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 93
InPort_13506751_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 97
OutPort_13506747_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 97
InPort_13506751_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 93
OutPort_13506749_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 93
Port_13506753_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_13506821_1 | SINK | PIPE | SEWAGE
OutPort_13506812_1 | SOURCE | PIPE | SEWAGE
InPort_13506813_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 96
InPort_13506815_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 96
OutPort_13506813_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 96
InPort_13506814_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 78
InPort_13506817_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 78
OutPort_13506814_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 78
InPort_13506819_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 96
OutPort_13506815_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 96
InPort_13506819_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 78
OutPort_13506817_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 78
Port_13506821_2 | SOURCEANDSINK | PIPE | SEWAGE
Port_13507136_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13507140_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13507136_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13507142_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13507137_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13507142_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13507137_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13507146_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13513876_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13513878_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13513876_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13513880_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13987622_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13513880_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13986609_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
InPort_13514517_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13514350_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13630574_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13514517_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13514844_3 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13514832_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13514832_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13514859_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13613051_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13514844_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13514844_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13624441_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13514845_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13611676_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13624461_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13514845_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
InPort_13514859_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13613538_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
Port_13516215_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13516524_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13516215_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13516238_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13516229_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13528844_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13516229_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13621325_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13516238_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13516707_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13516419_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13517063_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13516419_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13516524_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13516707_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13516709_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13516709_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13614068_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13527635_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13516793_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13517022_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13527635_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13517063_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13517022_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13517063_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13613595_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13517064_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13613591_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13517064_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13527545_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13517164_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13517199_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13517164_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13840869_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13517225_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13517231_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13517225_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13517755_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13517231_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13840854_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13517738_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13517755_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13517738_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13517811_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13517809_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
Port_13517811_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 11
