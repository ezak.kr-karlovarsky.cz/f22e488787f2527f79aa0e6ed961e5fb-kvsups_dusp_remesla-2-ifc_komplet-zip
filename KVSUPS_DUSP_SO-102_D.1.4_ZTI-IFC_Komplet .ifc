Properties of the parts of a building model (IFC4), part 19 of 60

# IfcDistributionPort (11856)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_13157483_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13829037_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157483_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157489_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157487_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13170158_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157487_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13827239_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157489_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13826706_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157491_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13829217_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157491_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13829221_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157494_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13829037_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157494_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13168923_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157494_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13829231_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157499_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13829221_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157499_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13175643_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157503_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157515_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157503_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13647433_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157507_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13175643_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157507_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13175645_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157509_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13647433_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157509_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13647437_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157513_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157515_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157513_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13358622_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157515_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13175789_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157516_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13175645_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13157516_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13175789_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_14019771_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13157587_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13157587_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14023328_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13994072_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13160031_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13995073_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13160042_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13656215_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13161055_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13163625_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13161055_2 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 16
Port_13161562_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13161570_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13161562_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13161605_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13161570_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13613066_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13161570_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13161571_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13161603_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13161605_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13161603_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13656334_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13163384_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13681865_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13163625_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13163886_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13163888_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14001046_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13163886_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13496698_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13163908_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13163908_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13163910_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13432652_3 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13165227_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13165227_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13165276_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13165276_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13165260_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13165260_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13165351_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13165321_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13165347_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
InPort_13165351_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
OutPort_13165321_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 3
Port_13168906_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13168930_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13168906_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13175658_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13168923_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13807374_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13168928_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13175652_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13168928_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13168930_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13168936_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13537043_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13168936_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13807776_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13168936_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13175658_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13168937_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13807776_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13168937_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13807778_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13168952_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13986513_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13168952_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13168957_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323052_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13168957_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323054_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13168963_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13537079_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13168963_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13651663_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13168963_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13175684_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13169152_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169152_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169174_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169174_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169242_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169176_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169582_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169176_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175745_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169184_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169582_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169184_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169584_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169236_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13826857_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169236_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13826859_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169241_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13826482_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169241_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175784_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169241_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175745_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169242_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175784_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169332_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169348_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169332_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13826857_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169346_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169348_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169493_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175702_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169493_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169649_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169527_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175737_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169527_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175739_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169584_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169978_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169641_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169649_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169641_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169669_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169653_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169665_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169653_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169669_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169663_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175688_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169663_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169665_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169704_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175706_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169704_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169734_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169712_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175763_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169712_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175702_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169712_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175706_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169713_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175769_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169713_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175763_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169718_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169730_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169718_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169734_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169728_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175704_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169728_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169730_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169764_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169850_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169764_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169854_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169774_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175716_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169774_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169850_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169840_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175771_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169840_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169854_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169842_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169843_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169842_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175769_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169842_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175771_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169843_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169977_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169922_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175775_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169922_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169998_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169977_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169978_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169977_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175775_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13169998_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13170053_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13170045_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175780_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13170045_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13170149_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13170052_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175780_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13170052_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175782_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13170052_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175739_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13170053_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175782_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13170131_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13170145_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13170131_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13170149_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13170143_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13175729_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13170143_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13170145_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 3
Port_13170641_0 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13170643_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13170641_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13704174_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13170643_2 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13652541_0 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13170647_0 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13704672_2 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13170647_1 | SOURCEANDSINK | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13181480_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Odvětrání kanalizace 16
Port_13170668_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13546845_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13170668_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13679157_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13170674_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13170678_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13170680_3 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13170674_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13170680_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13683072_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14020349_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13170680_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13682644_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13170681_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_13170681_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13682360_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_13173758_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993466_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13173758_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13993525_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13174410_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13175684_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13175839_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13175799_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13916165_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13175799_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13651546_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13175822_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13271959_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13175822_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13349047_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13175839_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323054_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
InPort_13236995_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13181839_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13181839_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13181859_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13181847_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13182044_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13181859_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13181851_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13181851_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13182003_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13182003_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13182001_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13182001_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13236765_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13236997_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13182035_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13182035_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13182054_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13182043_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13236995_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13182044_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13182043_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13182043_3 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13236997_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13182054_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13182048_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13182048_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13182088_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13182088_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13182086_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13182086_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13236942_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237199_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237036_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237036_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237040_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237287_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237038_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237038_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237043_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237331_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237070_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237070_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237283_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237078_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237316_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237166_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237199_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237325_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237166_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237283_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237230_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237230_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237287_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237323_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237298_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237298_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237325_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237316_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237315_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237315_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237331_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237315_3 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237323_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237628_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237343_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237343_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13243246_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237758_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237361_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237361_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13243178_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237610_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237628_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242399_3 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237610_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237632_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242086_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237648_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237632_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237642_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237648_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242007_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237642_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237722_3 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237714_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237714_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237758_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242086_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237722_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237722_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13237723_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13237723_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242399_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13238021_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13241694_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14002302_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13238021_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13240227_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13238105_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13240577_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13238236_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13706117_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13238237_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13243728_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13238383_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13243859_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13238390_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239501_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13238469_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13238469_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13238471_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13238522_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13238524_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239508_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13238522_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13238868_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239501_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239505_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13238868_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13238889_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239508_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239512_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13238889_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239016_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239505_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239165_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239016_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239026_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239165_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239233_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239026_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239055_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239512_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239270_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239055_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239122_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239704_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239610_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239122_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239243_3 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239207_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239207_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239233_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239704_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239243_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239243_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239258_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239258_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239414_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239260_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239270_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239386_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239260_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239378_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239386_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239414_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239378_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239519_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
OutPort_13356678_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Požární nezavodněný 1
InPort_13239602_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239610_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239622_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239602_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239614_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239622_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13239671_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239614_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13982639_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13239671_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13239886_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13239903_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13239886_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13504005_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13239899_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13244944_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13239899_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13239903_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13240137_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13241887_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13244619_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13240137_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13240148_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14002436_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13241887_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13240148_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13269654_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13240227_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13241247_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13240577_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13241225_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13241247_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13684869_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13241225_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13241694_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14004206_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13241854_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14002432_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14002436_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13241854_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14002680_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242007_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242399_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13243046_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016857_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242411_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242411_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242984_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13243046_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242485_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242485_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242487_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242487_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_14016855_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242614_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242557_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242557_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242559_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242893_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242571_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242571_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242573_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242595_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242614_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242683_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242595_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242673_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242683_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242831_3 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242673_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242809_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13243048_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242914_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242809_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13243048_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242831_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242831_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242843_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242843_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242864_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242864_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242853_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242853_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242897_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242866_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242893_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242897_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242866_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242984_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242972_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242972_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13243302_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13243302_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13242988_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13242988_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13243349_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13243149_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13243174_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13243178_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13243149_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13243222_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13243242_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13243246_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13243222_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13243320_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13243345_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13243349_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13243320_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13243994_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13243728_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13243968_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13243859_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13244204_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13243968_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13243984_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13243994_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13244122_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13243984_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13244112_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13244122_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14003356_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13244112_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_14016056_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13244204_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13244605_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13244619_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13244629_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13244605_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13244623_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13244629_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13244639_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13244623_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13244633_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13244639_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13244655_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13244633_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13244643_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13244655_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13244665_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13244643_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13244659_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13244665_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13244675_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13244659_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13244669_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13244675_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13244913_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13244669_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13678539_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13244913_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13244917_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13244944_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13244917_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13244948_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13244948_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13678529_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13244977_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13678534_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13244977_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13678538_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
Port_13262066_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993144_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13262066_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13262334_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993470_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13262334_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13993274_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13264838_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13491031_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13264838_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14000900_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13264851_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13496782_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13264851_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14001894_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13267077_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_13546846_0 | SOURCE | PIPE | SEWAGE | SW_Odvětrání kanalizace 16
InPort_13268437_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13688679_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13689381_2 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13268437_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13269634_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13269654_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13269671_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13269634_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13269658_0 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13269671_2 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13687760_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13269658_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13706115_2 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13269839_0 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13269839_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
OutPort_13706111_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní podtlak 4
InPort_13271040_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13271054_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13271071_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13271040_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13271054_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13461546_0 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13271058_0 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13271071_2 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_13426715_1 | SINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
OutPort_13271058_1 | SOURCE | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13271156_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13456548_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13271156_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_13271405_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13651546_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13271405_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13271474_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13271653_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13706050_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13271653_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13271671_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13271665_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13271671_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13271665_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_13271701_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 4
Port_13271713_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 4
Port_13271701_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 4
Port_13271721_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 4
Port_13271713_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 4
Port_13705969_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 4
Port_13271715_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 4
Port_13271721_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 4
Port_13271715_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Cirkulace vnitřní 4
Port_13271739_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13705769_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13271739_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13271755_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13271749_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13271755_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13271749_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_13271773_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13271781_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13271773_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13271789_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13271783_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13271789_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13271783_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_"Jiný typ" studená vnitřní 1
Port_13271951_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13271959_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13271951_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13271967_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13271961_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13271967_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13271961_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13272230_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13272230_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13835831_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 6
Port_13272271_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13272271_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
Port_13835900_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 8
InPort_13472605_1 | SINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
OutPort_13319594_1 | SOURCE | PIPE | SEWAGE | SW_Deště vnitřní gravitační 2
Port_13322434_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323184_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13322434_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13322811_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13322464_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324385_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13322464_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324090_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13322791_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13322801_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13322791_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13322815_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13322801_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323040_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13322803_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13322811_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13322803_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13322815_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323040_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323054_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323079_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323171_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323079_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323372_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323178_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323184_3 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323178_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323199_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323184_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323185_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323185_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324975_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323188_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323199_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323188_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323257_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323247_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323257_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323247_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323374_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323351_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323372_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323351_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323374_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323392_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323501_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323392_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324942_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323968_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324291_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13323968_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324333_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324033_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324362_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324033_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324477_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324078_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324090_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324078_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324208_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324094_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324208_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324094_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324979_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324298_0 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324308_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324298_1 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
Port_13324320_2 | SOURCEANDSINK | PIPE | FIREPROTECTION | WS_Požární zavodněný 1
