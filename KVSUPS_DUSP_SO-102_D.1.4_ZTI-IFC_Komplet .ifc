Properties of the parts of a building model (IFC4), part 42 of 60

# IfcPipeSegment: Ohebné trubky:Pancéřová hadice (265)
Name (Ohebné trubky:Pancéřová hadice:...) | In | Referenční podlaží | Počáteční střední výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Délka (mm) | Kód prvku | Název sestavy | Označení
12891687 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 49 | 239.66 | TR00.02.0088 | Umyvadlo + modul | 0088
12891689 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 48 | 239.66 | TR00.02.0089 | Umyvadlo + modul | 0089
12891778 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 55 | 239.66 | TR00.02.0090 | Umyvadlo + modul | 0090
12891780 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 54 | 239.66 | TR00.02.0091 | Umyvadlo + modul | 0091
12891851 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 59 | 239.66 | TR00.02.0092 | Umyvadlo + modul | 0092
12891853 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 58 | 239.66 | TR00.02.0093 | Umyvadlo + modul | 0093
12891923 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 61 | 239.66 | TR00.02.0094 | Umyvadlo + modul | 0094
12891925 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 60 | 239.66 | TR00.02.0095 | Umyvadlo + modul | 0095
12891998 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 63 | 239.66 | TR00.02.0096 | Umyvadlo + modul | 0096
12892000 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 62 | 239.66 | TR00.02.0097 | Umyvadlo + modul | 0097
12892064 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 65 | 239.66 | TR00.02.0098 | Umyvadlo + modul | 0098
12892066 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 64 | 239.66 | TR00.02.0099 | Umyvadlo + modul | 0099
12892281 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 67 | 239.66 | TR00.02.0100 | Umyvadlo + modul | 0100
12892283 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 66 | 239.66 | TR00.02.0101 | Umyvadlo + modul | 0101
12892348 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 69 | 239.66 | TR00.02.0102 | Umyvadlo + modul | 0102
12892350 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 68 | 239.66 | TR00.02.0103 | Umyvadlo + modul | 0103
12892414 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 71 | 239.66 | TR00.02.0104 | Umyvadlo + modul | 0104
12892416 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 70 | 239.66 | TR00.02.0105 | Umyvadlo + modul | 0105
12892480 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 73 | 239.66 | TR00.02.0106 | Umyvadlo + modul | 0106
12892482 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 72 | 239.66 | TR00.02.0107 | Umyvadlo + modul | 0107
12892545 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 75 | 239.66 | TR00.02.0108 | Umyvadlo + modul | 0108
12892547 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 74 | 239.66 | TR00.02.0109 | Umyvadlo + modul | 0109
12892798 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 87 | 239.66 | TR00.02.0110 | Umyvadlo + modul | 0110
12892800 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 86 | 239.66 | TR00.02.0111 | Umyvadlo + modul | 0111
12892901 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 89 | 239.66 | TR00.02.0112 | Umyvadlo + modul | 0112
12892903 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 88 | 239.66 | TR00.02.0113 | Umyvadlo + modul | 0113
12893032 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 91 | 239.66 | TR00.02.0114 | Umyvadlo + modul | 0114
12893034 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 90 | 239.66 | TR00.02.0115 | Umyvadlo + modul | 0115
12893157 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 93 | 239.66 | TR00.02.0116 | Umyvadlo + modul | 0116
12893159 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 92 | 239.66 | TR00.02.0117 | Umyvadlo + modul | 0117
12894058 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 98 | 239.66 | TR00.02.0121 | Umyvadlo + modul | 0121
12894060 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 94 | 239.66 | TR00.02.0122 | Umyvadlo + modul | 0122
12894124 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 99 | 239.66 | TR00.02.0123 | Umyvadlo + modul | 0123
12894126 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 95 | 239.66 | TR00.02.0124 | Umyvadlo + modul | 0124
12894203 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 100 | 239.66 | TR00.02.0125 | Umyvadlo + modul | 0125
12894205 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 96 | 239.66 | TR00.02.0126 | Umyvadlo + modul | 0126
12894267 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 101 | 239.66 | TR00.02.0127 | Umyvadlo + modul | 0127
12894269 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 97 | 239.66 | TR00.02.0128 | Umyvadlo + modul | 0128
12894328 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 102 | 239.66 | TR00.02.0129 | Umyvadlo + modul | 0129
12894330 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 98 | 239.66 | TR00.02.0130 | Umyvadlo + modul | 0130
12894673 | -2.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 103 | 239.66 | TR00.02.0131 | Umyvadlo + modul | 0131
12894675 | -2.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 99 | 239.66 | TR00.02.0132 | Umyvadlo + modul | 0132
12894787 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 104 | 239.66 | TR00.02.0133 | Umyvadlo + modul | 0133
12894789 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 100 | 239.66 | TR00.02.0134 | Umyvadlo + modul | 0134
12895097 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 105 | 239.66 | TR00.02.0135 | Umyvadlo + modul | 0135
12895099 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 101 | 239.66 | TR00.02.0136 | Umyvadlo + modul | 0136
12895280 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 106 | 239.66 | TR00.02.0137 | Umyvadlo + modul | 0137
12895282 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 102 | 239.66 | TR00.02.0138 | Umyvadlo + modul | 0138
12895304 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 107 | 239.66 | TR00.02.0139 | Umyvadlo + modul | 0139
12895306 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 103 | 239.66 | TR00.02.0140 | Umyvadlo + modul | 0140
12895435 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 110 | 239.66 | TR00.02.0141 | Umyvadlo + modul | 0141
12895437 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 106 | 239.66 | TR00.02.0142 | Umyvadlo + modul | 0142
12895781 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 113 | 239.66 | TR00.02.0143 | Umyvadlo + modul | 0143
12895783 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 109 | 239.66 | TR00.02.0144 | Umyvadlo + modul | 0144
12896135 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 114 | 239.66 | TR00.02.0145 | Umyvadlo + modul | 0145
12896137 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 110 | 239.66 | TR00.02.0146 | Umyvadlo + modul | 0146
12896335 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 115 | 239.66 | TR00.02.0147 | Umyvadlo + modul | 0147
12896337 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 111 | 239.66 | TR00.02.0148 | Umyvadlo + modul | 0148
12896403 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 116 | 239.66 | TR00.02.0149 | Umyvadlo + modul | 0149
12896405 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 112 | 239.66 | TR00.02.0150 | Umyvadlo + modul | 0150
12896716 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 120 | 239.66 | TR00.02.0151 | Umyvadlo + modul | 0151
12896718 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 116 | 239.66 | TR00.02.0152 | Umyvadlo + modul | 0152
12896776 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 121 | 239.66 | TR00.02.0153 | Umyvadlo + modul | 0153
12896778 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 117 | 239.66 | TR00.02.0154 | Umyvadlo + modul | 0154
12896892 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 122 | 239.66 | TR00.02.0155 | Umyvadlo + modul | 0155
12896894 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 118 | 239.66 | TR00.02.0156 | Umyvadlo + modul | 0156
12896916 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 123 | 239.66 | TR00.02.0157 | Umyvadlo + modul | 0157
12896918 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 119 | 239.66 | TR00.02.0158 | Umyvadlo + modul | 0158
12897289 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 124 | 239.66 | TR00.02.0159 | Umyvadlo + modul | 0159
12897291 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 120 | 239.66 | TR00.02.0160 | Umyvadlo + modul | 0160
12897362 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 125 | 239.66 | TR00.02.0161 | Umyvadlo + modul | 0161
12897364 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 121 | 239.66 | TR00.02.0162 | Umyvadlo + modul | 0162
12897413 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 127 | 239.66 | TR00.02.0163 | Umyvadlo + modul | 0163
12897415 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 123 | 239.66 | TR00.02.0164 | Umyvadlo + modul | 0164
12897444 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 128 | 239.66 | TR00.02.0165 | Umyvadlo + modul | 0165
12897446 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 124 | 239.66 | TR00.02.0166 | Umyvadlo + modul | 0166
12897751 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 130 | 239.66 | TR00.02.0167 | Umyvadlo + modul | 0167
12897753 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 126 | 239.66 | TR00.02.0168 | Umyvadlo + modul | 0168
12897775 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 131 | 239.66 | TR00.02.0169 | Umyvadlo + modul | 0169
12897777 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 127 | 239.66 | TR00.02.0170 | Umyvadlo + modul | 0170
12898199 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 132 | 239.66 | TR00.02.0171 | Umyvadlo + modul | 0171
12898201 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 128 | 239.66 | TR00.02.0172 | Umyvadlo + modul | 0172
12898223 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 133 | 239.66 | TR00.02.0173 | Umyvadlo + modul | 0173
12898225 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 129 | 239.66 | TR00.02.0174 | Umyvadlo + modul | 0174
12898545 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 135 | 239.66 | TR00.02.0175 | Umyvadlo + modul | 0175
12898547 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 131 | 239.66 | TR00.02.0176 | Umyvadlo + modul | 0176
12898596 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 137 | 239.66 | TR00.02.0177 | Umyvadlo + modul | 0177
12898598 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 133 | 239.66 | TR00.02.0178 | Umyvadlo + modul | 0178
12899101 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 79 | 239.66 | TR00.02.0179 | Umyvadlo + modul | 0179
12899103 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 50 | 239.66 | TR00.02.0180 | Umyvadlo + modul | 0180
12899369 | -1.PP_SO-102 | 1.NP_SO-102 | 120 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 46 | 355.681 | TR00.02.0181 | Bidet + modul | 0181
12899371 | -1.PP_SO-102 | 1.NP_SO-102 | 120 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 23 | 349.775 | TR00.02.0182 | Bidet + modul | 0182
12899472 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 57 | 239.66 | TR00.02.0183 | Umyvadlo + modul | 0183
12899474 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 56 | 239.66 | TR00.02.0184 | Umyvadlo + modul | 0184
12899560 | 2.NP_SO-102 | 3.NP_SO-102 | 120 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 51 | 355.681 | TR00.02.0185 | Bidet + modul | 0185
12899562 | 2.NP_SO-102 | 3.NP_SO-102 | 120 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 45 | 349.775 | TR00.02.0186 | Bidet + modul | 0186
12899622 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 139 | 239.66 | TR00.02.0187 | Umyvadlo + modul | 0187
12899624 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 135 | 239.66 | TR00.02.0188 | Umyvadlo + modul | 0188
12992014 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 183 | 239.66 | TR00.02.0189 | Umyvadlo + modul | 0189
12992016 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 76 | 239.66 | TR00.02.0190 | Umyvadlo + modul | 0190
12992032 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 78 | 239.66 | TR00.02.0191 | Umyvadlo + modul | 0191
12992034 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 77 | 239.66 | TR00.02.0192 | Umyvadlo + modul | 0192
13067071 | 3.NP_SO-102 | 4.NP_SO-102 | 120 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 182 | 355.681 | TR00.02.0193 | Bidet + modul | 0193
13067073 | 3.NP_SO-102 | 4.NP_SO-102 | 120 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 178 | 349.775 | TR00.02.0194 | Bidet + modul | 0194
13068778 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 199 | 239.66 | TR00.02.0195 | Umyvadlo + modul | 0195
13068780 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 200 | 239.66 | TR00.02.0196 | Umyvadlo + modul | 0196
13068916 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 200 | 239.66 | TR00.02.0197 | Umyvadlo + modul | 0197
13068918 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 201 | 239.66 | TR00.02.0198 | Umyvadlo + modul | 0198
13071947 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 37 | 239.66 | TR00.02.0199 | Umyvadlo + modul | 0199
13071949 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 36 | 239.66 | TR00.02.0200 | Umyvadlo + modul | 0200
13102567 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 12 | 239.66 | TR00.02.0201 | Umyvadlo + modul | 0201
13102569 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 4 | 239.66 | TR00.02.0202 | Umyvadlo + modul | 0202
13102682 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 14 | 239.66 | TR00.02.0203 | Umyvadlo + modul | 0203
13102684 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 9 | 239.66 | TR00.02.0204 | Umyvadlo + modul | 0204
13105037 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 15 | 239.66 | TR00.02.0205 | Umyvadlo + modul | 0205
13105039 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 10 | 239.66 | TR00.02.0206 | Umyvadlo + modul | 0206
13154253 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 13 | 239.66 | TR00.02.0207 | Umyvadlo + modul | 0207
13154255 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 8 | 239.66 | TR00.02.0208 | Umyvadlo + modul | 0208
13401577 | -1.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 19 | 238.594 | TR00.02.0210 | Výlevka nástěnné | 0210
13401579 | -1.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 21 | 238.594 | TR00.02.0211 | Výlevka nástěnné | 0211
13401604 | 1.NP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 18 | 238.594 | TR00.02.0212 | Výlevka nástěnné | 0212
13401606 | 1.NP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 17 | 238.594 | TR00.02.0213 | Výlevka nástěnné | 0213
13401725 | 2.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 89 | 302.376 | TR00.02.0214 | Výlevka nástěnnê | 0214
13401727 | 2.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 33 | 302.376 | TR00.02.0215 | Výlevka nástěnnê | 0215
13401874 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 36 | 239.66 | TR00.02.0216 | Umyvadlo | 0216
13401876 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 91 | 239.66 | TR00.02.0217 | Umyvadlo | 0217
13505814 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 90 | 239.66 | TR00.02.0218 | Umyvadlo + modul | 0218
13505816 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 138 | 239.66 | TR00.02.0219 | Umyvadlo + modul | 0219
13505922 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 117 | 239.66 | TR00.02.0220 | Umyvadlo + modul | 0220
13505924 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 114 | 239.66 | TR00.02.0221 | Umyvadlo + modul | 0221
13506564 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 92 | 239.66 | TR00.02.0222 | Umyvadlo + modul | 0222
13506566 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 122 | 239.66 | TR00.02.0223 | Umyvadlo + modul | 0223
13506637 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 94 | 239.66 | TR00.02.0224 | Umyvadlo + modul | 0224
13506639 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 113 | 239.66 | TR00.02.0225 | Umyvadlo + modul | 0225
13506747 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 97 | 239.66 | TR00.02.0226 | Umyvadlo + modul | 0226
13506749 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 93 | 239.66 | TR00.02.0227 | Umyvadlo + modul | 0227
13506815 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 96 | 239.66 | TR00.02.0228 | Umyvadlo + modul | 0228
13506817 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 78 | 239.66 | TR00.02.0229 | Umyvadlo + modul | 0229
13525886 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 118 | 239.66 | TR00.02.0230 | Umyvadlo + modul | 0230
13525888 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 130 | 239.66 | TR00.02.0231 | Umyvadlo + modul | 0231
13526119 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 126 | 239.66 | TR00.02.0232 | Umyvadlo + modul | 0232
13526121 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 140 | 239.66 | TR00.02.0233 | Umyvadlo + modul | 0233
13526370 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 119 | 239.66 | TR00.02.0234 | Umyvadlo + modul | 0234
13526372 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 125 | 239.66 | TR00.02.0235 | Umyvadlo + modul | 0235
13526787 | -2.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 88 | 239.66 | TR00.02.0236 | Umyvadlo + modul | 0236
13526789 | -2.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 115 | 239.66 | TR00.02.0237 | Umyvadlo + modul | 0237
13544047 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 80 | 239.66 | TR00.02.0238 | Umyvadlo + modul | 0238
13544049 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 73 | 239.66 | TR00.02.0239 | Umyvadlo + modul | 0239
13544816 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 134 | 239.66 | TR00.02.0240 | Umyvadlo | 0240
13544818 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 141 | 239.66 | TR00.02.0241 | Umyvadlo | 0241
13545128 | 3.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 142 | 238.594 | TR00.02.0242 | Výlevka nástěnnë | 0242
13545130 | 3.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 136 | 238.594 | TR00.02.0243 | Výlevka nástěnnë | 0243
13545325 | -2.PP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 65 | 238.594 | TR00.02.0244 | Výlevka nástěnnë | 0244
13545327 | -2.PP_SO-102 | 4.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 74 | 238.594 | TR00.02.0245 | Výlevka nástěnnë | 0245
13545423 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 138 | 239.66 | TR00.02.0246 | Umyvadlo + modul | 0246
13545425 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 144 | 239.66 | TR00.02.0247 | Umyvadlo + modul | 0247
13546120 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 140 | 239.66 | TR00.02.0248 | Umyvadlo | 0248
13546122 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 145 | 239.66 | TR00.02.0249 | Umyvadlo | 0249
13550212 | 3.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 146 | 302.376 | TR00.02.0250 | Výlevka nástěnnê | 0250
13550214 | 3.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 141 | 302.376 | TR00.02.0251 | Výlevka nástěnnê | 0251
13725005 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 18 | 288.19 | TR00.02.0252 | Výlevka nástěnnî | 0252
13725007 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 13 | 240.295 | TR00.02.0253 | Výlevka nástěnnî | 0253
13728593 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 22 | 288.19 | TR00.02.0254 | Výlevka nástěnnñ | 0254
13728595 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 14 | 240.295 | TR00.02.0255 | Výlevka nástěnnñ | 0255
13728669 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 5 | 288.19 | TR00.02.0256 | Výlevka nástěnnñ | 0256
13728671 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 11 | 240.295 | TR00.02.0257 | Výlevka nástěnnñ | 0257
13733482 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 39 | 288.19 | TR00.02.0258 | Výlevka nástěnnî | 0258
13733484 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 17 | 240.295 | TR00.02.0259 | Výlevka nástěnnî | 0259
14005552 | -2.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 23 | 288.19 | TR00.02.0260 | Výlevka nástěnnò | 0260
14005554 | -2.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 1 | 240.295 | TR00.02.0261 | Výlevka nástěnnò | 0261
14005933 | -2.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 1 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 24 | 288.19 | TR00.02.0262 | Výlevka nástěnnô | 0262
14005935 | -2.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 1 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 20 | 240.295 | TR00.02.0263 | Výlevka nástěnnô | 0263
14007194 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 40 | 288.19 | TR00.02.0264 | Výlevka nástěnnö | 0264
14007196 | 3.NP_SO-102 | 4.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 22 | 240.295 | TR00.02.0265 | Výlevka nástěnnö | 0265
14007274 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 11 | 288.19 | TR00.02.0266 | Výlevka nástěnnö | 0266
14007276 | 2.NP_SO-102 | 3.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 12 | 240.295 | TR00.02.0267 | Výlevka nástěnnö | 0267
14007305 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 41 | 288.19 | TR00.02.0268 | Výlevka nástěnnö | 0268
14007307 | 1.NP_SO-102 | 2.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 32 | 240.295 | TR00.02.0269 | Výlevka nástěnnö | 0269
14007334 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 77 | 288.19 | TR00.02.0270 | Výlevka nástěnnö | 0270
14007336 | -1.PP_SO-102 | 1.NP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 35 | 240.295 | TR00.02.0271 | Výlevka nástěnnö | 0271
14030747 | -2.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 2 | WS_Teplá vnitřní | Teplá voda v domácnosti | WS_Teplá vnitřní 109 | 239.66 | TR00.02.0272 | Umyvadlo | 0272
14030749 | -2.PP_SO-102 | -1.PP_SO-102 | 605 | Fáze 2 | WS_Studená vnitřní | Studená voda v domácnosti | WS_Studená vnitřní 39 | 239.66 | TR00.02.0273 | Umyvadlo | 0273

# IfcPipeSegment: Typy trubek:HDPE 100+_odvodnění střech (126)
Type - Material: 0-128-0
Type - Požární ochrana - Požární odolnost: B2, DIN 4102
Type - Identifikační data - ID kategorie: TR; Kód sestavy: TR12; Komentáře k typům: black, RAL 9002, ø30-ø315, Lmax 5m (ø32 = Lmax 3m); Model: QuickStream PE; Název typu: HDPE 100+_odvodnění střech; Označení typu: 02; Popis: HDPE 100+; Popis sestavy: High-density Polyethylene (HDPE); URL: https://www.wavin.com; Výrobce: Wavin
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR12 SNIM (SNIM); TR12 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Instalační jednotky: 0
Text - CCI Komponenta: WPA; CCI Technický systém: JD
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Mechanické - Drsnost: 0.01 mm; Klasifikace systému: Sanitární; Materiál: PE, Black, RAL9200; Popis úseku: HDPE–QSPE PN3,2; Typ přípoje: Obecné; Úsek potrubí: PE, Black, RAL9200 - PE, Black, RAL9200 -PE100 (EN1519 /PN 3.2) (OD); Výkaz/typ: PE, Black, RAL9200 -PE100 (EN1519 /PN 3.2) (OD)
Jiné - Rodina: Typy trubek; Id typu: 9442182; Rodina a typ: Typy trubek: HDPE 100+_odvodnění střech; Typ: HDPE 100+_odvodnění střech
Name (Typy trubek:HDPE 100+_odvodnění střech:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Relativní drsnost | CCI Funkční systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) | Spodní výška (mm) | Střední výška (mm) | Fáze vytvoření | Řez | Název systému = Group | Obrátit výšku (mm) | Průměr (mm) = Vnější průměr (mm) | Typ systému | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Sklon
12903732 | 4.NP_SO-102 | 11937.8 | 0.00950189 | 4.1254 | ø110 mm | 0.0000984252 | G | 4.NP_SO-102 | 3187.06 | 3187.06 | -8750.71 | -8750.71 | -8750.71 | Fáze 1 | 3 | SW_Deště vnitřní podtlak 4 | 3249.29 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.0002 | 0002 | yes | Identifikační data - Komentáře: D5
12911809 | 4.NP_SO-102 | 11876.2 | 0.00950189 | 4.10413 | ø110 mm | 0.0000984252 | G | 4.NP_SO-102 | 3187.06 | 3187.06 | -8689.17 | -8689.17 | -8689.17 | Fáze 1 | 14 | SW_Deště vnitřní podtlak 4 | 3310.83 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.0006 | 0006 | yes | Identifikační data - Komentáře: D6
12913860 | 4.NP_SO-102 | 11646.2 | 0.01227 | 4.57345 | ø125 mm | 0.0000866551 | G | 4.NP_SO-102 | 3177.56 | -8468.64 | 3177.56 | -8468.64 | 3177.56 | Fáze 2 | 33 | SW_Deště vnitřní podtlak 4 | 3531.36 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.0024 | 0024 | yes
13181839 | 4.NP_SO-102 | 280.87 | 0.00246264 | 0.0494133 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3278 | 3250 | 3250 | 3222 | 3250 | Fáze 1 | 1 | SW_Deště vnitřní podtlak 4 | 15225 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1102 | 1102 | no | 0
13181851 | 4.NP_SO-102 | 5072.34 | 0.00246264 | 0.892372 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3278 | 3250 | 3250 | 3222 | 3250 | Fáze 1 | 1 | SW_Deště vnitřní podtlak 4 | 15225 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1103 | 1103 | no | 0
13182001 | 4.NP_SO-102 | 507.062 | 0.00246264 | 0.0892071 | ø56 mm | 0.0002 | G | STŘECHA_SO-102 | -57 | -57 | -564.062 | -564.062 | -564.062 | Fáze 1 | 1 | SW_Deště vnitřní podtlak 4 | 15285.9 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1104 | 1104 | no
13182035 | 4.NP_SO-102 | 501.455 | 0.00246264 | 0.0882206 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3278 | 3250 | 3250 | 3222 | 3250 | Fáze 1 | 10 | SW_Deště vnitřní podtlak 4 | 15225 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1105 | 1105 | no | 0
13182044 | 4.NP_SO-102 | 1128.25 | 0.00950189 | 0.389895 | ø110 mm | 0.0000984252 | G | 4.NP_SO-102 | 3305 | 3250 | 3250 | 3195 | 3250 | Fáze 1 | 3 | SW_Deště vnitřní podtlak 4 | 15199.2 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1106 | 1106 | no | 0
13182048 | 4.NP_SO-102 | 1322.79 | 0.00246264 | 0.232717 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3278 | 3250 | 3250 | 3222 | 3250 | Fáze 1 | 10 | SW_Deště vnitřní podtlak 4 | 15225 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1107 | 1107 | no | 0
13182086 | 4.NP_SO-102 | 507.062 | 0.00246264 | 0.0892071 | ø56 mm | 0.0002 | G | STŘECHA_SO-102 | -57 | -57 | -564.062 | -564.062 | -564.062 | Fáze 1 | 10 | SW_Deště vnitřní podtlak 4 | 15285.9 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1108 | 1108 | no
13237036 | 4.NP_SO-102 | 507.062 | 0.00246264 | 0.0892071 | ø56 mm | 0.0002 | G | STŘECHA_SO-102 | -57 | -57 | -564.062 | -564.062 | -564.062 | Fáze 1 | 12 | SW_Deště vnitřní podtlak 4 | 15285.9 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1109 | 1109 | no
13237038 | 4.NP_SO-102 | 507.062 | 0.00246264 | 0.0892071 | ø56 mm | 0.0002 | G | STŘECHA_SO-102 | -57 | -57 | -564.062 | -564.062 | -564.062 | Fáze 1 | 16 | SW_Deště vnitřní podtlak 4 | 15285.9 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1110 | 1110 | no
13237070 | 4.NP_SO-102 | 234.062 | 0.00246264 | 0.0411784 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3278 | 3250 | 3250 | 3222 | 3250 | Fáze 1 | 16 | SW_Deště vnitřní podtlak 4 | 15225 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1111 | 1111 | no | 0
13237166 | 4.NP_SO-102 | 1324.69 | 0.00246264 | 0.233052 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3278 | 3250 | 3250 | 3222 | 3250 | Fáze 1 | 12 | SW_Deště vnitřní podtlak 4 | 15225 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1112 | 1112 | no | 0
13237230 | 4.NP_SO-102 | 4867.24 | 0.00246264 | 0.856289 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3278 | 3250 | 3250 | 3222 | 3250 | Fáze 1 | 16 | SW_Deště vnitřní podtlak 4 | 15225 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1113 | 1113 | no | 0
13237298 | 4.NP_SO-102 | 435.259 | 0.00246264 | 0.0765748 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3278 | 3250 | 3250 | 3222 | 3250 | Fáze 1 | 12 | SW_Deště vnitřní podtlak 4 | 15225 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1114 | 1114 | no | 0
13237316 | 4.NP_SO-102 | 1175.04 | 0.00950189 | 0.406064 | ø110 mm | 0.0000984252 | G | 4.NP_SO-102 | 3305 | 3250 | 3250 | 3195 | 3250 | Fáze 1 | 14 | SW_Deště vnitřní podtlak 4 | 15199.2 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1115 | 1115 | no | 0
13237343 | 1.NP_SO-102 | 4314.54 | 0.00950189 | 1.491 | ø110 mm | 0.0000984252 | G | 1.NP_SO-102 | 3192.04 | 3137.04 | 3093.9 | 3038.9 | 3093.9 | Fáze 1 | 14 | SW_Deště vnitřní podtlak 4 | 3043.1 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1116 | 1116 | yes | 1
13237361 | 1.NP_SO-102 | 4197.14 | 0.00950189 | 1.45043 | ø110 mm | 0.0000984252 | G | 1.NP_SO-102 | 3061.4 | 3006.41 | 2964.44 | 2909.44 | 2964.44 | Fáze 1 | 3 | SW_Deště vnitřní podtlak 4 | 2913.64 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1117 | 1117 | yes | 1
13237610 | 1.NP_SO-102 | 381.14 | 0.00950189 | 0.131713 | ø110 mm | 0.0000984252 | G | 1.NP_SO-102 | 3148.37 | 3089.57 | 3093.38 | 3034.57 | 3093.38 | Fáze 1 | 14 | SW_Deště vnitřní podtlak 4 | 3038.77 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1118 | 1118 | yes | 1
13237632 | 1.NP_SO-102 | 510.836 | 0.01227 | 0.200605 | ø125 mm | 0.0000866551 | G | 1.NP_SO-102 | 3021.03 | 2953.42 | 2958.53 | 2890.92 | 2958.53 | Fáze 1 | 46 | SW_Deště vnitřní podtlak 4 | 2895.72 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1119 | 1119 | yes | 1
13237642 | 1.NP_SO-102 | 1090.01 | 0.01227 | 0.428044 | ø125 mm | 0.0000866551 | G | 1.NP_SO-102 | 3015.32 | 2941.92 | 2952.82 | 2879.42 | 2952.82 | Fáze 1 | 46 | SW_Deště vnitřní podtlak 4 | 2884.22 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1120 | 1120 | yes | 1
13237714 | 1.NP_SO-102 | 449.485 | 0.00950189 | 0.155331 | ø110 mm | 0.0000984252 | G | 1.NP_SO-102 | 3018.91 | 2963.91 | 2959.42 | 2904.42 | 2959.42 | Fáze 1 | 3 | SW_Deště vnitřní podtlak 4 | 2908.62 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1121 | 1121 | yes | 1
13237723 | 1.NP_SO-102 | 12742 | 0.00950189 | 4.4033 | ø110 mm | 0.0000984252 | G | 1.NP_SO-102 | 3141.83 | 2959.42 | 3086.83 | 2904.42 | 3086.83 | Fáze 1 | 15 | SW_Deště vnitřní podtlak 4 | 2908.62 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1122 | 1122 | yes | 1
13238021 | 1.NP_SO-102 | 950.973 | 0.00950189 | 0.328633 | ø110 mm | 0.0000984252 | G | 1.NP_SO-102 | 2697.66 | 2633.15 | 2642.66 | 2578.15 | 2642.66 | Fáze 1 | 45 | SW_Deště vnitřní podtlak 4 | 2582.35 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1123 | 1123 | yes | 1
13238469 | 4.NP_SO-102 | 471.125 | 0.00246264 | 0.0828846 | ø56 mm | 0.0002 | G | STŘECHA_SO-102 | -57 | -57 | -528.125 | -528.125 | -528.125 | Fáze 1 | 27 | SW_Deště vnitřní podtlak 4 | 15321.9 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1124 | 1124 | no
13238522 | 4.NP_SO-102 | 471.125 | 0.00246264 | 0.0828846 | ø56 mm | 0.0002 | G | STŘECHA_SO-102 | -57 | -528.125 | -57 | -528.125 | -57 | Fáze 1 | 30 | SW_Deště vnitřní podtlak 4 | 15321.9 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1125 | 1125 | no | Identifikační data - Komentáře: D1
13238868 | 4.NP_SO-102 | 257.825 | 0.00246264 | 0.0453589 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3313.94 | 3285.94 | 3285.94 | 3257.94 | 3285.94 | Fáze 1 | 27 | SW_Deště vnitřní podtlak 4 | 15260.9 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1126 | 1126 | no | 0
13238889 | 4.NP_SO-102 | 575.887 | 0.00246264 | 0.101315 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3313.94 | 3285.94 | 3285.94 | 3257.94 | 3285.94 | Fáze 1 | 30 | SW_Deště vnitřní podtlak 4 | 15260.9 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1127 | 1127 | no | 0
13239016 | 4.NP_SO-102 | 668.125 | 0.00246264 | 0.117543 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3313.94 | 3285.94 | 3285.94 | 3257.94 | 3285.94 | Fáze 1 | 27 | SW_Deště vnitřní podtlak 4 | 15260.9 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1128 | 1128 | no | 0
13239026 | 4.NP_SO-102 | 15879.2 | 0.00246264 | 2.79361 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3313.94 | 3285.94 | 3285.94 | 3257.94 | 3285.94 | Fáze 1 | 27 | SW_Deště vnitřní podtlak 4 | 15260.9 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1129 | 1129 | no | 0
13239055 | 4.NP_SO-102 | 668.125 | 0.00246264 | 0.117543 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3313.94 | 3285.94 | 3285.94 | 3257.94 | 3285.94 | Fáze 1 | 30 | SW_Deště vnitřní podtlak 4 | 15260.9 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1130 | 1130 | no | 0
13239122 | 4.NP_SO-102 | 7668.77 | 0.00950189 | 2.65014 | ø110 mm | 0.0000984252 | G | 4.NP_SO-102 | 2978.15 | -4690.62 | 2978.15 | -4690.62 | 2978.15 | Fáze 1 | 38 | SW_Deště vnitřní podtlak 4 | 7309.38 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1131 | 1131 | yes | Identifikační data - Komentáře: D1
13239207 | 4.NP_SO-102 | 207.928 | 0.00246264 | 0.0365806 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3295.21 | 3275.41 | 3128.38 | 3108.59 | 3128.38 | Fáze 1 | 27 | SW_Deště vnitřní podtlak 4 | 15110.7 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1132 | 1132 | no | 100
13239258 | 4.NP_SO-102 | 51.7457 | 0.00246264 | 0.00910357 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3201.05 | 3149.31 | 3201.05 | 3149.31 | 3201.05 | Fáze 1 | 30 | SW_Deště vnitřní podtlak 4 | 15149.3 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1133 | 1133 | no
13239260 | 4.NP_SO-102 | 459.177 | 0.00246264 | 0.0807826 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3313.94 | 3285.94 | 3285.94 | 3257.94 | 3285.94 | Fáze 1 | 30 | SW_Deště vnitřní podtlak 4 | 15260.9 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1134 | 1134 | no | 0
13239378 | 4.NP_SO-102 | 69.2233 | 0.00246264 | 0.0121784 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3295.21 | 3226.46 | 3275.41 | 3206.66 | 3275.41 | Fáze 1 | 30 | SW_Deště vnitřní podtlak 4 | 15208.8 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1135 | 1135 | no | 100
13239602 | 2.NP_SO-102 | 374.48 | 0.00950189 | 0.129411 | ø110 mm | 0.0000984252 | G | 2.NP_SO-102 | 3301.44 | 3246.44 | 3246.44 | 3191.44 | 3246.44 | Fáze 1 | 38 | SW_Deště vnitřní podtlak 4 | 7195.64 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1136 | 1136 | yes | 0
13239614 | 2.NP_SO-102 | 254.125 | 0.00950189 | 0.0878193 | ø110 mm | 0.0000984252 | G | 2.NP_SO-102 | 3301.44 | 3246.44 | 3246.44 | 3191.44 | 3246.44 | Fáze 1 | 38 | SW_Deště vnitřní podtlak 4 | 7195.64 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1137 | 1137 | yes | 0
13239886 | -1.PP_SO-102 | 727.837 | 0.0779194 | 0.720268 | ø315 mm | 0.0000338295 | G | -1.PP_SO-102 | -3566.58 | -3724.08 | -3724.08 | -3881.58 | -3724.08 | Fáze 1 | 42 | SW_Deště vnitřní podtlak 4 | -7871.88 | 315 | SW_Deště vnitřní podtlak | ø315 | 295.6 | TR12.02.1138 | 1138 | yes | 0
13239899 | -1.PP_SO-102 | 6070.3 | 0.0779194 | 6.00718 | ø315 mm | 0.0000338295 | G | -1.PP_SO-102 | 2511.66 | -3558.64 | 2511.66 | -3558.64 | 2511.66 | Fáze 1 | 42 | SW_Deště vnitřní podtlak 4 | -7558.64 | 315 | SW_Deště vnitřní podtlak | ø315 | 295.6 | TR12.02.1139 | 1139 | yes | Identifikační data - Komentáře: D1
13240137 | -1.PP_SO-102 | 337.655 | 0.00950189 | 0.116685 | ø110 mm | 0.0000984252 | G | -1.PP_SO-102 | 2922.07 | 2867.07 | 2867.07 | 2812.07 | 2867.07 | Fáze 1 | 45 | SW_Deště vnitřní podtlak 4 | -1183.73 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1140 | 1140 | yes | 0
13240148 | 1.NP_SO-102 | 3360.95 | 0.00950189 | 1.16146 | ø110 mm | 0.0000984252 | G | 1.NP_SO-102 | 2290.96 | -1069.99 | 2290.96 | -1069.99 | 2290.96 | Fáze 1 | 45 | SW_Deště vnitřní podtlak 4 | -1069.99 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1141 | 1141 | yes | Identifikační data - Komentáře: D1
13240227 | 3.NP_SO-102 | 830.101 | 0.01227 | 0.32598 | ø125 mm | 0.0000866551 | G | 3.NP_SO-102 | 10.0006 | -820.101 | 10 | -820.102 | 10 | Fáze 1 | 18 | SW_Deště vnitřní podtlak 4 | 7179.9 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1142 | 1142 | yes | Identifikační data - Komentáře: D3
13240577 | 2.NP_SO-102 | 875.1 | 0.01227 | 0.343651 | ø125 mm | 0.0000866551 | G | 2.NP_SO-102 | 3790 | 2914.9 | 3790 | 2914.9 | 3790 | Fáze 1 | 20 | SW_Deště vnitřní podtlak 4 | 6914.9 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1143 | 1143 | yes | Identifikační data - Komentáře: D5
13241225 | 2.NP_SO-102 | 264.935 | 0.01227 | 0.10404 | ø125 mm | 0.0000866551 | G | 2.NP_SO-102 | 2908.58 | 2677.05 | 2864.39 | 2632.85 | 2864.39 | Fáze 1 | 20 | SW_Deště vnitřní podtlak 4 | 6636.25 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1144 | 1144 | yes | 100
13241854 | 1.NP_SO-102 | 317.161 | 0.00950189 | 0.109603 | ø110 mm | 0.0000984252 | G | 1.NP_SO-102 | 2598.62 | 2335.46 | 2559.73 | 2296.57 | 2559.73 | Fáze 1 | 45 | SW_Deště vnitřní podtlak 4 | 2299.54 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1145 | 1145 | yes | 100
13242411 | 1.NP_SO-102 | 4948.06 | 0.01227 | 1.9431 | ø125 mm | 0.0000866551 | G | 1.NP_SO-102 | 3350.55 | 3288.05 | 3238.57 | 3176.07 | 3238.57 | Fáze 2 | 33 | SW_Deště vnitřní podtlak 4 | 3180.87 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1146 | 1146 | yes | 1
13242485 | 1.NP_SO-102 | 13512.7 | 0.01227 | 5.30644 | ø125 mm | 0.0000866551 | G | 1.NP_SO-102 | 3287.51 | 3225.01 | 3089.89 | 3027.39 | 3089.89 | Fáze 1 | 33 | SW_Deště vnitřní podtlak 4 | 3032.19 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1147 | 1147 | yes | 1
13242557 | 4.NP_SO-102 | 508.062 | 0.00246264 | 0.089383 | ø56 mm | 0.0002 | G | STŘECHA_SO-102 | -57 | -57 | -565.062 | -565.062 | -565.062 | Fáze 2 | 31 | SW_Deště vnitřní podtlak 4 | 15284.9 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1148 | 1148 | no
13242571 | 4.NP_SO-102 | 508.062 | 0.00246264 | 0.089383 | ø56 mm | 0.0002 | G | STŘECHA_SO-102 | -57 | -57 | -565.062 | -565.062 | -565.062 | Fáze 2 | 35 | SW_Deště vnitřní podtlak 4 | 15284.9 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1149 | 1149 | no
13242595 | 4.NP_SO-102 | 4322.38 | 0.00246264 | 0.760432 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3277 | 3249 | 3249 | 3221 | 3249 | Fáze 2 | 31 | SW_Deště vnitřní podtlak 4 | 15224 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1150 | 1150 | no | 0
13242673 | 4.NP_SO-102 | 727.66 | 0.00246264 | 0.128017 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3277 | 3249 | 3249 | 3221 | 3249 | Fáze 2 | 31 | SW_Deště vnitřní podtlak 4 | 15224 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1151 | 1151 | no | 0
13242809 | 4.NP_SO-102 | 979.02 | 0.01227 | 0.38446 | ø125 mm | 0.0000866551 | G | 4.NP_SO-102 | 3311.5 | 3249 | 3249 | 3186.5 | 3249 | Fáze 2 | 33 | SW_Deště vnitřní podtlak 4 | 15191.3 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1152 | 1152 | no | 0
13242843 | 4.NP_SO-102 | 245.114 | 0.00246264 | 0.0431227 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3277 | 3249 | 3249 | 3221 | 3249 | Fáze 2 | 35 | SW_Deště vnitřní podtlak 4 | 15224 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1153 | 1153 | no | 0
13242853 | 4.NP_SO-102 | 315.492 | 0.00246264 | 0.0555042 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3277 | 3249 | 3249 | 3221 | 3249 | Fáze 2 | 35 | SW_Deště vnitřní podtlak 4 | 15224 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1154 | 1154 | no | 0
13242866 | 4.NP_SO-102 | 2606.27 | 0.00246264 | 0.458519 | ø56 mm | 0.0002 | G | 4.NP_SO-102 | 3277 | 3249 | 3249 | 3221 | 3249 | Fáze 2 | 35 | SW_Deště vnitřní podtlak 4 | 15224 | 56 | SW_Deště vnitřní podtlak | ø56 | 50 | TR12.02.1155 | 1155 | no | 0
13242972 | 1.NP_SO-102 | 659.766 | 0.01227 | 0.259089 | ø125 mm | 0.0000866551 | G | 1.NP_SO-102 | 3357.73 | 3295.24 | 3288.64 | 3226.14 | 3288.64 | Fáze 2 | 33 | SW_Deště vnitřní podtlak 4 | 3230.94 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1156 | 1156 | yes | 1
13242988 | 1.NP_SO-102 | 4086.91 | 0.01227 | 1.60492 | ø125 mm | 0.0000866551 | G | 1.NP_SO-102 | 3399.19 | 3336.7 | 3295.83 | 3233.33 | 3295.83 | Fáze 2 | 33 | SW_Deště vnitřní podtlak 4 | 3238.13 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1157 | 1157 | yes | 1
13243149 | 1.NP_SO-102 | 254.492 | 0.00950189 | 0.087946 | ø110 mm | 0.0000984252 | G | 1.NP_SO-102 | 3243.68 | 3024.84 | 3204.79 | 2985.95 | 3204.79 | Fáze 1 | 3 | SW_Deště vnitřní podtlak 4 | 2988.92 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1158 | 1158 | yes | 100
13243222 | 1.NP_SO-102 | 156.778 | 0.00950189 | 0.0541784 | ø110 mm | 0.0000984252 | G | 1.NP_SO-102 | 3305.22 | 3155.47 | 3266.33 | 3116.58 | 3266.33 | Fáze 1 | 14 | SW_Deště vnitřní podtlak 4 | 3119.55 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1159 | 1159 | yes | 100
13243320 | 1.NP_SO-102 | 174.279 | 0.01227 | 0.0684393 | ø125 mm | 0.0000866551 | G | 1.NP_SO-102 | 3525.04 | 3357.62 | 3480.85 | 3313.42 | 3480.85 | Fáze 2 | 33 | SW_Deště vnitřní podtlak 4 | 3316.82 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1160 | 1160 | yes | 100
13243728 | 3.NP_SO-102 | 4592.19 | 0.01227 | 1.80335 | ø125 mm | 0.0000866551 | G | 3.NP_SO-102 | 3789 | -803.194 | 3789 | -803.194 | 3789 | Fáze 1 | 54 | SW_Deště vnitřní podtlak 4 | 7196.81 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1161 | 1161 | yes | Identifikační data - Komentáře: D4
13243859 | 3.NP_SO-102 | 4674.28 | 0.01227 | 1.83559 | ø125 mm | 0.0000866551 | G | 3.NP_SO-102 | 3789.7 | -884.584 | 3789.7 | -884.584 | 3789.7 | Fáze 1 | 57 | SW_Deště vnitřní podtlak 4 | 7115.42 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1162 | 1162 | yes | Identifikační data - Komentáře: D3
13243984 | 2.NP_SO-102 | 4395.05 | 0.01227 | 1.72593 | ø125 mm | 0.0000866551 | G | 2.NP_SO-102 | 3187.87 | 3081.42 | 3125.37 | 3018.93 | 3125.37 | Fáze 1 | 54 | SW_Deště vnitřní podtlak 4 | 7023.73 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1163 | 1163 | yes | 1
13244112 | 2.NP_SO-102 | 199.027 | 0.01227 | 0.0781578 | ø125 mm | 0.0000866551 | G | 2.NP_SO-102 | 3143.33 | 3078.84 | 3080.83 | 3016.35 | 3080.83 | Fáze 1 | 54 | SW_Deště vnitřní podtlak 4 | 7021.15 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1164 | 1164 | yes | 1
13244204 | 2.NP_SO-102 | 4439.68 | 0.01227 | 1.74346 | ø125 mm | 0.0000866551 | G | 2.NP_SO-102 | 3106.48 | 2999.59 | 3043.98 | 2937.09 | 3043.98 | Fáze 1 | 57 | SW_Deště vnitřní podtlak 4 | 6941.89 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1165 | 1165 | yes | 1
13244605 | -1.PP_SO-102 | 309.007 | 0.00950189 | 0.106785 | ø110 mm | 0.0000984252 | G | -1.PP_SO-102 | 2921.8 | 2863.72 | 2866.81 | 2808.72 | 2866.81 | Fáze 1 | 45 | SW_Deště vnitřní podtlak 4 | -1187.08 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1166 | 1166 | yes | 1
13244623 | -1.PP_SO-102 | 940.22 | 0.00950189 | 0.324917 | ø110 mm | 0.0000984252 | G | -1.PP_SO-102 | 2918.19 | 2853.79 | 2863.2 | 2798.8 | 2863.2 | Fáze 1 | 45 | SW_Deště vnitřní podtlak 4 | -1197 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1167 | 1167 | yes | 1
13244633 | -1.PP_SO-102 | 216.861 | 0.00950189 | 0.0749418 | ø110 mm | 0.0000984252 | G | -1.PP_SO-102 | 2908.27 | 2851.1 | 2853.27 | 2796.11 | 2853.27 | Fáze 1 | 45 | SW_Deště vnitřní podtlak 4 | -1199.69 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1168 | 1168 | yes | 1
13244643 | -1.PP_SO-102 | 6137.11 | 0.00950189 | 2.12083 | ø110 mm | 0.0000984252 | G | -1.PP_SO-102 | 2905.58 | 2789.22 | 2850.58 | 2734.22 | 2850.58 | Fáze 1 | 45 | SW_Deště vnitřní podtlak 4 | -1261.58 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1169 | 1169 | yes | 1
13244659 | -1.PP_SO-102 | 474.588 | 0.00950189 | 0.164006 | ø110 mm | 0.0000984252 | G | -1.PP_SO-102 | 2843.69 | 2783.95 | 2788.69 | 2728.95 | 2788.69 | Fáze 1 | 45 | SW_Deště vnitřní podtlak 4 | -1266.85 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1170 | 1170 | yes | 1
13244669 | -1.PP_SO-102 | 9264.95 | 0.00950189 | 3.20174 | ø110 mm | 0.0000984252 | G | -1.PP_SO-102 | 2838.42 | 2690.78 | 2783.43 | 2635.78 | 2783.43 | Fáze 1 | 45 | SW_Deště vnitřní podtlak 4 | -1360.02 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1171 | 1171 | yes | 1
13244917 | -1.PP_SO-102 | 364.11 | 0.0779194 | 0.360324 | ø315 mm | 0.0000338295 | G | -1.PP_SO-102 | 2838.22 | 2680.73 | 2677.09 | 2519.59 | 2677.09 | Fáze 1 | 42 | SW_Deště vnitřní podtlak 4 | -1470.71 | 315 | SW_Deště vnitřní podtlak | ø315 | 295.6 | TR12.02.1172 | 1172 | yes | 1
13244977 | -1.PP_SO-102 | 948.626 | 0.00950189 | 0.327822 | ø110 mm | 0.0000984252 | G | -1.PP_SO-102 | 2750.35 | 2685.87 | 2695.35 | 2630.87 | 2685.87 | Fáze 1 | 39 | SW_Deště vnitřní podtlak 4 | -1364.93 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1173 | 1173 | yes | 1
13269634 | 2.NP_SO-102 | 329.217 | 0.01227 | 0.129283 | ø125 mm | 0.0000866551 | G | 2.NP_SO-102 | 3173.58 | 2896.59 | 3129.39 | 2852.4 | 3129.39 | Fáze 1 | 18 | SW_Deště vnitřní podtlak 4 | 6855.79 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1179 | 1179 | yes | 100
13269658 | 2.NP_SO-102 | 7832.07 | 0.01227 | 3.07565 | ø125 mm | 0.0000866551 | G | 2.NP_SO-102 | 2938.17 | 2797.36 | 2875.67 | 2734.86 | 2875.67 | Fáze 1 | 18 | SW_Deště vnitřní podtlak 4 | 6739.66 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1180 | 1180 | yes | 1
13269839 | 3.NP_SO-102 | 984.827 | 0.01227 | 0.386741 | ø125 mm | 0.0000866551 | G | 3.NP_SO-102 | 10.0006 | 10.0006 | -974.826 | -974.826 | -974.826 | Fáze 1 | 36 | SW_Deště vnitřní podtlak 4 | 7025.17 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1181 | 1181 | yes | Identifikační data - Komentáře: D3
13504003 | -1.PP_SO-102 | 334.563 | 0.0779194 | 0.331084 | ø315 mm | 0.0000338295 | G | -1.PP_SO-102 | -3224.08 | -3224.08 | -3558.64 | -3558.64 | -3558.64 | Fáze 1 | 42 | SW_Deště vnitřní podtlak 4 | -7558.64 | 315 | SW_Deště vnitřní podtlak | ø315 | 295.6 | TR12.02.1512 | 1512 | yes
13514517 | -1.PP_SO-102 | 1007.89 | 0.01227 | 0.395798 | ø125 mm | 0.0000866551 | G | -1.PP_SO-102 | 3890 | 2882.11 | 3890 | 2882.11 | 3890 | Fáze 1 | 6 | SW_Deště vnitřní gravitační 2 | -1117.89 | 125 | SW_Deště vnitřní gravitační | ø125 | 115.4 | TR12.02.1522 | 1522 | yes
13630558 | -1.PP_SO-102 | 3318.72 | 0.01227 | 1.30326 | ø125 mm | 0.0000866551 | G | -1.PP_SO-102 | 2873.17 | 2777.49 | 2810.68 | 2714.99 | 2810.68 | Fáze 1 | 6 | SW_Deště vnitřní gravitační 2 | -1280.21 | 125 | SW_Deště vnitřní gravitační | ø125 | 115.4 | TR12.02.1615 | 1615 | yes | 1
13630685 | -1.PP_SO-102 | 4215.34 | 0.01227 | 1.65536 | ø125 mm | 0.0000866551 | G | -1.PP_SO-102 | 2706.06 | -1509.28 | 2706.06 | -1509.28 | 2706.06 | Fáze 1 | 6 | SW_Deště vnitřní gravitační 2 | -5509.28 | 125 | SW_Deště vnitřní gravitační | ø125 | 115.4 | TR12.02.1616 | 1616 | yes
13630772 | -1.PP_SO-102 | 1179.68 | 0.01227 | 0.46326 | ø125 mm | 0.0000866551 | G | -1.PP_SO-102 | -1515.6 | -2393.96 | -1559.79 | -2438.15 | -1559.79 | Fáze 1 | 6 | SW_Deště vnitřní gravitační 2 | -6434.76 | 125 | SW_Deště vnitřní gravitační | ø125 | 115.4 | TR12.02.1617 | 1617 | yes | 100
13678529 | -1.PP_SO-102 | 24.2592 | 0.0779194 | 0.0240069 | ø315 mm | 0.0000338295 | G | -1.PP_SO-102 | 2839.83 | 2682.1 | 2682.34 | 2524.6 | 2682.34 | Fáze 1 | 42 | SW_Deště vnitřní podtlak 4 | -1465.7 | 315 | SW_Deště vnitřní podtlak | ø315 | 295.6 | TR12.02.1761 | 1761 | yes | 1
13678539 | -1.PP_SO-102 | 439.402 | 0.00950189 | 0.151847 | ø110 mm | 0.0000984252 | G | -1.PP_SO-102 | 2745.26 | 2685.87 | 2690.26 | 2630.87 | 2690.26 | Fáze 1 | 45 | SW_Deště vnitřní podtlak 4 | -1364.93 | 110 | SW_Deště vnitřní podtlak | ø110 | 101.6 | TR12.02.1762 | 1762 | yes | 1
13683857 | 2.NP_SO-102 | 9083.95 | 0.01227 | 3.56726 | ø125 mm | 0.0000866551 | G | 2.NP_SO-102 | 2718.62 | 2656.13 | 2565.29 | 2502.79 | 2565.29 | Fáze 1 | 20 | SW_Deště vnitřní podtlak 4 | 6507.59 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1787 | 1787 | yes | 1.00002
13687747 | 2.NP_SO-102 | 421.027 | 0.01227 | 0.165337 | ø125 mm | 0.0000866551 | G | 2.NP_SO-102 | 2859.26 | 2792.56 | 2796.77 | 2730.06 | 2796.77 | Fáze 1 | 18 | SW_Deště vnitřní podtlak 4 | 6734.86 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1788 | 1788 | yes | 1
13687764 | 2.NP_SO-102 | 115.086 | 0.01227 | 0.0451941 | ø125 mm | 0.0000866551 | G | 2.NP_SO-102 | 2851.91 | 2788.26 | 2789.41 | 2725.76 | 2789.41 | Fáze 1 | 44 | SW_Deště vnitřní podtlak 4 | 6730.56 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1789 | 1789 | yes | 1
13687837 | 2.NP_SO-102 | 41.0891 | 0.01227 | 0.0161357 | ø125 mm | 0.0000866551 | G | 2.NP_SO-102 | 2855.46 | 2792.97 | 2792.56 | 2730.06 | 2792.56 | Fáze 1 | 36 | SW_Deště vnitřní podtlak 4 | 6734.86 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1790 | 1790 | yes | 1
13687846 | 2.NP_SO-102 | 227.369 | 0.01227 | 0.0892875 | ø125 mm | 0.0000866551 | G | 2.NP_SO-102 | 3018.85 | 2813.89 | 2974.66 | 2769.69 | 2974.66 | Fáze 1 | 36 | SW_Deště vnitřní podtlak 4 | 6773.09 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1791 | 1791 | yes | 100
13687968 | 2.NP_SO-102 | 284.816 | 0.01227 | 0.111847 | ø125 mm | 0.0000866551 | G | 2.NP_SO-102 | 2811.54 | 2565.95 | 2767.34 | 2521.75 | 2767.34 | Fáze 1 | 44 | SW_Deště vnitřní podtlak 4 | 6525.15 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1792 | 1792 | yes | 100
13688043 | 2.NP_SO-102 | 3376.7 | 0.01227 | 1.32603 | ø125 mm | 0.0000866551 | G | 2.NP_SO-102 | 2515.43 | -861.271 | 2515.43 | -861.271 | 2515.43 | Fáze 1 | 44 | SW_Deště vnitřní podtlak 4 | 3138.73 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1793 | 1793 | yes
13706117 | 2.NP_SO-102 | 290.212 | 0.01227 | 0.113966 | ø125 mm | 0.0000866551 | G | 2.NP_SO-102 | 3790 | 3790 | 3499.79 | 3499.79 | 3499.79 | Fáze 1 | 23 | SW_Deště vnitřní podtlak 4 | 7499.79 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1829 | 1829 | yes
13706119 | 2.NP_SO-102 | 1093.01 | 0.01227 | 0.429225 | ø125 mm | 0.0000866551 | G | 2.NP_SO-102 | 3493.47 | 3449.27 | 2676.4 | 2632.2 | 2676.4 | Fáze 1 | 23 | SW_Deště vnitřní podtlak 4 | 6635.6 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1830 | 1830 | yes | 100
13706122 | 2.NP_SO-102 | 3165.41 | 0.01227 | 1.24305 | ø125 mm | 0.0000866551 | G | 2.NP_SO-102 | 2624.6 | 2530.45 | 2562.1 | 2467.96 | 2562.1 | Fáze 1 | 21 | SW_Deště vnitřní podtlak 4 | 6472.75 | 125 | SW_Deště vnitřní podtlak | ø125 | 115.4 | TR12.02.1831 | 1831 | yes | 0.999911
