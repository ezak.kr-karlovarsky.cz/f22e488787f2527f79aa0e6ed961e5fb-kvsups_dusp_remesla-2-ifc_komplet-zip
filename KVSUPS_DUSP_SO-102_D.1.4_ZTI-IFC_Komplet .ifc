Properties of the parts of a building model (IFC4), part 26 of 60

# IfcDistributionPort (11856)
Name | FlowDirection | PredefinedType | SystemType | Group
OutPort_14025333_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14025333_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14035054_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14025590_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14036746_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14035052_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14025590_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_14026467_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14026649_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027454_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027465_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027454_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027480_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027469_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027480_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027469_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027490_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027484_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027490_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027484_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027571_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027494_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027571_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027494_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027583_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027575_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027576_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027575_3 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14027583_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14028057_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14028059_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14028665_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 3
Port_14028665_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 3
Port_14028667_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Deště vnitřní gravitační 3
InPort_14030753_1 | SINK | PIPE | SEWAGE
OutPort_14030744_1 | SOURCE | PIPE | SEWAGE
InPort_14030745_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 109
InPort_14030747_0 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 109
OutPort_14030745_2 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 109
InPort_14030746_1 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 39
InPort_14030749_0 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 39
OutPort_14030746_2 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 39
InPort_14030751_1 | SINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 109
OutPort_14030747_1 | SOURCE | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 109
InPort_14030751_2 | SINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 39
OutPort_14030749_1 | SOURCE | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 39
Port_14030753_2 | SOURCEANDSINK | PIPE | SEWAGE
InPort_14033857_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 14
OutPort_14033720_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 14
InPort_14033840_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 14
OutPort_14033861_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 14
InPort_14033867_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 14
OutPort_14033840_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 14
InPort_14033855_0 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 14
OutPort_14033857_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 14
InPort_14033861_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 14
OutPort_14033855_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 14
Port_14035997_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14036414_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14036076_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14036117_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14036117_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14036456_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14036406_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14036414_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14036406_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14036452_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14036418_0 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14036452_2 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14036418_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
Port_14036456_1 | SOURCEANDSINK | PIPE | SEWAGE | SW_Splašky vnitřní gravitační 35 (1)
InPort_14036748_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14036671_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14036671_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14036752_2 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14036746_2 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14036744_0 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
InPort_14036744_1 | SINK | PIPE | VENT | SW_Odvětrání kanalizace 16
OutPort_14036748_1 | SOURCE | PIPE | VENT | SW_Odvětrání kanalizace 16
Port_14037121_0 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14037185_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14037121_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14037132_1 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14037185_2 | SOURCEANDSINK | PIPE | DOMESTICCOLDWATER | WS_Studená vnitřní 134
Port_14037147_0 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14037175_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14037147_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14037156_1 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83
Port_14037175_2 | SOURCEANDSINK | PIPE | DOMESTICHOTWATER | WS_Teplá vnitřní 83

# IfcDistributionSystem: SW_Deště vnitřní gravitační (5)
PredefinedType: SEWAGE
Name
SW_Deště vnitřní gravitační 2
SW_Deště vnitřní gravitační 1
SW_Deště vnitřní gravitační 3
SW_Deště vnitřní gravitační 4
SW_Deště vnitřní gravitační 5

# IfcDistributionSystem: SW_Deště vnitřní podtlak, SW_Deště vnitřní podtlak 4
PredefinedType: SEWAGE

# IfcDistributionSystem: SW_Deště čerpání, SW_Deště čerpání 1
PredefinedType: SEWAGE

# IfcDistributionSystem: SW_Odvětrání kanalizace (17)
PredefinedType: VENT
Name
SW_Odvětrání kanalizace 1
SW_Odvětrání kanalizace 16
SW_Odvětrání kanalizace 15
SW_Odvětrání kanalizace 10
SW_Odvětrání kanalizace 17
SW_Odvětrání kanalizace 2
SW_Odvětrání kanalizace 3
SW_Odvětrání kanalizace 6
SW_Odvětrání kanalizace 7
SW_Odvětrání kanalizace 8
SW_Odvětrání kanalizace 9
SW_Odvětrání kanalizace 4
SW_Odvětrání kanalizace 11
SW_Odvětrání kanalizace 20
SW_Odvětrání kanalizace 14
SW_Odvětrání kanalizace 18
SW_Odvětrání kanalizace 19

# IfcDistributionSystem: SW_Splašky přípojka (3)
PredefinedType: SEWAGE
Name
SW_Splašky přípojka 1
SW_Splašky přípojka 3
SW_Splašky přípojka 2

# IfcDistributionSystem: SW_Splašky vnitřní gravitační (7)
PredefinedType: SEWAGE
Name
SW_Splašky vnitřní gravitační 16
SW_Splašky vnitřní gravitační 35 (1)
SW_Splašky vnitřní gravitační 3
SW_Splašky vnitřní gravitační 4
SW_Splašky vnitřní gravitační 15
SW_Splašky vnitřní gravitační 65
SW_Splašky vnitřní gravitační 11

# IfcDistributionSystem: SW_Splašky čerpání (2)
PredefinedType: SEWAGE
Name
SW_Splašky čerpání 1
SW_Splašky čerpání 2

# IfcDistributionSystem: WS_"ŠEDÁ" studená vnitřní (7)
PredefinedType: DOMESTICCOLDWATER
Name
WS_"Jiný typ" studená vnitřní 1
WS_"ŠEDÁ" studená vnitřní 3
WS_"ŠEDÁ" studená vnitřní 1
WS_"ŠEDÁ" studená vnitřní 2
WS_"ŠEDÁ" studená vnitřní 22
WS_"ŠEDÁ" studená vnitřní 23
WS_"ŠEDÁ" studená vnitřní 24

# IfcDistributionSystem: WS_Cirkulace vnitřní (3)
PredefinedType: DOMESTICHOTWATER
Name
WS_Cirkulace vnitřní 9
WS_Cirkulace vnitřní 4
WS_Cirkulace vnitřní 3

# IfcDistributionSystem: WS_Požární nezavodněný (2)
PredefinedType: FIREPROTECTION
Name
WS_Požární nezavodněný 1
WS_Požární nezavodněný 2

# IfcDistributionSystem: WS_Požární zavodněný (3)
PredefinedType: FIREPROTECTION
Name
WS_Požární zavodněný 2
WS_Požární zavodněný 1
WS_Požární zavodněný 3

# IfcDistributionSystem: WS_Studená vnitřní (137)
PredefinedType: DOMESTICCOLDWATER
Name
WS_Studená vnitřní 5
WS_Studená vnitřní 24
WS_Studená vnitřní 25
WS_Studená vnitřní 16
WS_Studená vnitřní 15
WS_Studená vnitřní 7
WS_Studená vnitřní 26
WS_Studená vnitřní 21
WS_Studená vnitřní 27
WS_Studená vnitřní 28
WS_Studená vnitřní 29
WS_Studená vnitřní 30
WS_Studená vnitřní 41
WS_Studená vnitřní 43
WS_Studená vnitřní 47
WS_Studená vnitřní 49
WS_Studená vnitřní 51
WS_Studená vnitřní 42
WS_Studená vnitřní 46
WS_Studená vnitřní 53
WS_Studená vnitřní 55
WS_Studená vnitřní 57
WS_Studená vnitřní 44
WS_Studená vnitřní 52
WS_Studená vnitřní 59
WS_Studená vnitřní 61
WS_Studená vnitřní 63
WS_Studená vnitřní 67
WS_Studená vnitřní 2
WS_Studená vnitřní 71
WS_Studená vnitřní 75
WS_Studená vnitřní 69
WS_Studená vnitřní 33
WS_Studená vnitřní 34
WS_Studená vnitřní 37
WS_Studená vnitřní 80
WS_Studená vnitřní 82
WS_Studená vnitřní 83
WS_Studená vnitřní 81
WS_Studená vnitřní 84
WS_Studená vnitřní 85
WS_Studená vnitřní 31
WS_Studená vnitřní 48
WS_Studená vnitřní 54
WS_Studená vnitřní 58
WS_Studená vnitřní 60
WS_Studená vnitřní 62
WS_Studená vnitřní 64
WS_Studená vnitřní 66
WS_Studená vnitřní 68
WS_Studená vnitřní 70
WS_Studená vnitřní 72
WS_Studená vnitřní 74
WS_Studená vnitřní 86
WS_Studená vnitřní 88
WS_Studená vnitřní 90
WS_Studená vnitřní 92
WS_Studená vnitřní 94
WS_Studená vnitřní 95
WS_Studená vnitřní 96
WS_Studená vnitřní 97
WS_Studená vnitřní 98
WS_Studená vnitřní 99
WS_Studená vnitřní 100
WS_Studená vnitřní 101
WS_Studená vnitřní 102
WS_Studená vnitřní 103
WS_Studená vnitřní 106
WS_Studená vnitřní 109
WS_Studená vnitřní 110
WS_Studená vnitřní 111
WS_Studená vnitřní 112
WS_Studená vnitřní 116
WS_Studená vnitřní 117
WS_Studená vnitřní 118
WS_Studená vnitřní 119
WS_Studená vnitřní 120
WS_Studená vnitřní 121
WS_Studená vnitřní 123
WS_Studená vnitřní 124
WS_Studená vnitřní 126
WS_Studená vnitřní 127
WS_Studená vnitřní 128
WS_Studená vnitřní 129
WS_Studená vnitřní 131
WS_Studená vnitřní 133
WS_Studená vnitřní 50
WS_Studená vnitřní 23
WS_Studená vnitřní 56
WS_Studená vnitřní 45
WS_Studená vnitřní 135
WS_Studená vnitřní 134
WS_Studená vnitřní 179
WS_Studená vnitřní 76
WS_Studená vnitřní 77
WS_Studená vnitřní 3
WS_Studená vnitřní 6
WS_Studená vnitřní 178
WS_Studená vnitřní 200
WS_Studená vnitřní 201
WS_Studená vnitřní 36
WS_Studená vnitřní 4
WS_Studená vnitřní 9
WS_Studená vnitřní 10
WS_Studená vnitřní 8
WS_Studená vnitřní 19
WS_Studená vnitřní 18
WS_Studená vnitřní 89
WS_Studená vnitřní 91
WS_Studená vnitřní 138
WS_Studená vnitřní 114
WS_Studená vnitřní 122
WS_Studená vnitřní 113
WS_Studená vnitřní 93
WS_Studená vnitřní 78
WS_Studená vnitřní 130
WS_Studená vnitřní 140
WS_Studená vnitřní 125
WS_Studená vnitřní 115
WS_Studená vnitřní 73
WS_Studená vnitřní 141
WS_Studená vnitřní 142
WS_Studená vnitřní 65
WS_Studená vnitřní 144
WS_Studená vnitřní 145
WS_Studená vnitřní 146
WS_Studená vnitřní 13
WS_Studená vnitřní 14
WS_Studená vnitřní 11
WS_Studená vnitřní 17
WS_Studená vnitřní 1
WS_Studená vnitřní 20
WS_Studená vnitřní 22
WS_Studená vnitřní 12
WS_Studená vnitřní 32
WS_Studená vnitřní 35
WS_Studená vnitřní 39

# IfcDistributionSystem: WS_Teplá vnitřní (142)
PredefinedType: DOMESTICHOTWATER
Name
WS_Teplá vnitřní 1
WS_Teplá vnitřní 3
WS_Teplá vnitřní 7
WS_Teplá vnitřní 6
WS_Teplá vnitřní 2
WS_Teplá vnitřní 26
WS_Teplá vnitřní 19
WS_Teplá vnitřní 10
WS_Teplá vnitřní 9
WS_Teplá vnitřní 27
WS_Teplá vnitřní 25
WS_Teplá vnitřní 28
WS_Teplá vnitřní 29
WS_Teplá vnitřní 30
WS_Teplá vnitřní 31
WS_Teplá vnitřní 42
WS_Teplá vnitřní 44
WS_Teplá vnitřní 48
WS_Teplá vnitřní 50
WS_Teplá vnitřní 52
WS_Teplá vnitřní 43
WS_Teplá vnitřní 47
WS_Teplá vnitřní 54
WS_Teplá vnitřní 56
WS_Teplá vnitřní 58
WS_Teplá vnitřní 45
WS_Teplá vnitřní 53
WS_Teplá vnitřní 60
WS_Teplá vnitřní 62
WS_Teplá vnitřní 64
WS_Teplá vnitřní 68
WS_Teplá vnitřní 4
WS_Teplá vnitřní 72
WS_Teplá vnitřní 76
WS_Teplá vnitřní 70
WS_Teplá vnitřní 34
WS_Teplá vnitřní 35
WS_Teplá vnitřní 38
WS_Teplá vnitřní 81
WS_Teplá vnitřní 83
WS_Teplá vnitřní 84
WS_Teplá vnitřní 82
WS_Teplá vnitřní 85
WS_Teplá vnitřní 86
WS_Teplá vnitřní 32
WS_Teplá vnitřní 49
WS_Teplá vnitřní 55
WS_Teplá vnitřní 59
WS_Teplá vnitřní 61
WS_Teplá vnitřní 63
WS_Teplá vnitřní 65
WS_Teplá vnitřní 67
WS_Teplá vnitřní 69
WS_Teplá vnitřní 71
WS_Teplá vnitřní 73
WS_Teplá vnitřní 75
WS_Teplá vnitřní 87
WS_Teplá vnitřní 89
WS_Teplá vnitřní 91
WS_Teplá vnitřní 93
WS_Teplá vnitřní 20
WS_Teplá vnitřní 95
WS_Teplá vnitřní 66
WS_Teplá vnitřní 98
WS_Teplá vnitřní 99
WS_Teplá vnitřní 100
WS_Teplá vnitřní 101
WS_Teplá vnitřní 102
WS_Teplá vnitřní 103
WS_Teplá vnitřní 104
WS_Teplá vnitřní 105
WS_Teplá vnitřní 106
WS_Teplá vnitřní 107
WS_Teplá vnitřní 110
WS_Teplá vnitřní 113
WS_Teplá vnitřní 114
WS_Teplá vnitřní 115
WS_Teplá vnitřní 116
WS_Teplá vnitřní 120
WS_Teplá vnitřní 121
WS_Teplá vnitřní 122
WS_Teplá vnitřní 123
WS_Teplá vnitřní 124
WS_Teplá vnitřní 125
WS_Teplá vnitřní 127
WS_Teplá vnitřní 128
WS_Teplá vnitřní 130
WS_Teplá vnitřní 131
WS_Teplá vnitřní 132
WS_Teplá vnitřní 133
WS_Teplá vnitřní 135
WS_Teplá vnitřní 137
WS_Teplá vnitřní 79
WS_Teplá vnitřní 46
WS_Teplá vnitřní 57
WS_Teplá vnitřní 51
WS_Teplá vnitřní 139
WS_Teplá vnitřní 193
WS_Teplá vnitřní 183
WS_Teplá vnitřní 78
WS_Teplá vnitřní 8
WS_Teplá vnitřní 182
WS_Teplá vnitřní 199
WS_Teplá vnitřní 200
WS_Teplá vnitřní 37
WS_Teplá vnitřní 12
WS_Teplá vnitřní 14
WS_Teplá vnitřní 15
WS_Teplá vnitřní 13
WS_Teplá vnitřní 16
WS_Teplá vnitřní 21
WS_Teplá vnitřní 17
WS_Teplá vnitřní 33
WS_Teplá vnitřní 36
WS_Teplá vnitřní 90
WS_Teplá vnitřní 117
WS_Teplá vnitřní 92
WS_Teplá vnitřní 94
WS_Teplá vnitřní 97
WS_Teplá vnitřní 96
WS_Teplá vnitřní 118
WS_Teplá vnitřní 126
WS_Teplá vnitřní 119
WS_Teplá vnitřní 88
WS_Teplá vnitřní 80
WS_Teplá vnitřní 134
WS_Teplá vnitřní 136
WS_Teplá vnitřní 74
WS_Teplá vnitřní 138
WS_Teplá vnitřní 140
WS_Teplá vnitřní 141
WS_Teplá vnitřní 18
WS_Teplá vnitřní 22
WS_Teplá vnitřní 5
WS_Teplá vnitřní 39
WS_Teplá vnitřní 23
WS_Teplá vnitřní 24
WS_Teplá vnitřní 40
WS_Teplá vnitřní 11
WS_Teplá vnitřní 41
WS_Teplá vnitřní 77
WS_Teplá vnitřní 109

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Bidet + modul (4)
PredefinedType: USERDEFINED; Classification: ZT03 SNIM (SNIM); ZT03 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JB
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 12882067; Rodina a typ: Sestava Instalační zařizovací předměty: Bidet + modul; Typ: Bidet + modul
Identifikační data(Type) - ID kategorie: BI; Název typu: Bidet + modul
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Bidet + modul:...) | In | Fáze vytvoření
12882004 | 1.NP_SO-102 | Fáze 1
12899373 | -1.PP_SO-102 | Fáze 2
12899564 | 2.NP_SO-102 | Fáze 2
13067075 | 3.NP_SO-102 | Fáze 1

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Pisoár + modul (20)
PredefinedType: USERDEFINED; Classification: MT04 SNIM (SNIM); MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JB
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 12878709; Rodina a typ: Sestava Instalační zařizovací předměty: Pisoár + modul; Typ: Pisoár + modul
Identifikační data(Type) - ID kategorie: P; Název typu: Pisoár + modul
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Pisoár + modul:...) | In | Fáze vytvoření
12879584 | -1.PP_SO-102 | Fáze 1
12879626 | -1.PP_SO-102 | Fáze 1
12879638 | -1.PP_SO-102 | Fáze 1
12880775 | 1.NP_SO-102 | Fáze 1
12880780 | 1.NP_SO-102 | Fáze 1
12880785 | 1.NP_SO-102 | Fáze 1
12880945 | 2.NP_SO-102 | Fáze 1
12880950 | 2.NP_SO-102 | Fáze 1
12880955 | 2.NP_SO-102 | Fáze 1
12881115 | 3.NP_SO-102 | Fáze 1
12881120 | 3.NP_SO-102 | Fáze 1
12881125 | 3.NP_SO-102 | Fáze 1
12890549 | 1.NP_SO-102 | Fáze 1
12890558 | 1.NP_SO-102 | Fáze 1
12890570 | 1.NP_SO-102 | Fáze 1
12894933 | -1.PP_SO-102 | Fáze 2
12895863 | 1.NP_SO-102 | Fáze 2
12897019 | 2.NP_SO-102 | Fáze 2
12897902 | 3.NP_SO-102 | Fáze 2
13154273 | -1.PP_SO-102 | Fáze 2

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Sprchový kout + modul (podomítková baterie) (6)
In: -2.PP_SO-102
PredefinedType: USERDEFINED
Text - CCI Funkční systém: F; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 12833297; Rodina a typ: Sestava Instalační zařizovací předměty: Sprchový kout + modul (podomítková baterie); Typ: Sprchový kout + modul (podomítková baterie)
Identifikační data(Type) - ID kategorie: SP; Název typu: Sprchový kout + modul (podomítková baterie)
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Sprchový kout + modul (podomítková baterie):...)
12825558
12825572 | Classification: MT04 SNIM (SNIM); MT04 Uniformat (Uniformat)
12886115
14005432
14005462
14005514

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Sprchový kout - vanička (nástěnná baterie) (8)
PredefinedType: USERDEFINED; Classification: ZT08 SNIM (SNIM); ZT08 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JB
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Id typu: 12798050; Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Rodina a typ: Sestava Instalační zařizovací předměty: Sprchový kout - vanička (nástěnná baterie); Typ: Sprchový kout - vanička (nástěnná baterie)
Identifikační data(Type) - ID kategorie: SP; Název typu: Sprchový kout - vanička (nástěnná baterie)
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Sprchový kout - vanička (nástěnná baterie):...) | In | Fáze vytvoření
12797924 | -1.PP_SO-102 | Fáze 1
12805484 | -1.PP_SO-102 | Fáze 1
12833684 | -2.PP_SO-102 | Fáze 1
12833748 | -2.PP_SO-102 | Fáze 1
12893443 | 2.NP_SO-102 | Fáze 1
12893488 | 2.NP_SO-102 | Fáze 1
12893967 | 2.NP_SO-102 | Fáze 1
13325306 | -1.PP_SO-102 | Fáze 2

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Toaleta + modul (50)
PredefinedType: USERDEFINED; Classification: ZT01 SNIM (SNIM); ZT01 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JB
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 12822894; Rodina a typ: Sestava Instalační zařizovací předměty: Toaleta + modul; Typ: Toaleta + modul
Identifikační data(Type) - ID kategorie: WC; Název typu: Toaleta + modul
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Toaleta + modul:...) | In | Fáze vytvoření
12833556 | -2.PP_SO-102 | Fáze 1
12833581 | -2.PP_SO-102 | Fáze 1
12866035 | -1.PP_SO-102 | Fáze 1
12879218 | -1.PP_SO-102 | Fáze 1 | Fázování - Bouráno ve FÁZI 2: no
12879267 | -1.PP_SO-102 | Fáze 1
12879278 | -1.PP_SO-102 | Fáze 1
12879293 | -1.PP_SO-102 | Fáze 1
12879306 | -1.PP_SO-102 | Fáze 1
12880186 | -1.PP_SO-102 | Fáze 1
12880672 | 1.NP_SO-102 | Fáze 1
12880676 | 1.NP_SO-102 | Fáze 1
12880680 | 1.NP_SO-102 | Fáze 1
12880684 | 1.NP_SO-102 | Fáze 1
12880688 | 1.NP_SO-102 | Fáze 1
12880842 | 2.NP_SO-102 | Fáze 1
12880846 | 2.NP_SO-102 | Fáze 1
12880850 | 2.NP_SO-102 | Fáze 1
12880854 | 2.NP_SO-102 | Fáze 1
12880858 | 2.NP_SO-102 | Fáze 1
12881012 | 3.NP_SO-102 | Fáze 1
12881016 | 3.NP_SO-102 | Fáze 1
12881020 | 3.NP_SO-102 | Fáze 1
12881024 | 3.NP_SO-102 | Fáze 1
12881028 | 3.NP_SO-102 | Fáze 1
12881913 | 1.NP_SO-102 | Fáze 1
12889907 | 1.NP_SO-102 | Fáze 1
12889915 | 1.NP_SO-102 | Fáze 1
12889926 | 1.NP_SO-102 | Fáze 1
12889948 | 1.NP_SO-102 | Fáze 1
12892700 | 3.NP_SO-102 | Fáze 1
12894600 | -2.PP_SO-102 | Fáze 2
12894890 | -1.PP_SO-102 | Fáze 2
12894983 | -1.PP_SO-102 | Fáze 2
12894991 | -1.PP_SO-102 | Fáze 2
12895978 | 1.NP_SO-102 | Fáze 2
12896033 | 1.NP_SO-102 | Fáze 2
12896041 | 1.NP_SO-102 | Fáze 2
12897075 | 2.NP_SO-102 | Fáze 2
12897083 | 2.NP_SO-102 | Fáze 2
12897094 | 2.NP_SO-102 | Fáze 2
12897990 | 3.NP_SO-102 | Fáze 2
12897998 | 3.NP_SO-102 | Fáze 2
12898009 | 3.NP_SO-102 | Fáze 2
12899419 | -1.PP_SO-102 | Fáze 2
12899601 | 2.NP_SO-102 | Fáze 2
12992048 | 1.NP_SO-102 | Fáze 1
12992052 | 1.NP_SO-102 | Fáze 1
13154283 | -1.PP_SO-102 | Fáze 2
13691414 | 1.NP_SO-102 | Fáze 1
14005368 | -2.PP_SO-102 | Fáze 1

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Toaleta + modul (madla, lehká kce)_invalida (6)
PredefinedType: USERDEFINED; Classification: MT04 SNIM (SNIM); MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JB
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 13717418; Rodina a typ: Sestava Instalační zařizovací předměty: Toaleta + modul (madla, lehká kce)_invalida; Typ: Toaleta + modul (madla, lehká kce)_invalida
Identifikační data(Type) - ID kategorie: WCI; Název typu: Toaleta + modul (madla, lehká kce)_invalida
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Toaleta + modul (madla, lehká kce)_invalida:...) | In | Fáze vytvoření | Bouráno ve FÁZI 2
13725114 | -1.PP_SO-102 | Fáze 1 | yes
13733495 | 2.NP_SO-102 | Fáze 1 | yes
14007102 | 3.NP_SO-102 | Fáze 2 | no
14007267 | 2.NP_SO-102 | Fáze 2 | no
14007298 | 1.NP_SO-102 | Fáze 2 | no
14007327 | -1.PP_SO-102 | Fáze 2 | no

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Umyvadlo (7)
PredefinedType: USERDEFINED; Classification: ZT05 SNIM (SNIM); ZT05 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JB
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 12871338; Rodina a typ: Sestava Instalační zařizovací předměty: Umyvadlo; Typ: Umyvadlo
Identifikační data(Type) - ID kategorie: UM; Název typu: Umyvadlo
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Umyvadlo:...) | In | Fáze vytvoření
12825630 | -2.PP_SO-102 | Fáze 1
12884691 | 1.NP_SO-102 | Fáze 1
12884801 | 1.NP_SO-102 | Fáze 1
13401881 | 1.NP_SO-102 | Fáze 1
13544823 | 2.NP_SO-102 | Fáze 1
13546127 | 2.NP_SO-102 | Fáze 1
14030754 | -2.PP_SO-102 | Fáze 2

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Umyvadlo + modul (105)
PredefinedType: USERDEFINED; Classification: MT04 SNIM (SNIM); MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JB
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 12869983; Rodina a typ: Sestava Instalační zařizovací předměty: Umyvadlo + modul; Typ: Umyvadlo + modul
Identifikační data(Type) - ID kategorie: UM; Název typu: Umyvadlo + modul
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Umyvadlo + modul:...) | In | Fáze vytvoření
12865988 | -1.PP_SO-102 | Fáze 1
12871092 | -2.PP_SO-102 | Fáze 1
12871120 | -2.PP_SO-102 | Fáze 1
12871181 | -2.PP_SO-102 | Fáze 1
12879382 | -1.PP_SO-102 | Fáze 1
12879423 | -1.PP_SO-102 | Fáze 1
12879452 | -1.PP_SO-102 | Fáze 1
12879483 | -1.PP_SO-102 | Fáze 1
12879510 | -1.PP_SO-102 | Fáze 1
12879539 | -1.PP_SO-102 | Fáze 1
12880701 | 1.NP_SO-102 | Fáze 1
12880715 | 1.NP_SO-102 | Fáze 1
12880743 | 1.NP_SO-102 | Fáze 1
12880757 | 1.NP_SO-102 | Fáze 1
12880771 | 1.NP_SO-102 | Fáze 1
12880871 | 2.NP_SO-102 | Fáze 1
12880885 | 2.NP_SO-102 | Fáze 1
12880913 | 2.NP_SO-102 | Fáze 1
12880927 | 2.NP_SO-102 | Fáze 1
12880941 | 2.NP_SO-102 | Fáze 1
12881041 | 3.NP_SO-102 | Fáze 1
12881055 | 3.NP_SO-102 | Fáze 1
12881083 | 3.NP_SO-102 | Fáze 1
12881097 | 3.NP_SO-102 | Fáze 1
12881111 | 3.NP_SO-102 | Fáze 1
12881942 | 1.NP_SO-102 | Fáze 1
12886227 | -2.PP_SO-102 | Fáze 1
12888142 | -1.PP_SO-102 | Fáze 1
12888849 | 1.NP_SO-102 | Fáze 1
12888873 | 1.NP_SO-102 | Fáze 1
12889683 | 1.NP_SO-102 | Fáze 1
12890315 | 1.NP_SO-102 | Fáze 1
12890342 | 1.NP_SO-102 | Fáze 1
12890453 | 1.NP_SO-102 | Fáze 1
12890838 | 1.NP_SO-102 | Fáze 1
12890862 | 1.NP_SO-102 | Fáze 1
12891283 | -1.PP_SO-102 | Fáze 1
12891694 | 1.NP_SO-102 | Fáze 1
12891785 | 1.NP_SO-102 | Fáze 1
12891858 | 1.NP_SO-102 | Fáze 1
12891930 | 1.NP_SO-102 | Fáze 1
12892005 | 1.NP_SO-102 | Fáze 1
12892071 | 1.NP_SO-102 | Fáze 1
12892288 | 2.NP_SO-102 | Fáze 1
12892355 | 2.NP_SO-102 | Fáze 1
12892421 | 2.NP_SO-102 | Fáze 1
12892487 | 2.NP_SO-102 | Fáze 1
12892552 | 2.NP_SO-102 | Fáze 1
12892805 | 3.NP_SO-102 | Fáze 1
12892908 | 3.NP_SO-102 | Fáze 1
12893039 | 3.NP_SO-102 | Fáze 1
12893164 | 3.NP_SO-102 | Fáze 1
12894065 | 3.NP_SO-102 | Fáze 1
12894131 | 3.NP_SO-102 | Fáze 1
12894210 | 2.NP_SO-102 | Fáze 1
12894274 | 2.NP_SO-102 | Fáze 1
12894335 | 2.NP_SO-102 | Fáze 1
12894680 | -2.PP_SO-102 | Fáze 2
12894794 | -1.PP_SO-102 | Fáze 2
12895104 | -1.PP_SO-102 | Fáze 2
12895287 | -1.PP_SO-102 | Fáze 2
12895311 | -1.PP_SO-102 | Fáze 2
12895442 | -1.PP_SO-102 | Fáze 2
12895788 | 1.NP_SO-102 | Fáze 2
12896142 | 1.NP_SO-102 | Fáze 2
12896342 | 1.NP_SO-102 | Fáze 2
12896410 | 1.NP_SO-102 | Fáze 2
12896723 | 1.NP_SO-102 | Fáze 2
12896783 | 1.NP_SO-102 | Fáze 2
12896899 | 2.NP_SO-102 | Fáze 2
12896923 | 2.NP_SO-102 | Fáze 2
12897296 | 2.NP_SO-102 | Fáze 2
12897369 | 2.NP_SO-102 | Fáze 2
12897420 | 2.NP_SO-102 | Fáze 2
12897451 | 2.NP_SO-102 | Fáze 2
12897758 | 3.NP_SO-102 | Fáze 2
12897782 | 3.NP_SO-102 | Fáze 2
12898206 | 3.NP_SO-102 | Fáze 2
12898230 | 3.NP_SO-102 | Fáze 2
12898552 | 3.NP_SO-102 | Fáze 2
12898603 | 3.NP_SO-102 | Fáze 2
12899108 | 2.NP_SO-102 | Fáze 1
12899479 | -1.PP_SO-102 | Fáze 2
12899629 | 2.NP_SO-102 | Fáze 2
12992021 | 1.NP_SO-102 | Fáze 1
12992039 | 1.NP_SO-102 | Fáze 1
13068785 | 3.NP_SO-102 | Fáze 1
13068923 | 2.NP_SO-102 | Fáze 1
13071954 | -1.PP_SO-102 | Fáze 1
13102574 | -1.PP_SO-102 | Fáze 1
13102689 | -1.PP_SO-102 | Fáze 1
13105044 | 1.NP_SO-102 | Fáze 1
13154260 | -1.PP_SO-102 | Fáze 2
13505821 | 2.NP_SO-102 | Fáze 2
13505929 | 1.NP_SO-102 | Fáze 2
13506571 | 3.NP_SO-102 | Fáze 2
13506644 | 3.NP_SO-102 | Fáze 1
13506754 | 2.NP_SO-102 | Fáze 1
13506822 | 1.NP_SO-102 | Fáze 1
13525893 | 3.NP_SO-102 | Fáze 2
13526126 | 2.NP_SO-102 | Fáze 2
13526377 | 1.NP_SO-102 | Fáze 2
13526794 | -2.PP_SO-102 | Fáze 1
13544054 | 3.NP_SO-102 | Fáze 2
13545430 | 2.NP_SO-102 | Fáze 1

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Vana (nástěnná baterie), Sestava Instalační zařizovací předměty:Vana (nástěnná baterie):12858974
In: 1.NP_SO-102
PredefinedType: USERDEFINED
Text - CCI Funkční systém: F; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 12859098; Rodina a typ: Sestava Instalační zařizovací předměty: Vana (nástěnná baterie); Typ: Vana (nástěnná baterie)
Identifikační data(Type) - ID kategorie: V; Název typu: Vana (nástěnná baterie)
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Výlevka + modul (7)
PredefinedType: USERDEFINED; Classification: MT04 SNIM (SNIM); MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JB
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 12828512; Rodina a typ: Sestava Instalační zařizovací předměty: Výlevka + modul; Typ: Výlevka + modul
Identifikační data(Type) - ID kategorie: VY; Název typu: Výlevka + modul
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Výlevka + modul:...) | In | Fáze vytvoření
12828511 | -2.PP_SO-102 | Fáze 1
12895161 | -1.PP_SO-102 | Fáze 2
12896222 | 1.NP_SO-102 | Fáze 2
12897199 | 2.NP_SO-102 | Fáze 2
12898142 | 3.NP_SO-102 | Fáze 2
12992061 | 1.NP_SO-102 | Fáze 1
13691386 | 1.NP_SO-102 | Fáze 1

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Výlevka DN50_modul+nástěnná baterie (3)
In: 3.NP_SO-102
PredefinedType: USERDEFINED; Classification: ZT04 SNIM (SNIM); ZT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 12932551; Rodina a typ: Sestava Instalační zařizovací předměty: Výlevka DN50_modul+nástěnná baterie; Typ: Výlevka DN50_modul+nástěnná baterie
Identifikační data(Type) - ID kategorie: VY; Název typu: Výlevka DN50_modul+nástěnná baterie
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Výlevka DN50_modul+nástěnná baterie:...)
12932542
12937669
12937712

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Výlevka nástěnné (2)
PredefinedType: USERDEFINED; Classification: VE13 SNIM (SNIM); VE13 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JB
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 13401585; Rodina a typ: Sestava Instalační zařizovací předměty: Výlevka nástěnné; Typ: Výlevka nástěnné
Identifikační data(Type) - ID kategorie: D; Název typu: Výlevka nástěnné
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Výlevka nástěnné:...) | In | Fáze vytvoření
13401574 | -1.PP_SO-102 | Fáze 2
13401601 | 1.NP_SO-102 | Fáze 1

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Výlevka nástěnnê (2)
PredefinedType: USERDEFINED; Classification: VE13 SNIM (SNIM); VE13 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 13401735; Rodina a typ: Sestava Instalační zařizovací předměty: Výlevka nástěnnê; Typ: Výlevka nástěnnê
Identifikační data(Type) - ID kategorie: D; Název typu: Výlevka nástěnnê
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Výlevka nástěnnê:...) | In
13401722 | 2.NP_SO-102
13550209 | 3.NP_SO-102

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Výlevka nástěnnë (2)
PredefinedType: USERDEFINED
Text - CCI Funkční systém: F; CCI Technický systém: JB
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 13545101; Rodina a typ: Sestava Instalační zařizovací předměty: Výlevka nástěnnë; Typ: Výlevka nástěnnë
Identifikační data(Type) - ID kategorie: D; Název typu: Výlevka nástěnnë
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Výlevka nástěnnë:...) | In | Fáze vytvoření
13544942 | 3.NP_SO-102 | Fáze 2
13545318 | -2.PP_SO-102 | Fáze 1

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Výlevka nástěnnî (2)
PredefinedType: USERDEFINED; Classification: VE13 SNIM (SNIM); VE13 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1; Bouráno ve FÁZI 2: yes
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 13725024; Rodina a typ: Sestava Instalační zařizovací předměty: Výlevka nástěnnî; Typ: Výlevka nástěnnî
Identifikační data(Type) - ID kategorie: UMI; Název typu: Výlevka nástěnnî
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Výlevka nástěnnî:...) | In
13725011 | -1.PP_SO-102
13733488 | 2.NP_SO-102

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Výlevka nástěnnï, Sestava Instalační zařizovací předměty:Výlevka nástěnnï:13728393
In: 1.NP_SO-102
PredefinedType: USERDEFINED; Classification: MT04 SNIM (SNIM); MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 13728395; Rodina a typ: Sestava Instalační zařizovací předměty: Výlevka nástěnnï; Typ: Výlevka nástěnnï
Identifikační data(Type) - ID kategorie: WCI; Název typu: Výlevka nástěnnï
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Výlevka nástěnnð, Sestava Instalační zařizovací předměty:Výlevka nástěnnð:13728474
In: 1.NP_SO-102
PredefinedType: USERDEFINED; Classification: MT04 SNIM (SNIM); MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 13728479; Rodina a typ: Sestava Instalační zařizovací předměty: Výlevka nástěnnð; Typ: Výlevka nástěnnð
Identifikační data(Type) - ID kategorie: WCI; Název typu: Výlevka nástěnnð
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Výlevka nástěnnñ (2)
In: 1.NP_SO-102
PredefinedType: USERDEFINED; Classification: VE13 SNIM (SNIM); VE13 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1; Bouráno ve FÁZI 2: no
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 13728607; Rodina a typ: Sestava Instalační zařizovací předměty: Výlevka nástěnnñ; Typ: Výlevka nástěnnñ
Identifikační data(Type) - ID kategorie: UMI; Název typu: Výlevka nástěnnñ
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Výlevka nástěnnñ:...)
13728599
13728675

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Výlevka nástěnnò, Sestava Instalační zařizovací předměty:Výlevka nástěnnò:14005558
In: -2.PP_SO-102
PredefinedType: USERDEFINED; Classification: VE13 SNIM (SNIM); VE13 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 14005566; Rodina a typ: Sestava Instalační zařizovací předměty: Výlevka nástěnnò; Typ: Výlevka nástěnnò
Identifikační data(Type) - ID kategorie: UMI; Název typu: Výlevka nástěnnò
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Výlevka nástěnnó, Sestava Instalační zařizovací předměty:Výlevka nástěnnó:14005660
In: -2.PP_SO-102
PredefinedType: USERDEFINED; Classification: MT04 SNIM (SNIM); MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 14005662; Rodina a typ: Sestava Instalační zařizovací předměty: Výlevka nástěnnó; Typ: Výlevka nástěnnó
Identifikační data(Type) - ID kategorie: WCI; Název typu: Výlevka nástěnnó
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Výlevka nástěnnô, Sestava Instalační zařizovací předměty:Výlevka nástěnnô:14005939
In: -2.PP_SO-102
PredefinedType: USERDEFINED; Classification: VE13 SNIM (SNIM); VE13 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 14005947; Rodina a typ: Sestava Instalační zařizovací předměty: Výlevka nástěnnô; Typ: Výlevka nástěnnô
Identifikační data(Type) - Název typu: Výlevka nástěnnô
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Výlevka nástěnnõ, Sestava Instalační zařizovací předměty:Výlevka nástěnnõ:14006029
In: -2.PP_SO-102
PredefinedType: USERDEFINED; Classification: MT04 SNIM (SNIM); MT04 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 1
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 14006032; Rodina a typ: Sestava Instalační zařizovací předměty: Výlevka nástěnnõ; Typ: Výlevka nástěnnõ
Identifikační data(Type) - Název typu: Výlevka nástěnnõ
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty

# IfcElementAssembly: Sestava Instalační zařizovací předměty:Výlevka nástěnnö (4)
PredefinedType: USERDEFINED; Classification: VE13 SNIM (SNIM); VE13 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Technický systém: JB
Fázování - Fáze vytvoření: Fáze 2
Identifikační data - Pojmenování kategorie: Instalační zařizovací předměty
Jiné - Kategorie: Sestavy; Rodina: Sestava Instalační zařizovací předměty; Id typu: 14007208; Rodina a typ: Sestava Instalační zařizovací předměty: Výlevka nástěnnö; Typ: Výlevka nástěnnö
Identifikační data(Type) - ID kategorie: UMI; Název typu: Výlevka nástěnnö
Jiné(Type) - Kategorie: Sestavy; Název rodiny: Sestava Instalační zařizovací předměty
Name (Sestava Instalační zařizovací předměty:Výlevka nástěnnö:...) | In
14007200 | 3.NP_SO-102
14007280 | 2.NP_SO-102
14007311 | 1.NP_SO-102
14007340 | -1.PP_SO-102

# IfcFlowTerminal: Baterie bidetová stojánková:Baterie bidetová stojánková (4)
Type - Classification: ZT09 SNIM (SNIM); Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_TEPLÁ_VODA: 0 m3/s; PRŮTOK_VODA: 0 m3/s
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Kóty - JMENOVITÝ PRŮMĚR: 15 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: BS; Kód sestavy: ZT09; Komentáře k typům: Baterie stojíánková pro bidet; Název typu: Baterie bidetová stojánková; Označení typu: 27; Popis: Baterie stojánková pro bidet; Popis sestavy: Baterie; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Baterie bidetová stojánková
Classification: ZT09 SNIM (SNIM); ZT09 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 0 mm; Pracovní rovina: Bidet nástěnný : Bidet nástěnný; Výška od podlaží: 400 mm
Mechanické - Klasifikace systému: Teplá voda v domácnosti,Studená voda v domácnosti
Kóty - Objem: 0.000493428 m3
Identifikační data - Název sestavy: Bidet + modul
Jiné - Id typu: 12882063; JM: 12.5 mm; Rodina: Baterie bidetová stojánková; Rodina a typ: Baterie bidetová stojánková: Baterie bidetová stojánková; Typ: Baterie bidetová stojánková
Name (Baterie bidetová stojánková:Baterie bidetová stojánková:...) | In | Podlaží = Vztažné podlaží | Fáze vytvoření | Název systému | Kód prvku | Označení | Group
12881997 | 1.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní 4,WS_Studená vnitřní 2 | ZT09.27.0254 | 0254 | WS_Teplá vnitřní 4; WS_Studená vnitřní 2
12899366 | -1.PP_SO-102 | 1.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní 46,WS_Studená vnitřní 23 | ZT09.27.0592 | 0592 | WS_Teplá vnitřní 46; WS_Studená vnitřní 23
12899557 | 2.NP_SO-102 | 3.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní 51,WS_Studená vnitřní 45 | ZT09.27.0602 | 0602 | WS_Teplá vnitřní 51; WS_Studená vnitřní 45
13067068 | 3.NP_SO-102 | 4.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní 182,WS_Studená vnitřní 178 | ZT09.27.0642 | 0642 | WS_Teplá vnitřní 182; WS_Studená vnitřní 178

# IfcFlowTerminal: Baterie dřezová stojánková:Baterie dřezová stojánková (6)
Type - Classification: ZT09 SNIM (SNIM); Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_VODA: 0 m3/s
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Kóty - JMENOVITÝ PRŮMĚR: 15 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: BD; Kód sestavy: ZT09; Komentáře k typům: stojánková páková; Název typu: Baterie dřezová stojánková; Označení typu: 39; Popis: Baterie stojánková pro dřez; Popis sestavy: Baterie; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Baterie dřezová stojánková
Classification: ZT09 SNIM (SNIM); ZT09 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: XKA; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 777 mm; Pracovní rovina: <nepřiřazeno>; Výška od podlaží: 842 mm
Mechanické - Klasifikace systému: Teplá voda v domácnosti,Studená voda v domácnosti
Kóty - Objem: 0.000503789 m3
Jiné - Id typu: 13399824; Rodina: Baterie dřezová stojánková; Rodina a typ: Baterie dřezová stojánková: Baterie dřezová stojánková; Typ: Baterie dřezová stojánková
Name (Baterie dřezová stojánková:Baterie dřezová stojánková:...) | In | Podlaží = Vztažné podlaží | Fáze vytvoření | Název systému | Kód prvku | Název sestavy | Označení | Group
13401575 | -1.PP_SO-102 | -1.PP_SO-102 | Fáze 2 | WS_Teplá vnitřní 21,WS_Studená vnitřní 19 | ZT09.39.0728 | Výlevka nástěnné | 0728 | WS_Teplá vnitřní 21; WS_Studená vnitřní 19
13401602 | 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní 17,WS_Studená vnitřní 18 | ZT09.39.0731 | Výlevka nástěnné | 0731 | WS_Teplá vnitřní 17; WS_Studená vnitřní 18
13401723 | 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní 33,WS_Studená vnitřní 89 | ZT09.39.0734 | Výlevka nástěnnê | 0734 | WS_Teplá vnitřní 33; WS_Studená vnitřní 89
13545165 | 3.NP_SO-102 | 3.NP_SO-102 | Fáze 2 | WS_Teplá vnitřní 136,WS_Studená vnitřní 142 | ZT09.39.0794 | Výlevka nástěnnë | 0794 | WS_Teplá vnitřní 136; WS_Studená vnitřní 142
13545329 | -2.PP_SO-102 | 4.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní 74,WS_Studená vnitřní 65 | ZT09.39.0797 | Výlevka nástěnnë | 0797 | WS_Teplá vnitřní 74; WS_Studená vnitřní 65
13550210 | 3.NP_SO-102 | 3.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní 141,WS_Studená vnitřní 146 | ZT09.39.0806 | Výlevka nástěnnê | 0806 | WS_Teplá vnitřní 141; WS_Studená vnitřní 146

# IfcFlowTerminal: Baterie sprchová nástěnná:Baterie sprchová nástěnná (8)
Type - Classification: ZT09 SNIM (SNIM); Material: CHROM
Type - Vazby - Výchozí výška: 0 mm
Type - Materiály a povrchové úpravy - Materiál: CHROM
Type - Identifikační data - Kód sestavy: ZT09; Komentáře k typům: nástěnná, bez příslušenství; Model: HansaPico 46120103 46120103 46120103; Název typu: Baterie sprchová nástěnná; Označení typu: 05; Popis: Baterie sprchová; Popis sestavy: Baterie; Výrobce: HANSA
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Baterie sprchová nástěnná
Classification: ZT09 SNIM (SNIM); ZT09 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABE; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 950 mm; Výška od podlaží: 950 mm
Mechanické - Typ systému: WS_Teplá vnitřní; Klasifikace systému: Teplá voda v domácnosti,Studená voda v domácnosti,Teplá voda v domácnosti
Kóty - Objem: 0.000505262 m3; Rozteč: 150 mm
Identifikační data - Název sestavy: Sprchový kout - vanička (nástěnná baterie)
Jiné - Id typu: 12798058; Rodina: Baterie sprchová nástěnná; Rodina a typ: Baterie sprchová nástěnná: Baterie sprchová nástěnná; Typ: Baterie sprchová nástěnná
Name (Baterie sprchová nástěnná:Baterie sprchová nástěnná:...) | In | Podlaží | Hostitel | Fáze vytvoření | Název systému = Group | Kód prvku | Označení
12797926 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | WS_Teplá vnitřní 1 | ZT09.05.0005 | 0005
12805486 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | WS_Teplá vnitřní 3 | ZT09.05.0010 | 0010
12833686 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | WS_Teplá vnitřní 6 | ZT09.05.0031 | 0031
12833750 | -2.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | WS_Teplá vnitřní 2 | ZT09.05.0036 | 0036
12893445 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní 20 | ZT09.05.0396 | 0396
12893490 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní 95 | ZT09.05.0401 | 0401
12893969 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | WS_Teplá vnitřní 66 | ZT09.05.0406 | 0406
13325308 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | WS_Teplá vnitřní 16 | ZT09.05.0719 | 0719

# IfcFlowTerminal: Baterie sprchová podomítková:Baterie sprchová podomítková (6)
In: -2.PP_SO-102
Type - Classification: ZT09 SNIM (SNIM); Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - JMENOVITÝ PRŮMĚR: 30 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: BP; Kód sestavy: ZT09; Komentáře k typům: Komentáře k typům; Model: Model; Název typu: Baterie sprchová podomítková; Označení typu: 11; Popis: Baterie podomítková; Popis sestavy: Baterie; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Baterie sprchová podomítková
Classification: ZT09 SNIM (SNIM); ZT09 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABE; CCI Technický systém: JB
Vazby - Podlaží: -1.PP_SO-102; Hostitel: Podlaží : -1.PP_SO-102; Odsazení od hostitele: 1116.91 mm; Výška od podlaží: 1116.91 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Studená voda v domácnosti,Teplá voda v domácnosti; PRŮTOK_VODA: 0 m3/s
Kóty - Objem: 0.00111865 m3; Plocha: 0.060331 m2
Identifikační data - Název sestavy: Sprchový kout + modul (podomítková baterie)
Jiné - Id typu: 12831425; Rodina: Baterie sprchová podomítková; Rodina a typ: Baterie sprchová podomítková: Baterie sprchová podomítková; Typ: Baterie sprchová podomítková
Name (Baterie sprchová podomítková:Baterie sprchová podomítková:...) | Kód prvku | Označení
12832321 | ZT09.11.0016 | 0016
12833329 | ZT09.11.0019 | 0019
12886121 | ZT09.11.0262 | 0262
14005434 | ZT09.11.0847 | 0847
14005464 | ZT09.11.0850 | 0850
14005516 | ZT09.11.0853 | 0853

# IfcFlowTerminal: Baterie umyvadlová stojánková:Baterie umyvadlová stojánková (112)
Type - Classification: ZT09 SNIM (SNIM); Material: NEREZOVÁ OCEL
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - PRŮTOK_TEPLÁ_VODA: 0 m3/s; PRŮTOK_VODA: 0 m3/s
Type - Materiály a povrchové úpravy - Materiál: NEREZOVÁ OCEL
Type - Kóty - JMENOVITÝ PRŮMĚR: 15 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; ID kategorie: BS; Kód sestavy: ZT09; Komentáře k typům: Baterie stojánková; Název typu: Baterie umyvadlová stojánková; Označení typu: 08; Popis: Baterie stojánková; Popis sestavy: Baterie; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Instalační zařizovací předměty; Název rodiny: Baterie umyvadlová stojánková
Classification: ZT09 SNIM (SNIM); ZT09 Uniformat (Uniformat)
Text - CCI Funkční systém: F; CCI Komponenta: ABA; CCI Technický systém: JB
Vazby - Odsazení od hostitele: 0 mm; Pracovní rovina: Umyvadlo : Umyvadlo
Mechanické - Klasifikace systému: Teplá voda v domácnosti,Studená voda v domácnosti
Kóty - Objem: 0.00046128 m3
Jiné - Id typu: 12812718; JM: 12.5 mm; Rodina: Baterie umyvadlová stojánková; Rodina a typ: Baterie umyvadlová stojánková: Baterie umyvadlová stojánková; Typ: Baterie umyvadlová stojánková
Name (Baterie umyvadlová stojánková:Baterie umyvadlová stojánková:...) | In | Podlaží = Vztažné podlaží | Výška od podlaží (mm) | Fáze vytvoření | Název systému | Kód prvku | Název sestavy | Označení | Group
12825627 | -2.PP_SO-102 | -1.PP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 7,WS_Studená vnitřní 5 | ZT09.08.0013 | Umyvadlo | 0013 | WS_Teplá vnitřní 7; WS_Studená vnitřní 5
12865985 | -1.PP_SO-102 | 1.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 26,WS_Studená vnitřní 25 | ZT09.08.0043 | Umyvadlo + modul | 0043 | WS_Teplá vnitřní 26; WS_Studená vnitřní 25
12871089 | -2.PP_SO-102 | -1.PP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 19,WS_Studená vnitřní 16 | ZT09.08.0051 | Umyvadlo + modul | 0051 | WS_Teplá vnitřní 19; WS_Studená vnitřní 16
12871117 | -2.PP_SO-102 | -1.PP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 10,WS_Studená vnitřní 15 | ZT09.08.0055 | Umyvadlo + modul | 0055 | WS_Teplá vnitřní 10; WS_Studená vnitřní 15
12871178 | -2.PP_SO-102 | -1.PP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 9,WS_Studená vnitřní 7 | ZT09.08.0059 | Umyvadlo + modul | 0059 | WS_Teplá vnitřní 9; WS_Studená vnitřní 7
12879379 | -1.PP_SO-102 | 1.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 27,WS_Studená vnitřní 26 | ZT09.08.0079 | Umyvadlo + modul | 0079 | WS_Teplá vnitřní 27; WS_Studená vnitřní 26
12879420 | -1.PP_SO-102 | 1.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 25,WS_Studená vnitřní 21 | ZT09.08.0083 | Umyvadlo + modul | 0083 | WS_Teplá vnitřní 25; WS_Studená vnitřní 21
12879449 | -1.PP_SO-102 | 1.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 28,WS_Studená vnitřní 27 | ZT09.08.0087 | Umyvadlo + modul | 0087 | WS_Teplá vnitřní 28; WS_Studená vnitřní 27
12879480 | -1.PP_SO-102 | 1.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 29,WS_Studená vnitřní 28 | ZT09.08.0091 | Umyvadlo + modul | 0091 | WS_Teplá vnitřní 29; WS_Studená vnitřní 28
12879507 | -1.PP_SO-102 | 1.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 30,WS_Studená vnitřní 29 | ZT09.08.0095 | Umyvadlo + modul | 0095 | WS_Teplá vnitřní 30; WS_Studená vnitřní 29
12879536 | -1.PP_SO-102 | 1.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 31,WS_Studená vnitřní 30 | ZT09.08.0099 | Umyvadlo + modul | 0099 | WS_Teplá vnitřní 31; WS_Studená vnitřní 30
12880698 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 42,WS_Studená vnitřní 41 | ZT09.08.0130 | Umyvadlo + modul | 0130 | WS_Teplá vnitřní 42; WS_Studená vnitřní 41
12880712 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 44,WS_Studená vnitřní 43 | ZT09.08.0134 | Umyvadlo + modul | 0134 | WS_Teplá vnitřní 44; WS_Studená vnitřní 43
12880740 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 48,WS_Studená vnitřní 47 | ZT09.08.0138 | Umyvadlo + modul | 0138 | WS_Teplá vnitřní 48; WS_Studená vnitřní 47
12880754 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 50,WS_Studená vnitřní 49 | ZT09.08.0142 | Umyvadlo + modul | 0142 | WS_Teplá vnitřní 50; WS_Studená vnitřní 49
12880768 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 52,WS_Studená vnitřní 51 | ZT09.08.0146 | Umyvadlo + modul | 0146 | WS_Teplá vnitřní 52; WS_Studená vnitřní 51
12880868 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 43,WS_Studená vnitřní 42 | ZT09.08.0174 | Umyvadlo + modul | 0174 | WS_Teplá vnitřní 43; WS_Studená vnitřní 42
12880882 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 47,WS_Studená vnitřní 46 | ZT09.08.0178 | Umyvadlo + modul | 0178 | WS_Teplá vnitřní 47; WS_Studená vnitřní 46
12880910 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 54,WS_Studená vnitřní 53 | ZT09.08.0182 | Umyvadlo + modul | 0182 | WS_Teplá vnitřní 54; WS_Studená vnitřní 53
12880924 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 56,WS_Studená vnitřní 55 | ZT09.08.0186 | Umyvadlo + modul | 0186 | WS_Teplá vnitřní 56; WS_Studená vnitřní 55
12880938 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 58,WS_Studená vnitřní 57 | ZT09.08.0190 | Umyvadlo + modul | 0190 | WS_Teplá vnitřní 58; WS_Studená vnitřní 57
12881038 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 45,WS_Studená vnitřní 44 | ZT09.08.0218 | Umyvadlo + modul | 0218 | WS_Teplá vnitřní 45; WS_Studená vnitřní 44
12881052 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 53,WS_Studená vnitřní 52 | ZT09.08.0222 | Umyvadlo + modul | 0222 | WS_Teplá vnitřní 53; WS_Studená vnitřní 52
12881080 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 60,WS_Studená vnitřní 59 | ZT09.08.0226 | Umyvadlo + modul | 0226 | WS_Teplá vnitřní 60; WS_Studená vnitřní 59
12881094 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 62,WS_Studená vnitřní 61 | ZT09.08.0230 | Umyvadlo + modul | 0230 | WS_Teplá vnitřní 62; WS_Studená vnitřní 61
12881108 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 64,WS_Studená vnitřní 63 | ZT09.08.0234 | Umyvadlo + modul | 0234 | WS_Teplá vnitřní 64; WS_Studená vnitřní 63
12881939 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 68,WS_Studená vnitřní 67 | ZT09.08.0250 | Umyvadlo + modul | 0250 | WS_Teplá vnitřní 68; WS_Studená vnitřní 67
12884688 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 72,WS_Studená vnitřní 71 | ZT09.08.0256 | Umyvadlo | 0256 | WS_Teplá vnitřní 72; WS_Studená vnitřní 71
12884798 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 76,WS_Studená vnitřní 75 | ZT09.08.0259 | Umyvadlo | 0259 | WS_Teplá vnitřní 76; WS_Studená vnitřní 75
12886224 | -2.PP_SO-102 | -1.PP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 70,WS_Studená vnitřní 69 | ZT09.08.0266 | Umyvadlo + modul | 0266 | WS_Teplá vnitřní 70; WS_Studená vnitřní 69
12888139 | -1.PP_SO-102 | 1.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 34,WS_Studená vnitřní 33 | ZT09.08.0270 | Umyvadlo + modul | 0270 | WS_Teplá vnitřní 34; WS_Studená vnitřní 33
12888846 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 35,WS_Studená vnitřní 34 | ZT09.08.0274 | Umyvadlo + modul | 0274 | WS_Teplá vnitřní 35; WS_Studená vnitřní 34
12888870 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 38,WS_Studená vnitřní 37 | ZT09.08.0278 | Umyvadlo + modul | 0278 | WS_Teplá vnitřní 38; WS_Studená vnitřní 37
12889680 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 81,WS_Studená vnitřní 80 | ZT09.08.0282 | Umyvadlo + modul | 0282 | WS_Teplá vnitřní 81; WS_Studená vnitřní 80
12890312 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 83,WS_Studená vnitřní 82 | ZT09.08.0298 | Umyvadlo + modul | 0298 | WS_Teplá vnitřní 83; WS_Studená vnitřní 82
12890339 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 84,WS_Studená vnitřní 83 | ZT09.08.0302 | Umyvadlo + modul | 0302 | WS_Teplá vnitřní 84; WS_Studená vnitřní 83
12890450 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 82,WS_Studená vnitřní 81 | ZT09.08.0306 | Umyvadlo + modul | 0306 | WS_Teplá vnitřní 82; WS_Studená vnitřní 81
12890835 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 85,WS_Studená vnitřní 84 | ZT09.08.0319 | Umyvadlo + modul | 0319 | WS_Teplá vnitřní 85; WS_Studená vnitřní 84
12890859 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 86,WS_Studená vnitřní 85 | ZT09.08.0323 | Umyvadlo + modul | 0323 | WS_Teplá vnitřní 86; WS_Studená vnitřní 85
12891280 | -1.PP_SO-102 | 1.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 32,WS_Studená vnitřní 31 | ZT09.08.0327 | Umyvadlo + modul | 0327 | WS_Teplá vnitřní 32; WS_Studená vnitřní 31
12891691 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 49,WS_Studená vnitřní 48 | ZT09.08.0331 | Umyvadlo + modul | 0331 | WS_Teplá vnitřní 49; WS_Studená vnitřní 48
12891782 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 55,WS_Studená vnitřní 54 | ZT09.08.0335 | Umyvadlo + modul | 0335 | WS_Teplá vnitřní 55; WS_Studená vnitřní 54
12891855 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 59,WS_Studená vnitřní 58 | ZT09.08.0339 | Umyvadlo + modul | 0339 | WS_Teplá vnitřní 59; WS_Studená vnitřní 58
12891927 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 61,WS_Studená vnitřní 60 | ZT09.08.0343 | Umyvadlo + modul | 0343 | WS_Teplá vnitřní 61; WS_Studená vnitřní 60
12892002 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 63,WS_Studená vnitřní 62 | ZT09.08.0347 | Umyvadlo + modul | 0347 | WS_Teplá vnitřní 63; WS_Studená vnitřní 62
12892068 | 1.NP_SO-102 | 2.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 65,WS_Studená vnitřní 64 | ZT09.08.0351 | Umyvadlo + modul | 0351 | WS_Teplá vnitřní 65; WS_Studená vnitřní 64
12892285 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 67,WS_Studená vnitřní 66 | ZT09.08.0355 | Umyvadlo + modul | 0355 | WS_Teplá vnitřní 67; WS_Studená vnitřní 66
12892352 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 69,WS_Studená vnitřní 68 | ZT09.08.0359 | Umyvadlo + modul | 0359 | WS_Teplá vnitřní 69; WS_Studená vnitřní 68
12892418 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 71,WS_Studená vnitřní 70 | ZT09.08.0363 | Umyvadlo + modul | 0363 | WS_Teplá vnitřní 71; WS_Studená vnitřní 70
12892484 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 73,WS_Studená vnitřní 72 | ZT09.08.0367 | Umyvadlo + modul | 0367 | WS_Teplá vnitřní 73; WS_Studená vnitřní 72
12892549 | 2.NP_SO-102 | 3.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 75,WS_Studená vnitřní 74 | ZT09.08.0371 | Umyvadlo + modul | 0371 | WS_Teplá vnitřní 75; WS_Studená vnitřní 74
12892802 | 3.NP_SO-102 | 4.NP_SO-102 | 843.333 | Fáze 1 | WS_Teplá vnitřní 87,WS_Studená vnitřní 86 | ZT09.08.0378 | Umyvadlo + modul | 0378 | WS_Teplá vnitřní 87; WS_Studená vnitřní 86
