Properties of the parts of a building model (IFC4), part 50 of 72

# IfcPipeFitting: M_Koleno, obecné:Standardní (1543)
Name (M_Koleno, obecné:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm) | Group
13335696 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 2650 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1639 | 1639 | yes | 20.6375 | 14.2875 | HT/CL_vratné vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13335719 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 2750 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1640 | 1640 | yes | 20.6375 | 14.2875 | HT/CL_přívodní vodní 1
13335729 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 2650 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1641 | 1641 | yes | 20.6375 | 14.2875 | HT/CL_přívodní vodní 1
13335752 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2750 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1642 | 1642 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 1
13335764 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1644 | 1644 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 1
13335787 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2750 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1645 | 1645 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 9
13335799 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1647 | 1647 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 9
13336884 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1648 | 1648 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 9
13336894 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-102 | 2530 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1649 | 1649 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 9
13337945 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1651 | 1651 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13337957 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2400 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1653 | 1653 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13338006 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2200 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1654 | 1654 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 25
13338018 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1656 | 1656 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 25
13339234 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HD | 2.NP_SO-102 | 2750 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1657 | 1657 | yes | 20.6375 | 14.2875 | HT_přívodní vodní (55 °C) 9
13339236 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1658 | 1658 | yes | 20.6375 | 14.2875 | HT_přívodní vodní (55 °C) 9
13339240 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1659 | 1659 | yes | 20.6375 | 14.2875 | HT_přívodní vodní (55 °C) 9
13339249 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HD | 2.NP_SO-102 | 2750 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1660 | 1660 | yes | 20.6375 | 14.2875 | HT_vratné vodní (45 °C) 1
13339251 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1661 | 1661 | yes | 20.6375 | 14.2875 | HT_vratné vodní (45 °C) 1
13339255 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1662 | 1662 | yes | 20.6375 | 14.2875 | HT_vratné vodní (45 °C) 1
13340353 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2820 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1664 | 1664 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 9
13340355 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2700 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1665 | 1665 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 9
13340359 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2700 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1666 | 1666 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 9
13340364 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2700 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1667 | 1667 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 9
13340366 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2750 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1668 | 1668 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 9
13340486 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2820 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1670 | 1670 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 9
13340501 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2750 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1671 | 1671 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 9
13340649 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 3200 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1673 | 1673 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 9
13340653 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 3200 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1674 | 1674 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 9
13340683 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 3200 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1676 | 1676 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 9
13340687 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 3200 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1677 | 1677 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 9
13342083 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.1678 | 1678 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 1
13342314 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.1679 | 1679 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13342503 | 1.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1680 | 1680 | no | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13344430 | 3.NP_SO-102 | 40 | ø120 mm-ø120 mm | HD | 3.NP_SO-102 | 2500 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1687 | 1687 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13344435 | 3.NP_SO-102 | 40 | ø120 mm-ø120 mm | HD | 3.NP_SO-102 | 2500 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1688 | 1688 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13344579 | 3.NP_SO-102 | 40 | ø120 mm-ø120 mm | HD | 3.NP_SO-102 | 2500 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1689 | 1689 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13344584 | 3.NP_SO-102 | 40 | ø120 mm-ø120 mm | HD | 3.NP_SO-102 | 2500 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1690 | 1690 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13347554 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2920 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1697 | 1697 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13347600 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 2780 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1700 | 1700 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13347602 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 2780 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1701 | 1701 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13349001 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1702 | 1702 | yes | 20.6375 | 14.2875 | CL_vratné vodní (15 °C) 11
13349065 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1703 | 1703 | yes | 20.6375 | 14.2875 | CL_přívodní vodní (10 °C) 4
13349096 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1704 | 1704 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 25
13349174 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2500 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1705 | 1705 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13349216 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2400 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.00000512309 | 6.93691 | 43.3305 | ø20-ø20 | 3.53152 | 22.225 | TT01.01.1707 | 1707 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13349239 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2400 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1708 | 1708 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13349247 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1709 | 1709 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13349251 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1710 | 1710 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13349274 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1711 | 1711 | yes | 20.6375 | 14.2875 | CL_vratné vodní (15 °C) 11
13349282 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2000 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1712 | 1712 | yes | 20.6375 | 14.2875 | CL_vratné vodní (15 °C) 11
13349286 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2000 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1713 | 1713 | yes | 20.6375 | 14.2875 | CL_vratné vodní (15 °C) 11
13349309 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1714 | 1714 | yes | 20.6375 | 14.2875 | CL_přívodní vodní (10 °C) 4
13349317 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2000 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1715 | 1715 | yes | 20.6375 | 14.2875 | CL_přívodní vodní (10 °C) 4
13349321 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2000 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1716 | 1716 | yes | 20.6375 | 14.2875 | CL_přívodní vodní (10 °C) 4
13349344 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1717 | 1717 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 25
13349352 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2000 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1718 | 1718 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 25
13349356 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2000 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1719 | 1719 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 25
13350051 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 3150 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1720 | 1720 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 13
13350059 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 3300 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1721 | 1721 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 13
13350061 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 3300 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1722 | 1722 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 13
13350084 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 3150 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1723 | 1723 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 13
13350094 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 3300 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1724 | 1724 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 13
13350682 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1725 | 1725 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13352308 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 3340 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1727 | 1727 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13352312 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2900 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1728 | 1728 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13352316 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2900 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1729 | 1729 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13353803 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1730 | 1730 | no | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 32
13353805 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1731 | 1731 | no | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 32
13358243 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-102 | 2600 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1732 | 1732 | yes | 26.9875 | 20.6375 | CL_přívodní vodní (10 °C) 4
13358247 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-102 | 2600 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1733 | 1733 | yes | 26.9875 | 20.6375 | CL_přívodní vodní (10 °C) 4
13358278 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-102 | 2600 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1734 | 1734 | yes | 26.9875 | 20.6375 | CL_vratné vodní (15 °C) 8
13358282 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-102 | 2600 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1735 | 1735 | yes | 26.9875 | 20.6375 | CL_vratné vodní (15 °C) 8
13362175 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.01.1738 | 1738 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9
13362462 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3250 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.01.1740 | 1740 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9
13368495 | -1.PP_SO-102 | 60 | ø152 mm-ø152 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1741 | 1741 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23 | Izolace - Typ izolace: Tepelná
13368506 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1742 | 1742 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23 | Izolace - Typ izolace: Tepelná
13368509 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1743 | 1743 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23 | Izolace - Typ izolace: Tepelná
13368731 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2450 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1744 | 1744 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 2 | Izolace - Typ izolace: Tepelná
13368763 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1745 | 1745 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 6 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13369705 | -1.PP_SO-102 | 60 | ø200 mm-ø200 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1746 | 1746 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13369708 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1747 | 1747 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13369726 | -1.PP_SO-102 | 60 | ø200 mm-ø200 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1748 | 1748 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39 | Izolace - Typ izolace: Tepelná
13369729 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1749 | 1749 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13370341 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1750 | 1750 | yes | 20.6375 | 14.2875 | HT_přívodní vodní (55 °C) 12 | Mechanické – tok - Tlaková ztráta: 0 Pa
13370343 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1751 | 1751 | yes | 20.6375 | 14.2875 | HT_přívodní vodní (55 °C) 12 | Mechanické – tok - Tlaková ztráta: 0 Pa
13370368 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1752 | 1752 | yes | 20.6375 | 14.2875 | HT_vratné vodní (45 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13370370 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1753 | 1753 | yes | 20.6375 | 14.2875 | HT_vratné vodní (45 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13380716 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 2700 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1758 | 1758 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 9
13380720 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 2700 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1759 | 1759 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 9
13384501 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 4214 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1760 | 1760 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3
13384549 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | STŘECHA_SO-102 | 364 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1761 | 1761 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3
13384761 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | STŘECHA_SO-102 | 364 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1762 | 1762 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13384763 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1763 | 1763 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13384846 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | STŘECHA_SO-102 | 364 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1764 | 1764 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13385848 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1766 | 1766 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13385883 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1767 | 1767 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13385946 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2700 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1768 | 1768 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13390736 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 3000 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1771 | 1771 | yes | 39.6875 | 33.3375 | CL_vratné vodní (15 °C) 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13390757 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 3000 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1773 | 1773 | yes | 39.6875 | 33.3375 | CL_přívodní vodní (10 °C) 7 | Mechanické – tok - Tlaková ztráta: 0 Pa
13390875 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1775 | 1775 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 23
13390879 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1776 | 1776 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 23
13390910 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1777 | 1777 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 8
13390914 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 300 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1778 | 1778 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 8
13391140 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 1900 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1779 | 1779 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 1
13391292 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 1900 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1780 | 1780 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 1
13391391 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 900 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1781 | 1781 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 1
13391430 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 1900 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1782 | 1782 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 5
13391508 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 1900 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1783 | 1783 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 5
13391512 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 900 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1784 | 1784 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 5
13391658 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 3000 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1787 | 1787 | yes | 39.6875 | 33.3375 | CL_vratné vodní (15 °C) 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13391660 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 3000 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1788 | 1788 | yes | 39.6875 | 33.3375 | CL_vratné vodní (15 °C) 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13391696 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 3000 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1791 | 1791 | yes | 39.6875 | 33.3375 | CL_přívodní vodní (10 °C) 7 | Mechanické – tok - Tlaková ztráta: 0 Pa
13391698 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 3000 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1792 | 1792 | yes | 39.6875 | 33.3375 | CL_přívodní vodní (10 °C) 7 | Mechanické – tok - Tlaková ztráta: 0 Pa
13391816 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 2.NP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1795 | 1795 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13391857 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1798 | 1798 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13393848 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1799 | 1799 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3
13394006 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1800 | 1800 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3
13394453 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000108828 | 16.4391 | 45 | ø65-ø65 | 11.0471 | 66.675 | TT01.01.1801 | 1801 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13394479 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1802 | 1802 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13394496 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1803 | 1803 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13394498 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000108828 | 16.4391 | 45 | ø65-ø65 | 11.0471 | 66.675 | TT01.01.1804 | 1804 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13395205 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1805 | 1805 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13395211 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1806 | 1806 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13395221 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1807 | 1807 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13395227 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1808 | 1808 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13395422 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1809 | 1809 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13395428 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1810 | 1810 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13395430 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1811 | 1811 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13395453 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3100 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1812 | 1812 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3
13395459 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1813 | 1813 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3
13395461 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1814 | 1814 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3
13395509 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1816 | 1816 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13395539 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000108828 | 16.4391 | 45 | ø65-ø65 | 11.0471 | 66.675 | TT01.01.1818 | 1818 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3
13395541 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1819 | 1819 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3
13395573 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 3100 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1821 | 1821 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13395578 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 3100 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1822 | 1822 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13395602 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 3100 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1823 | 1823 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13395639 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1826 | 1826 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13395641 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1827 | 1827 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13395681 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1829 | 1829 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3
13395683 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1830 | 1830 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3
13395867 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 32.5 | 65 | 0.000108828 | 16.4391 | 45 | ø65-ø65 | 11.0471 | 66.675 | TT01.01.1831 | 1831 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 1
13396537 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1832 | 1832 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 1
13396541 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1833 | 1833 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 1
13396871 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1834 | 1834 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 1
13396940 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1835 | 1835 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 5
13396950 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1836 | 1836 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 5
13398599 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1837 | 1837 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13398603 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1838 | 1838 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13398636 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1839 | 1839 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13399203 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000108828 | 16.4391 | 45 | ø65-ø65 | 11.0471 | 66.675 | TT01.01.1840 | 1840 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13399289 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2700 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1841 | 1841 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13399291 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2700 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1842 | 1842 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13399456 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2700 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1843 | 1843 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13401051 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1844 | 1844 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13401303 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1845 | 1845 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13401325 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1847 | 1847 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13401327 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1848 | 1848 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 4
13401355 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1850 | 1850 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13401357 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1851 | 1851 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 4
13401385 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1853 | 1853 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13401387 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1854 | 1854 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 7
13401585 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1856 | 1856 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13401587 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1857 | 1857 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 7
13401830 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1858 | 1858 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 4
13402039 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1860 | 1860 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 4
13402078 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1861 | 1861 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13402080 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1862 | 1862 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13402084 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000108828 | 16.4391 | 45 | ø65-ø65 | 11.0471 | 66.675 | TT01.01.1863 | 1863 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13402297 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1864 | 1864 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13402301 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2700 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1865 | 1865 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13402305 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2700 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1866 | 1866 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13402331 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1867 | 1867 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13402335 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2700 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1868 | 1868 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13402339 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2700 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1869 | 1869 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13402360 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1870 | 1870 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13402364 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1871 | 1871 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13402391 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1872 | 1872 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13402395 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1873 | 1873 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13402399 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000108828 | 16.4391 | 45 | ø65-ø65 | 11.0471 | 66.675 | TT01.01.1874 | 1874 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13402505 | 2.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 2.NP_SO-102 | 10500 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1875 | 1875 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13402568 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 2500 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1876 | 1876 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13402574 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 2500 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1877 | 1877 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13402612 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1878 | 1878 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 5
13403266 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3120 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 32.5 | 65 | 0.000108828 | 16.4391 | 45 | ø65-ø65 | 11.0471 | 66.675 | TT01.01.1879 | 1879 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 5
13403268 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3120 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1880 | 1880 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 5
13403459 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1881 | 1881 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 5
13403463 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1882 | 1882 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 5
13403478 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1883 | 1883 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 5
13404067 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 6 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1885 | 1885 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 6
13404103 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1887 | 1887 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13404151 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1888 | 1888 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 5
13404186 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1889 | 1889 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 1
13404252 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 4.NP_SO-102 | -5770 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1890 | 1890 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 5 | Izolace - Typ izolace: Tepelná
13404544 | 2.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 2.NP_SO-102 | 2230 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1891 | 1891 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 5 | Izolace - Typ izolace: Tepelná
13404554 | 2.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 2.NP_SO-102 | 2230 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1892 | 1892 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 5 | Izolace - Typ izolace: Tepelná
13404672 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2230 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 40 | 80 | 0.000178912 | 19.0694 | 45 | ø80-ø80 | 13.1513 | 79.375 | TT01.01.1893 | 1893 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 1
