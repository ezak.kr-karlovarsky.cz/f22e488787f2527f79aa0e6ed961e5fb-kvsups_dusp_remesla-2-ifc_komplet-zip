Properties of the parts of a building model (IFC4), part 72 of 72

# IfcPipeSegment: Typy trubek:Ocel_černá (499)
Name (Typy trubek:Ocel_černá:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Celková velikost | Tloušťka izolace (mm) | Relativní drsnost | CCI Technický systém | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Sklon | Spodní výška (mm) | Fáze vytvoření | Klasifikace systému | Název systému | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) | Řez | Typ systému | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group
13422803 | 2.NP_SO-102 | 678.732 | 0.00454772 | 0.162268 | ø65 mm | 0 | 0.00145138 | HD | 3127.64 | 3094.68 | 2755.32 | 2.NP_SO-102 | 57.735 | 2722.36 | Fáze 2 | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 6725.48 | 0.138599 | 65 | 529 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.2232 | 2232 | yes | HT_přívodní vodní (55 °C) 19
13422901 | 2.NP_SO-102 | 678.732 | 0.00454772 | 0.162268 | ø65 mm | 0 | 0.00145138 | HD | 3127.64 | 3094.68 | 2755.32 | 2.NP_SO-102 | 57.735 | 2722.36 | Fáze 2 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 6725.48 | 0.138599 | 65 | 549 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.2233 | 2233 | yes | HT_vratné vodní (45 °C) 13
13422903 | 2.NP_SO-102 | 1160.17 | 0.00454772 | 0.277367 | ø65 mm | 0 | 0.00145138 | HD | 2788.05 | 2750 | 2750 | 2.NP_SO-102 | 0 | 2711.95 | Fáze 2 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 6715.55 | 0.23691 | 65 | 549 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.2234 | 2234 | yes | HT_vratné vodní (45 °C) 13
13422905 | 2.NP_SO-102 | 678.732 | 0.00454772 | 0.162268 | ø65 mm | 0 | 0.00145138 | HD | 3127.64 | 3094.68 | 2755.32 | 2.NP_SO-102 | 57.735 | 2722.36 | Fáze 2 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 6725.48 | 0.138599 | 65 | 549 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.2235 | 2235 | yes | HT_vratné vodní (45 °C) 13
13426726 | -1.PP_SO-102 | 11543.9 | 0.00620623 | 3.22408 | ø80 mm | 0 | 0.00123762 | HD | 2844.45 | 2800 | 2800 | -1.PP_SO-102 | 0 | 2755.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | -1240.4 | 2.90131 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.2248 | 2248 | yes | HT_vratné vodní (45 °C) 39
13426736 | -1.PP_SO-102 | 107.925 | 0.00620623 | 0.0301421 | ø80 mm | 0 | 0.00123762 | HD | 2844.45 | 2800 | 2800 | -1.PP_SO-102 | 0 | 2755.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | -1240.4 | 0.0271245 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.2249 | 2249 | yes | HT_vratné vodní (45 °C) 39
13426744 | -1.PP_SO-102 | 787.892 | 0.00620623 | 0.220049 | ø80 mm | 0 | 0.00123762 | HD | 2644.45 | 2600 | 2600 | -1.PP_SO-102 | 0 | 2555.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | -1440.4 | 0.198019 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.2250 | 2250 | yes | HT_vratné vodní (45 °C) 39
13426819 | -1.PP_SO-102 | 107.925 | 0.00620623 | 0.0301421 | ø80 mm | 0 | 0.00123762 | HD | 2753.96 | 2646.04 | 2753.96 | -1.PP_SO-102 |  | 2646.04 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | -1353.96 | 0.0271245 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.2251 | 2251 | yes | HT_vratné vodní (45 °C) 39
13426830 | -1.PP_SO-102 | 357.925 | 0.00620623 | 0.099964 | ø80 mm | 0 | 0.00123762 | HD | 2553.96 | 2553.96 | 2196.04 | -1.PP_SO-102 |  | 2196.04 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | -1803.96 | 0.0899564 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.2252 | 2252 | yes | HT_vratné vodní (45 °C) 39
13426873 | -1.PP_SO-102 | 11300 | 0.00620623 | 3.15596 | ø80 mm | 0 | 0.00123762 | HD | 2844.45 | 2800 | 2800 | -1.PP_SO-102 | 0 | 2755.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | -1240.4 | 2.84001 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.2253 | 2253 | yes | HT_přívodní vodní (65 °C) 5
13426891 | -1.PP_SO-102 | 747.892 | 0.00620623 | 0.208877 | ø80 mm | 0 | 0.00123762 | HD | 2644.45 | 2600 | 2600 | -1.PP_SO-102 | 0 | 2555.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | -1440.4 | 0.187966 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.2254 | 2254 | yes | HT_přívodní vodní (65 °C) 5
13426960 | -1.PP_SO-102 | 357.925 | 0.00620623 | 0.099964 | ø80 mm | 0 | 0.00123762 | HD | 2553.96 | 2553.96 | 2196.04 | -1.PP_SO-102 |  | 2196.04 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | -1803.96 | 0.0899564 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.2255 | 2255 | yes | HT_přívodní vodní (65 °C) 5
13427998 | -1.PP_SO-102 | 107.925 | 0.00620623 | 0.0301421 | ø80 mm | 0 | 0.00123762 | HD | 2753.96 | 2646.04 | 2753.96 | -1.PP_SO-102 |  | 2646.04 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | -1353.96 | 0.0271245 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.2266 | 2266 | yes | HT_přívodní vodní (65 °C) 5
13444369 | 2.NP_SO-102 | 357.925 | 0.00620623 | 0.099964 | ø80 mm | 0 | 0.00123762 | HC | 2453.96 | 2096.04 | 2453.96 | 2.NP_SO-102 |  | 2096.04 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 6096.04 | 0.0899564 | 80 | 102 | CL_vratné vodní (15 °C) | ø80 | 88.9 | 80.8 | TR02.01.2292 | 2292 | yes | CL_vratné vodní (15 °C) 8
13444379 | 2.NP_SO-102 | 657.925 | 0.00620623 | 0.18375 | ø80 mm | 0 | 0.00123762 | HC | 2753.96 | 2096.04 | 2753.96 | 2.NP_SO-102 |  | 2096.04 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6096.04 | 0.165355 | 80 | 125 | CL_přívodní vodní (10 °C) | ø80 | 88.9 | 80.8 | TR02.01.2293 | 2293 | yes | CL_přívodní vodní (10 °C) 4
13445426 | 2.NP_SO-102 | 239.786 | 0.00620623 | 0.0669691 | ø80 mm | 0 | 0.00123762 | HC | 2544.45 | 2500 | 2500 | 2.NP_SO-102 | 0 | 2455.55 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 6459.6 | 0.0602647 | 80 | 102 | CL_vratné vodní (15 °C) | ø80 | 88.9 | 80.8 | TR02.01.2294 | 2294 | yes | CL_vratné vodní (15 °C) 8
13445544 | 2.NP_SO-102 | 306.841 | 0.00620623 | 0.085697 | ø80 mm | 0 | 0.00123762 | HC | 2544.45 | 2500 | 2500 | 2.NP_SO-102 | 0 | 2455.55 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6459.6 | 0.0771176 | 80 | 125 | CL_přívodní vodní (10 °C) | ø80 | 88.9 | 80.8 | TR02.01.2295 | 2295 | yes | CL_přívodní vodní (10 °C) 4
13445629 | 2.NP_SO-102 | 357.925 | 0.00620623 | 0.099964 | ø80 mm | 0 | 0.00123762 | HC | 2453.96 | 2453.96 | 2096.04 | 2.NP_SO-102 |  | 2096.04 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6096.04 | 0.0899564 | 80 | 125 | CL_přívodní vodní (10 °C) | ø80 | 88.9 | 80.8 | TR02.01.2296 | 2296 | yes | CL_přívodní vodní (10 °C) 4
13445641 | 2.NP_SO-102 | 357.925 | 0.00620623 | 0.099964 | ø80 mm | 0 | 0.00123762 | HC | 2453.96 | 2453.96 | 2096.04 | 2.NP_SO-102 |  | 2096.04 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 6096.04 | 0.0899564 | 80 | 102 | CL_vratné vodní (15 °C) | ø80 | 88.9 | 80.8 | TR02.01.2297 | 2297 | yes | CL_vratné vodní (15 °C) 8
13446102 | 2.NP_SO-102 | 598.932 | 0.00454772 | 0.14319 | ø65 mm | 0 | 0.00145138 | HD | 3288.05 | 3250 | 3250 | 2.NP_SO-102 | 0 | 3211.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 7215.55 | 0.122304 | 65 | 70 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2307 | 2307 |  | HT_PRIMÁR_vratné 3
13446110 | 2.NP_SO-102 | 45.175 | 0.00454772 | 0.0108002 | ø65 mm | 0 | 0.00145138 | HD | 3288.05 | 3250 | 3250 | 2.NP_SO-102 | 0 | 3211.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 7215.55 | 0.00922489 | 65 | 70 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2308 | 2308 |  | HT_PRIMÁR_vratné 3
13446159 | 2.NP_SO-102 | 170.625 | 0.00454772 | 0.0407922 | ø65 mm | 0 | 0.00145138 | HD | 3210.31 | 3210.31 | 3039.69 | 2.NP_SO-102 |  | 3039.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 7039.69 | 0.0348422 | 65 | 70 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2309 | 2309 |  | HT_PRIMÁR_vratné 3
13450632 | 4.NP_SO-102 | 16.0906 | 0.00620623 | 0.00449392 | ø80 mm | 0 | 0.00123762 | HD | 2994.45 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2905.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 14909.6 | 0.00404402 | 80 | 62 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2344 | 2344 |  | HT_PRIMÁR_vratné 7
13450633 | 4.NP_SO-102 | 32.572 | 0.00620623 | 0.00909695 | ø200 mm | 60 | 0.00123762 | HD | 3017.95 | 2986.52 | 2963.48 | 4.NP_SO-102 | 100 | 2932.05 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 14934.9 | 0.00818623 | 80 | 62 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2345 | 2345 |  | HT_PRIMÁR_vratné 7 | Izolace - Typ izolace: Tepelná
13450654 | 4.NP_SO-102 | 16.0906 | 0.00620623 | 0.00449392 | ø80 mm | 0 | 0.00123762 | HD | 2994.45 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2905.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14909.6 | 0.00404402 | 80 | 18 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2346 | 2346 |  | HT_PRIMÁR_přívodní 4
13450655 | 4.NP_SO-102 | 32.572 | 0.00620623 | 0.00909695 | ø200 mm | 60 | 0.00123762 | HD | 3017.95 | 2986.52 | 2963.48 | 4.NP_SO-102 | 100 | 2932.05 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14934.9 | 0.00818623 | 80 | 18 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2347 | 2347 |  | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13450906 | 4.NP_SO-102 | 207.925 | 0.00620623 | 0.0580709 | ø200 mm | 60 | 0.00123762 | HD | 2953.96 | 2746.04 | 2953.96 | 4.NP_SO-102 |  | 2746.04 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 14746 | 0.0522573 | 80 | 62 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2348 | 2348 | yes | HT_PRIMÁR_vratné 7 | Izolace - Typ izolace: Tepelná
13450921 | 4.NP_SO-102 | 207.925 | 0.00620623 | 0.0580709 | ø200 mm | 60 | 0.00123762 | HD | 2953.96 | 2746.04 | 2953.96 | 4.NP_SO-102 |  | 2746.04 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14746 | 0.0522573 | 80 | 18 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2349 | 2349 | yes | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13453411 | 4.NP_SO-102 | 294.668 | 0.00620623 | 0.082297 | ø80 mm | 0 | 0.00123762 | HD | 3044.45 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2955.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 14959.6 | 0.074058 | 80 | 71 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2350 | 2350 |  | HT_PRIMÁR_přívodní 1
13453421 | 4.NP_SO-102 | 131.567 | 0.00620623 | 0.036745 | ø80 mm | 0 | 0.00123762 | HD | 3044.45 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2955.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 14959.6 | 0.0330664 | 80 | 71 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2351 | 2351 |  | HT_PRIMÁR_přívodní 1
13453685 | 4.NP_SO-102 | 59.3334 | 0.00620623 | 0.0165711 | ø80 mm | 0 | 0.00123762 | HD | 3044.45 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2955.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 14959.6 | 0.0149121 | 80 | 65 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2352 | 2352 |  | HT_PRIMÁR_vratné 5
13453697 | 4.NP_SO-102 | 446.853 | 0.00620623 | 0.1248 | ø80 mm | 0 | 0.00123762 | HD | 3044.45 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2955.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 14959.6 | 0.112306 | 80 | 65 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2353 | 2353 |  | HT_PRIMÁR_vratné 5
13454038 | 4.NP_SO-102 | 114.275 | 0.00454772 | 0.0273203 | ø65 mm | 0 | 0.00145138 | HD | 2960.31 | 2960.31 | 2846.04 | 4.NP_SO-102 |  | 2846.04 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 14846 | 0.0233354 | 65 | 56 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2354 | 2354 |  | HT_PRIMÁR_přívodní 1
13454041 | 4.NP_SO-102 | 54.158 | 0.00620623 | 0.0151257 | ø200 mm | 60 | 0.00123762 | HD | 2844.45 | 2800 | 2800 | 4.NP_SO-102 | 0 | 2755.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 14759.6 | 0.0136114 | 80 | 71 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2355 | 2355 | yes | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
13454106 | 4.NP_SO-102 | 407.925 | 0.00620623 | 0.113928 | ø80 mm | 0 | 0.00123762 | HD | 2844.45 | 2800 | 2800 | 4.NP_SO-102 | 0 | 2755.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 14759.6 | 0.102523 | 80 | 71 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2356 | 2356 |  | HT_PRIMÁR_přívodní 1
13454117 | 4.NP_SO-102 | 107.925 | 0.00620623 | 0.0301421 | ø80 mm | 0 | 0.00123762 | HD | 2953.96 | 2846.04 | 2953.96 | 4.NP_SO-102 |  | 2846.04 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 14846 | 0.0271245 | 80 | 71 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2357 | 2357 |  | HT_PRIMÁR_přívodní 1
13454172 | 4.NP_SO-102 | 707.925 | 0.00620623 | 0.197715 | ø80 mm | 0 | 0.00123762 | HD | 2844.45 | 2800 | 2800 | 4.NP_SO-102 | 0 | 2755.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 14759.6 | 0.177921 | 80 | 65 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2358 | 2358 |  | HT_PRIMÁR_vratné 5
13454181 | 4.NP_SO-102 | 107.925 | 0.00620623 | 0.0301421 | ø80 mm | 0 | 0.00123762 | HD | 2953.96 | 2846.04 | 2953.96 | 4.NP_SO-102 |  | 2846.04 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 14846 | 0.0271245 | 80 | 65 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2359 | 2359 |  | HT_PRIMÁR_vratné 5
13454208 | 4.NP_SO-102 | 320.625 | 0.00454772 | 0.0766535 | ø185 mm | 60 | 0.00145138 | HD | 3160.31 | 2839.69 | 3160.31 | 4.NP_SO-102 |  | 2839.69 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 14839.7 | 0.0654728 | 65 | 70 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2360 | 2360 |  | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
13454240 | 4.NP_SO-102 | 240.625 | 0.00454772 | 0.0575275 | ø65 mm | 0 | 0.00145138 | HD | 3080.31 | 2839.69 | 3080.31 | 4.NP_SO-102 |  | 2839.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 14839.7 | 0.0491365 | 65 | 67 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2361 | 2361 |  | HT_PRIMÁR_vratné 5

# IfcZone (2)
Energetická analýza - Možnost pro prostor s venkovním vzduchem: Z typu prostoru; Nastavená hodnota chlazení: 23.3333 C; Nastavená hodnota topení: 21.1111 C; Nastavená hodnota zvlhčování: 0; Obtokový součinitel: 0; Použít nastavenou hodnotu odvlhčování: no; Použít nastavenou hodnotu zvlhčování: no; Použít vnější vzduch na osobu: no; Použít vnější vzduch na plochu: no; Použít výměnu vzduchu na hodinu: no; Proudění venkovního vzduchu / výměna vzduchu na hodinu: 0; Teplota chladicího vzduchu: 12.2222 C; Teplota vzduchu topení: 32.2222 C; Typ služby: <Budova>; Venkovní vzduch na osobu: 0 m3/s; Venkovní vzduch na plochu: 0
Kóty - Hrubý objem: 0 m3; Obsazený objem: 0 m3
Jiné - Kategorie: Zóny VZT
Name | Nastavená hodnota odvlhčování | Hrubá plocha (m2) = Obsazená plocha (m2) | Název
Výchozí:102462 | 0 | 21839.9 | Výchozí
VZT 3:13325337 | 0.7 | 18.9033 | VZT 3 | Vazby - Podlaží: 1.NP_SO-102; Fázování - Fáze: Fáze 1; Kóty - Plocha povrchu průřezu: 21440.9 mm; Jiné - Id fáze: 86961
