Properties of the parts of a building model (IFC4), part 53 of 72

# IfcPipeFitting: M_Přechod, obecný:Standardní (221)
Name (M_Přechod, obecný:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Délka (mm) | Jmenovitý poloměr 1 (mm) | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Šířkové odsazení (mm) | Výškové odsazení (mm) | Viditelnost 2 | Viditelnost 3 | Max. vnější průměr tvarovky 12 (mm) | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm) | Group
13222969 | 2.NP_SO-102 | 0 | ø125 mm-ø80 mm | HD | 2.NP_SO-102 | 2571.42 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 32.5438 | 62.5 | 40 | 125 | 80 | 125 | 80 | 0.000285995 | 62.5 | 62.5 | 0.0186138 | ø125-ø80 | 52.07 | 31.75 | 130.175 | 79.375 | TT03.03.1033 | 1033 | yes | 3048 | 3048 | yes | no | 130.175 | 39.6875 | 65.0875 | HT_přívodní vodní (65 °C) 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13227860 | 2.NP_SO-102 | 0 | ø65 mm-ø25 mm | HD | 2.NP_SO-102 | 240.637 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 16.6688 | 12.5 | 32.5 | 25 | 65 | 65 | 25 | 0.0000312399 | 12.5 | 12.5 | 0.00433875 | ø65-ø25 | 11.43 | 26.67 | 28.575 | 66.675 | TT03.03.1057 | 1057 | yes | 3048 | 3048 | no | yes | 66.675 | 33.3375 | 14.2875 | HT_vratné vodní (45 °C) 7
13231166 | 2.NP_SO-102 | 0 | ø22 mm-ø20 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 6.29375 | 11 | 10 | 22 | 20 | 22 | 20 | 0.00000276911 | 11 | 11 | 0.000785339 | ø22-ø20 | 10.07 | 8.89 | 25.175 | 22.225 | TT03.03.1070 | 1070 | yes | 3048 | 3048 | yes | no | 25.175 | 11.1125 | 12.5875 | HT_vratné vodní (45 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13310433 | -1.PP_SO-102 | 0 | ø16 mm-ø15 mm | HD | -1.PP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1332 | 1332 | no | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_vratné vodní (45 °C) 1
13310435 | -1.PP_SO-102 | 0 | ø16 mm-ø15 mm | HD | -1.PP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1333 | 1333 | no | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_vratné vodní (45 °C) 1
13311109 | -1.PP_SO-102 | 0 | ø20 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 10 | 8 | 20 | 16 | 20 | 16 | 0.00000184965 | 10 | 10 | 0.000597935 | ø20-ø16 | 8.89 | 7.67 | 22.225 | 19.175 | TT03.03.1337 | 1337 | no | 3048 | 3048 | yes | no | 22.225 | 9.5875 | 11.1125 | HT_vratné vodní (45 °C) 13
13311151 | 1.NP_SO-102 | 0 | ø40 mm-ø32 mm | HD | 1.NP_SO-102 | 3166.66 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT03.03.1339 | 1339 | yes | 3048 | 3048 | yes | no | 41.275 | 17.4625 | 20.6375 | HT_vratné vodní (45 °C) 13
13311157 | -1.PP_SO-102 | 0 | ø32 mm-ø15 mm | HD | -1.PP_SO-102 | 3309.84 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8.73125 | 16 | 7.5 | 32 | 15 | 32 | 15 | 0.0000046023 | 16 | 16 | 0.00116529 | ø32-ø15 | 13.97 | 6.35 | 34.925 | 15.875 | TT03.03.1340 | 1340 | yes | 3048 | 3048 | yes | no | 34.925 | 7.9375 | 17.4625 | HT_vratné vodní (45 °C) 13
13311159 | -1.PP_SO-102 | 0 | ø32 mm-ø15 mm | HD | -1.PP_SO-102 | 3309.84 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8.73125 | 16 | 7.5 | 32 | 15 | 32 | 15 | 0.0000046023 | 16 | 16 | 0.00116529 | ø32-ø15 | 13.97 | 6.35 | 34.925 | 15.875 | TT03.03.1341 | 1341 | yes | 3048 | 3048 | yes | no | 34.925 | 7.9375 | 17.4625 | HT_přívodní vodní (55 °C) 19
13311163 | -1.PP_SO-102 | 0 | ø32 mm-ø15 mm | HD | -1.PP_SO-102 | 3309.84 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8.73125 | 16 | 7.5 | 32 | 15 | 32 | 15 | 0.0000046023 | 16 | 16 | 0.00116529 | ø32-ø15 | 13.97 | 6.35 | 34.925 | 15.875 | TT03.03.1342 | 1342 | yes | 3048 | 3048 | yes | no | 34.925 | 7.9375 | 17.4625 | HT_přívodní vodní (55 °C) 19
13311167 | -1.PP_SO-102 | 0 | ø32 mm-ø15 mm | HD | -1.PP_SO-102 | 3309.84 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8.73125 | 16 | 7.5 | 32 | 15 | 32 | 15 | 0.0000046023 | 16 | 16 | 0.00116529 | ø32-ø15 | 13.97 | 6.35 | 34.925 | 15.875 | TT03.03.1343 | 1343 | yes | 3048 | 3048 | yes | no | 34.925 | 7.9375 | 17.4625 | HT_vratné vodní (45 °C) 13
13311346 | 2.NP_SO-102 | 0 | ø32 mm-ø20 mm | HD | 2.NP_SO-102 | 2532.54 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 8.73125 | 10 | 16 | 20 | 32 | 32 | 20 | 0.00000565444 | 10 | 10 | 0.00129853 | ø32-ø20 | 8.89 | 13.97 | 22.225 | 34.925 | TT03.03.1345 | 1345 | yes | 3048 | 3048 | no | yes | 34.925 | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13311348 | -1.PP_SO-102 | 0 | ø32 mm-ø20 mm | HD | -1.PP_SO-102 | 2750 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 8.73125 | 10 | 16 | 20 | 32 | 32 | 20 | 0.00000565444 | 10 | 10 | 0.00129853 | ø32-ø20 | 8.89 | 13.97 | 22.225 | 34.925 | TT03.03.1346 | 1346 | yes | 3048 | 3048 | no | yes | 34.925 | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27 | Mechanické – tok - Tlaková ztráta: 0 Pa
13311350 | -1.PP_SO-102 | 0 | ø32 mm-ø20 mm | HD | -1.PP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 8.73125 | 10 | 16 | 20 | 32 | 32 | 20 | 0.00000565444 | 10 | 10 | 0.00129853 | ø32-ø20 | 8.89 | 13.97 | 22.225 | 34.925 | TT03.03.1347 | 1347 | yes | 3048 | 3048 | no | yes | 34.925 | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13311425 | 2.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5.55625 | 10 | 8 | 20 | 16 | 20 | 16 | 0.00000184965 | 10 | 10 | 0.000597935 | ø20-ø16 | 8.89 | 7.67 | 22.225 | 19.175 | TT03.03.1348 | 1348 | no | 3048 | 3048 | yes | no | 22.225 | 9.5875 | 11.1125 | HT_vratné vodní (45 °C) 1
13311427 | 2.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 14 | 5.55625 | 10 | 8 | 20 | 16 | 20 | 16 | 0.00000184965 | 10 | 10 | 0.000597935 | ø20-ø16 | 8.89 | 7.67 | 22.225 | 19.175 | TT03.03.1349 | 1349 | no | 3048 | 3048 | yes | no | 22.225 | 9.5875 | 11.1125 | HT_přívodní vodní (55 °C) 14 | Mechanické – tok - Tlaková ztráta: 0 Pa
13311481 | 1.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 5.55625 | 10 | 8 | 20 | 16 | 20 | 16 | 0.00000184965 | 10 | 10 | 0.000597935 | ø20-ø16 | 8.89 | 7.67 | 22.225 | 19.175 | TT03.03.1350 | 1350 | no | 3048 | 3048 | yes | no | 22.225 | 9.5875 | 11.1125 | HT_přívodní vodní (55 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13311804 | 1.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 21 | 5.55625 | 10 | 8 | 20 | 16 | 20 | 16 | 0.00000184965 | 10 | 10 | 0.000597935 | ø20-ø16 | 8.89 | 7.67 | 22.225 | 19.175 | TT03.03.1353 | 1353 | no | 3048 | 3048 | yes | no | 22.225 | 9.5875 | 11.1125 | HT_přívodní vodní (65 °C) 21 | Mechanické – tok - Tlaková ztráta: 0 Pa
13311856 | 1.NP_SO-102 | 0 | ø32 mm-ø15 mm | HD | 1.NP_SO-102 | 3249.84 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8.73125 | 16 | 7.5 | 32 | 15 | 32 | 15 | 0.0000046023 | 16.0022 | 16 | 0.00116528 | ø32-ø15 | 13.97 | 6.35 | 34.925 | 15.875 | TT03.03.1362 | 1362 | yes | 3048 | 3048 | yes | no | 34.925 | 7.9375 | 17.4625 | HT_vratné vodní (45 °C) 1
13311935 | 1.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 1.NP_SO-102 | -44.0625 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1365 | 1365 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 1
13311941 | 1.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 1.NP_SO-102 | -34.0625 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 23 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1366 | 1366 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (65 °C) 23; HT_přívodní vodní (55 °C) 16
13312260 | 1.NP_SO-102 | 0 | ø22 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 6.29375 | 11 | 8 | 22 | 16 | 22 | 16 | 0.00000243454 | 11 | 11 | 0.000703658 | ø22-ø16 | 10.07 | 7.67 | 25.175 | 19.175 | TT03.03.1367 | 1367 | no | 3048 | 3048 | yes | no | 25.175 | 9.5875 | 12.5875 | HT_vratné vodní (45 °C) 32
13312262 | 1.NP_SO-102 | 0 | ø22 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 6.29375 | 11 | 8 | 22 | 16 | 22 | 16 | 0.00000243454 | 11 | 11 | 0.000703658 | ø22-ø16 | 10.07 | 7.67 | 25.175 | 19.175 | TT03.03.1368 | 1368 | no | 3048 | 3048 | yes | no | 25.175 | 9.5875 | 12.5875 | HT_vratné vodní (45 °C) 32
13312264 | 1.NP_SO-102 | 0 | ø22 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 6.29375 | 11 | 8 | 22 | 16 | 22 | 16 | 0.00000243454 | 11 | 11 | 0.000703658 | ø22-ø16 | 10.07 | 7.67 | 25.175 | 19.175 | TT03.03.1369 | 1369 | no | 3048 | 3048 | yes | no | 25.175 | 9.5875 | 12.5875 | HT_vratné vodní (45 °C) 32
13312298 | 1.NP_SO-102 | 0 | ø22 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 6.29375 | 11 | 8 | 22 | 16 | 22 | 16 | 0.00000243454 | 11 | 11 | 0.000703658 | ø22-ø16 | 10.07 | 7.67 | 25.175 | 19.175 | TT03.03.1370 | 1370 | no | 3048 | 3048 | yes | no | 25.175 | 9.5875 | 12.5875 | HT_vratné vodní (45 °C) 32
13312402 | 1.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 1.NP_SO-102 | -72.2875 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1371 | 1371 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 9
13312406 | 1.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 1.NP_SO-102 | -80.2875 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1372 | 1372 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 32
13312469 | 1.NP_SO-102 | 0 | ø22 mm-ø16 mm | HD | 1.NP_SO-102 | 3950 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6.29375 | 11 | 8 | 22 | 16 | 22 | 16 | 0.00000243454 | 11 | 11 | 0.000703658 | ø22-ø16 | 10.07 | 7.67 | 25.175 | 19.175 | TT03.03.1373 | 1373 | no | 3048 | 3048 | yes | no | 25.175 | 9.5875 | 12.5875 | HT_přívodní vodní (55 °C) 9
13312475 | 1.NP_SO-102 | 0 | ø22 mm-ø16 mm | HD | 1.NP_SO-102 | 3940 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 6.29375 | 11 | 8 | 22 | 16 | 22 | 16 | 0.00000243454 | 11 | 11 | 0.000703658 | ø22-ø16 | 10.07 | 7.67 | 25.175 | 19.175 | TT03.03.1374 | 1374 | no | 3048 | 3048 | yes | no | 25.175 | 9.5875 | 12.5875 | HT_vratné vodní (45 °C) 32
13312696 | 1.NP_SO-102 | 0 | ø25 mm-ø15 mm | HD | 1.NP_SO-102 | 3273.01 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 12.5 | 12.5 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.1381 | 1381 | yes | 3048 | 3048 | yes | no | 28.575 | 7.9375 | 14.2875 | HT_přívodní vodní (55 °C) 19
13312700 | 1.NP_SO-102 | 0 | ø25 mm-ø20 mm | HD | 1.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT03.03.1383 | 1383 | yes | 3048 | 3048 | yes | no | 28.575 | 11.1125 | 14.2875 | HT_vratné vodní (45 °C) 13
13312708 | 1.NP_SO-102 | 0 | ø25 mm-ø15 mm | HD | 1.NP_SO-102 | 3173.01 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 12.5 | 12.5 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.1385 | 1385 | yes | 3048 | 3048 | yes | no | 28.575 | 7.9375 | 14.2875 | HT_vratné vodní (45 °C) 13
13312723 | 1.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 1.NP_SO-102 | -29.2687 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1386 | 1386 | no | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_přívodní vodní (55 °C) 19
13312725 | 1.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 1.NP_SO-102 | -39.2688 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1387 | 1387 | no | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_vratné vodní (45 °C) 13
13312770 | 1.NP_SO-102 | 0 | ø25 mm-ø20 mm | HD | 1.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT03.03.1388 | 1388 | yes | 3048 | 3048 | yes | no | 28.575 | 11.1125 | 14.2875 | HT_vratné vodní (45 °C) 13
13312772 | 1.NP_SO-102 | 0 | ø25 mm-ø20 mm | HD | 1.NP_SO-102 | 3200 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT03.03.1389 | 1389 | yes | 3048 | 3048 | yes | no | 28.575 | 11.1125 | 14.2875 | HT_přívodní vodní (55 °C) 19
13312791 | 1.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 1.NP_SO-102 | -34.0625 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1390 | 1390 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 19
13312793 | 1.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 1.NP_SO-102 | -44.0625 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1391 | 1391 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 13
13312904 | 2.NP_SO-102 | 0 | ø25 mm-ø22 mm | HD | 2.NP_SO-102 | 2750 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.14375 | 11 | 12.5 | 22 | 25 | 25 | 22 | 0.00000404537 | 11 | 11 | 0.00100151 | ø25-ø22 | 10.07 | 11.43 | 25.175 | 28.575 | TT03.03.1393 | 1393 | yes | 3048 | 3048 | no | yes | 28.575 | 14.2875 | 12.5875 | HT_vratné vodní (45 °C) 1
13312908 | 2.NP_SO-102 | 0 | ø42 mm-ø25 mm | HD | 2.NP_SO-102 | 2614.71 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11.2937 | 21 | 12.5 | 42 | 25 | 42 | 25 | 0.0000122392 | 21 | 21 | 0.00217651 | ø42-ø25 | 18.07 | 11.43 | 45.175 | 28.575 | TT03.03.1395 | 1395 | yes | 3048 | 3048 | yes | no | 45.175 | 14.2875 | 22.5875 | HT_vratné vodní (45 °C) 1
13312912 | 2.NP_SO-102 | 0 | ø25 mm-ø22 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.14375 | 11 | 12.5 | 22 | 25 | 25 | 22 | 0.00000404537 | 11 | 11 | 0.00100151 | ø25-ø22 | 10.07 | 11.43 | 25.175 | 28.575 | TT03.03.1397 | 1397 | yes | 3048 | 3048 | no | yes | 28.575 | 14.2875 | 12.5875 | HT_vratné vodní (45 °C) 1
13312916 | 2.NP_SO-102 | 0 | ø25 mm-ø22 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.14375 | 11 | 12.5 | 22 | 25 | 25 | 22 | 0.00000404537 | 11 | 11 | 0.00100151 | ø25-ø22 | 10.07 | 11.43 | 25.175 | 28.575 | TT03.03.1399 | 1399 | yes | 3048 | 3048 | no | yes | 28.575 | 14.2875 | 12.5875 | HT_vratné vodní (45 °C) 1
13312918 | 2.NP_SO-102 | 0 | ø42 mm-ø25 mm | HD | 2.NP_SO-102 | 2614.71 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 11.2937 | 21 | 12.5 | 42 | 25 | 42 | 25 | 0.0000122392 | 21 | 21 | 0.00217651 | ø42-ø25 | 18.07 | 11.43 | 45.175 | 28.575 | TT03.03.1400 | 1400 | yes | 3048 | 3048 | yes | no | 45.175 | 14.2875 | 22.5875 | HT_přívodní vodní (55 °C) 9
13312922 | 2.NP_SO-102 | 0 | ø25 mm-ø22 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.14375 | 11 | 12.5 | 22 | 25 | 25 | 22 | 0.00000404537 | 11 | 11 | 0.00100151 | ø25-ø22 | 10.07 | 11.43 | 25.175 | 28.575 | TT03.03.1402 | 1402 | yes | 3048 | 3048 | no | yes | 28.575 | 14.2875 | 12.5875 | HT_přívodní vodní (55 °C) 9
13312926 | 2.NP_SO-102 | 0 | ø25 mm-ø22 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.14375 | 11 | 12.5 | 22 | 25 | 25 | 22 | 0.00000404537 | 11 | 11 | 0.00100151 | ø25-ø22 | 10.07 | 11.43 | 25.175 | 28.575 | TT03.03.1404 | 1404 | yes | 3048 | 3048 | no | yes | 28.575 | 14.2875 | 12.5875 | HT_přívodní vodní (55 °C) 9
13313121 | 2.NP_SO-102 | 0 | ø25 mm-ø22 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 7.14375 | 11 | 12.5 | 22 | 25 | 25 | 22 | 0.00000404537 | 11 | 11 | 0.00100151 | ø25-ø22 | 10.07 | 11.43 | 25.175 | 28.575 | TT03.03.1405 | 1405 | yes | 3048 | 3048 | no | yes | 28.575 | 14.2875 | 12.5875 | HT_přívodní vodní (55 °C) 12 | Mechanické – tok - Tlaková ztráta: 0 Pa
13313199 | 2.NP_SO-102 | 40 | ø120 mm-ø112 mm | HD | 2.NP_SO-102 | 3300 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT03.03.1408 | 1408 | yes | 3048 | 3048 | no | yes | 41.275 | 20.6375 | 17.4625 | HT_přívodní vodní (65 °C) 6; HT_přívodní vodní (55 °C) 11 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13313206 | -1.PP_SO-102 | 40 | ø120 mm-ø112 mm | HD | -1.PP_SO-102 | 2623.81 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT03.03.1409 | 1409 | yes | 3048 | 3048 | no | yes | 41.275 | 20.6375 | 17.4625 | HT_přívodní vodní (65 °C) 6 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13313209 | 2.NP_SO-102 | 40 | ø120 mm-ø112 mm | HD | 2.NP_SO-102 | 3276.19 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT03.03.1410 | 1410 | yes | 3048 | 3048 | no | yes | 41.275 | 20.6375 | 17.4625 | HT_přívodní vodní (65 °C) 6 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13313226 | 2.NP_SO-102 | 40 | ø120 mm-ø112 mm | HD | 2.NP_SO-102 | 3126.19 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT03.03.1411 | 1411 | yes | 3048 | 3048 | no | yes | 41.275 | 20.6375 | 17.4625 | HT_vratné vodní (45 °C) 2 | Izolace - Typ izolace: Tepelná
13313229 | -1.PP_SO-102 | 40 | ø120 mm-ø112 mm | HD | -1.PP_SO-102 | 2623.81 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT03.03.1412 | 1412 | yes | 3048 | 3048 | no | yes | 41.275 | 20.6375 | 17.4625 | HT_vratné vodní (45 °C) 2 | Izolace - Typ izolace: Tepelná
13313812 | 2.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1421 | 1421 | no | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_vratné vodní (45 °C) 1
13313814 | 2.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1422 | 1422 | no | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13313852 | 2.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1423 | 1423 | no | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_vratné vodní (45 °C) 1
13313854 | 2.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1424 | 1424 | no | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_vratné vodní (45 °C) 1
13313856 | 2.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1425 | 1425 | no | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13313858 | 2.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1426 | 1426 | no | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13314223 | 2.NP_SO-102 | 40 | ø120 mm-ø100 mm | HD | 2.NP_SO-102 | 3160 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 18.7701 | 20 | 0.00177584 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.1431 | 1431 | yes | 3046.77 | 3048 | yes | no | 41.275 | 11.1125 | 20.6375 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13314230 | 2.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 2.NP_SO-102 | -44.0625 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1432 | 1432 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 1
13314232 | 2.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 2.NP_SO-102 | -34.0625 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1433 | 1433 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13314291 | 2.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 2.NP_SO-102 | -29.2687 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1435 | 1435 | no | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_vratné vodní (45 °C) 1
13314293 | 2.NP_SO-102 | 0 | ø20 mm-ø15 mm | HD | 2.NP_SO-102 | 3136.19 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5.55625 | 10 | 7.5 | 20 | 15 | 20 | 15 | 0.00000157471 | 10 | 10 | 0.000554533 | ø20-ø15 | 8.89 | 6.35 | 22.225 | 15.875 | TT03.03.1436 | 1436 | yes | 3048 | 3048 | yes | no | 22.225 | 7.9375 | 11.1125 | HT_vratné vodní (45 °C) 1
13314297 | 2.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 2.NP_SO-102 | -29.2687 | Fáze 1 | HT_přívodní vodní (45 °C) | Přívod teplé vody | HT_přívodní vodní (45 °C) 2 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1438 | 1438 | no | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_přívodní vodní (45 °C) 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13314354 | 2.NP_SO-102 | 60 | ø200 mm-ø140 mm | HD | 2.NP_SO-102 | 3047.61 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 19.8438 | 40 | 10 | 80 | 20 | 80 | 20 | 0.0000443954 | 40 | 40 | 0.00584559 | ø80-ø20 | 31.75 | 8.89 | 79.375 | 22.225 | TT03.03.1439 | 1439 | yes | 3048 | 3048 | yes | no | 79.375 | 11.1125 | 39.6875 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13314357 | 2.NP_SO-102 | 0 | ø80 mm-ø20 mm | HD | 2.NP_SO-102 | 3047.61 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 19.8438 | 40 | 10 | 80 | 20 | 80 | 20 | 0.0000443954 | 40 | 40 | 0.00584559 | ø80-ø20 | 31.75 | 8.89 | 79.375 | 22.225 | TT03.03.1440 | 1440 | yes | 3048 | 3048 | yes | no | 79.375 | 11.1125 | 39.6875 | HT_přívodní vodní (55 °C) 9
13314363 | 2.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 2.NP_SO-102 | -44.0625 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1441 | 1441 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 1
13314365 | 2.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 2.NP_SO-102 | -34.0625 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1442 | 1442 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 9
13314627 | 2.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 2.NP_SO-102 | -29.2688 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1449 | 1449 | no | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_přívodní vodní (55 °C) 19
13314719 | 2.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 2.NP_SO-102 | -34.0625 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1454 | 1454 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 19
13314721 | 2.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 2.NP_SO-102 | -44.0625 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1455 | 1455 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 13
13314947 | 3.NP_SO-102 | 40 | ø120 mm-ø100 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.1457 | 1457 | yes | 3048 | 3048 | yes | no | 41.275 | 11.1125 | 20.6375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13315103 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 5.55625 | 10 | 8 | 20 | 16 | 20 | 16 | 0.00000184965 | 10 | 10 | 0.000597935 | ø20-ø16 | 8.89 | 7.67 | 22.225 | 19.175 | TT03.03.1462 | 1462 | yes | 3048 | 3048 | yes | no | 22.225 | 9.5875 | 11.1125 | HT_přívodní vodní (55 °C) 9
13315109 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5.55625 | 10 | 8 | 20 | 16 | 20 | 16 | 0.00000184965 | 10 | 10 | 0.000597935 | ø20-ø16 | 8.89 | 7.67 | 22.225 | 19.175 | TT03.03.1465 | 1465 | yes | 3048 | 3048 | yes | no | 22.225 | 9.5875 | 11.1125 | HT_vratné vodní (45 °C) 1
13315149 | 3.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 3.NP_SO-102 | 3929.27 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1468 | 1468 | yes | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_vratné vodní (45 °C) 1
13315173 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -44.0625 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1469 | 1469 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 1
13315175 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -34.0625 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 17 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1470 | 1470 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 17 | Mechanické – tok - Tlaková ztráta: 0 Pa
13315287 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -34.0625 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 18 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1471 | 1471 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 18 | Mechanické – tok - Tlaková ztráta: 0 Pa
13315289 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -44.0625 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1472 | 1472 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 1
13315464 | 3.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 3.NP_SO-102 | -22.9187 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1483 | 1483 | no | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13315470 | 3.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 3.NP_SO-102 | -25.0873 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1484 | 1484 | no | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_vratné vodní (45 °C) 1
13315488 | 3.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 3.NP_SO-102 | 3929.27 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1485 | 1485 | no | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13315490 | 3.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 3.NP_SO-102 | 3929.27 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1486 | 1486 | no | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_vratné vodní (45 °C) 1
13315624 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1487 | 1487 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 19
13315626 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1488 | 1488 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 19
13315628 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1489 | 1489 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 19
13315630 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1490 | 1490 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 19
13315632 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1491 | 1491 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 19
13315634 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1492 | 1492 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 19
13315636 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1493 | 1493 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 19
13315638 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1494 | 1494 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 13
13315640 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1495 | 1495 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 13
13315642 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1496 | 1496 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 13
13315644 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1497 | 1497 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 13
13315646 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1498 | 1498 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 13
13315648 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1499 | 1499 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 13
13315650 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1500 | 1500 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 13
13315652 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1501 | 1501 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 19
13315654 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1502 | 1502 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 19
13315656 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1503 | 1503 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 19
13315658 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1504 | 1504 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 13
13315660 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1505 | 1505 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 13
13315662 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1506 | 1506 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 13
13315664 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1507 | 1507 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 19
13315666 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1508 | 1508 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 19
13315668 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1509 | 1509 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 19
13315670 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1510 | 1510 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 13
13315672 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1511 | 1511 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 13
13315674 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1512 | 1512 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 13
13315752 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -34.0625 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1513 | 1513 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 19
13315754 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -44.0625 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1514 | 1514 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 13
13315914 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -34.0625 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1519 | 1519 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 19
13315916 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -44.0625 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1520 | 1520 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 13
13315918 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -34.0625 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1521 | 1521 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 19
13315920 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -44.0625 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1522 | 1522 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 13
13316015 | 3.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1524 | 1524 | no | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_vratné vodní (45 °C) 13
13316120 | 3.NP_SO-102 | 0 | ø32 mm-ø15 mm | HD | 3.NP_SO-102 | 3119.84 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8.73125 | 16 | 7.5 | 32 | 15 | 32 | 15 | 0.0000046023 | 16 | 16 | 0.00116529 | ø32-ø15 | 13.97 | 6.35 | 34.925 | 15.875 | TT03.03.1526 | 1526 | yes | 3048 | 3048 | yes | no | 34.925 | 7.9375 | 17.4625 | HT_přívodní vodní (55 °C) 19
13316128 | 3.NP_SO-102 | 0 | ø32 mm-ø15 mm | HD | 3.NP_SO-102 | 3019.84 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8.73125 | 16 | 7.5 | 32 | 15 | 32 | 15 | 0.0000046023 | 16 | 15.9951 | 0.00116524 | ø32-ø15 | 13.97 | 6.35 | 34.925 | 15.875 | TT03.03.1530 | 1530 | yes | 3048 | 3048 | yes | no | 34.925 | 7.9375 | 17.4625 | HT_vratné vodní (45 °C) 13
13316368 | 2.NP_SO-102 | 0 | ø25 mm-ø20 mm | HE | 2.NP_SO-102 | 2650 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT03.03.1536 | 1536 | yes | 3048 | 3048 | yes | no | 28.575 | 11.1125 | 14.2875 | HT/CL_vratné vodní 1
13316665 | 4.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 4.NP_SO-102 | -27.7125 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 34 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1546 | 1546 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (65 °C) 34; HT_přívodní vodní (55 °C) 21 | Mechanické – tok - Tlaková ztráta: 0 Pa
13316667 | 4.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 4.NP_SO-102 | -37.7125 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1547 | 1547 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 1
13316822 | 4.NP_SO-102 | 0 | ø25 mm-ø20 mm | HD | 4.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT03.03.1551 | 1551 | yes | 3048 | 3048 | yes | no | 28.575 | 11.1125 | 14.2875 | HT_vratné vodní (45 °C) 1
13316824 | 4.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 4.NP_SO-102 | -34.0625 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 24 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1552 | 1552 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 24 | Mechanické – tok - Tlaková ztráta: 0 Pa
13316826 | 4.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 4.NP_SO-102 | -44.0625 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1553 | 1553 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 1
13316844 | 4.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 4.NP_SO-102 | -29.2687 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1554 | 1554 | no | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_vratné vodní (45 °C) 1
13316846 | 4.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 4.NP_SO-102 | -29.2687 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1555 | 1555 | no | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13316908 | 4.NP_SO-102 | 0 | ø22 mm-ø20 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6.29375 | 11 | 10 | 22 | 20 | 22 | 20 | 0.00000276911 | 11 | 11 | 0.000785339 | ø22-ø20 | 10.07 | 8.89 | 25.175 | 22.225 | TT03.03.1556 | 1556 | yes | 3048 | 3048 | yes | no | 25.175 | 11.1125 | 12.5875 | HT_přívodní vodní (55 °C) 9
13316910 | 4.NP_SO-102 | 0 | ø25 mm-ø20 mm | HD | 4.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT03.03.1557 | 1557 | yes | 3048 | 3048 | yes | no | 28.575 | 11.1125 | 14.2875 | HT_vratné vodní (45 °C) 1
13317048 | 4.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 4.NP_SO-102 | -34.0625 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 23 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1561 | 1561 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 23 | Mechanické – tok - Tlaková ztráta: 0 Pa
13317050 | 4.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 4.NP_SO-102 | -44.0625 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1562 | 1562 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 1
13317280 | 4.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 4.NP_SO-102 | -34.0625 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1563 | 1563 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 19
13317282 | 4.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 4.NP_SO-102 | -44.0625 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1564 | 1564 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 13
13317284 | 4.NP_SO-102 | 0 | ø22 mm-ø20 mm | HD | 4.NP_SO-102 | -31.0625 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 6.29375 | 11 | 10 | 22 | 20 | 22 | 20 | 0.00000276911 | 11 | 11 | 0.000785339 | ø22-ø20 | 10.07 | 8.89 | 25.175 | 22.225 | TT03.03.1565 | 1565 | no | 3048 | 3048 | yes | no | 25.175 | 11.1125 | 12.5875 | HT_přívodní vodní (55 °C) 19
13317286 | 4.NP_SO-102 | 0 | ø22 mm-ø20 mm | HD | 4.NP_SO-102 | -41.0625 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 6.29375 | 11 | 10 | 22 | 20 | 22 | 20 | 0.00000276911 | 11 | 11 | 0.000785339 | ø22-ø20 | 10.07 | 8.89 | 25.175 | 22.225 | TT03.03.1566 | 1566 | no | 3048 | 3048 | yes | no | 25.175 | 11.1125 | 12.5875 | HT_vratné vodní (45 °C) 13
13317389 | 4.NP_SO-102 | 0 | ø40 mm-ø20 mm | HD | 4.NP_SO-102 | 3200 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.1569 | 1569 | yes | 3048 | 3048 | yes | no | 41.275 | 11.1125 | 20.6375 | HT_přívodní vodní (55 °C) 19
13317391 | 4.NP_SO-102 | 0 | ø40 mm-ø20 mm | HD | 4.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.1570 | 1570 | yes | 3048 | 3048 | yes | no | 41.275 | 11.1125 | 20.6375 | HT_vratné vodní (45 °C) 13
13317393 | 4.NP_SO-102 | 0 | ø40 mm-ø20 mm | HD | 4.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.1571 | 1571 | yes | 3048 | 3048 | yes | no | 41.275 | 11.1125 | 20.6375 | HT_vratné vodní (45 °C) 13
13317494 | 4.NP_SO-102 | 0 | ø20 mm-ø15 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 10 | 7.5 | 20 | 15 | 20 | 15 | 0.00000157471 | 10 | 10 | 0.000554533 | ø20-ø15 | 8.89 | 6.35 | 22.225 | 15.875 | TT03.03.1574 | 1574 | no | 3048 | 3048 | yes | no | 22.225 | 7.9375 | 11.1125 | HT_vratné vodní (45 °C) 13
13322225 | 3.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 3.NP_SO-102 | -44.0625 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1581 | 1581 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 1
13322249 | 2.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 2.NP_SO-102 | -34.0625 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1582 | 1582 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_přívodní vodní (55 °C) 19
13322251 | 2.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 2.NP_SO-102 | -44.0625 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 8 | 10 | 16 | 20 | 20 | 16 | 0.00000185568 | 8 | 8 | 0.000597935 | ø20-ø16 | 7.67 | 8.89 | 19.175 | 22.225 | TT03.03.1583 | 1583 | no | 3048 | 3048 | no | yes | 22.225 | 11.1125 | 9.5875 | HT_vratné vodní (45 °C) 13
13322273 | 4.NP_SO-102 | 0 | ø22 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 6.29375 | 11 | 8 | 22 | 16 | 22 | 16 | 0.00000243454 | 11 | 11 | 0.000703658 | ø22-ø16 | 10.07 | 7.67 | 25.175 | 19.175 | TT03.03.1584 | 1584 | no | 3048 | 3048 | yes | no | 25.175 | 9.5875 | 12.5875 | HT_přívodní vodní (55 °C) 19
13322277 | 4.NP_SO-102 | 0 | ø22 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 6.29375 | 11 | 8 | 22 | 16 | 22 | 16 | 0.00000243454 | 11 | 11 | 0.000703658 | ø22-ø16 | 10.07 | 7.67 | 25.175 | 19.175 | TT03.03.1585 | 1585 | no | 3048 | 3048 | yes | no | 25.175 | 9.5875 | 12.5875 | HT_vratné vodní (45 °C) 13
13322422 | 2.NP_SO-102 | 0 | ø65 mm-ø40 mm | HD | 2.NP_SO-102 | 3019.02 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 16.6688 | 32.5 | 20 | 65 | 40 | 65 | 40 | 0.0000388042 | 32.5 | 32.5 | 0.00492645 | ø65-ø40 | 26.67 | 16.51 | 66.675 | 41.275 | TT03.03.1589 | 1589 | yes | 3048 | 3048 | yes | no | 66.675 | 20.6375 | 33.3375 | HT_přívodní vodní (55 °C) 19
13323029 | -1.PP_SO-102 | 0 | ø40 mm-ø15 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10.3188 | 7.5 | 20 | 15 | 40 | 40 | 15 | 0.00000703078 | 7.5 | 7.5 | 0.00162635 | ø40-ø15 | 6.35 | 16.51 | 15.875 | 41.275 | TT03.03.1591 | 1591 | yes | 3048 | 3048 | no | yes | 41.275 | 20.6375 | 7.9375 | HT_vratné vodní (45 °C) 1
13327809 | 2.NP_SO-102 | 0 | ø40 mm-ø20 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.1607 | 1607 | yes | 3048 | 3048 | yes | no | 41.275 | 11.1125 | 20.6375 | HT_přívodní vodní (55 °C) 9
13327859 | 2.NP_SO-102 | 0 | ø40 mm-ø20 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.1610 | 1610 | yes | 3048 | 3048 | yes | no | 41.275 | 11.1125 | 20.6375 | HT_vratné vodní (45 °C) 1
13335624 | 2.NP_SO-102 | 0 | ø42 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11.2937 | 21 | 20 | 42 | 40 | 42 | 40 | 0.0000165584 | 21 | 21 | 0.00273098 | ø42-ø40 | 18.07 | 16.51 | 45.175 | 41.275 | TT03.03.1633 | 1633 | yes | 3048 | 3048 | yes | no | 45.175 | 20.6375 | 22.5875 | HT_vratné vodní (45 °C) 1
13335659 | 2.NP_SO-102 | 0 | ø42 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 11.2937 | 21 | 20 | 42 | 40 | 42 | 40 | 0.0000165584 | 21 | 21 | 0.00273098 | ø42-ø40 | 18.07 | 16.51 | 45.175 | 41.275 | TT03.03.1636 | 1636 | yes | 3048 | 3048 | yes | no | 45.175 | 20.6375 | 22.5875 | HT_přívodní vodní (55 °C) 9
