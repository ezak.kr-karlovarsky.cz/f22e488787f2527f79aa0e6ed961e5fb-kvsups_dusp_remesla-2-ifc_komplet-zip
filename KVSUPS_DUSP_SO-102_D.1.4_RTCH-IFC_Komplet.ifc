Properties of the parts of a building model (IFC4), part 68 of 72

# IfcPipeSegment: Typy trubek:Ocel_uhlíková (1186)
Name (Typy trubek:Ocel_uhlíková:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Tloušťka izolace (mm) | Celková velikost | Relativní drsnost | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) | Řez | Délka (mm) | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
13335246 | 2.NP_SO-102 | 604.419 | 0.000891835 | 0.0639908 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 2666.85 | 2650 | 2650 | 2633.15 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 6636.4 | 0.0474709 | 25 | 38 | 604.419 | ø25 | 33.7 | 27.2 | TR02.02.1865 | 1865 | yes | HT/CL_vratné vodní 1 | 0
13335289 | 2.NP_SO-102 | 504.419 | 0.000891835 | 0.0534037 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 2666.85 | 2650 | 2650 | 2633.15 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 6636.4 | 0.039617 | 25 | 15 | 504.419 | ø25 | 33.7 | 27.2 | TR02.02.1866 | 1866 | yes | HT/CL_přívodní vodní 1 | 0
13335310 | 2.NP_SO-102 | 493.955 | 0.000891835 | 0.0522958 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 2766.85 | 2750 | 2750 | 2733.15 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 6736.4 | 0.0387951 | 25 | 15 | 493.955 | ø25 | 33.7 | 27.2 | TR02.02.1867 | 1867 | yes | HT/CL_přívodní vodní 1 | 0
13335335 | 2.NP_SO-102 | 468.555 | 0.00183197 | 0.071098 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2774.15 | 2750 | 2750 | 2725.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6729.1 | 0.0588803 | 40 | 44 | 468.555 | ø40 | 48.3 | 41.8 | TR02.02.1868 | 1868 | yes | HT_vratné vodní (45 °C) 1 | 0
13335354 | 2.NP_SO-102 | 784.825 | 0.00183197 | 0.119089 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2674.15 | 2650 | 2650 | 2625.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6629.1 | 0.098624 | 40 | 44 | 784.825 | ø40 | 48.3 | 41.8 | TR02.02.1869 | 1869 | yes | HT_vratné vodní (45 °C) 1 | 0
13335375 | 2.NP_SO-102 | 468.555 | 0.00183197 | 0.071098 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2774.15 | 2750 | 2750 | 2725.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6729.1 | 0.0588803 | 40 | 78 | 468.555 | ø40 | 48.3 | 41.8 | TR02.02.1870 | 1870 | yes | HT_přívodní vodní (55 °C) 9 | 0
13335396 | 2.NP_SO-102 | 684.825 | 0.00183197 | 0.103915 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2674.15 | 2650 | 2650 | 2625.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6629.1 | 0.0860577 | 40 | 78 | 684.825 | ø40 | 48.3 | 41.8 | TR02.02.1871 | 1871 | yes | HT_přívodní vodní (55 °C) 9 | 0
13335539 | 2.NP_SO-102 | 58.725 | 0.000891835 | 0.00621731 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 2729.36 | 2670.64 | 2729.36 | 2670.64 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 6670.64 | 0.00461225 | 25 | 38 | 58.725 | ø25 | 33.7 | 27.2 | TR02.02.1872 | 1872 | yes | HT/CL_vratné vodní 1
13335572 | 2.NP_SO-102 | 58.725 | 0.000891835 | 0.00621731 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 2729.36 | 2670.64 | 2729.36 | 2670.64 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 6670.64 | 0.00461225 | 25 | 15 | 58.725 | ø25 | 33.7 | 27.2 | TR02.02.1873 | 1873 | yes | HT/CL_přívodní vodní 1
13335607 | 2.NP_SO-102 | 46.025 | 0.00183197 | 0.00698378 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2723.01 | 2676.99 | 2723.01 | 2676.99 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6676.99 | 0.00578367 | 40 | 44 | 46.025 | ø40 | 48.3 | 41.8 | TR02.02.1874 | 1874 | yes | HT_vratné vodní (45 °C) 1
13335647 | 2.NP_SO-102 | 46.025 | 0.00183197 | 0.00698378 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2723.01 | 2676.99 | 2723.01 | 2676.99 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6676.99 | 0.00578367 | 40 | 78 | 46.025 | ø40 | 48.3 | 41.8 | TR02.02.1875 | 1875 | yes | HT_přívodní vodní (55 °C) 9
13335684 | 2.NP_SO-102 | 58.725 | 0.000891835 | 0.00621731 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 2729.36 | 2670.64 | 2729.36 | 2670.64 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 6670.64 | 0.00461225 | 25 | 38 | 58.725 | ø25 | 33.7 | 27.2 | TR02.02.1876 | 1876 | yes | HT/CL_vratné vodní 1
13335717 | 2.NP_SO-102 | 58.725 | 0.000891835 | 0.00621731 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 2729.36 | 2670.64 | 2729.36 | 2670.64 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 6670.64 | 0.00461225 | 25 | 15 | 58.725 | ø25 | 33.7 | 27.2 | TR02.02.1877 | 1877 | yes | HT/CL_přívodní vodní 1
13335750 | 2.NP_SO-102 | 46.025 | 0.00183197 | 0.00698378 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2723.01 | 2676.99 | 2723.01 | 2676.99 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6676.99 | 0.00578367 | 40 | 44 | 46.025 | ø40 | 48.3 | 41.8 | TR02.02.1878 | 1878 | yes | HT_vratné vodní (45 °C) 1
13335785 | 2.NP_SO-102 | 46.025 | 0.00183197 | 0.00698378 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2723.01 | 2676.99 | 2723.01 | 2676.99 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6676.99 | 0.00578367 | 40 | 78 | 46.025 | ø40 | 48.3 | 41.8 | TR02.02.1879 | 1879 | yes | HT_přívodní vodní (55 °C) 9
13336691 | 2.NP_SO-102 | 225.713 | 0.000356274 | 0.0151038 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 3110.65 | 3100 | 3100 | 3089.35 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 7092 | 0.0106365 | 15 | 37 | 225.713 | ø15 | 21.3 | 16 | TR02.02.1880 | 1880 | no | HT_přívodní vodní (55 °C) 12 | 0
13336842 | 2.NP_SO-102 | 175.712 | 0.000356274 | 0.011758 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 2540.65 | 2530 | 2530 | 2519.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 6522 | 0.00828026 | 15 | 129 | 175.712 | ø15 | 21.3 | 16 | TR02.02.1881 | 1881 | yes | HT_vratné vodní (45 °C) 9 | 0
13336882 | 2.NP_SO-102 | 541.425 | 0.000356274 | 0.03623 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 3085.71 | 2544.29 | 3085.71 | 2544.29 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 6544.29 | 0.0255141 | 15 | 129 | 541.425 | ø15 | 21.3 | 16 | TR02.02.1882 | 1882 | yes | HT_vratné vodní (45 °C) 9
13337312 | 2.NP_SO-102 | 7125.6 | 0.000568237 | 0.602177 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2213.45 | 2200 | 2200 | 2186.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6189.2 | 0.447715 | 20 | 101 | 7125.6 | ø20 | 26.9 | 21.6 | TR02.02.1883 | 1883 | yes | HT_vratné vodní (45 °C) 26 | 0
13337364 | 2.NP_SO-102 | 1515.2 | 0.000568237 | 0.128048 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2463.45 | 2450 | 2450 | 2436.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6439.2 | 0.0952027 | 20 | 106 | 1515.2 | ø20 | 26.9 | 21.6 | TR02.02.1884 | 1884 | yes | HT_přívodní vodní (55 °C) 25 | 0
13337943 | 2.NP_SO-102 | 165.075 | 0.000568237 | 0.0139503 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2382.54 | 2382.54 | 2217.46 | 2217.46 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6217.46 | 0.010372 | 20 | 101 | 165.075 | ø20 | 26.9 | 21.6 | TR02.02.1885 | 1885 | yes | HT_vratné vodní (45 °C) 26
13337954 | 2.NP_SO-102 | 4323.78 | 0.000568237 | 0.365397 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2013.45 | 2000 | 2000 | 1986.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 5989.2 | 0.271671 | 20 | 112 | 4323.78 | ø20 | 26.9 | 21.6 | TR02.02.1886 | 1886 | yes | HT_vratné vodní (45 °C) 26 | 0
13338004 | 2.NP_SO-102 | 215.075 | 0.000568237 | 0.0181757 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2432.54 | 2432.54 | 2217.46 | 2217.46 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6217.46 | 0.0135136 | 20 | 106 | 215.075 | ø20 | 26.9 | 21.6 | TR02.02.1887 | 1887 | yes | HT_přívodní vodní (55 °C) 25
13338015 | 2.NP_SO-102 | 4326.74 | 0.000568237 | 0.365648 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2013.45 | 2000 | 2000 | 1986.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 5989.2 | 0.271857 | 20 | 108 | 4326.74 | ø20 | 26.9 | 21.6 | TR02.02.1888 | 1888 | yes | HT_přívodní vodní (55 °C) 25 | 0
13339232 | 2.NP_SO-102 | 208.725 | 0.000891835 | 0.0220981 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 2979.36 | 2979.36 | 2770.64 | 2770.64 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6770.64 | 0.0163932 | 25 | 565 | 208.725 | ø25 | 33.7 | 27.2 | TR02.02.1889 | 1889 | yes | HT_přívodní vodní (55 °C) 9
13339247 | 2.NP_SO-102 | 208.725 | 0.000891835 | 0.0220981 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 2979.36 | 2979.36 | 2770.64 | 2770.64 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6770.64 | 0.0163932 | 25 | 830 | 208.725 | ø25 | 33.7 | 27.2 | TR02.02.1890 | 1890 | yes | HT_vratné vodní (45 °C) 1
13339969 | -1.PP_SO-102 | 1284.44 | 0.000356274 | 0.0859493 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2760.65 | 2750 | 2750 | 2739.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | -1258 | 0.0605277 | 15 | 11 | 1284.44 | ø15 | 21.3 | 16 | TR02.02.1891 | 1891 | yes | CL_přívodní vodní (10 °C) 9 | 0
13339986 | -1.PP_SO-102 | 1284.44 | 0.000356274 | 0.0859493 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2830.65 | 2820 | 2820 | 2809.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | -1188 | 0.0605277 | 15 | 16 | 1284.44 | ø15 | 21.3 | 16 | TR02.02.1892 | 1892 | yes | CL_vratné vodní (15 °C) 9 | 0
13340100 | -1.PP_SO-102 | 553.147 | 0.000356274 | 0.0370143 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2830.65 | 2820 | 2820 | 2809.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | -1188 | 0.0260664 | 15 | 6 | 553.147 | ø15 | 21.3 | 16 | TR02.02.1893 | 1893 | yes | CL_vratné vodní (15 °C) 9 | 0
13340201 | -1.PP_SO-102 | 338.725 | 0.000356274 | 0.0226661 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2760.65 | 2750 | 2750 | 2739.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | -1258 | 0.015962 | 15 | 19 | 338.725 | ø15 | 21.3 | 16 | TR02.02.1894 | 1894 | yes | CL_přívodní vodní (10 °C) 9 | 0
13340230 | -1.PP_SO-102 | 338.725 | 0.000356274 | 0.0226661 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2830.65 | 2820 | 2820 | 2809.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | -1188 | 0.015962 | 15 | 19 | 338.725 | ø15 | 21.3 | 16 | TR02.02.1895 | 1895 | yes | CL_vratné vodní (15 °C) 9 | 0
13340266 | -1.PP_SO-102 | 225.712 | 0.000356274 | 0.0151038 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2760.65 | 2750 | 2750 | 2739.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | -1258 | 0.0106365 | 15 | 16 | 225.712 | ø15 | 21.3 | 16 | TR02.02.1896 | 1896 | yes | CL_přívodní vodní (10 °C) 9 | 0
13340268 | -1.PP_SO-102 | 425.712 | 0.000356274 | 0.0284869 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2830.65 | 2820 | 2820 | 2809.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | -1188 | 0.0200612 | 15 | 7 | 425.712 | ø15 | 21.3 | 16 | TR02.02.1897 | 1897 | yes | CL_vratné vodní (15 °C) 9 | 0
13340351 | -1.PP_SO-102 | 91.425 | 0.000356274 | 0.00611779 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2805.71 | 2714.29 | 2805.71 | 2714.29 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | -1285.71 | 0.0043083 | 15 | 16 | 91.425 | ø15 | 21.3 | 16 | TR02.02.1898 | 1898 | yes | CL_vratné vodní (15 °C) 9
13340362 | -1.PP_SO-102 | 21.425 | 0.000356274 | 0.00143367 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2735.71 | 2735.71 | 2714.29 | 2714.29 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | -1285.71 | 0.00100963 | 15 | 11 | 21.425 | ø15 | 21.3 | 16 | TR02.02.1899 | 1899 | yes | CL_přívodní vodní (10 °C) 9
13340371 | -1.PP_SO-102 | 563.576 | 0.000356274 | 0.0377122 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2760.65 | 2750 | 2750 | 2739.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | -1258 | 0.0265579 | 15 | 3 | 563.576 | ø15 | 21.3 | 16 | TR02.02.1900 | 1900 | yes | CL_přívodní vodní (10 °C) 9 | 0
13340639 | -1.PP_SO-102 | 345.075 | 0.000356274 | 0.023091 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 3185.71 | 3185.71 | 2840.64 | 2840.64 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | -1159.36 | 0.0162613 | 15 | 18 | 345.075 | ø15 | 21.3 | 16 | TR02.02.1901 | 1901 | yes | CL_vratné vodní (15 °C) 9
13340642 | -1.PP_SO-102 | 245.903 | 0.000356274 | 0.0164548 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2830.65 | 2820 | 2820 | 2809.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | -1188 | 0.0115879 | 15 | 7 | 245.903 | ø15 | 21.3 | 16 | TR02.02.1902 | 1902 | yes | CL_vratné vodní (15 °C) 9 | 0
13340673 | -1.PP_SO-102 | 415.075 | 0.000356274 | 0.0277751 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 3185.71 | 3185.71 | 2770.64 | 2770.64 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | -1229.36 | 0.0195599 | 15 | 18 | 415.075 | ø15 | 21.3 | 16 | TR02.02.1903 | 1903 | yes | CL_přívodní vodní (10 °C) 9
13340676 | -1.PP_SO-102 | 180.224 | 0.000356274 | 0.0120598 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2760.65 | 2750 | 2750 | 2739.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | -1258 | 0.00849283 | 15 | 16 | 180.224 | ø15 | 21.3 | 16 | TR02.02.1904 | 1904 | yes | CL_přívodní vodní (10 °C) 9 | 0
13344339 | 3.NP_SO-102 | 279.777 | 0.00183197 | 0.042453 | 40 | ø120 mm | 0.00239234 | HD | 3.NP_SO-102 | 2524.15 | 2500 | 2500 | 2475.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10479.1 | 0.0351578 | 40 | 831 | 279.777 | ø40 | 48.3 | 41.8 | TR02.02.1912 | 1912 | yes | HT_vratné vodní (45 °C) 1 | 0 | Izolace - Typ izolace: Tepelná
13344352 | 3.NP_SO-102 | 3239.67 | 0.00183197 | 0.491585 | 40 | ø120 mm | 0.00239234 | HD | 3.NP_SO-102 | 2473.01 | 2473.01 | -766.663 | -766.663 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7233.34 | 0.40711 | 40 | 831 | 3239.67 | ø40 | 48.3 | 41.8 | TR02.02.1913 | 1913 | yes | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13344496 | 3.NP_SO-102 | 129.534 | 0.00183197 | 0.0196554 | 40 | ø120 mm | 0.00239234 | HD | 3.NP_SO-102 | 2524.15 | 2500 | 2500 | 2475.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10479.1 | 0.0162778 | 40 | 571 | 129.534 | ø40 | 48.3 | 41.8 | TR02.02.1914 | 1914 | yes | HT_přívodní vodní (55 °C) 9 | 0 | Izolace - Typ izolace: Tepelná
13344507 | 3.NP_SO-102 | 589.675 | 0.00183197 | 0.0894767 | 40 | ø120 mm | 0.00239234 | HD | 3.NP_SO-102 | 3116.66 | 2526.99 | 3116.66 | 2526.99 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10527 | 0.0741007 | 40 | 571 | 589.675 | ø40 | 48.3 | 41.8 | TR02.02.1915 | 1915 | yes | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13346992 | -1.PP_SO-102 | 165.075 | 0.000356274 | 0.0110461 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 3285.71 | 3120.64 | 3285.71 | 3120.64 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -879.362 | 0.00777898 | 15 | 14 | 165.075 | ø15 | 21.3 | 16 | TR02.02.1917 | 1917 | yes | CL_vratné vodní (15 °C) 8
13347013 | -1.PP_SO-102 | 165.075 | 0.000356274 | 0.0110461 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 3285.71 | 3120.64 | 3285.71 | 3120.64 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -879.362 | 0.00777898 | 15 | 16 | 165.075 | ø15 | 21.3 | 16 | TR02.02.1918 | 1918 | yes | CL_přívodní vodní (10 °C) 4
13347038 | -1.PP_SO-102 | 158.725 | 0.000568237 | 0.0134137 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3282.54 | 3123.81 | 3282.54 | 3123.81 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -876.187 | 0.00997299 | 20 | 139 | 158.725 | ø20 | 26.9 | 21.6 | TR02.02.1919 | 1919 | yes | HT_vratné vodní (45 °C) 26
13347059 | -1.PP_SO-102 | 158.725 | 0.000568237 | 0.0134137 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3282.54 | 3123.81 | 3282.54 | 3123.81 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -876.187 | 0.00997299 | 20 | 37 | 158.725 | ø20 | 26.9 | 21.6 | TR02.02.1920 | 1920 | yes | HT_přívodní vodní (65 °C) 27
13347584 | 4.NP_SO-102 | 96.3437 | 0.000356274 | 0.00644693 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 2890.63 | 2794.29 | 2890.63 | 2794.29 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 14794.3 | 0.00454009 | 15 | 772 | 96.3437 | ø15 | 21.3 | 16 | TR02.02.1921 | 1921 | yes | HT_vratné vodní (45 °C) 1
13347587 | 4.NP_SO-102 | 2494.47 | 0.000568237 | 0.210805 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2933.45 | 2920 | 2920 | 2906.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 14909.2 | 0.156732 | 20 | 764 | 2494.47 | ø20 | 26.9 | 21.6 | TR02.02.1922 | 1922 | yes | HT_vratné vodní (45 °C) 1 | 0
13348701 | 2.NP_SO-102 | 3306.19 | 0.000891835 | 0.350032 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 6186.4 | 0.259667 | 25 | 10 | 3306.19 | ø25 | 33.7 | 27.2 | TR02.02.1923 | 1923 | yes | CL_vratné vodní (15 °C) 11 | 0
13348731 | 2.NP_SO-102 | 2862.54 | 0.000568237 | 0.24191 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2463.45 | 2450 | 2450 | 2436.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6439.2 | 0.179859 | 20 | 108 | 2862.54 | ø20 | 26.9 | 21.6 | TR02.02.1924 | 1924 | yes | HT_přívodní vodní (55 °C) 25 | 0
13348757 | 2.NP_SO-102 | 3156.19 | 0.000891835 | 0.334151 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6186.4 | 0.247886 | 25 | 11 | 3156.19 | ø25 | 33.7 | 27.2 | TR02.02.1925 | 1925 | yes | CL_přívodní vodní (10 °C) 4 | 0
13348783 | 2.NP_SO-102 | 3012.54 | 0.000568237 | 0.254586 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2413.45 | 2400 | 2400 | 2386.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6389.2 | 0.189283 | 20 | 112 | 3012.54 | ø20 | 26.9 | 21.6 | TR02.02.1926 | 1926 | yes | HT_vratné vodní (45 °C) 26 | 0
13348848 | 2.NP_SO-102 | 45.8476 | 0.000891835 | 0.00485396 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 6186.4 | 0.00360086 | 25 | 10 | 45.8476 | ø25 | 33.7 | 27.2 | TR02.02.1927 | 1927 | yes | CL_vratné vodní (15 °C) 11 | 0
13348871 | 2.NP_SO-102 | 245.848 | 0.000891835 | 0.0260283 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6186.4 | 0.0193088 | 25 | 11 | 245.848 | ø25 | 33.7 | 27.2 | TR02.02.1928 | 1928 | yes | CL_přívodní vodní (10 °C) 4 | 0
13348896 | 2.NP_SO-102 | 212.538 | 0.000568237 | 0.0179613 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2463.45 | 2450 | 2450 | 2436.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6439.2 | 0.0133541 | 20 | 108 | 212.538 | ø20 | 26.9 | 21.6 | TR02.02.1929 | 1929 | yes | HT_přívodní vodní (55 °C) 25 | 0
13348999 | 2.NP_SO-102 | 158.725 | 0.000891835 | 0.0168045 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2179.36 | 2020.64 | 2179.36 | 2020.64 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 6020.64 | 0.0124662 | 25 | 10 | 158.725 | ø25 | 33.7 | 27.2 | TR02.02.1930 | 1930 | yes | CL_vratné vodní (15 °C) 11
13349063 | 2.NP_SO-102 | 158.725 | 0.000891835 | 0.0168045 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2179.36 | 2020.64 | 2179.36 | 2020.64 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6020.64 | 0.0124662 | 25 | 11 | 158.725 | ø25 | 33.7 | 27.2 | TR02.02.1931 | 1931 | yes | CL_přívodní vodní (10 °C) 4
13349094 | 2.NP_SO-102 | 415.075 | 0.000568237 | 0.0350775 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2432.54 | 2017.46 | 2432.54 | 2017.46 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6017.46 | 0.0260799 | 20 | 108 | 415.075 | ø20 | 26.9 | 21.6 | TR02.02.1932 | 1932 | yes | HT_přívodní vodní (55 °C) 25
13349160 | 2.NP_SO-102 | 58.725 | 0.000568237 | 0.00496278 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2482.54 | 2482.54 | 2423.81 | 2423.81 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6423.81 | 0.0036898 | 20 | 110 | 58.725 | ø20 | 26.9 | 21.6 | TR02.02.1933 | 1933 | yes | HT_vratné vodní (45 °C) 26
13349197 | 2.NP_SO-102 | 51.9898 | 0.000568237 | 0.0043936 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2413.45 | 2400 | 2400 | 2386.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6389.2 | 0.00326662 | 20 | 111 | 51.9898 | ø20 | 26.9 | 21.6 | TR02.02.1934 | 1934 | yes | HT_vratné vodní (45 °C) 26 | 0
13349211 | 2.NP_SO-102 | 358.725 | 0.000568237 | 0.0303154 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2376.19 | 2376.19 | 2017.46 | 2017.46 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6017.46 | 0.0225394 | 20 | 112 | 358.725 | ø20 | 26.9 | 21.6 | TR02.02.1935 | 1935 | yes | HT_vratné vodní (45 °C) 26
13349237 | 2.NP_SO-102 | 365.075 | 0.000568237 | 0.0308521 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2382.54 | 2017.46 | 2382.54 | 2017.46 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6017.46 | 0.0229383 | 20 | 112 | 365.075 | ø20 | 26.9 | 21.6 | TR02.02.1936 | 1936 | yes | HT_vratné vodní (45 °C) 26
13349272 | 2.NP_SO-102 | 158.725 | 0.000891835 | 0.0168045 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2179.36 | 2020.64 | 2179.36 | 2020.64 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 6020.64 | 0.0124662 | 25 | 10 | 158.725 | ø25 | 33.7 | 27.2 | TR02.02.1937 | 1937 | yes | CL_vratné vodní (15 °C) 11
13349307 | 2.NP_SO-102 | 158.725 | 0.000891835 | 0.0168045 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2179.36 | 2020.64 | 2179.36 | 2020.64 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6020.64 | 0.0124662 | 25 | 11 | 158.725 | ø25 | 33.7 | 27.2 | TR02.02.1938 | 1938 | yes | CL_přívodní vodní (10 °C) 4
13349342 | 2.NP_SO-102 | 415.075 | 0.000568237 | 0.0350775 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2432.54 | 2017.46 | 2432.54 | 2017.46 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6017.46 | 0.0260799 | 20 | 108 | 415.075 | ø20 | 26.9 | 21.6 | TR02.02.1939 | 1939 | yes | HT_přívodní vodní (55 °C) 25
13349751 | -1.PP_SO-102 | 334.532 | 0.00183197 | 0.0507616 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-102 | 2374.15 | 2350 | 2350 | 2325.85 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1670.9 | 0.0420386 | 40 | 72 | 334.532 | ø40 | 48.3 | 41.8 | TR02.02.1940 | 1940 | yes | CL_vratné vodní (15 °C) 8 | 0
13349776 | -1.PP_SO-102 | 3052.84 | 0.00183197 | 0.463235 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-102 | 2624.15 | 2600 | 2600 | 2575.85 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1420.9 | 0.383632 | 40 | 80 | 3052.84 | ø40 | 48.3 | 41.8 | TR02.02.1941 | 1941 | yes | CL_přívodní vodní (10 °C) 4 | 0
13349999 | 4.NP_SO-102 | 421.953 | 0.000356274 | 0.0282354 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3160.65 | 3150 | 3150 | 3139.35 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 15142 | 0.0198841 | 15 | 542 | 421.953 | ø15 | 21.3 | 16 | TR02.02.1942 | 1942 | yes | HT_vratné vodní (45 °C) 13 | 0
13350021 | 4.NP_SO-102 | 1480.49 | 0.000356274 | 0.0990687 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3310.65 | 3300 | 3300 | 3289.35 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 15292 | 0.0697667 | 15 | 542 | 1480.49 | ø15 | 21.3 | 16 | TR02.02.1943 | 1943 | yes | HT_vratné vodní (45 °C) 13 | 0
13350049 | 4.NP_SO-102 | 121.425 | 0.000356274 | 0.00812527 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3285.71 | 3285.71 | 3164.29 | 3164.29 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 15164.3 | 0.00572202 | 15 | 542 | 121.425 | ø15 | 21.3 | 16 | TR02.02.1944 | 1944 | yes | HT_vratné vodní (45 °C) 13
13350082 | 4.NP_SO-102 | 121.425 | 0.000356274 | 0.00812527 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3285.71 | 3285.71 | 3164.29 | 3164.29 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 15164.3 | 0.00572202 | 15 | 542 | 121.425 | ø15 | 21.3 | 16 | TR02.02.1945 | 1945 | yes | HT_vratné vodní (45 °C) 13
13352253 | -1.PP_SO-102 | 820.583 | 0.000568237 | 0.0693465 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | -1110.8 | 0.0515587 | 20 | 551 | 820.583 | ø20 | 26.9 | 21.6 | TR02.02.1946 | 1946 | yes | HT_vratné vodní (45 °C) 13 | 0
13352289 | -1.PP_SO-102 | 1281.98 | 0.000568237 | 0.108338 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | -1110.8 | 0.0805491 | 20 | 524 | 1281.98 | ø20 | 26.9 | 21.6 | TR02.02.1947 | 1947 | yes | HT_přívodní vodní (55 °C) 19 | 0
13352297 | -1.PP_SO-102 | 1798.93 | 0.000568237 | 0.152025 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | -1110.8 | 0.11303 | 20 | 524 | 1798.93 | ø20 | 26.9 | 21.6 | TR02.02.1948 | 1948 | yes | HT_přívodní vodní (55 °C) 19 | 0
13352306 | -1.PP_SO-102 | 405.075 | 0.000568237 | 0.0342324 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3322.54 | 2917.46 | 3322.54 | 2917.46 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | -1082.54 | 0.0254516 | 20 | 524 | 405.075 | ø20 | 26.9 | 21.6 | TR02.02.1949 | 1949 | yes | HT_přívodní vodní (55 °C) 19
13357518 | -1.PP_SO-102 | 1358.35 | 0.000568237 | 0.114793 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2363.45 | 2350 | 2350 | 2336.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1660.8 | 0.0853477 | 20 | 140 | 1358.35 | ø20 | 26.9 | 21.6 | TR02.02.1950 | 1950 | yes | HT_vratné vodní (45 °C) 26 | 0
13358233 | -1.PP_SO-102 | 246.025 | 0.00183197 | 0.0373316 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-102 | 2573.01 | 2573.01 | 2326.99 | 2326.99 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1673.01 | 0.0309164 | 40 | 80 | 246.025 | ø40 | 48.3 | 41.8 | TR02.02.1951 | 1951 | yes | CL_přívodní vodní (10 °C) 4
13358268 | -1.PP_SO-102 | 196.025 | 0.00183197 | 0.0297446 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-102 | 2573.01 | 2573.01 | 2376.99 | 2376.99 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1623.01 | 0.0246332 | 40 | 72 | 196.025 | ø40 | 48.3 | 41.8 | TR02.02.1952 | 1952 | yes | CL_vratné vodní (15 °C) 8
13362057 | 2.NP_SO-102 | 160.536 | 0.000568237 | 0.0135667 | 40 | ø100 mm | 0.00462963 | HD | 2.NP_SO-102 | 3113.45 | 3100 | 3100 | 3086.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7089.2 | 0.0100867 | 20 | 250 | 160.536 | ø20 | 26.9 | 21.6 | TR02.02.1953 | 1953 | yes | HT_přívodní vodní (55 °C) 9 | 0 | Izolace - Typ izolace: Tepelná
13362145 | 2.NP_SO-102 | 197.666 | 0.000568237 | 0.0167045 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3254.4 | 3244.89 | 3105.11 | 3095.6 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7097.48 | 0.0124197 | 20 | 250 | 197.666 | ø20 | 26.9 | 21.6 | TR02.02.1955 | 1955 | yes | HT_přívodní vodní (55 °C) 9 | 100
13362457 | 2.NP_SO-102 | 3249.99 | 0.000568237 | 0.274653 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3226.19 | 3226.19 | -23.8062 | -23.8062 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 3976.19 | 0.204203 | 20 | 410 | 3249.99 | ø20 | 26.9 | 21.6 | TR02.02.1956 | 1956 | yes | HT_přívodní vodní (55 °C) 9
13368493 | -1.PP_SO-102 | 252.375 | 0.00141175 | 0.0336172 | 60 | ø152 mm | 0.00278552 | HD | -1.PP_SO-102 | 2576.19 | 2323.81 | 2576.19 | 2323.81 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -1676.19 | 0.0253715 | 32 | 36 | 252.375 | ø32 | 42.4 | 35.9 | TR02.02.1957 | 1957 | yes | HT_vratné vodní (45 °C) 23 | Izolace - Typ izolace: Tepelná
13368658 | -1.PP_SO-102 | 2164.92 | 0.00141175 | 0.288375 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2321.2 | 2300 | 2300 | 2278.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | -1717.95 | 0.217641 | 32 | 39 | 2164.92 | ø32 | 42.4 | 35.9 | TR02.02.1958 | 1958 | yes | HT_přívodní vodní (65 °C) 6 | 0 | Izolace - Typ izolace: Tepelná
13368683 | -1.PP_SO-102 | 2164.92 | 0.00141175 | 0.288375 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2321.2 | 2300 | 2300 | 2278.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -1717.95 | 0.217641 | 32 | 146 | 2164.92 | ø32 | 42.4 | 35.9 | TR02.02.1959 | 1959 | yes | HT_vratné vodní (45 °C) 2 | 0 | Izolace - Typ izolace: Tepelná
13368723 | -1.PP_SO-102 | 102.375 | 0.00141175 | 0.0136367 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2426.19 | 2426.19 | 2323.81 | 2323.81 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -1676.19 | 0.0102919 | 32 | 146 | 102.375 | ø32 | 42.4 | 35.9 | TR02.02.1960 | 1960 | yes | HT_vratné vodní (45 °C) 2 | Izolace - Typ izolace: Tepelná
13368755 | -1.PP_SO-102 | 102.375 | 0.00141175 | 0.0136367 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2426.19 | 2426.19 | 2323.81 | 2323.81 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | -1676.19 | 0.0102919 | 32 | 39 | 102.375 | ø32 | 42.4 | 35.9 | TR02.02.1961 | 1961 | yes | HT_přívodní vodní (65 °C) 6 | Izolace - Typ izolace: Tepelná
13391782 | 2.NP_SO-102 | 2423.15 | 0.00141175 | 0.322773 | 0 | ø32 mm | 0.00278552 | HD | 2.NP_SO-102 | 2621.2 | 2600 | 2600 | 2578.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 6582.05 | 0.243602 | 32 | 36 | 2423.15 | ø32 | 42.4 | 35.9 | TR02.02.2022 | 2022 | yes | HT_vratné vodní (45 °C) 23 | 0
13391790 | 2.NP_SO-102 | 69.0378 | 0.00141175 | 0.00919608 | 0 | ø32 mm | 0.00278552 | HD | 2.NP_SO-102 | 2621.2 | 2600 | 2600 | 2578.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 6582.05 | 0.00694044 | 32 | 36 | 69.0378 | ø32 | 42.4 | 35.9 | TR02.02.2023 | 2023 | yes | HT_vratné vodní (45 °C) 23 | 0
13391829 | 2.NP_SO-102 | 2423.15 | 0.00141175 | 0.322773 | 0 | ø32 mm | 0.00278552 | HD | 2.NP_SO-102 | 2671.2 | 2650 | 2650 | 2628.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 6632.05 | 0.243602 | 32 | 55 | 2423.15 | ø32 | 42.4 | 35.9 | TR02.02.2025 | 2025 | yes | HT_přívodní vodní (65 °C) 8 | 0
13391837 | 2.NP_SO-102 | 599.038 | 0.00141175 | 0.0797939 | 0 | ø32 mm | 0.00278552 | HD | 2.NP_SO-102 | 2671.2 | 2650 | 2650 | 2628.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 6632.05 | 0.0602218 | 32 | 55 | 599.038 | ø32 | 42.4 | 35.9 | TR02.02.2026 | 2026 | yes | HT_přívodní vodní (65 °C) 8 | 0
13408063 | -1.PP_SO-102 | 569.831 | 0.00183197 | 0.0864656 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-102 | 2946.82 | 2376.99 | 2946.82 | 2376.99 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1623.01 | 0.0716071 | 40 | 72 | 569.831 | ø40 | 48.3 | 41.8 | TR02.02.2155 | 2155 | yes | CL_vratné vodní (15 °C) 8
13408066 | -1.PP_SO-102 | 6086.19 | 0.00285535 | 1.15296 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 3030.15 | 3000 | 3000 | 2969.85 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1026.5 | 0.956017 | 50 | 88 | 6086.19 | ø50 | 60.3 | 53 | TR02.02.2156 | 2156 | yes | CL_vratné vodní (15 °C) 8 | 0
13408145 | -1.PP_SO-102 | 619.831 | 0.00183197 | 0.0940525 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-102 | 2946.82 | 2326.99 | 2946.82 | 2326.99 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1673.01 | 0.0778903 | 40 | 80 | 619.831 | ø40 | 48.3 | 41.8 | TR02.02.2157 | 2157 | yes | CL_přívodní vodní (10 °C) 4
13408148 | -1.PP_SO-102 | 6336.19 | 0.00285535 | 1.20032 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 3030.15 | 3000 | 3000 | 2969.85 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1026.5 | 0.995287 | 50 | 109 | 6336.19 | ø50 | 60.3 | 53 | TR02.02.2158 | 2158 | yes | CL_přívodní vodní (10 °C) 4 | 0
13408377 | 2.NP_SO-102 | 2344.6 | 0.000891835 | 0.248226 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 3016.85 | 3000 | 3000 | 2983.15 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 6986.4 | 0.184144 | 25 | 120 | 2344.6 | ø25 | 33.7 | 27.2 | TR02.02.2159 | 2159 | yes | HT_vratné vodní (45 °C) 9 | 0
13408999 | -1.PP_SO-102 | 104.484 | 0.00141175 | 0.0139176 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 21.2 | 0 | 0 | -21.2 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -4017.95 | 0.0105038 | 32 | 47 | 104.484 | ø32 | 42.4 | 35.9 | TR02.02.2160 | 2160 | yes | HT_přívodní vodní (65 °C) 8 | 0
13409010 | -1.PP_SO-102 | 1746.02 | 0.00141175 | 0.232577 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 1769.84 | 23.8125 | 1769.84 | 23.8125 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -3976.19 | 0.17553 | 32 | 47 | 1746.02 | ø32 | 42.4 | 35.9 | TR02.02.2161 | 2161 | yes | HT_přívodní vodní (65 °C) 8
13409013 | -1.PP_SO-102 | 1039.68 | 0.00141175 | 0.138488 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 1821.2 | 1800 | 1800 | 1778.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -2217.95 | 0.10452 | 32 | 46 | 1039.68 | ø32 | 42.4 | 35.9 | TR02.02.2162 | 2162 | yes | HT_přívodní vodní (65 °C) 8 | 0
13409020 | -1.PP_SO-102 | 128.486 | 0.00141175 | 0.0171147 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 21.2 | 0 | 0 | -21.2 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -4017.95 | 0.0129168 | 32 | 49 | 128.486 | ø32 | 42.4 | 35.9 | TR02.02.2163 | 2163 | yes | HT_přívodní vodní (65 °C) 8 | 0
13409029 | -1.PP_SO-102 | 1746.02 | 0.00141175 | 0.232577 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 1769.84 | 23.8125 | 1769.84 | 23.8125 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -3976.19 | 0.17553 | 32 | 49 | 1746.02 | ø32 | 42.4 | 35.9 | TR02.02.2164 | 2164 | yes | HT_přívodní vodní (65 °C) 8
13409032 | -1.PP_SO-102 | 1039.68 | 0.00141175 | 0.138488 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 1821.2 | 1800 | 1800 | 1778.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -2217.95 | 0.10452 | 32 | 45 | 1039.68 | ø32 | 42.4 | 35.9 | TR02.02.2165 | 2165 | yes | HT_přívodní vodní (65 °C) 8 | 0
13409103 | -1.PP_SO-102 | 128.486 | 0.00141175 | 0.0171147 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 21.2 | 0 | 0 | -21.2 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -4017.95 | 0.0129168 | 32 | 48 | 128.486 | ø32 | 42.4 | 35.9 | TR02.02.2166 | 2166 | yes | HT_přívodní vodní (65 °C) 8 | 0
13409114 | -1.PP_SO-102 | 1752.38 | 0.00141175 | 0.233423 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 1776.19 | 23.8125 | 1776.19 | 23.8125 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -3976.19 | 0.176168 | 32 | 48 | 1752.38 | ø32 | 42.4 | 35.9 | TR02.02.2167 | 2167 | yes | HT_přívodní vodní (65 °C) 8
13409135 | -1.PP_SO-102 | 83.6021 | 0.00141175 | 0.0111361 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | -478.8 | -500 | -500 | -521.2 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -4517.95 | 0.0084046 | 32 | 31 | 83.6021 | ø32 | 42.4 | 35.9 | TR02.02.2168 | 2168 | yes | HT_vratné vodní (45 °C) 23 | 0
13409144 | -1.PP_SO-102 | 2246.02 | 0.00141175 | 0.299178 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 1769.84 | -476.188 | 1769.84 | -476.188 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -4476.19 | 0.225795 | 32 | 31 | 2246.02 | ø32 | 42.4 | 35.9 | TR02.02.2169 | 2169 | yes | HT_vratné vodní (45 °C) 23
13409147 | -1.PP_SO-102 | 1039.75 | 0.00141175 | 0.138498 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 1821.2 | 1800 | 1800 | 1778.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -2217.95 | 0.104527 | 32 | 29 | 1039.75 | ø32 | 42.4 | 35.9 | TR02.02.2170 | 2170 | yes | HT_vratné vodní (45 °C) 23 | 0
13409154 | -1.PP_SO-102 | 117.891 | 0.00141175 | 0.0157035 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | -478.8 | -500 | -500 | -521.2 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -4517.95 | 0.0118517 | 32 | 33 | 117.891 | ø32 | 42.4 | 35.9 | TR02.02.2171 | 2171 | yes | HT_vratné vodní (45 °C) 23 | 0
13409163 | -1.PP_SO-102 | 2246.02 | 0.00141175 | 0.299178 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 1769.84 | -476.188 | 1769.84 | -476.188 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -4476.19 | 0.225795 | 32 | 33 | 2246.02 | ø32 | 42.4 | 35.9 | TR02.02.2172 | 2172 | yes | HT_vratné vodní (45 °C) 23
13409166 | -1.PP_SO-102 | 1039.68 | 0.00141175 | 0.138488 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 1821.2 | 1800 | 1800 | 1778.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -2217.95 | 0.10452 | 32 | 30 | 1039.68 | ø32 | 42.4 | 35.9 | TR02.02.2173 | 2173 | yes | HT_vratné vodní (45 °C) 23 | 0
13409173 | -1.PP_SO-102 | 124.749 | 0.00141175 | 0.016617 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | -478.8 | -500 | -500 | -521.2 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -4517.95 | 0.0125411 | 32 | 32 | 124.749 | ø32 | 42.4 | 35.9 | TR02.02.2174 | 2174 | yes | HT_vratné vodní (45 °C) 23 | 0
13409182 | -1.PP_SO-102 | 2252.38 | 0.00141175 | 0.300024 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 1776.19 | -476.188 | 1776.19 | -476.188 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -4476.19 | 0.226433 | 32 | 32 | 2252.38 | ø32 | 42.4 | 35.9 | TR02.02.2175 | 2175 | yes | HT_vratné vodní (45 °C) 23
13409312 | -1.PP_SO-102 | 104.484 | 0.00141175 | 0.0139176 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 21.2 | 0 | 0 | -21.2 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -4017.95 | 0.0105038 | 32 | 51 | 104.484 | ø32 | 42.4 | 35.9 | TR02.02.2176 | 2176 | yes | HT_přívodní vodní (65 °C) 8 | 0
13409321 | -1.PP_SO-102 | 1746.02 | 0.00141175 | 0.232577 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 1769.84 | 23.8125 | 1769.84 | 23.8125 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -3976.19 | 0.17553 | 32 | 51 | 1746.02 | ø32 | 42.4 | 35.9 | TR02.02.2177 | 2177 | yes | HT_přívodní vodní (65 °C) 8
13409324 | -1.PP_SO-102 | 3658.67 | 0.00141175 | 0.487347 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 1821.2 | 1800 | 1800 | 1778.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -2217.95 | 0.367809 | 32 | 55 | 3658.67 | ø32 | 42.4 | 35.9 | TR02.02.2178 | 2178 | yes | HT_přívodní vodní (65 °C) 8 | 0
13409340 | -1.PP_SO-102 | 107.201 | 0.00141175 | 0.0142796 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | -478.8 | -500 | -500 | -521.2 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -4517.95 | 0.0107771 | 32 | 35 | 107.201 | ø32 | 42.4 | 35.9 | TR02.02.2179 | 2179 | yes | HT_vratné vodní (45 °C) 23 | 0
13409349 | -1.PP_SO-102 | 2246.02 | 0.00141175 | 0.299178 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 1769.84 | -476.188 | 1769.84 | -476.188 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -4476.19 | 0.225795 | 32 | 35 | 2246.02 | ø32 | 42.4 | 35.9 | TR02.02.2180 | 2180 | yes | HT_vratné vodní (45 °C) 23
13409352 | -1.PP_SO-102 | 3408.59 | 0.00141175 | 0.454037 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 1821.2 | 1800 | 1800 | 1778.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -2217.95 | 0.342669 | 32 | 36 | 3408.59 | ø32 | 42.4 | 35.9 | TR02.02.2181 | 2181 | yes | HT_vratné vodní (45 °C) 23 | 0
13416196 | -1.PP_SO-102 | 215.075 | 0.000568237 | 0.0181757 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2982.54 | 2767.46 | 2982.54 | 2767.46 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1232.54 | 0.0135136 | 20 | 131 | 215.075 | ø20 | 26.9 | 21.6 | TR02.02.2187 | 2187 | yes | CL_přívodní vodní (10 °C) 4
13416231 | -1.PP_SO-102 | 215.075 | 0.000568237 | 0.0181757 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2982.54 | 2767.46 | 2982.54 | 2767.46 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1232.54 | 0.0135136 | 20 | 105 | 215.075 | ø20 | 26.9 | 21.6 | TR02.02.2188 | 2188 | yes | CL_vratné vodní (15 °C) 8
13416632 | -1.PP_SO-102 | 7199.43 | 0.000568237 | 0.608415 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3013.45 | 3000 | 3000 | 2986.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1010.8 | 0.452354 | 20 | 140 | 7199.43 | ø20 | 26.9 | 21.6 | TR02.02.2193 | 2193 | yes | HT_vratné vodní (45 °C) 26 | 0
13416753 | -1.PP_SO-102 | 615.075 | 0.000568237 | 0.0519793 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2982.54 | 2982.54 | 2367.46 | 2367.46 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1632.54 | 0.0386463 | 20 | 140 | 615.075 | ø20 | 26.9 | 21.6 | TR02.02.2194 | 2194 | yes | HT_vratné vodní (45 °C) 26
13416786 | -1.PP_SO-102 | 615.075 | 0.000568237 | 0.0519793 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2982.54 | 2982.54 | 2367.46 | 2367.46 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1632.54 | 0.0386463 | 20 | 39 | 615.075 | ø20 | 26.9 | 21.6 | TR02.02.2195 | 2195 | yes | HT_přívodní vodní (65 °C) 27
13416917 | -1.PP_SO-102 | 215.075 | 0.000568237 | 0.0181757 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2982.54 | 2982.54 | 2767.46 | 2767.46 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1232.54 | 0.0135136 | 20 | 140 | 215.075 | ø20 | 26.9 | 21.6 | TR02.02.2196 | 2196 | yes | HT_vratné vodní (45 °C) 26
13416936 | -1.PP_SO-102 | 1673.56 | 0.000568237 | 0.14143 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2763.45 | 2750 | 2750 | 2736.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1260.8 | 0.105153 | 20 | 39 | 1673.56 | ø20 | 26.9 | 21.6 | TR02.02.2197 | 2197 | yes | HT_přívodní vodní (65 °C) 27 | 0
13416942 | -1.PP_SO-102 | 100.159 | 0.000568237 | 0.00846436 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2763.45 | 2750 | 2750 | 2736.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1260.8 | 0.00629321 | 20 | 39 | 100.159 | ø20 | 26.9 | 21.6 | TR02.02.2198 | 2198 | yes | HT_přívodní vodní (65 °C) 27 | 0
13416953 | -1.PP_SO-102 | 215.075 | 0.000568237 | 0.0181757 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2982.54 | 2767.46 | 2982.54 | 2767.46 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1232.54 | 0.0135136 | 20 | 39 | 215.075 | ø20 | 26.9 | 21.6 | TR02.02.2199 | 2199 | yes | HT_přívodní vodní (65 °C) 27
13418106 | -1.PP_SO-102 | 252.375 | 0.00141175 | 0.0336172 | 60 | ø152 mm | 0.00278552 | HD | -1.PP_SO-102 | 2576.19 | 2323.81 | 2576.19 | 2323.81 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -1676.19 | 0.0253715 | 32 | 55 | 252.375 | ø32 | 42.4 | 35.9 | TR02.02.2200 | 2200 | yes | HT_přívodní vodní (65 °C) 8 | Izolace - Typ izolace: Tepelná
13418170 | -1.PP_SO-102 | 25.075 | 0.000568237 | 0.00211906 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2363.45 | 2350 | 2350 | 2336.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1660.8 | 0.00157551 | 20 | 140 | 25.075 | ø20 | 26.9 | 21.6 | TR02.02.2201 | 2201 | yes | HT_vratné vodní (45 °C) 26 | 0
13418178 | -1.PP_SO-102 | 10763.4 | 0.000568237 | 0.909601 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1210.8 | 0.676283 | 20 | 139 | 10763.4 | ø20 | 26.9 | 21.6 | TR02.02.2202 | 2202 | yes | HT_vratné vodní (45 °C) 26 | 0
13418221 | -1.PP_SO-102 | 1455.94 | 0.000568237 | 0.12304 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2363.45 | 2350 | 2350 | 2336.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1660.8 | 0.0914793 | 20 | 39 | 1455.94 | ø20 | 26.9 | 21.6 | TR02.02.2203 | 2203 | yes | HT_přívodní vodní (65 °C) 27 | 0
13418229 | -1.PP_SO-102 | 125.075 | 0.000568237 | 0.0105699 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2363.45 | 2350 | 2350 | 2336.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1660.8 | 0.00785869 | 20 | 39 | 125.075 | ø20 | 26.9 | 21.6 | TR02.02.2204 | 2204 | yes | HT_přívodní vodní (65 °C) 27 | 0
13418237 | -1.PP_SO-102 | 10613.4 | 0.000568237 | 0.896925 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1210.8 | 0.666859 | 20 | 37 | 10613.4 | ø20 | 26.9 | 21.6 | TR02.02.2205 | 2205 | yes | HT_přívodní vodní (65 °C) 27 | 0
13418268 | -1.PP_SO-102 | 1608.04 | 0.00285535 | 0.304624 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 2350.15 | 2320 | 2320 | 2289.85 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1706.5 | 0.252591 | 50 | 98 | 1608.04 | ø50 | 60.3 | 53 | TR02.02.2206 | 2206 | yes | CL_vratné vodní (15 °C) 8 | 0
13418276 | -1.PP_SO-102 | 193.325 | 0.00285535 | 0.0366231 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 2350.15 | 2320 | 2320 | 2289.85 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1706.5 | 0.0303674 | 50 | 98 | 193.325 | ø50 | 60.3 | 53 | TR02.02.2207 | 2207 | yes | CL_vratné vodní (15 °C) 8 | 0
13418284 | -1.PP_SO-102 | 10290.9 | 0.00285535 | 1.94949 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 2830.15 | 2800 | 2800 | 2769.85 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1226.5 | 1.6165 | 50 | 88 | 10290.9 | ø50 | 60.3 | 53 | TR02.02.2208 | 2208 | yes | CL_vratné vodní (15 °C) 8 | 0
13418307 | -1.PP_SO-102 | 1657.02 | 0.00285535 | 0.313902 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 2350.15 | 2320 | 2320 | 2289.85 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1706.5 | 0.260284 | 50 | 119 | 1657.02 | ø50 | 60.3 | 53 | TR02.02.2209 | 2209 | yes | CL_přívodní vodní (10 °C) 4 | 0
13418315 | -1.PP_SO-102 | 332.445 | 0.00285535 | 0.0629777 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 2350.15 | 2320 | 2320 | 2289.85 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1706.5 | 0.0522203 | 50 | 119 | 332.445 | ø50 | 60.3 | 53 | TR02.02.2210 | 2210 | yes | CL_přívodní vodní (10 °C) 4 | 0
13418323 | -1.PP_SO-102 | 10440.9 | 0.00285535 | 1.97791 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 2830.15 | 2800 | 2800 | 2769.85 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1226.5 | 1.64006 | 50 | 109 | 10440.9 | ø50 | 60.3 | 53 | TR02.02.2211 | 2211 | yes | CL_přívodní vodní (10 °C) 4 | 0
13419267 | -1.PP_SO-102 | 158.725 | 0.000568237 | 0.0134137 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2776.19 | 2617.46 | 2776.19 | 2617.46 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1382.54 | 0.00997299 | 20 | 19 | 158.725 | ø20 | 26.9 | 21.6 | TR02.02.2212 | 2212 | no | HT_přívodní vodní (65 °C) 27
13419299 | -1.PP_SO-102 | 158.725 | 0.000568237 | 0.0134137 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2776.19 | 2617.46 | 2776.19 | 2617.46 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1382.54 | 0.00997299 | 20 | 114 | 158.725 | ø20 | 26.9 | 21.6 | TR02.02.2213 | 2213 | no | HT_vratné vodní (45 °C) 26
13419339 | -1.PP_SO-102 | 132.531 | 0.000356274 | 0.00886845 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2746.82 | 2614.29 | 2746.82 | 2614.29 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1385.71 | 0.00624539 | 15 | 108 | 132.531 | ø15 | 21.3 | 16 | TR02.02.2214 | 2214 | no | CL_přívodní vodní (10 °C) 4
13419377 | -1.PP_SO-102 | 132.531 | 0.000356274 | 0.00886845 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2746.82 | 2614.29 | 2746.82 | 2614.29 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1385.71 | 0.00624539 | 15 | 87 | 132.531 | ø15 | 21.3 | 16 | TR02.02.2215 | 2215 | no | CL_vratné vodní (15 °C) 8
13419658 | -1.PP_SO-102 | 692.64 | 0.000568237 | 0.0585342 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2804.4 | 2305.11 | 2794.89 | 2295.6 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1702.52 | 0.0435199 | 20 | 139 | 692.64 | ø20 | 26.9 | 21.6 | TR02.02.2216 | 2216 | yes | HT_vratné vodní (45 °C) 26 | 100
13419687 | -1.PP_SO-102 | 692.64 | 0.000568237 | 0.0585342 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2804.4 | 2794.89 | 2305.11 | 2295.6 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1702.52 | 0.0435199 | 20 | 37 | 692.64 | ø20 | 26.9 | 21.6 | TR02.02.2217 | 2217 | yes | HT_přívodní vodní (65 °C) 27 | 100
13419712 | -1.PP_SO-102 | 679.489 | 0.00285535 | 0.128721 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 2811.55 | 2790.24 | 2309.76 | 2288.45 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1708.97 | 0.106734 | 50 | 88 | 679.489 | ø50 | 60.3 | 53 | TR02.02.2218 | 2218 | yes | CL_vratné vodní (15 °C) 8 | 100
13419740 | -1.PP_SO-102 | 679.489 | 0.00285535 | 0.128721 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 2811.55 | 2790.24 | 2309.76 | 2288.45 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1708.97 | 0.106734 | 50 | 109 | 679.489 | ø50 | 60.3 | 53 | TR02.02.2219 | 2219 | yes | CL_přívodní vodní (10 °C) 4 | 100
13419845 | -1.PP_SO-102 | 1025.23 | 0.00285535 | 0.194218 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 2330.15 | 2300 | 2300 | 2269.85 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1726.5 | 0.161043 | 50 | 109 | 1025.23 | ø50 | 60.3 | 53 | TR02.02.2220 | 2220 | yes | CL_přívodní vodní (10 °C) 4 | 0
13419905 | -1.PP_SO-102 | 1038.38 | 0.000568237 | 0.0877527 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2313.45 | 2300 | 2300 | 2286.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1710.8 | 0.0652436 | 20 | 37 | 1038.38 | ø20 | 26.9 | 21.6 | TR02.02.2221 | 2221 | yes | HT_přívodní vodní (65 °C) 27 | 0
13419927 | -1.PP_SO-102 | 1038.38 | 0.000568237 | 0.0877527 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2313.45 | 2300 | 2300 | 2286.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1710.8 | 0.0652436 | 20 | 139 | 1038.38 | ø20 | 26.9 | 21.6 | TR02.02.2222 | 2222 | yes | HT_vratné vodní (45 °C) 26 | 0
13419977 | -1.PP_SO-102 | 1025.23 | 0.00285535 | 0.194218 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 2330.15 | 2300 | 2300 | 2269.85 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1726.5 | 0.161043 | 50 | 88 | 1025.23 | ø50 | 60.3 | 53 | TR02.02.2223 | 2223 | yes | CL_vratné vodní (15 °C) 8 | 0
13421657 | -1.PP_SO-102 | 975.483 | 0.000568237 | 0.0824369 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3004.4 | 2994.89 | 2305.11 | 2295.6 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1702.52 | 0.0612914 | 20 | 139 | 975.483 | ø20 | 26.9 | 21.6 | TR02.02.2224 | 2224 | yes | HT_vratné vodní (45 °C) 26 | 100
13421686 | -1.PP_SO-102 | 975.483 | 0.000568237 | 0.0824369 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3004.4 | 2305.11 | 2994.89 | 2295.6 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1702.52 | 0.0612914 | 20 | 37 | 975.483 | ø20 | 26.9 | 21.6 | TR02.02.2225 | 2225 | yes | HT_přívodní vodní (65 °C) 27 | 100
13421711 | -1.PP_SO-102 | 962.332 | 0.00285535 | 0.182302 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 3011.55 | 2309.76 | 2990.24 | 2288.45 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1708.97 | 0.151163 | 50 | 88 | 962.332 | ø50 | 60.3 | 53 | TR02.02.2226 | 2226 | yes | CL_vratné vodní (15 °C) 8 | 100
13421744 | -1.PP_SO-102 | 962.332 | 0.00285535 | 0.182302 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 3011.55 | 2309.76 | 2990.24 | 2288.45 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1708.97 | 0.151163 | 50 | 109 | 962.332 | ø50 | 60.3 | 53 | TR02.02.2227 | 2227 | yes | CL_přívodní vodní (10 °C) 4 | 100
13426354 | -1.PP_SO-102 | 841.654 | 0.00285535 | 0.159441 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 2830.15 | 2800 | 2800 | 2769.85 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1226.5 | 0.132207 | 50 | 119 | 841.654 | ø50 | 60.3 | 53 | TR02.02.2236 | 2236 | yes | CL_přívodní vodní (10 °C) 4 | 0
13426364 | -1.PP_SO-102 | 397.891 | 0.00285535 | 0.0753757 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 2830.15 | 2800 | 2800 | 2769.85 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1226.5 | 0.0625006 | 50 | 119 | 397.891 | ø50 | 60.3 | 53 | TR02.02.2237 | 2237 | yes | CL_přívodní vodní (10 °C) 4 | 0
13426377 | -1.PP_SO-102 | 413.325 | 0.00285535 | 0.0782995 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 2766.66 | 2766.66 | 2353.34 | 2353.34 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1646.66 | 0.0649249 | 50 | 119 | 413.325 | ø50 | 60.3 | 53 | TR02.02.2238 | 2238 | yes | CL_přívodní vodní (10 °C) 4
13426451 | -1.PP_SO-102 | 1191.65 | 0.00285535 | 0.225745 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 2830.15 | 2800 | 2800 | 2769.85 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1226.5 | 0.187185 | 50 | 98 | 1191.65 | ø50 | 60.3 | 53 | TR02.02.2239 | 2239 | yes | CL_vratné vodní (15 °C) 8 | 0
13426459 | -1.PP_SO-102 | 548.405 | 0.00285535 | 0.103889 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 2830.15 | 2800 | 2800 | 2769.85 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1226.5 | 0.0861432 | 50 | 98 | 548.405 | ø50 | 60.3 | 53 | TR02.02.2240 | 2240 | yes | CL_vratné vodní (15 °C) 8 | 0
13426468 | -1.PP_SO-102 | 413.325 | 0.00285535 | 0.0782995 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 2766.66 | 2766.66 | 2353.34 | 2353.34 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1646.66 | 0.0649249 | 50 | 98 | 413.325 | ø50 | 60.3 | 53 | TR02.02.2241 | 2241 | yes | CL_vratné vodní (15 °C) 8
13426506 | -1.PP_SO-102 | 1023.4 | 0.000568237 | 0.0864866 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1210.8 | 0.0643023 | 20 | 39 | 1023.4 | ø20 | 26.9 | 21.6 | TR02.02.2242 | 2242 | yes | HT_přívodní vodní (65 °C) 27 | 0
13426516 | -1.PP_SO-102 | 726.697 | 0.000568237 | 0.0614123 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1210.8 | 0.0456597 | 20 | 39 | 726.697 | ø20 | 26.9 | 21.6 | TR02.02.2243 | 2243 | yes | HT_přívodní vodní (65 °C) 27 | 0
13426525 | -1.PP_SO-102 | 415.075 | 0.000568237 | 0.0350775 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2782.54 | 2782.54 | 2367.46 | 2367.46 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1632.54 | 0.0260799 | 20 | 39 | 415.075 | ø20 | 26.9 | 21.6 | TR02.02.2244 | 2244 | yes | HT_přívodní vodní (65 °C) 27
13426572 | -1.PP_SO-102 | 973.404 | 0.000568237 | 0.0822612 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1210.8 | 0.0611607 | 20 | 140 | 973.404 | ø20 | 26.9 | 21.6 | TR02.02.2245 | 2245 | yes | HT_vratné vodní (45 °C) 26 | 0
13426580 | -1.PP_SO-102 | 826.697 | 0.000568237 | 0.0698632 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1210.8 | 0.0519429 | 20 | 140 | 826.697 | ø20 | 26.9 | 21.6 | TR02.02.2246 | 2246 | yes | HT_vratné vodní (45 °C) 26 | 0
13426591 | -1.PP_SO-102 | 415.075 | 0.000568237 | 0.0350775 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2782.54 | 2782.54 | 2367.46 | 2367.46 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1632.54 | 0.0260799 | 20 | 140 | 415.075 | ø20 | 26.9 | 21.6 | TR02.02.2247 | 2247 | yes | HT_vratné vodní (45 °C) 26
