Properties of the parts of a building model (IFC4), part 30 of 72

# IfcBuildingElementProxy: Výměník tepla:Standardní (3)
Kóty - Jmenovitý poloměr 1: 20 mm; Jmenovitý poloměr 2: 14 mm; Jmenovitý poloměr 3: 14 mm; Jmenovitý poloměr 4: 20 mm; Jmenovitý průměr 1: 40 mm; Jmenovitý průměr 2: 28 mm; Jmenovitý průměr 3: 28 mm; Jmenovitý průměr 4: 40 mm; L1: 20 mm; L2: 20 mm; Lgt1_1: 3 mm; Lgt1_2: 2.4176 mm; Lgt1_3: 2.4176 mm; Lgt1_4: 3 mm; Lgt2_1: 11 mm; Lgt2_2: 11.976 mm; Lgt2_3: 11.976 mm; Lgt2_4: 11 mm; Pol1_1: 40 mm; Pol1_2: 33.92 mm; Pol1_3: 33.92 mm; Pol1_4: 40 mm; Pol2_1: 65 mm; Pol2_2: 58.46 mm; Pol2_3: 58.46 mm; Pol2_4: 65 mm; Výška: 1000 mm; X1: 70 mm; X2: 50 mm; X3: 70 mm; X4: 50 mm; Y1: 100 mm; Y2: 90 mm; Y3: 100 mm; Y4: 80 mm
Identifikační data - ID systému: 2; Komentáře: Deskový výměník tepla, vytápění/chlazení, primár nemrznoucí směs, sekundár voda
Jiné - Páteřní trasa: yes; Id typu: 12849933; Rodina: Výměník tepla; Rodina a typ: Výměník tepla: Standardní; Typ: Standardní
Name (Výměník tepla:Standardní:...) | NetSurfaceArea (m2) | NetVolume (m3) = Objem (m3) | Délka (mm) | Roh (mm) | ID pozice | Kód prvku | Označení
12906882 | 2.1214 | 0.168328 | 420 | 20.2222 | 02 | VI01.42.0094 | 0094
12906972 | 2.06659 | 0.160352 | 400 | 20 | 01 | VI01.42.0095 | 0095
13389314 | 2.06659 | 0.160352 | 400 | 20 | 03 | VI01.42.0237 | 0237

# IfcBuildingElementProxy: Zásobník TUV:Standardní (4)
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - Horká voda, poloměr: 10 mm; Poloměr oběhu: 10 mm; Poloměr vytápění: 12.5 mm; Studená voda, poloměr: 12.5 mm
Type - Identifikační data - Cena: 82600; Kód sestavy: ZN01; Název typu: Standardní; Označení typu: 62; Popis sestavy: Stojatý
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Zásobník TUV
Classification: ZN01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 8.59363 m2; NetVolume: 1.38889 m3
Text - CCI Funkční systém: H; CCI Komponenta: CPA; CCI Technický systém: HD
Vazby - Podlaží: -1.PP_SO-102; Hostitel: Podlaží : -1.PP_SO-102; Odsazení od hostitele: -1200 mm; Výška od podlaží: -1200 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Teplá voda v domácnosti,Přívod teplé vody,Teplá voda v domácnosti,Zpětné vedení teplé vody,Studená voda v domácnosti; Objem vody: 0 m3; Pokles tlaku užitkové vody: 0 Pa; Tlakový spád vody: 0 Pa; Tok vody: 0 m3/s
Kóty - Objem: 1.38889 m3; Poloměr: 500 mm; Výš.: 1850 mm; Výška A: 93.24 mm; Výška B: 264.273 mm; Výška C: 155.4 mm
Identifikační data - ID systému: 3; Komentáře: Zásobník TUV
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 12862455; Rodina: Zásobník TUV; Rodina a typ: Zásobník TUV: Standardní
Name (Zásobník TUV:Standardní:...) | ID pozice | Kód prvku | Označení
13214598 | 04 | ZN01.62.0211 | 0211
13214600 | 05 | ZN01.62.0212 | 0212
13214601 | 06 | ZN01.62.0213 | 0213
13409218 | 03 | ZN01.62.0239 | 0239

# IfcBuildingElementProxy: podlahovka B0132:podlahovka B0132, podlahovka B0132:podlahovka B0132:12767196
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B0132; Označení typu: 06; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B0132
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 291.361 m2; NetVolume: 0.726566 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.726566 m3; Plocha: 145.313 m2
Identifikační data - Kód prvku: KP01.06.0006; Označení: 0006
Jiné - Id typu: 12767194; Rodina: podlahovka B0132; Rodina a typ: podlahovka B0132: podlahovka B0132; Typ: podlahovka B0132

# IfcBuildingElementProxy: podlahovka B0135.1:podlahovka B0135.1, podlahovka B0135.1:podlahovka B0135.1:12763657
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B0135.1; Označení typu: 01; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B0135.1
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 23.3098 m2; NetVolume: 0.0580506 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0580506 m3; Plocha: 11.6101 m2
Identifikační data - Kód prvku: KP01.01.0001; Označení: 0001
Jiné - Id typu: 12763655; Rodina: podlahovka B0135.1; Rodina a typ: podlahovka B0135.1: podlahovka B0135.1; Typ: podlahovka B0135.1

# IfcBuildingElementProxy: podlahovka B0135.2:podlahovka B0135.2, podlahovka B0135.2:podlahovka B0135.2:12764846
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B0135.2; Označení typu: 02; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B0135.2
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 20.5048 m2; NetVolume: 0.051102 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.051102 m3; Plocha: 10.2204 m2
Identifikační data - Kód prvku: KP01.02.0002; Označení: 0002
Jiné - Id typu: 12764844; Rodina: podlahovka B0135.2; Rodina a typ: podlahovka B0135.2: podlahovka B0135.2; Typ: podlahovka B0135.2

# IfcBuildingElementProxy: podlahovka B0136.1:podlahovka B0136.1, podlahovka B0136.1:podlahovka B0136.1:12766578
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B0136.1; Označení typu: 03; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B0136.1
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 10.6491 m2; NetVolume: 0.0263995 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0263995 m3; Plocha: 5.2799 m2
Identifikační data - Kód prvku: KP01.03.0003; Označení: 0003
Jiné - Id typu: 12766576; Rodina: podlahovka B0136.1; Rodina a typ: podlahovka B0136.1: podlahovka B0136.1; Typ: podlahovka B0136.1

# IfcBuildingElementProxy: podlahovka B0136.2:podlahovka B0136.2, podlahovka B0136.2:podlahovka B0136.2:12766673
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B0136.2; Označení typu: 04; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B0136.2
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 11.3786 m2; NetVolume: 0.0282987 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0282987 m3; Plocha: 5.65975 m2
Identifikační data - Kód prvku: KP01.04.0004; Označení: 0004
Jiné - Id typu: 12766671; Rodina: podlahovka B0136.2; Rodina a typ: podlahovka B0136.2: podlahovka B0136.2; Typ: podlahovka B0136.2

# IfcBuildingElementProxy: podlahovka B0136.3:podlahovka B0136.3, podlahovka B0136.3:podlahovka B0136.3:12766707
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B0136.3; Označení typu: 05; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B0136.3
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 7.4642 m2; NetVolume: 0.018564 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.018564 m3; Plocha: 3.7128 m2
Identifikační data - Kód prvku: KP01.05.0005; Označení: 0005
Jiné - Id typu: 12766705; Rodina: podlahovka B0136.3; Rodina a typ: podlahovka B0136.3: podlahovka B0136.3; Typ: podlahovka B0136.3

# IfcBuildingElementProxy: podlahovka B0137.1:podlahovka B0137.1, podlahovka B0137.1:podlahovka B0137.1:12767573
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B0137.1; Označení typu: 11; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B0137.1
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.06737 m2; NetVolume: 0.0125826 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0125826 m3; Plocha: 2.51651 m2
Identifikační data - Kód prvku: KP01.11.0011; Označení: 0011
Jiné - Id typu: 12767571; Rodina: podlahovka B0137.1; Rodina a typ: podlahovka B0137.1: podlahovka B0137.1; Typ: podlahovka B0137.1

# IfcBuildingElementProxy: podlahovka B0137.2:podlahovka B0137.2, podlahovka B0137.2:podlahovka B0137.2:12767536
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B0137.2; Označení typu: 10; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B0137.2
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.39367 m2; NetVolume: 0.00592531 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.00592531 m3; Plocha: 1.18506 m2
Identifikační data - Kód prvku: KP01.10.0010; Označení: 0010
Jiné - Id typu: 12767534; Rodina: podlahovka B0137.2; Rodina a typ: podlahovka B0137.2: podlahovka B0137.2; Typ: podlahovka B0137.2

# IfcBuildingElementProxy: podlahovka B0137.3:podlahovka B0137.3, podlahovka B0137.3:podlahovka B0137.3:12767602
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B0137.3; Označení typu: 12; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B0137.3
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.06828 m2; NetVolume: 0.00511839 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.00511839 m3; Plocha: 1.02368 m2
Identifikační data - Kód prvku: KP01.12.0012; Označení: 0012
Jiné - Id typu: 12767600; Rodina: podlahovka B0137.3; Rodina a typ: podlahovka B0137.3: podlahovka B0137.3; Typ: podlahovka B0137.3

# IfcBuildingElementProxy: podlahovka B0138.1:podlahovka B0138.1, podlahovka B0138.1:podlahovka B0138.1:12767291
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B0138.1; Označení typu: 08; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B0138.1
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.98357 m2; NetVolume: 0.0123738 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0123738 m3; Plocha: 2.47477 m2
Identifikační data - Kód prvku: KP01.08.0008; Označení: 0008
Jiné - Id typu: 12767289; Rodina: podlahovka B0138.1; Rodina a typ: podlahovka B0138.1: podlahovka B0138.1; Typ: podlahovka B0138.1

# IfcBuildingElementProxy: podlahovka B0138.2:podlahovka B0138.2, podlahovka B0138.2:podlahovka B0138.2:12767507
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B0138.2; Označení typu: 09; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B0138.2
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.34162 m2; NetVolume: 0.00579572 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.00579572 m3; Plocha: 1.15914 m2
Identifikační data - Kód prvku: KP01.09.0009; Označení: 0009
Jiné - Id typu: 12767505; Rodina: podlahovka B0138.2; Rodina a typ: podlahovka B0138.2: podlahovka B0138.2; Typ: podlahovka B0138.2

# IfcBuildingElementProxy: podlahovka B0138.3:podlahovka B0138.3, podlahovka B0138.3:podlahovka B0138.3:12767253
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B0138.3; Označení typu: 07; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B0138.3
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.0878 m2; NetVolume: 0.00516703 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.00516703 m3; Plocha: 1.03341 m2
Identifikační data - Kód prvku: KP01.07.0007; Označení: 0007
Jiné - Id typu: 12767251; Rodina: podlahovka B0138.3; Rodina a typ: podlahovka B0138.3: podlahovka B0138.3; Typ: podlahovka B0138.3

# IfcBuildingElementProxy: podlahovka B114.1:podlahovka B114.1, podlahovka B114.1:podlahovka B114.1:12788506
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B114.1; Označení typu: 24; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B114.1
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 21.3549 m2; NetVolume: 0.053111 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.053111 m3; Plocha: 10.6222 m2
Identifikační data - Kód prvku: KP01.24.0066; Označení: 0066
Jiné - Id typu: 12788504; Rodina: podlahovka B114.1; Rodina a typ: podlahovka B114.1: podlahovka B114.1; Typ: podlahovka B114.1

# IfcBuildingElementProxy: podlahovka B114.6:podlahovka B114.6, podlahovka B114.6:podlahovka B114.6:12784704
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B114.6; Označení typu: 21; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B114.6
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 55.5536 m2; NetVolume: 0.138477 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.138477 m3; Plocha: 27.6954 m2
Identifikační data - Kód prvku: KP01.21.0063; Označení: 0063
Jiné - Id typu: 12784702; Rodina: podlahovka B114.6; Rodina a typ: podlahovka B114.6: podlahovka B114.6; Typ: podlahovka B114.6

# IfcBuildingElementProxy: podlahovka B114.7:podlahovka B114.7, podlahovka B114.7:podlahovka B114.7:12785368
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B114.7; Označení typu: 22; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B114.7
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 32.4449 m2; NetVolume: 0.0809065 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0809065 m3; Plocha: 16.1813 m2
Identifikační data - Kód prvku: KP01.22.0064; Označení: 0064
Jiné - Id typu: 12785366; Rodina: podlahovka B114.7; Rodina a typ: podlahovka B114.7: podlahovka B114.7; Typ: podlahovka B114.7

# IfcBuildingElementProxy: podlahovka B114.8:podlahovka B114.8, podlahovka B114.8:podlahovka B114.8:12786106
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B114.8; Označení typu: 23; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B114.8
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 26.4808 m2; NetVolume: 0.0660188 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0660188 m3; Plocha: 13.2038 m2
Identifikační data - Kód prvku: KP01.23.0065; Označení: 0065
Jiné - Id typu: 12786104; Rodina: podlahovka B114.8; Rodina a typ: podlahovka B114.8: podlahovka B114.8; Typ: podlahovka B114.8

# IfcBuildingElementProxy: podlahovka B234:podlahovka B234, podlahovka B234:podlahovka B234:12812985
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B234; Označení typu: 29; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B234
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 228.642 m2; NetVolume: 0.570878 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.570878 m3; Plocha: 114.176 m2
Identifikační data - Kód prvku: KP01.29.0076; Označení: 0076
Jiné - Id typu: 12812983; Rodina: podlahovka B234; Rodina a typ: podlahovka B234: podlahovka B234; Typ: podlahovka B234

# IfcBuildingElementProxy: podlahovka B235:podlahovka B235, podlahovka B235:podlahovka B235:12814248
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B235; Označení typu: 31; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B235
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 28.6619 m2; NetVolume: 0.0714313 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0714313 m3; Plocha: 14.2863 m2
Identifikační data - Kód prvku: KP01.31.0078; Označení: 0078
Jiné - Id typu: 12814246; Rodina: podlahovka B235; Rodina a typ: podlahovka B235: podlahovka B235; Typ: podlahovka B235

# IfcBuildingElementProxy: podlahovka B236:podlahovka B236, podlahovka B236:podlahovka B236:12813618
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B236; Označení typu: 30; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B236
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 83.4258 m2; NetVolume: 0.208106 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.208106 m3; Plocha: 41.6213 m2
Identifikační data - Kód prvku: KP01.30.0077; Označení: 0077
Jiné - Id typu: 12813616; Rodina: podlahovka B236; Rodina a typ: podlahovka B236: podlahovka B236; Typ: podlahovka B236

# IfcBuildingElementProxy: podlahovka B242:podlahovka B242, podlahovka B242:podlahovka B242:12816160
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B242; Označení typu: 32; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B242
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 350.496 m2; NetVolume: 0.875131 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HE
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.875131 m3; Plocha: 175.026 m2
Identifikační data - Kód prvku: KP01.32.0079; Označení: 0079
Jiné - Id typu: 12816158; Rodina: podlahovka B242; Rodina a typ: podlahovka B242: podlahovka B242; Typ: podlahovka B242

# IfcBuildingElementProxy: podlahovka B258:podlahovka B258, podlahovka B258:podlahovka B258:12998726
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B258; Označení typu: 48; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B258
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 28.5337 m2; NetVolume: 0.07092 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.07092 m3; Plocha: 14.184 m2
Identifikační data - Kód prvku: KP01.48.0141; Označení: 0141
Jiné - Id typu: 12998724; Rodina: podlahovka B258; Rodina a typ: podlahovka B258: podlahovka B258; Typ: podlahovka B258

# IfcBuildingElementProxy: podlahovka B340:podlahovka B340, podlahovka B340:podlahovka B340:12800727
In: 3.NP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B340; Označení typu: 25; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B340
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 406.068 m2; NetVolume: 1.0138 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HE
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 1.0138 m3; Plocha: 202.76 m2
Identifikační data - Kód prvku: KP01.25.0067; Označení: 0067
Jiné - Id typu: 12800725; Rodina: podlahovka B340; Rodina a typ: podlahovka B340: podlahovka B340; Typ: podlahovka B340

# IfcBuildingElementProxy: podlahovka B342-1 (B333_1):podlahovka B342-1 (B333_1), podlahovka B342-1 (B333_1):podlahovka B342-1 (B333_1):13010638
In: 3.NP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B342-1 (B333_1); Označení typu: 51; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B342-1 (B333_1)
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 90.8125 m2; NetVolume: 0.226629 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.226629 m3; Plocha: 45.3257 m2
Identifikační data - Kód prvku: KP01.51.0172; Označení: 0172
Jiné - Id typu: 13010636; Rodina: podlahovka B342-1 (B333_1); Rodina a typ: podlahovka B342-1 (B333_1): podlahovka B342-1 (B333_1); Typ: podlahovka B342-1 (B333_1)

# IfcBuildingElementProxy: podlahovka B342-1 (B334_1):podlahovka B342-1, podlahovka B342-1 (B334_1):podlahovka B342-1:12808360
In: 3.NP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B342-1; Označení typu: 27; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B342-1 (B334_1)
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 123.117 m2; NetVolume: 0.30739 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.30739 m3; Plocha: 61.4779 m2
Identifikační data - Kód prvku: KP01.27.0074; Označení: 0074
Jiné - Id typu: 12808358; Rodina: podlahovka B342-1 (B334_1); Rodina a typ: podlahovka B342-1 (B334_1): podlahovka B342-1; Typ: podlahovka B342-1

# IfcBuildingElementProxy: podlahovka B343-1 (B333_2):podlahovka B343-1, podlahovka B343-1 (B333_2):podlahovka B343-1:12809273
In: 3.NP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B343-1; Označení typu: 28; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B343-1 (B333_2)
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 25.8887 m2; NetVolume: 0.0645421 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0645421 m3; Plocha: 12.9084 m2
Identifikační data - Kód prvku: KP01.28.0075; Označení: 0075
Jiné - Id typu: 12809271; Páteřní trasa: no; Rodina: podlahovka B343-1 (B333_2); Rodina a typ: podlahovka B343-1 (B333_2): podlahovka B343-1; Typ: podlahovka B343-1

# IfcBuildingElementProxy: podlahovka B343-1 (B334_2):podlahovka B343-1 (B334_2), podlahovka B343-1 (B334_2):podlahovka B343-1 (B334_2):13009779
In: 3.NP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B343-1 (B334_2); Označení typu: 50; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B343-1 (B334_2)
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 116.405 m2; NetVolume: 0.290625 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.290625 m3; Plocha: 58.125 m2
Identifikační data - Kód prvku: KP01.50.0171; Označení: 0171
Jiné - Id typu: 13009777; Rodina: podlahovka B343-1 (B334_2); Rodina a typ: podlahovka B343-1 (B334_2): podlahovka B343-1 (B334_2); Typ: podlahovka B343-1 (B334_2)

# IfcBuildingElementProxy: podlahovka B343-1 (B336):podlahovka B336, podlahovka B343-1 (B336):podlahovka B336:13009007
In: 3.NP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B336; Označení typu: 49; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B343-1 (B336)
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 34.7615 m2; NetVolume: 0.0866716 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0866716 m3; Plocha: 17.3343 m2
Identifikační data - Kód prvku: KP01.49.0170; Označení: 0170
Jiné - Id typu: 13009005; Rodina: podlahovka B343-1 (B336); Rodina a typ: podlahovka B343-1 (B336): podlahovka B336; Typ: podlahovka B336

# IfcBuildingElementProxy: podlahovka B435:podlahovka B435, podlahovka B435:podlahovka B435:12805271
In: 4.NP_SO-102
Type - Material: <Unnamed>
Type - Mechanické - Klasifikace: Žádné
Type - Identifikační data - Kód sestavy: KP01; Název typu: podlahovka B435; Označení typu: 26; Popis sestavy: Teplovodní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: podlahovka B435
Classification: KP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 569.55 m2; NetVolume: 1.42281 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPA; CCI Technický systém: HE
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 1.42281 m3; Plocha: 284.562 m2
Identifikační data - Kód prvku: KP01.26.0068; Označení: 0068
Jiné - Id typu: 12805269; Rodina: podlahovka B435; Rodina a typ: podlahovka B435: podlahovka B435; Typ: podlahovka B435

# IfcCovering: Izolace trubky:Tepelná (382)
PredefinedType: INSULATION; Classification: IZ01 Uniformat (Uniformat)
Text - CCI Funkční systém: H; CCI Komponenta: RQA; CCI Technický systém: HD
Jiné - Id typu: 9105621; Kategorie: Izolace trubky; Rodina: Izolace trubky; Rodina a typ: Izolace trubky: Tepelná; Typ: Tepelná
Požární ochrana(Type) - Požární odolnost: A1
Identifikační data(Type) - ID kategorie: IZT; Kód sestavy: IZ01; Název typu: Tepelná; Označení typu: 01; Popis: TEPELNÁ IZOLACE; Popis sestavy: Tepelná
Jiné(Type) - Kategorie: Izolace trubky; MJ: m; Název rodiny: Izolace trubky
Name (Izolace trubky:Tepelná:...) | In | Material | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Objem (m3) | Plocha (m2) | Tloušťka izolace (mm) | Délka (mm) | Velikost potrubí | Kód prvku | Označení
13058191 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 0.2892 | 4.81999 | 60 | 7344.43 | ø80 | IZ01.01.0001 | 0001
13058203 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 0.2892 | 4.81999 | 60 | 7344.43 | ø80 | IZ01.01.0002 | 0002
13062901 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 0.0690461 | 1.15077 | 60 | 1753.47 | ø80 | IZ01.01.0003 | 0003
13062902 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 0.0823616 | 1.37269 | 60 | 2091.63 | ø80 | IZ01.01.0004 | 0004
13062908 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 0.0547555 | 0.912591 | 60 | 1390.55 | ø80 | IZ01.01.0005 | 0005
13062912 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 0.0544767 | 0.907945 | 60 | 1383.47 | ø80 | IZ01.01.0006 | 0006
13062913 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 0.0838769 | 1.39795 | 60 | 2130.11 | ø80 | IZ01.01.0007 | 0007
13062914 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 0.0788902 | 1.31484 | 60 | 2003.47 | ø80 | IZ01.01.0008 | 0008
13062915 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 0.0921166 | 1.53528 | 60 | 2339.37 | ø80 | IZ01.01.0009 | 0009
13062919 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 |  |  | 60 |  | ø80-ø80 | IZ01.01.0010 | 0010
13063243 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 |  |  | 60 |  | ø80-ø80 | IZ01.01.0011 | 0011
13063249 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 0.275945 | 4.59908 | 60 | 7007.81 | ø80 | IZ01.01.0012 | 0012
13063254 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 0.293011 | 4.88352 | 60 | 7441.23 | ø80 | IZ01.01.0013 | 0013
13063263 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 0.288943 | 4.81572 | 60 | 7337.92 | ø80 | IZ01.01.0014 | 0014
13063265 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 0.281324 | 4.68874 | 60 | 7144.43 | ø80 | IZ01.01.0015 | 0015
13063266 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 |  |  | 60 |  | ø65-ø65 | IZ01.01.0016 | 0016
13063270 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 |  |  | 60 |  | ø65-ø65 | IZ01.01.0017 | 0017
13063271 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 0.2892 | 4.81999 | 60 | 7344.43 | ø80 | IZ01.01.0018 | 0018
13063863 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 0.0304577 | 0.507628 | 60 | 773.494 | ø80 | IZ01.01.0019 | 0019
13064026 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 0.102299 | 1.70498 | 60 | 2597.96 | ø80 | IZ01.01.0020 | 0020
13064027 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 36 |  |  | 60 |  | ø32-ø32 | IZ01.01.0021 | 0021
13064028 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 31 |  |  | 60 |  | ø50-ø50 | IZ01.01.0022 | 0022
13064030 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 0.53504 | 8.91733 | 60 | 13587.7 | ø80 | IZ01.01.0023 | 0023
13064815 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 0.0274169 | 0.685424 | 40 | 1700.52 | ø40 | IZ01.01.0024 | 0024
13064816 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.0326998 | 0.817494 | 40 | 2028.19 | ø40 | IZ01.01.0025 | 0025 | Qto_CoveringBaseQuantities - GrossArea: 0.0129264 m2
13065146 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 0.0266122 | 0.665305 | 40 | 1730.17 | ø32 | IZ01.01.0026 | 0026
13065147 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 |  |  | 40 |  | ø32-ø32 | IZ01.01.0027 | 0027
13065586 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 7 | 0.0391167 | 0.977917 | 40 | 2426.19 | ø40 | IZ01.01.0028 | 0028
13065589 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 0.139167 | 3.47916 | 40 | 8631.74 | ø40 | IZ01.01.0029 | 0029 | Qto_CoveringBaseQuantities - GrossArea: 0.0129264 m2
13069819 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø40-ø40-ø40 | IZ01.01.0030 | 0030 | Qto_CoveringBaseQuantities - GrossArea: 0.0113968 m2; Width: 121.275 mm
13069954 | 1.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 0.0128832 | 0.32208 | 40 | 1012.06 | ø15 | IZ01.01.0031 | 0031
13069955 | 1.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 0.00600111 | 0.150028 | 40 | 471.425 | ø15 | IZ01.01.0032 | 0032
13069956 | 1.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø15-ø15 | IZ01.01.0033 | 0033
13069957 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 0.0402441 | 1.0061 | 40 | 3161.42 | ø15 | IZ01.01.0034 | 0034
13069958 | 1.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø15-ø15 | IZ01.01.0035 | 0035
13069960 | 1.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø40-ø40-ø40 | IZ01.01.0036 | 0036 | Qto_CoveringBaseQuantities - GrossArea: 0.0113968 m2; Width: 93.975 mm
13069966 | 1.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø40-ø15 | IZ01.01.0037 | 0037
13069969 | 3.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø40-ø40-ø40 | IZ01.01.0038 | 0038 | Qto_CoveringBaseQuantities - GrossArea: 0.0113968 m2; Width: 93.975 mm
13069970 | 3.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 0.0555188 | 1.38797 | 40 | 3885.71 | ø25 | IZ01.01.0039 | 0039 | Qto_CoveringBaseQuantities - GrossArea: 0.0101519 m2
13069971 | 3.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø40-ø25 | IZ01.01.0040 | 0040
13069975 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 0.0271668 | 0.67917 | 40 | 1540.89 | ø50 | IZ01.01.0041 | 0041 | Qto_CoveringBaseQuantities - GrossArea: 0.0154575 m2
13069982 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 0.00114737 | 0.0286842 | 40 | 71.165 | ø40 | IZ01.01.0042 | 0042 | Qto_CoveringBaseQuantities - GrossArea: 0.0129264 m2
13070120 | 1.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 0.0589038 | 1.4726 | 40 | 3653.48 | ø40 | IZ01.01.0043 | 0043 | Qto_CoveringBaseQuantities - GrossArea: 0.0129264 m2
13070126 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø50-ø40 | IZ01.01.0044 | 0044
13070127 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø50-ø50-ø50 | IZ01.01.0045 | 0045 | Qto_CoveringBaseQuantities - GrossArea: 0.0142918 m2; Width: 133.975 mm
13070128 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø50-ø40 | IZ01.01.0046 | 0046
13075133 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 0.538977 | 8.98296 | 60 | 13687.7 | ø80 | IZ01.01.0047 | 0047
13075143 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 0.10033 | 1.67217 | 60 | 2547.96 | ø80 | IZ01.01.0048 | 0048
13075163 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 0.0206135 | 0.343558 | 60 | 523.494 | ø80 | IZ01.01.0049 | 0049
13076715 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 0.0245161 | 0.612903 | 40 | 1593.9 | ø32 | IZ01.01.0050 | 0050
13077647 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 0.288943 | 4.81572 | 60 | 7337.92 | ø80 | IZ01.01.0051 | 0051
13079949 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 0.0485309 | 1.21327 | 40 | 3612.69 | ø20 | IZ01.01.0052 | 0052 | Qto_CoveringBaseQuantities - GrossArea: 0.00897387 m2
13079964 | 1.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 0.0666402 | 1.666 | 40 | 4133.32 | ø40 | IZ01.01.0053 | 0053
13079972 | 1.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø40-ø40-ø40 | IZ01.01.0054 | 0054 | Qto_CoveringBaseQuantities - GrossArea: 0.0113968 m2; Width: 121.275 mm
13080026 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø42-ø40 | IZ01.01.0055 | 0055
13080254 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.0345899 | 0.864746 | 40 | 1961.92 | ø50 | IZ01.01.0056 | 0056
13080874 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 0.48055 | 8.00917 | 60 | 12203.9 | ø80 | IZ01.01.0057 | 0057 | Qto_CoveringBaseQuantities - GrossArea: 0.034269 m2
13080885 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.500239 | 8.33731 | 60 | 12703.9 | ø80 | IZ01.01.0058 | 0058 | Qto_CoveringBaseQuantities - GrossArea: 0.034269 m2
13081147 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.013777 | 0.229617 | 60 | 349.877 | ø80 | IZ01.01.0059 | 0059 | Qto_CoveringBaseQuantities - GrossArea: 0.034269 m2
13081151 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 60 |  | ø80-ø80-ø80 | IZ01.01.0060 | 0060 | Qto_CoveringBaseQuantities - GrossArea: 0.0208895 m2; Width: 104.775 mm
13081161 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.00078335 | 0.0195838 | 40 | 44.4313 | ø50 | IZ01.01.0061 | 0061
13081309 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø50-ø50 | IZ01.01.0062 | 0062
13081317 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø50-ø40 | IZ01.01.0063 | 0063
13081318 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø50-ø50-ø50 | IZ01.01.0064 | 0064 | Qto_CoveringBaseQuantities - GrossArea: 0.0142918 m2; Width: 133.975 mm
13081321 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø50-ø40 | IZ01.01.0065 | 0065
13081717 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 0.064904 | 1.6226 | 40 | 4025.64 | ø40 | IZ01.01.0066 | 0066 | Qto_CoveringBaseQuantities - GrossArea: 0.0129264 m2
13081727 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø40-ø40-ø40 | IZ01.01.0067 | 0067 | Qto_CoveringBaseQuantities - GrossArea: 0.00808604 m2; Width: 66.6753 mm
13083330 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.700764 | 11.6794 | 60 | 17796.4 | ø80 | IZ01.01.0068 | 0068 | Qto_CoveringBaseQuantities - GrossArea: 0.034269 m2
13083338 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 60 |  | ø80-ø80-ø80 | IZ01.01.0069 | 0069 | Qto_CoveringBaseQuantities - GrossArea: 0.0208895 m2; Width: 104.775 mm
13084155 | 1.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.0614809 | 1.53702 | 40 | 3813.32 | ø40 | IZ01.01.0070 | 0070 | Qto_CoveringBaseQuantities - GrossArea: 0.0129264 m2
13084176 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.000056127 | 0.00140317 | 40 | 3.48125 | ø40 | IZ01.01.0071 | 0071 | Qto_CoveringBaseQuantities - GrossArea: 0.0129264 m2
13084184 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø40-ø40-ø40 | IZ01.01.0072 | 0072 | Qto_CoveringBaseQuantities - GrossArea: 0.0113968 m2; Width: 93.975 mm
13088754 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø40-ø20 | IZ01.01.0073 | 0073
13088757 | 1.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø40-ø20 | IZ01.01.0074 | 0074
13088771 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø42-ø42-ø42 | IZ01.01.0075 | 0075 | Qto_CoveringBaseQuantities - GrossArea: 0.0122515 m2; Width: 125.175 mm
13088772 | 1.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.0662131 | 1.65533 | 40 | 4106.84 | ø40 | IZ01.01.0076 | 0076 | Qto_CoveringBaseQuantities - GrossArea: 0.0129264 m2
13088773 | 1.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø42-ø42-ø42 | IZ01.01.0077 | 0077 | Qto_CoveringBaseQuantities - GrossArea: 0.0122515 m2; Width: 125.175 mm
13088774 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.0479691 | 1.19923 | 40 | 3570.87 | ø20 | IZ01.01.0078 | 0078 | Qto_CoveringBaseQuantities - GrossArea: 0.00897387 m2
13088775 | 1.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø42-ø20 | IZ01.01.0079 | 0079
13088776 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø42-ø40 | IZ01.01.0080 | 0080
13088777 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø42-ø40 | IZ01.01.0081 | 0081
13088778 | 1.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø42-ø40 | IZ01.01.0082 | 0082
13088779 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø42-ø40 | IZ01.01.0083 | 0083
13088783 | 1.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.000409029 | 0.0102257 | 40 | 23.1999 | ø50 | IZ01.01.0084 | 0084 | Qto_CoveringBaseQuantities - GrossArea: 0.0154575 m2
13091091 | 3.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.0576115 | 1.44029 | 40 | 3573.32 | ø40 | IZ01.01.0085 | 0085 | Qto_CoveringBaseQuantities - GrossArea: 0.0129264 m2
13091099 | 3.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø40-ø40-ø40 | IZ01.01.0086 | 0086 | Qto_CoveringBaseQuantities - GrossArea: 0.0113968 m2; Width: 121.275 mm
13091125 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 0.042501 | 1.06253 | 40 | 2636.1 | ø40 | IZ01.01.0087 | 0087 | Qto_CoveringBaseQuantities - GrossArea: 0.0129264 m2
13091139 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 0.136748 | 3.4187 | 40 | 8481.74 | ø40 | IZ01.01.0088 | 0088 | Qto_CoveringBaseQuantities - GrossArea: 0.0129264 m2
13091568 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 0.283167 | 4.71945 | 60 | 7191.23 | ø80 | IZ01.01.0089 | 0089
13093421 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.0635794 | 1.58948 | 40 | 3943.48 | ø40 | IZ01.01.0090 | 0090 | Qto_CoveringBaseQuantities - GrossArea: 0.0129264 m2
13093448 | 3.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.0621642 | 1.55411 | 40 | 3855.71 | ø40 | IZ01.01.0091 | 0091 | Qto_CoveringBaseQuantities - GrossArea: 0.0129264 m2
13093456 | 3.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø40-ø40-ø40 | IZ01.01.0092 | 0092 | Qto_CoveringBaseQuantities - GrossArea: 0.0113968 m2; Width: 93.975 mm
13096434 | 3.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 0.0564829 | 1.41207 | 40 | 3503.33 | ø40 | IZ01.01.0093 | 0093 | Qto_CoveringBaseQuantities - GrossArea: 0.0129264 m2
13096448 | 3.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 0.00102097 | 0.0255242 | 40 | 63.325 | ø40 | IZ01.01.0094 | 0094 | Qto_CoveringBaseQuantities - GrossArea: 0.0129264 m2
13096456 | 3.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø40-ø40-ø40 | IZ01.01.0095 | 0095 | Qto_CoveringBaseQuantities - GrossArea: 0.0113968 m2; Width: 121.275 mm
13096561 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.000323763 | 0.00809408 | 40 | 20.0812 | ø40 | IZ01.01.0096 | 0096 | Qto_CoveringBaseQuantities - GrossArea: 0.0129264 m2
13096805 | 3.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 0.00950713 | 0.237678 | 40 | 589.675 | ø40 | IZ01.01.0097 | 0097
13096813 | 3.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø40-ø40-ø40 | IZ01.01.0098 | 0098 | Qto_CoveringBaseQuantities - GrossArea: 0.0113968 m2; Width: 121.275 mm
13096848 | 3.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.00102097 | 0.0255242 | 40 | 63.325 | ø40 | IZ01.01.0099 | 0099 | Qto_CoveringBaseQuantities - GrossArea: 0.0129264 m2
13096856 | 3.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø40-ø40-ø40 | IZ01.01.0100 | 0100 | Qto_CoveringBaseQuantities - GrossArea: 0.0113968 m2; Width: 121.275 mm
13123649 | 1.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.0118648 | 0.296621 | 40 | 932.056 | ø15 | IZ01.01.0101 | 0101
13123657 | 1.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø40-ø40-ø40 | IZ01.01.0102 | 0102 | Qto_CoveringBaseQuantities - GrossArea: 0.0113968 m2; Width: 93.975 mm
13123856 | 1.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø40-ø15 | IZ01.01.0103 | 0103
13125745 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 0.0172441 | 0.287401 | 60 | 437.925 | ø80 | IZ01.01.0104 | 0104
13125755 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 |  |  | 60 |  | ø80-ø80 | IZ01.01.0105 | 0105
13125760 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 |  |  | 60 |  | ø80-ø80 | IZ01.01.0106 | 0106
13125812 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 0.0172441 | 0.287401 | 60 | 437.925 | ø80 | IZ01.01.0107 | 0107
13125822 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 |  |  | 60 |  | ø80-ø80 | IZ01.01.0108 | 0108
13125827 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 |  |  | 60 |  | ø80-ø80 | IZ01.01.0109 | 0109
13126223 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 11 | 0.000484767 | 0.0121192 | 40 | 30.0675 | ø40 | IZ01.01.0110 | 0110
13126224 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 |  |  | 40 |  | ø32-ø32 | IZ01.01.0111 | 0111
13127759 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 7 |  |  | 40 |  | ø40-ø40 | IZ01.01.0112 | 0112
13128010 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 |  |  | 40 |  | ø40-ø32 | IZ01.01.0113 | 0113
13128011 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 |  |  | 40 |  | ø32-ø32 | IZ01.01.0114 | 0114
13137636 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.0035217 | 0.058695 | 60 | 89.4362 | ø80 | IZ01.01.0115 | 0115 | Qto_CoveringBaseQuantities - GrossArea: 0.034269 m2
13137644 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 60 |  | ø80-ø80-ø80 | IZ01.01.0116 | 0116 | Qto_CoveringBaseQuantities - GrossArea: 0.0208895 m2; Width: 104.775 mm
13162793 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 0.06869 | 1.14483 | 60 | 1744.43 | ø80 | IZ01.01.0117 | 0117 | Qto_CoveringBaseQuantities - GrossArea: 0.034269 m2
13163108 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 0.0785222 | 1.3087 | 60 | 1994.13 | ø80 | IZ01.01.0118 | 0118
13180457 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 |  |  | 60 |  | ø80-ø80 | IZ01.01.0119 | 0119
13180647 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 0.0920418 | 1.53403 | 60 | 2337.47 | ø80 | IZ01.01.0120 | 0120
13180649 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 0.0807601 | 1.346 | 60 | 2050.96 | ø80 | IZ01.01.0121 | 0121
13180651 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 0.0081874 | 0.136457 | 60 | 207.925 | ø80 | IZ01.01.0122 | 0122
13180652 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 |  |  | 60 |  | ø80-ø80 | IZ01.01.0123 | 0123
13180654 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 |  |  | 60 |  | ø80-ø80 | IZ01.01.0124 | 0124
13180655 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 0.0121251 | 0.202085 | 60 | 307.925 | ø80 | IZ01.01.0125 | 0125
13180656 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 |  |  | 60 |  | ø80-ø80 | IZ01.01.0126 | 0126
13180658 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 |  |  | 60 |  | ø80-ø80 | IZ01.01.0127 | 0127
13185624 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 |  |  | 60 |  | ø80-ø80 | IZ01.01.0128 | 0128
13185742 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 |  |  | 60 |  | ø80-ø80 | IZ01.01.0129 | 0129
13186836 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 0.28661 | 4.77684 | 60 | 9362.77 | ø32 | IZ01.01.0130 | 0130
13187128 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 0.0326448 | 0.816119 | 40 | 2122.37 | ø32 | IZ01.01.0131 | 0131
13187298 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 0.0364901 | 0.912252 | 40 | 2372.38 | ø32 | IZ01.01.0132 | 0132
13187427 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 0.286719 | 4.77865 | 60 | 9366.32 | ø32 | IZ01.01.0133 | 0133
13189260 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 |  |  | 60 |  | ø80-ø80 | IZ01.01.0134 | 0134
13189261 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 0.00936871 | 0.156145 | 60 | 237.925 | ø80 | IZ01.01.0135 | 0135
13189276 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 |  |  | 60 |  | ø80-ø80 | IZ01.01.0136 | 0136
13189315 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 |  |  | 60 |  | ø80-ø80 | IZ01.01.0137 | 0137
13189316 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 0.00936871 | 0.156145 | 60 | 237.925 | ø80 | IZ01.01.0138 | 0138
13189331 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 |  |  | 60 |  | ø80-ø80 | IZ01.01.0139 | 0139
13190041 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 0.00215655 | 0.0539137 | 40 | 160.536 | ø20 | IZ01.01.0140 | 0140 | Qto_CoveringBaseQuantities - GrossArea: 0.00897387 m2
13206690 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 32 | 0.127125 | 3.17812 | 40 | 7884.85 | ø40 | IZ01.01.0141 | 0141 | Qto_CoveringBaseQuantities - GrossArea: 0.0129264 m2
13206727 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 8 | 0.121482 | 3.03705 | 40 | 7534.85 | ø40 | IZ01.01.0142 | 0142 | Qto_CoveringBaseQuantities - GrossArea: 0.0129264 m2
13207401 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 4 | 0.12676 | 3.169 | 40 | 8241.2 | ø32 | IZ01.01.0143 | 0143 | Qto_CoveringBaseQuantities - GrossArea: 0.0117649 m2
13207989 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 36 | 0.132143 | 3.30358 | 40 | 8591.2 | ø32 | IZ01.01.0144 | 0144 | Qto_CoveringBaseQuantities - GrossArea: 0.0117649 m2
13208025 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 31 | 0.163474 | 4.08684 | 40 | 9272.15 | ø50 | IZ01.01.0145 | 0145 | Qto_CoveringBaseQuantities - GrossArea: 0.0154575 m2
13208059 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 6 | 0.157303 | 3.93258 | 40 | 8922.15 | ø50 | IZ01.01.0146 | 0146 | Qto_CoveringBaseQuantities - GrossArea: 0.0154575 m2
13218786 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 |  |  | 60 |  | ø80-ø80 | IZ01.01.0147 | 0147
13219167 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 |  |  | 60 |  | ø80-ø80 | IZ01.01.0148 | 0148
13222739 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 0.168725 | 2.81209 | 60 | 4284.9 | ø80 | IZ01.01.0149 | 0149
13243320 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 0.153198 | 2.55331 | 60 | 3890.58 | ø80 | IZ01.01.0150 | 0150
13243413 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 0.153198 | 2.55331 | 60 | 3890.58 | ø80 | IZ01.01.0151 | 0151
