Properties of the parts of a building model (IFC4), part 40 of 72

# IfcDistributionPort (10261)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_13229975_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13229973_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13229977_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13229977_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13250950_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
InPort_13230095_0 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
OutPort_13431352_2 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
InPort_13431356_3 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
OutPort_13230095_1 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
InPort_13230105_0 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
OutPort_13313688_2 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
InPort_13431352_1 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
OutPort_13230105_1 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
InPort_13230138_0 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
OutPort_13431408_2 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 2
InPort_13431461_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
OutPort_13230138_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 2
InPort_13230150_0 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
OutPort_13313690_2 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 2
InPort_13431408_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
OutPort_13230150_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 2
InPort_13313121_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
OutPort_13230202_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
InPort_13230202_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
OutPort_13370341_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
InPort_13370341_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
OutPort_13230212_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
InPort_13230212_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
OutPort_13370343_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
InPort_13370343_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
OutPort_13230225_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
InPort_13230225_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
OutPort_13313141_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
InPort_13230281_0 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
OutPort_13370368_2 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 9
InPort_13370370_2 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
OutPort_13230281_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 9
InPort_13230291_0 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
OutPort_13370370_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 9
InPort_13313143_2 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
OutPort_13230291_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 9
InPort_13230585_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
OutPort_13230647_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
InPort_13231009_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
OutPort_13230585_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
InPort_13230608_0 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
OutPort_13231166_2 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 9
InPort_13231169_2 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
OutPort_13230608_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 9
InPort_13230643_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
OutPort_13284003_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
InPort_13230647_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
OutPort_13230643_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
InPort_13283785_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
OutPort_13230670_0 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 9
InPort_13230670_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
OutPort_13231169_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 9
InPort_13313141_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
OutPort_13231009_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
InPort_13231166_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
OutPort_13231164_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 9
InPort_13231164_2 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
OutPort_13313143_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 9
InPort_13242452_1 | SINK | PIPE | HEATING
OutPort_13242452_2 | SOURCE | PIPE | HEATING
InPort_13242454_1 | SINK | PIPE | HEATING
OutPort_13242454_2 | SOURCE | PIPE | HEATING
InPort_13242456_1 | SINK | PIPE | HEATING
OutPort_13242456_2 | SOURCE | PIPE | HEATING
InPort_13242458_1 | SINK | PIPE | HEATING
OutPort_13242458_2 | SOURCE | PIPE | HEATING
InPort_13242460_1 | SINK | PIPE | HEATING
OutPort_13242460_2 | SOURCE | PIPE | HEATING
InPort_13242462_1 | SINK | PIPE | HEATING
OutPort_13242462_2 | SOURCE | PIPE | HEATING
InPort_13242464_1 | SINK | PIPE | HEATING
OutPort_13242464_2 | SOURCE | PIPE | HEATING
InPort_13242894_0 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 4
OutPort_13391658_2 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 4
InPort_13390736_2 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 4
OutPort_13242894_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 4
InPort_13391696_2 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 7
OutPort_13242964_0 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 7
InPort_13242964_1 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 7
OutPort_13390757_2 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 7
Port_13243310_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13243338_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13243321_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13243334_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13243321_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13243338_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
InPort_13243426_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13243405_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13243422_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13243414_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13243414_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13243426_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
Port_13243631_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13243653_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13243639_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13243649_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13243639_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13243653_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
InPort_13243662_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13243682_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13243670_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13243678_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13243682_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13243670_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13243698_0 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 5
OutPort_13278422_1 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 5
InPort_13278424_2 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 5
OutPort_13243698_1 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 5
InPort_13278422_2 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 5
OutPort_13243707_0 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 5
InPort_13243707_1 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 5
OutPort_13245774_1 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 5
InPort_13245774_2 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 5
OutPort_13243717_0 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 5
InPort_13243717_1 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 5
OutPort_13245776_2 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 5
InPort_13278388_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 5
OutPort_13243807_0 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 5
InPort_13243807_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 5
OutPort_13278390_2 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 5
InPort_13243816_0 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 6
OutPort_13278483_1 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 6
InPort_13278485_3 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 13
OutPort_13243816_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 13
InPort_13278456_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 6
OutPort_13243825_0 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 6
InPort_13243825_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 6
OutPort_13278458_2 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 6
InPort_13243909_0 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 5
OutPort_13245549_2 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 5
InPort_13245551_2 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 5
OutPort_13243909_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 5
InPort_13245615_2 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 6
OutPort_13243927_0 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 6
InPort_13243927_1 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 6
OutPort_13245617_2 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 6
InPort_13243936_0 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 6
OutPort_13245517_2 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 6
InPort_13245519_2 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 6
OutPort_13243936_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 6
InPort_13245549_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 5
OutPort_13243959_0 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 5
InPort_13243959_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 5
OutPort_13278388_2 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 5
InPort_13278483_2 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 6
OutPort_13243968_0 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 6
InPort_13243968_1 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 6
OutPort_13245615_1 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 6
InPort_13243977_0 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 6
OutPort_13278456_2 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 6
InPort_13245517_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 6
OutPort_13243977_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 6
InPort_13390594_2 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 4
OutPort_13245479_0 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 4
InPort_13245479_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 4
OutPort_13390738_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 4
Port_13245487_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 13
Port_13322055_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 13
Port_13245487_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 13
InPort_13245511_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 6
OutPort_13245519_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 6
InPort_12903825_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 5
OutPort_13245543_0 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 5
InPort_13245543_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 5
OutPort_13245551_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 5
InPort_13245609_0 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 6
OutPort_12903824_2 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 6
InPort_13245617_1 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 6
OutPort_13245609_1 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 6
InPort_13245639_0 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 7
OutPort_13390629_2 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 7
InPort_13390759_1 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 7
OutPort_13245639_1 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 7
Port_13245647_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 12
Port_13322057_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 12
Port_13245647_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 12
InPort_13245776_1 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 5
OutPort_13245768_1 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 5
InPort_13246705_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
OutPort_13246021_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
InPort_13246021_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
OutPort_13246707_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
Port_13246121_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246121_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246148_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246130_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13338006_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246130_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246148_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246150_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246150_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246585_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246168_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13338014_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246168_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13278560_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13246223_3 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13246221_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13246221_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13284081_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246223_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13409966_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246223_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13409968_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246224_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13282940_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246224_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13409968_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246268_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13246455_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13246268_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13349216_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13246277_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13246455_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13246277_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13246295_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13246295_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13246959_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13246304_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13337953_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13246304_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13337957_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13246322_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13246940_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13246322_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13246436_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13409951_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13246436_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13349174_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13246438_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246581_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246438_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246585_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246581_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13348896_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246581_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246582_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246582_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13409966_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13246940_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13246962_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13246959_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13337312_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13246962_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13337953_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
InPort_13247000_0 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
OutPort_13247002_3 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 26
InPort_13283825_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
OutPort_13247000_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13247002_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13409951_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13247002_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13409953_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13247003_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282968_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13247003_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13409953_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
InPort_13247196_0 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13409887_1 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13409891_2 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13247196_1 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13247213_0 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13247221_1 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13247229_1 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13247213_1 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13247221_2 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13247444_0 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13247223_0 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13316334_2 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13247223_1 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13248316_1 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13250563_0 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13247229_2 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13247231_0 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13248456_2 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13247231_1 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13248324_2 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13247243_0 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13248456_1 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13247243_1 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13335582_1 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13247444_1 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13247475_2 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13247454_0 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13247471_2 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13247475_1 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13247454_1 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13247465_0 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13409891_1 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13247471_1 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13247465_1 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13248314_0 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13248316_2 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13248314_1 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13248324_1 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13248473_0 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13335549_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13248540_1 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13248473_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13248528_2 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13248482_0 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13248482_1 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13248540_2 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13316332_2 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13248491_0 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13248491_1 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13248526_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13248519_1 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13248500_0 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13248500_1 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13278355_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13248509_0 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13248519_2 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13248683_2 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13248509_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13248526_2 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13248524_0 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13248524_1 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13248528_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13248743_2 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13248603_0 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13248603_1 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13248747_2 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13248612_0 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13248683_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13248685_2 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13248612_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13248747_1 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13248643_0 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13248643_1 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13248685_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13283860_1 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13248737_0 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13248737_1 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13248743_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
Port_13248841_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13281016_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248841_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13313715_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248848_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13281016_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248848_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13250355_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248858_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13250355_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248858_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13249051_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248879_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13249051_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248879_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13249356_3 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248901_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248907_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248901_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13283163_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248907_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13249357_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248951_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248988_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248951_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248965_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248959_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248965_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248959_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248980_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248988_3 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248980_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13249000_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248988_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13348757_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248992_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13249000_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13248992_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13249043_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13249051_3 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13249043_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13249349_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13349317_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13249349_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13349321_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13249356_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13348871_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13249356_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13249357_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13249480_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13250463_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249480_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13250105_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249507_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13250029_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249507_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13250463_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249534_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249701_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249534_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13283128_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249543_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249800_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249543_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249552_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249816_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249552_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249818_3 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249561_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249816_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249561_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249701_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249731_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249730_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13348848_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249730_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249731_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249730_3 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13250030_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249800_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249807_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249807_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249818_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249818_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13348701_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249819_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13349282_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249819_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13349286_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249996_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13250029_3 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13249996_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13250029_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13250030_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13250085_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13250105_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13250085_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
InPort_13250099_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13310524_2 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13250377_0 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13250621_1 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13250623_2 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13250377_1 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13250621_2 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13250386_0 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13250386_1 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13250572_2 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13250738_2 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13250476_0 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13250476_1 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13250540_2 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13250485_0 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13250738_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13250740_2 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13250485_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13250528_0 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13250530_3 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13250540_1 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13250528_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13250530_1 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13316332_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13250531_0 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13250530_2 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13278355_2 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13250531_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13250560_0 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13250562_3 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13250572_1 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13250560_1 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13250562_1 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13316334_1 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13250562_2 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13250563_1 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13314044_2 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13250615_0 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13250615_1 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13250623_1 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13314046_2 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13250732_0 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13250732_1 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13250740_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
Port_13250941_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13250949_3 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13250941_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13250959_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13250949_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13250950_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13250953_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13250959_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13250953_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13250996_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13250988_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13250996_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13250988_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13253835_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13431543_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13253835_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13431564_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13253861_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13253861_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13253882_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13253870_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13431604_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13253870_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13253882_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13254102_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409031_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13254102_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409116_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
OutPort_13255628_1 | SOURCE | PIPE | HEATING
InPort_13255628_2 | SINK | PIPE | HEATING
Port_13255704_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13255710_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13255704_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13255710_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13255711_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13255719_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13255727_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13255719_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13255727_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13255728_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13255797_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447459_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13255812_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447442_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
OutPort_13256670_1 | SOURCE | PIPE | HEATING
InPort_13256670_2 | SINK | PIPE | HEATING
Port_13256696_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13256738_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13256696_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13256698_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13256719_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13256698_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13256719_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13372828_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13256738_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13372809_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
OutPort_13259487_1 | SOURCE | PIPE | HEATING
InPort_13259487_2 | SINK | PIPE | HEATING
Port_13259574_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13259734_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13259599_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13259754_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13259734_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13259735_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13259754_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13259755_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13259804_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13444537_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13259804_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13313442_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13259883_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13445637_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13259883_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13444537_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
InPort_13260028_0 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13444559_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13313444_2 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13260028_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13260092_0 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13445649_2 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13444559_2 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13260092_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13260191_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13260201_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13260191_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13260573_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13260201_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13260343_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13260343_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13444381_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13260351_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13444417_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13260351_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13445631_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
InPort_13260394_0 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13444453_2 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13445643_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13260394_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13444371_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13260449_0 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13260449_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13313485_2 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13304565_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13260457_0 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13260457_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13304325_2 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13313485_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13260533_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13260533_2 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13313499_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13260573_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13304051_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13260922_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13427273_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13260922_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13427277_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13260942_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13358278_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13260942_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13358282_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13260989_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13261012_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13260989_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13326987_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13261006_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13261012_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13261006_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13261480_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13427284_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13261480_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13427288_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13261500_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13408161_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13261500_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13408165_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13261508_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13261557_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13261508_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13326935_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13261551_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13261557_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13261551_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13267106_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267131_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267106_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267131_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267149_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267140_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13269156_3 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267140_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267149_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13269156_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267223_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268435_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267223_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267227_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267227_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267267_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267267_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267502_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267275_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13380720_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267275_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267487_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13380716_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267487_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13380720_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267500_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267502_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267500_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13380716_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13267560_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13267659_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13267560_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13267793_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13267569_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13267667_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13267569_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13267578_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13267667_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13267578_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13267669_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13267657_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13267659_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13267657_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13267669_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13267778_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13267797_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13267778_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13289589_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13267793_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268666_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13267797_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268620_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268091_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268233_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268091_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268100_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13269135_3 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268100_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268233_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13269136_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268418_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268444_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268418_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268452_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268431_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268435_3 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268431_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268441_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268432_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268441_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268432_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268444_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268435_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268436_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268436_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13289622_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268446_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268452_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268446_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268462_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268454_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268462_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268454_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13268498_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268528_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268498_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268526_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268516_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268526_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268516_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268528_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268565_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268565_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268669_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268613_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268665_3 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268613_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268669_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268620_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268665_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268665_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13268666_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13269135_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340100_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13269135_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13269136_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13269156_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340371_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13271095_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13289622_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13271095_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13289626_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13271140_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13289589_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13271140_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13289591_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13271183_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340355_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13271183_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340359_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13271191_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340359_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13271191_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13271207_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13271201_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13271207_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13271201_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13271406_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13271387_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13271410_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13271387_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13271404_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13271406_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13271404_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13271410_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13271522_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13271633_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13271522_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13271560_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13271598_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13271560_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13271629_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13271569_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13271609_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13271569_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13271598_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13271578_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13271609_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13271578_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340364_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13271627_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13271629_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13271627_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13271633_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13273383_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13273777_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13273383_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13384501_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13273777_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13393735_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13273859_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13435928_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13273859_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13273861_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13435938_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13273861_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13274443_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13435904_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13274443_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13274471_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13435916_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13274471_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13277688_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13278560_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13277688_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13278378_0 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 5
OutPort_13278380_3 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 5
InPort_13278390_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 5
OutPort_13278378_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 5
Port_13278380_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 21
Port_13278381_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 21
