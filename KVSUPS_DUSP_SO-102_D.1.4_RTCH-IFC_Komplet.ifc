Properties of the parts of a building model (IFC4), part 59 of 72

# IfcPipeSegment: Typy trubek:Kompozit PE-Xa_RAUTITAN flex (676)
Name (Typy trubek:Kompozit PE-Xa_RAUTITAN flex:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Relativní drsnost | Sklon | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Typ systému | Drsnost (mm) | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group
13080110 | -1.PP_SO-102 | 287.336 | 0.000201032 | 0.0144431 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -4065.8 | RAU–PE–Xa | 16 | 552 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0398 | 0398 | no | HT_vratné vodní (45 °C) 1
13080132 | -1.PP_SO-102 | 297.712 | 0.000201032 | 0.0149647 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -4065.8 | RAU–PE–Xa | 16 | 551 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0399 | 0399 | no | HT_vratné vodní (45 °C) 1
13080143 | -1.PP_SO-102 | 310.919 | 0.000201032 | 0.0156285 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -4065.8 | RAU–PE–Xa | 16 | 313 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0400 | 0400 | no | HT_vratné vodní (45 °C) 1
13080154 | -1.PP_SO-102 | 5624.95 | 0.000201032 | 0.282741 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -4065.8 | RAU–PE–Xa | 16 | 548 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0401 | 0401 | no | HT_vratné vodní (45 °C) 1
13081468 | 2.NP_SO-102 | 7486.18 | 0.000201032 | 0.376297 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 463 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0409 | 0409 | no | HT_vratné vodní (45 °C) 1
13081490 | 2.NP_SO-102 | 234.063 | 0.000201032 | 0.0117653 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 381 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0410 | 0410 | no | HT_vratné vodní (45 °C) 1
13081501 | 2.NP_SO-102 | 227.713 | 0.000201032 | 0.0114461 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 382 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0411 | 0411 | no | HT_vratné vodní (45 °C) 1
13081512 | 2.NP_SO-102 | 227.713 | 0.000201032 | 0.0114461 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 383 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0412 | 0412 | no | HT_vratné vodní (45 °C) 1
13081523 | 2.NP_SO-102 | 234.062 | 0.000201032 | 0.0117653 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 378 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0413 | 0413 | no | HT_vratné vodní (45 °C) 1
13081770 | 2.NP_SO-102 | 7256.48 | 0.000201032 | 0.364751 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 381 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0415 | 0415 | no | HT_vratné vodní (45 °C) 1
13081835 | 2.NP_SO-102 | 3808.27 | 0.000201032 | 0.191425 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 380 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0416 | 0416 | no | HT_vratné vodní (45 °C) 1
13082117 | 2.NP_SO-102 | 234.063 | 0.000201032 | 0.0117653 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 268 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0419 | 0419 | no | HT_vratné vodní (45 °C) 1
13082128 | 2.NP_SO-102 | 227.713 | 0.000201032 | 0.0114461 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 2 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0420 | 0420 | no | HT_vratné vodní (45 °C) 1
13082150 | 2.NP_SO-102 | 234.062 | 0.000201032 | 0.0117653 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 448 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0421 | 0421 | no | HT_vratné vodní (45 °C) 1
13082161 | 2.NP_SO-102 | 6731.51 | 0.000201032 | 0.338363 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 680 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0422 | 0422 | no | HT_vratné vodní (45 °C) 1
13082478 | 2.NP_SO-102 | 234.063 | 0.000201032 | 0.0117653 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 275 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0423 | 0423 | no | HT_vratné vodní (45 °C) 1
13082489 | 2.NP_SO-102 | 227.713 | 0.000201032 | 0.0114461 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 276 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0424 | 0424 | no | HT_vratné vodní (45 °C) 1
13082511 | 2.NP_SO-102 | 4346.67 | 0.000201032 | 0.218487 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 554 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0425 | 0425 | no | HT_vratné vodní (45 °C) 1
13082742 | 2.NP_SO-102 | 480.569 | 0.000201032 | 0.024156 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 273 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0429 | 0429 | no | HT_vratné vodní (45 °C) 1
13082797 | 2.NP_SO-102 | 2501.13 | 0.000201032 | 0.125721 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 272 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0430 | 0430 | no | HT_vratné vodní (45 °C) 1
13082891 | 2.NP_SO-102 | 1594.43 | 0.000201032 | 0.0801448 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 272 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0431 | 0431 | no | HT_vratné vodní (45 °C) 1
13082895 | 2.NP_SO-102 | 7816.2 | 0.000201032 | 0.392885 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 275 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0432 | 0432 | no | HT_vratné vodní (45 °C) 1
13083071 | 2.NP_SO-102 | 1674.06 | 0.000201032 | 0.0841476 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3944.2 | RAU–PE–Xa | 16 | 597 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0434 | 0434 | no | HT_vratné vodní (45 °C) 1
13083084 | 2.NP_SO-102 | 2440.87 | 0.000201032 | 0.122692 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3944.2 | RAU–PE–Xa | 16 | 597 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0435 | 0435 | no | HT_vratné vodní (45 °C) 1
13083397 | 4.NP_SO-102 | 2467.86 | 0.000201032 | 0.124048 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11944.2 | RAU–PE–Xa | 16 | 287 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0440 | 0440 | no | HT_vratné vodní (45 °C) 1
13083408 | 4.NP_SO-102 | 2374.06 | 0.000201032 | 0.119333 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11944.2 | RAU–PE–Xa | 16 | 287 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0441 | 0441 | no | HT_vratné vodní (45 °C) 1
13083482 | 3.NP_SO-102 | 1674.06 | 0.000201032 | 0.0841476 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7944.2 | RAU–PE–Xa | 16 | 696 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0442 | 0442 | no | HT_vratné vodní (45 °C) 1
13083493 | 3.NP_SO-102 | 2449.93 | 0.000201032 | 0.123147 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7944.2 | RAU–PE–Xa | 16 | 696 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0443 | 0443 | no | HT_vratné vodní (45 °C) 1
13083640 | 1.NP_SO-102 | 1675.65 | 0.000201032 | 0.0842271 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -55.8 | RAU–PE–Xa | 16 | 284 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0446 | 0446 | no | HT_vratné vodní (45 °C) 1
13083651 | 1.NP_SO-102 | 2465.01 | 0.000201032 | 0.123905 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -55.8 | RAU–PE–Xa | 16 | 284 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0447 | 0447 | no | HT_vratné vodní (45 °C) 1
13083928 | 2.NP_SO-102 | 864.063 | 0.000201032 | 0.0434325 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3944.2 | RAU–PE–Xa | 16 | 673 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0448 | 0448 | no | HT_vratné vodní (45 °C) 1
13084215 | 2.NP_SO-102 | 2464.06 | 0.000201032 | 0.123857 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 3 | 3944.2 | RAU–PE–Xa | 16 | 1 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0451 | 0451 | no | HT_přívodní vodní (45 °C) 2; HT_přívodní vodní (55 °C) 3
13085287 | -1.PP_SO-102 | 454.905 | 0.000201032 | 0.022866 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -4065.8 | RAU–PE–Xa | 16 | 838 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0458 | 0458 | no | HT_vratné vodní (45 °C) 1
13085708 | 1.NP_SO-102 | 7514.81 | 0.000201032 | 0.377736 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 455 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0459 | 0459 | no | HT_vratné vodní (45 °C) 1
13085719 | 1.NP_SO-102 | 376.712 | 0.000201032 | 0.0189356 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 456 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0460 | 0460 | no | HT_vratné vodní (45 °C) 1
13085730 | 1.NP_SO-102 | 341.275 | 0.000201032 | 0.0171544 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 4 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0461 | 0461 | no | HT_vratné vodní (45 °C) 1
13085741 | 1.NP_SO-102 | 730.044 | 0.000201032 | 0.036696 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 556 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0462 | 0462 | no | HT_vratné vodní (45 °C) 1
13085752 | 1.NP_SO-102 | 566.962 | 0.000201032 | 0.0284986 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 458 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0463 | 0463 | no | HT_vratné vodní (45 °C) 1
13085763 | 1.NP_SO-102 | 1419.53 | 0.000201032 | 0.0713531 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 457 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0464 | 0464 | no | HT_vratné vodní (45 °C) 1
13085774 | 1.NP_SO-102 | 274.063 | 0.000201032 | 0.0137759 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 371 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0465 | 0465 | no | HT_vratné vodní (45 °C) 1
13085809 | 1.NP_SO-102 | 274.062 | 0.000201032 | 0.0137759 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 564 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0466 | 0466 | no | HT_vratné vodní (45 °C) 1
13085820 | 1.NP_SO-102 | 267.712 | 0.000201032 | 0.0134567 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 567 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0467 | 0467 | no | HT_vratné vodní (45 °C) 1
13085831 | 1.NP_SO-102 | 267.713 | 0.000201032 | 0.0134567 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 578 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0468 | 0468 | no | HT_vratné vodní (45 °C) 1
13085871 | 1.NP_SO-102 | 7627.11 | 0.000201032 | 0.38338 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 556 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0469 | 0469 | no | HT_vratné vodní (45 °C) 1
13085884 | 1.NP_SO-102 | 153.425 | 0.000201032 | 0.00771198 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 454 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0470 | 0470 | no | HT_vratné vodní (45 °C) 1
13085965 | 1.NP_SO-102 | 2115.15 | 0.000201032 | 0.106319 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 4 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0471 | 0471 | no | HT_vratné vodní (45 °C) 1
13085977 | 1.NP_SO-102 | 383.062 | 0.000201032 | 0.0192548 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 455 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0472 | 0472 | no | HT_vratné vodní (45 °C) 1
13086261 | 1.NP_SO-102 | 6823.46 | 0.000201032 | 0.342985 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 574 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0473 | 0473 | no | HT_vratné vodní (45 °C) 1
13086272 | 1.NP_SO-102 | 1018.97 | 0.000201032 | 0.0512192 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 575 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0474 | 0474 | no | HT_vratné vodní (45 °C) 1
13086317 | 1.NP_SO-102 | 4205.72 | 0.000201032 | 0.211403 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 371 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0475 | 0475 | no | HT_vratné vodní (45 °C) 1
13086380 | 1.NP_SO-102 | 3625.68 | 0.000201032 | 0.182247 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 564 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0476 | 0476 | no | HT_vratné vodní (45 °C) 1
13086557 | 1.NP_SO-102 | 214.16 | 0.000201032 | 0.0107648 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 562 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0477 | 0477 | no | HT_vratné vodní (45 °C) 1
13086572 | 1.NP_SO-102 | 1059.67 | 0.000201032 | 0.0532649 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 572 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0478 | 0478 | no | HT_vratné vodní (45 °C) 1
13086817 | 1.NP_SO-102 | 255.425 | 0.000201032 | 0.0128391 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 21 | -55.8 | RAU–PE–Xa | 16 | 44 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0479 | 0479 | no | HT_přívodní vodní (65 °C) 21
13086858 | 1.NP_SO-102 | 4161.21 | 0.000201032 | 0.209165 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 568 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0480 | 0480 | no | HT_vratné vodní (45 °C) 1
13086862 | 1.NP_SO-102 | 344.063 | 0.000201032 | 0.0172945 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 575 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0481 | 0481 | no | HT_vratné vodní (45 °C) 1
13086881 | 1.NP_SO-102 | 194.063 | 0.000201032 | 0.00975465 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 4 | -55.8 | RAU–PE–Xa | 16 | 1 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0482 | 0482 | no | HT_přívodní vodní (65 °C) 21; HT_přívodní vodní (55 °C) 4
13087119 | 1.NP_SO-102 | 6913.22 | 0.000201032 | 0.347497 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 599 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0487 | 0487 | no | HT_vratné vodní (45 °C) 1
13087545 | 1.NP_SO-102 | 124.063 | 0.000201032 | 0.00623606 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 599 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0490 | 0490 | no | HT_vratné vodní (45 °C) 1
13087567 | 1.NP_SO-102 | 281.066 | 0.000201032 | 0.0141279 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 25 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0491 | 0491 | no | HT_vratné vodní (45 °C) 1
13087578 | 1.NP_SO-102 | 274.063 | 0.000201032 | 0.0137759 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 602 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0492 | 0492 | no | HT_vratné vodní (45 °C) 1
13087854 | 1.NP_SO-102 | 8222.86 | 0.000201032 | 0.413326 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 602 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0493 | 0493 | no | HT_vratné vodní (45 °C) 1
13087922 | 1.NP_SO-102 | 1210.69 | 0.000201032 | 0.060856 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 605 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0494 | 0494 | no | HT_vratné vodní (45 °C) 1
13089046 | -1.PP_SO-102 | 540.713 | 0.000201032 | 0.0271792 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -4055.8 | RAU–PE–Xa | 16 | 30 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0505 | 0505 | no | HT_přívodní vodní (55 °C) 9
13089091 | -1.PP_SO-102 | 390.712 | 0.000201032 | 0.0196394 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -4055.8 | RAU–PE–Xa | 16 | 323 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0507 | 0507 | no | HT_vratné vodní (45 °C) 1
13089314 | 3.NP_SO-102 | 3825.1 | 0.000201032 | 0.192271 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 22 | 7944.2 | RAU–PE–Xa | 16 | 17 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0509 | 0509 | no | HT_přívodní vodní (65 °C) 22
13089332 | 3.NP_SO-102 | 333.063 | 0.000201032 | 0.0167415 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 334 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0510 | 0510 | no | HT_vratné vodní (45 °C) 1
13089354 | 3.NP_SO-102 | 326.713 | 0.000201032 | 0.0164224 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 333 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0511 | 0511 | no | HT_vratné vodní (45 °C) 1
13089365 | 3.NP_SO-102 | 333.062 | 0.000201032 | 0.0167415 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 332 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0512 | 0512 | no | HT_vratné vodní (45 °C) 1
13089376 | 3.NP_SO-102 | 6472.59 | 0.000201032 | 0.325348 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 336 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0513 | 0513 | no | HT_vratné vodní (45 °C) 1
13089517 | 3.NP_SO-102 | 8120.73 | 0.000201032 | 0.408192 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 332 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0516 | 0516 | no | HT_vratné vodní (45 °C) 1
13092527 | 3.NP_SO-102 | 333.063 | 0.000201032 | 0.0167415 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 358 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0536 | 0536 | no | HT_vratné vodní (45 °C) 1
13092549 | 3.NP_SO-102 | 326.713 | 0.000201032 | 0.0164224 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 360 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0537 | 0537 | no | HT_vratné vodní (45 °C) 1
13092560 | 3.NP_SO-102 | 326.712 | 0.000201032 | 0.0164224 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 359 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0538 | 0538 | no | HT_vratné vodní (45 °C) 1
13092571 | 3.NP_SO-102 | 333.062 | 0.000201032 | 0.0167415 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 7 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0539 | 0539 | no | HT_vratné vodní (45 °C) 1
13092582 | 3.NP_SO-102 | 6540.06 | 0.000201032 | 0.328739 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 468 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0540 | 0540 | no | HT_vratné vodní (45 °C) 1
13092673 | 3.NP_SO-102 | 7153.34 | 0.000201032 | 0.359566 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 358 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0541 | 0541 | no | HT_vratné vodní (45 °C) 1
13092677 | 3.NP_SO-102 | 3825.1 | 0.000201032 | 0.192271 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 357 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0542 | 0542 | no | HT_vratné vodní (45 °C) 1
13092840 | 3.NP_SO-102 | 4240.8 | 0.000201032 | 0.213166 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 740 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0543 | 0543 | no | HT_vratné vodní (45 °C) 1
13092873 | 3.NP_SO-102 | 2684.06 | 0.000201032 | 0.134916 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 751 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0544 | 0544 | no | HT_vratné vodní (45 °C) 1
13092884 | 3.NP_SO-102 | 2517.71 | 0.000201032 | 0.126554 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 754 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0545 | 0545 | no | HT_vratné vodní (45 °C) 1
13092897 | 3.NP_SO-102 | 134.063 | 0.000201032 | 0.00673872 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 743 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0546 | 0546 | no | HT_vratné vodní (45 °C) 1
13092908 | 3.NP_SO-102 | 124.992 | 0.000201032 | 0.00628278 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 746 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0547 | 0547 | no | HT_vratné vodní (45 °C) 1
13093009 | 3.NP_SO-102 | 6142.2 | 0.000201032 | 0.308741 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 749 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0548 | 0548 | no | HT_vratné vodní (45 °C) 1
13093030 | 3.NP_SO-102 | 3484.28 | 0.000201032 | 0.175139 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 751 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0549 | 0549 | no | HT_vratné vodní (45 °C) 1
13093043 | 3.NP_SO-102 | 2658.19 | 0.000201032 | 0.133615 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 741 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0550 | 0550 | no | HT_vratné vodní (45 °C) 1
13093548 | 3.NP_SO-102 | 824.062 | 0.000201032 | 0.0414219 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7944.2 | RAU–PE–Xa | 16 | 350 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0555 | 0555 | no | HT_vratné vodní (45 °C) 1
13093863 | 3.NP_SO-102 | 2424.06 | 0.000201032 | 0.121847 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 7944.2 | RAU–PE–Xa | 16 | 299 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0561 | 0561 | no | HT_přívodní vodní (55 °C) 9
13094360 | 1.NP_SO-102 | 823.84 | 0.000201032 | 0.0414107 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 437 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0566 | 0566 | no | HT_vratné vodní (45 °C) 1
13094767 | 1.NP_SO-102 | 2424.06 | 0.000201032 | 0.121847 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -65.8 | RAU–PE–Xa | 16 | 306 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0569 | 0569 | no | HT_přívodní vodní (55 °C) 9
13095210 | 4.NP_SO-102 | 329.677 | 0.000201032 | 0.0165714 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 393 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0573 | 0573 | no | HT_vratné vodní (45 °C) 1
13095232 | 4.NP_SO-102 | 327.713 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 395 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0574 | 0574 | no | HT_vratné vodní (45 °C) 1
13095243 | 4.NP_SO-102 | 334.063 | 0.000201032 | 0.0167918 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 757 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0575 | 0575 | no | HT_vratné vodní (45 °C) 1
13095276 | 4.NP_SO-102 | 819.985 | 0.000201032 | 0.0412169 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 481 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0576 | 0576 | no | HT_vratné vodní (45 °C) 1
13095474 | 4.NP_SO-102 | 5473.9 | 0.000201032 | 0.275148 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 393 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0577 | 0577 | no | HT_vratné vodní (45 °C) 1
13095600 | 4.NP_SO-102 | 7438.85 | 0.000201032 | 0.373918 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 482 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0578 | 0578 | no | HT_vratné vodní (45 °C) 1
13097657 | 4.NP_SO-102 | 334.063 | 0.000201032 | 0.0167918 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 410 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0601 | 0601 | no | HT_vratné vodní (45 °C) 1
13097668 | 4.NP_SO-102 | 327.713 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 788 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0602 | 0602 | no | HT_vratné vodní (45 °C) 1
13097679 | 4.NP_SO-102 | 6002.49 | 0.000201032 | 0.301718 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 410 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0603 | 0603 | no | HT_vratné vodní (45 °C) 1
13097690 | 4.NP_SO-102 | 350 | 0.000201032 | 0.0175929 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 22 | 11934.2 | RAU–PE–Xa | 16 | 1 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0604 | 0604 | no | HT_vratné vodní (45 °C) 22
13097712 | 4.NP_SO-102 | 2799.57 | 0.000201032 | 0.140722 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 785 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0605 | 0605 | no | HT_vratné vodní (45 °C) 1
13097758 | 4.NP_SO-102 | 6565.42 | 0.000201032 | 0.330014 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 810 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0606 | 0606 | no | HT_vratné vodní (45 °C) 1
13098035 | 4.NP_SO-102 | 6565.42 | 0.000201032 | 0.330014 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 2 | 11944.2 | RAU–PE–Xa | 16 | 31 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0607 | 0607 | no | HT_přívodní vodní (65 °C) 2
13098081 | 4.NP_SO-102 | 14521.3 | 0.000201032 | 0.729918 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 813 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0608 | 0608 | no | HT_vratné vodní (45 °C) 1
13098162 | 4.NP_SO-102 | 515.662 | 0.000201032 | 0.02592 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 815 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0609 | 0609 | no | HT_vratné vodní (45 °C) 1
13098389 | 4.NP_SO-102 | 509.312 | 0.000201032 | 0.0256008 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 814 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0610 | 0610 | no | HT_vratné vodní (45 °C) 1
13098614 | 4.NP_SO-102 | 2735.66 | 0.000201032 | 0.137509 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 778 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0611 | 0611 | no | HT_vratné vodní (45 °C) 1
13098678 | 4.NP_SO-102 | 334.063 | 0.000201032 | 0.0167918 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 785 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0612 | 0612 | no | HT_vratné vodní (45 °C) 1
13099399 | 4.NP_SO-102 | 1324.06 | 0.000201032 | 0.0665546 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11944.2 | RAU–PE–Xa | 16 | 422 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0617 | 0617 | no | HT_vratné vodní (45 °C) 1
13099449 | 4.NP_SO-102 | 2984.06 | 0.000201032 | 0.149995 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 11944.2 | RAU–PE–Xa | 16 | 335 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0618 | 0618 | no | HT_přívodní vodní (55 °C) 9
13099869 | 2.NP_SO-102 | 334.063 | 0.000201032 | 0.0167918 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 3934.2 | RAU–PE–Xa | 16 | 347 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0624 | 0624 | no | HT_vratné vodní (45 °C) 13
13099880 | 2.NP_SO-102 | 327.712 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 3934.2 | RAU–PE–Xa | 16 | 4 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0625 | 0625 | no | HT_vratné vodní (45 °C) 13
13099891 | 2.NP_SO-102 | 334.062 | 0.000201032 | 0.0167918 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 3934.2 | RAU–PE–Xa | 16 | 3 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0626 | 0626 | no | HT_vratné vodní (45 °C) 13
13100035 | 2.NP_SO-102 | 8700.56 | 0.000201032 | 0.437338 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 3934.2 | RAU–PE–Xa | 16 | 3 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0628 | 0628 | no | HT_vratné vodní (45 °C) 13
13100298 | 2.NP_SO-102 | 334.063 | 0.000201032 | 0.0167918 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 3934.2 | RAU–PE–Xa | 16 | 26 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0629 | 0629 | no | HT_vratné vodní (45 °C) 13
13100309 | 2.NP_SO-102 | 7725.1 | 0.000201032 | 0.388306 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 3934.2 | RAU–PE–Xa | 16 | 24 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0630 | 0630 | no | HT_vratné vodní (45 °C) 13
13100320 | 2.NP_SO-102 | 327.712 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 3934.2 | RAU–PE–Xa | 16 | 25 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0631 | 0631 | no | HT_vratné vodní (45 °C) 13
13100331 | 2.NP_SO-102 | 334.063 | 0.000201032 | 0.0167918 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 3934.2 | RAU–PE–Xa | 16 | 24 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0632 | 0632 | no | HT_vratné vodní (45 °C) 13
13100342 | 2.NP_SO-102 | 7529.88 | 0.000201032 | 0.378493 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 3934.2 | RAU–PE–Xa | 16 | 18 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0633 | 0633 | no | HT_vratné vodní (45 °C) 13
13101014 | 2.NP_SO-102 | 6510 | 0.000201032 | 0.327228 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 29 | 3944.2 | RAU–PE–Xa | 16 | 1 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0637 | 0637 | no | HT_vratné vodní (45 °C) 29
13101025 | 2.NP_SO-102 | 1359.36 | 0.000201032 | 0.068329 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 29 | 3944.2 | RAU–PE–Xa | 16 | 3 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0638 | 0638 | no | HT_vratné vodní (45 °C) 29
13101109 | 2.NP_SO-102 | 288.725 | 0.000201032 | 0.0145129 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 29 | 3944.2 | RAU–PE–Xa | 16 | 2 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0639 | 0639 | no | HT_vratné vodní (45 °C) 29
13102299 | 1.NP_SO-102 | 334.062 | 0.000201032 | 0.0167918 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 555 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0643 | 0643 | no | HT_vratné vodní (45 °C) 13
13102312 | 1.NP_SO-102 | 6816.52 | 0.000201032 | 0.342636 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 43 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0644 | 0644 | no | HT_vratné vodní (45 °C) 13
13102334 | 1.NP_SO-102 | 327.712 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 44 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0645 | 0645 | no | HT_vratné vodní (45 °C) 13
13102345 | 1.NP_SO-102 | 334.063 | 0.000201032 | 0.0167918 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 43 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0646 | 0646 | no | HT_vratné vodní (45 °C) 13
13102527 | 1.NP_SO-102 | 4234.06 | 0.000201032 | 0.212827 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 555 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0649 | 0649 | no | HT_vratné vodní (45 °C) 13
13102767 | 1.NP_SO-102 | 2328.72 | 0.000201032 | 0.117054 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 7 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0650 | 0650 | no | HT_vratné vodní (45 °C) 13
13102772 | 1.NP_SO-102 | 1370.47 | 0.000201032 | 0.0688872 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 178 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0651 | 0651 | no | HT_vratné vodní (45 °C) 13
13102781 | 1.NP_SO-102 | 1623.74 | 0.000201032 | 0.0816179 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 357 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0652 | 0652 | no | HT_vratné vodní (45 °C) 13
13102878 | 1.NP_SO-102 | 284.063 | 0.000201032 | 0.0142785 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 61 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0653 | 0653 | no | HT_vratné vodní (45 °C) 13
13102889 | 1.NP_SO-102 | 287.713 | 0.000201032 | 0.014462 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 60 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0654 | 0654 | no | HT_vratné vodní (45 °C) 13
13102900 | 1.NP_SO-102 | 287.713 | 0.000201032 | 0.014462 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 59 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0655 | 0655 | no | HT_vratné vodní (45 °C) 13
13102911 | 1.NP_SO-102 | 6888.08 | 0.000201032 | 0.346233 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 373 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0656 | 0656 | no | HT_vratné vodní (45 °C) 13
13102944 | 1.NP_SO-102 | 7664.49 | 0.000201032 | 0.385259 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 58 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0657 | 0657 | no | HT_vratné vodní (45 °C) 13
13103278 | 1.NP_SO-102 | 7014.52 | 0.000201032 | 0.352588 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 54 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0659 | 0659 | no | HT_vratné vodní (45 °C) 13
13103289 | 1.NP_SO-102 | 1339.36 | 0.000201032 | 0.0673237 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 55 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0660 | 0660 | no | HT_vratné vodní (45 °C) 13
13103323 | 1.NP_SO-102 | 289.922 | 0.000201032 | 0.014573 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 52 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0661 | 0661 | no | HT_vratné vodní (45 °C) 13
13103803 | 3.NP_SO-102 | 328.506 | 0.000314112 | 0.0206407 | ø20 mm | 0.000694444 | 0 | 3.NP_SO-102 | -50 | -60 | -60 | -70 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7932.8 | RAU–PE–Xa | 20 | 411 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0669 | 0669 | no | HT_vratné vodní (45 °C) 13
13103814 | 3.NP_SO-102 | 322.156 | 0.000314112 | 0.0202417 | ø20 mm | 0.000694444 | 0 | 3.NP_SO-102 | -50 | -60 | -60 | -70 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7932.8 | RAU–PE–Xa | 20 | 75 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0670 | 0670 | no | HT_vratné vodní (45 °C) 13
13103825 | 3.NP_SO-102 | 328.506 | 0.000314112 | 0.0206407 | ø20 mm | 0.000694444 | 0 | 3.NP_SO-102 | -50 | -60 | -60 | -70 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7932.8 | RAU–PE–Xa | 20 | 74 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0671 | 0671 | no | HT_vratné vodní (45 °C) 13
13103845 | 3.NP_SO-102 | 7600.46 | 0.000314112 | 0.477551 | ø20 mm | 0.000694444 | 0 | 3.NP_SO-102 | -50 | -60 | -60 | -70 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7932.8 | RAU–PE–Xa | 20 | 421 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0673 | 0673 | no | HT_vratné vodní (45 °C) 13
