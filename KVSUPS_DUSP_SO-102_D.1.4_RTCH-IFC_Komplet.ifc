Properties of the parts of a building model (IFC4), part 28 of 72

# IfcSpace: Úklid. vozík B0119:13251561, B0119
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 5.7268 m2
Identifikační data - Číslo: B0119; Číslo místnosti: Neobsazené; Název: Úklid. vozík; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Ústředna EPS B0132.1:13251679, B0132.1
In: -1.PP_SO-102
LongName: Ústředna EPS; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 7.8324 m3; NetVolume: 7.8324 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.0685335; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 21.0768 W; Specifikované výkonové zatížení: 27.3999 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00075855 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 1.9581 m2
Identifikační data - Číslo: B0132.1; Číslo místnosti: Neobsazené; Název: Ústředna EPS; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna B0126.2:13256630, B0126.2
In: -1.PP_SO-102
LongName: Šatna; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 18.2355 m3; NetVolume: 18.2355 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.15956; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 49.0712 W; Specifikované výkonové zatížení: 63.7926 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 20 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00176606 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 4.55886 m2
Identifikační data - Číslo: B0126.2; Číslo místnosti: Neobsazené; Název: Šatna; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Šatna B0132:13251570, B0132
In: -1.PP_SO-102
LongName: Šatna; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 778.681 m3; NetVolume: 778.681 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 6.81346; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 2095.41 W; Specifikované výkonové zatížení: 2724.04 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 22 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0754134 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 194.67 m2
Identifikační data - Číslo: B0132; Číslo místnosti: Neobsazené; Název: Šatna; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna B251.1:13252664, B251.1
In: 2.NP_SO-102
LongName: Šatna; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 12.7986 m3; NetVolume: 12.7986 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.111988; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 34.4407 W; Specifikované výkonové zatížení: 44.7729 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 22 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00123951 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 3.19965 m2
Identifikační data - Číslo: B251.1; Číslo místnosti: Neobsazené; Název: Šatna; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna chlapci B121.2:13364130, B121.2
In: 1.NP_SO-102
LongName: Šatna chlapci; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 45.84 m3; NetVolume: 45.84 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.4011; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 123.354 W; Specifikované výkonové zatížení: 160.361 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 22 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0044395 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 11.46 m2
Identifikační data - Číslo: B121.2; Číslo místnosti: Neobsazené; Název: Šatna chlapci; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Šatna chlapci-1 B0135.1-1:13251591, B0135.1-1
In: -1.PP_SO-102
LongName: Šatna chlapci-1; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 71.0062 m3; NetVolume: 71.0062 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.621304; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 191.076 W; Specifikované výkonové zatížení: 248.399 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 22 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00687678 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 17.7515 m2
Identifikační data - Číslo: B0135.1-1; Číslo místnosti: Neobsazené; Název: Šatna chlapci-1; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna chlapci-2 B0135.1-2:13251603, B0135.1-2
In: -1.PP_SO-102
LongName: Šatna chlapci-2; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; NetVolume: 71.0062 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.142975; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 0 W; Specifikované výkonové zatížení: 0 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.000337383 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm
Identifikační data - Číslo: B0135.1-2; Číslo místnosti: Neobsazené; Název: Šatna chlapci-2; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna dívky-1 B0136.1-1:13251606, B0136.1-1
In: -1.PP_SO-102
LongName: Šatna dívky-1; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 39.84 m3; NetVolume: 39.84 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.3486; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 107.209 W; Specifikované výkonové zatížení: 139.371 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 22 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00385841 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 9.96 m2
Identifikační data - Číslo: B0136.1-1; Číslo místnosti: Neobsazené; Název: Šatna dívky-1; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna dívky-2 B0136.1-2:13251651, B0136.1-2
In: -1.PP_SO-102
LongName: Šatna dívky-2; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; NetVolume: 39.84 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.381281; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 0 W; Specifikované výkonové zatížení: 0 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 22 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.000899724 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm
Identifikační data - Číslo: B0136.1-2; Číslo místnosti: Neobsazené; Název: Šatna dívky-2; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna muži B258.2:13252736, B258.2
In: 2.NP_SO-102
LongName: Šatna muži; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 15.7358 m3; NetVolume: 15.7358 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.137688; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 42.3447 W; Specifikované výkonové zatížení: 55.0481 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 22 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00152398 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 3.93395 m2
Identifikační data - Číslo: B258.2; Číslo místnosti: Neobsazené; Název: Šatna muži; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Šatna ženy B258.5:13252733, B258.5
In: 2.NP_SO-102
LongName: Šatna ženy; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 25.4733 m3; NetVolume: 25.4733 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.222891; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 68.5481 W; Specifikované výkonové zatížení: 89.1125 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 22 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00246703 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 6.36832 m2
Identifikační data - Číslo: B258.5; Číslo místnosti: Neobsazené; Název: Šatna ženy; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Školní kaple-1 B338-1:13185055, B338-1
In: 4.NP_SO-102
LongName: Školní kaple-1; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 64.1267 m3; NetVolume: 64.1267 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.561109; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 172.564 W; Specifikované výkonové zatížení: 224.333 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00621053 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 4.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 4.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 16.0317 m2
Identifikační data - Číslo: B338-1; Číslo místnosti: Neobsazené; Název: Školní kaple-1; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Školní kaple-2 B338-2:13185966, B338-2
In: 3.NP_SO-102
LongName: Školní kaple-2; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 64.1267 m3; NetVolume: 64.1267 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.561109; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 172.564 W; Specifikované výkonové zatížení: 224.333 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00621053 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 3.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 3.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 16.0317 m2
Identifikační data - Číslo: B338-2; Číslo místnosti: Neobsazené; Název: Školní kaple-2; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcBuildingElementProxy: Akumulační nádoba 4 hrdla:Akumulační nádoba, Akumulační nádoba 4 hrdla:Akumulační nádoba:12903865
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - Poloměr: 425 mm; Připojení DN: 100 mm; r: 50 mm; r s izolací: 525 mm; tl.izolace: 100 mm; Výška: 1923 mm; Výška přípojky přívodu: 1662 mm; Výška přípojky zpátečky: 287 mm
Type - Identifikační data - Číslo OmniClass: 23.75.10.37.11; Kód sestavy: ZN01; Nadpis OmniClass: Mechanical-Draft Cooling Towers; Název typu: Akumulační nádoba; Označení typu: 41; Popis sestavy: Stojatý
Type - Jiné - Kategorie: Mechanické zařízení; Izolace: yes; Název rodiny: Akumulační nádoba 4 hrdla
Classification: ZN01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 14.5337 m2; NetVolume: 2.75949 m3
Text - CCI Funkční systém: H; CCI Komponenta: CPA; CCI Technický systém: HC
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 2.NP_SO-102; Hostitel: Podlaží : 2.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Nedefinovaný
Kóty - Objem: 2.75949 m3; Plocha: 7.26683 m2
Identifikační data - ID pozice: 01; ID systému: 3; Kód prvku: ZN01.41.0093; Komentáře: Akumulační nádoba chladu; Označení: 0093
Jiné - Páteřní trasa: yes; Typ: Akumulační nádoba; Id typu: 12846076; Rodina: Akumulační nádoba 4 hrdla; Rodina a typ: Akumulační nádoba 4 hrdla: Akumulační nádoba

# IfcBuildingElementProxy: Akumulační nádoba‍ 6 hrdel:Akumulační nádoba, Akumulační nádoba‍ 6 hrdel:Akumulační nádoba:12903388
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - Poloměr: 425 mm; Připojení DN: 100 mm; r: 50 mm; r s izolací: 525 mm; tl.izolace: 100 mm; Výška: 1923 mm; Výška 2.hrdla: 704 mm; Výška 3.hrdla: 961.5 mm; Výška přípojky přívodu: 1662 mm; Výška přípojky zpátečky: 300 mm
Type - Identifikační data - Číslo OmniClass: 23.75.10.37.11; Kód sestavy: ZN01; Nadpis OmniClass: Mechanical-Draft Cooling Towers; Název typu: Akumulační nádoba; Označení typu: 40; Popis sestavy: Stojatý
Type - Jiné - Kategorie: Mechanické zařízení; Hmotnost zařízení: 0; Izolace: yes; Název rodiny: Akumulační nádoba‍ 6 hrdel
Classification: ZN01 Uniformat (Uniformat); Group: HT_přívodní vodní (55 °C) 1; HT_PRIMÁR_vratné 4; HT_přívodní vodní (45 °C) 3; HT_přívodní vodní (45 °C) 5; HT_přívodní vodní (65 °C) 5
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 14.6279 m2; NetVolume: 2.76106 m3
Text - CCI Funkční systém: H; CCI Komponenta: CPA; CCI Technický systém: HD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 2.NP_SO-102; Hostitel: Podlaží : 2.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Přívod teplé vody,Zpětné vedení teplé vody,Přívod teplé vody; Název systému: HT_přívodní vodní (45 °C) 3,HT_přívodní vodní (55 °C) 1,HT_přívodní vodní (45 °C) 5,HT_PRIMÁR_vratné 4,HT_přívodní vodní (65 °C) 5
Kóty - Objem: 2.76106 m3; Plocha: 7.31395 m2
Identifikační data - ID pozice: 02; ID systému: 3; Kód prvku: ZN01.40.0089; Komentáře: Akumulační nádoba tepla; Označení: 0089
Jiné - Páteřní trasa: yes; Id typu: 12848710; Rodina: Akumulační nádoba‍ 6 hrdel; Rodina a typ: Akumulační nádoba‍ 6 hrdel: Akumulační nádoba; Typ: Akumulační nádoba

# IfcBuildingElementProxy: Deskové otopné těleso - VK připojení spodní pravé:Typ 10/600/500 (3)
Type - Material: <Unnamed>
Type - Text - Typ tělesa: VK 10
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; Jmenovitý poloměr: 7.5 mm; Jmenovitý průměr: 15 mm; Šířka: 61 mm; Výška: 300 mm
Type - Identifikační data - Kód sestavy: OT01; Název typu: Typ 10/600/500; Označení typu: 18; Popis sestavy: Deskové
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Deskové otopné těleso - VK připojení spodní pravé
Classification: OT01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.446167 m2; NetVolume: 0.00941726 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Odsazení od podlahy: 150 mm; Odsazení od stěny: 50 mm
Mechanické - Klasifikace systému: Zpětné vedení teplé vody,Přívod teplé vody; Průtok: 0 m3/s; Q: 0 W; Tlaková ztráta: 0 Pa
Kóty - Objem: 0.00915 m3
Jiné - Rodina: Deskové otopné těleso - VK připojení spodní pravé; Výběr hlavice: Termostatická hlavice.LH; Výběr šroubení: Šroubení pro otopná tělesa typu VK rohové.LH : Připojení tělesa G 1/2; Výběr ventilu: Radiátorový ventil integrovaný.LH : Připojení tělesa G 1/2; Id typu: 12772549; Rodina a typ: Deskové otopné těleso - VK připojení spodní pravé: Typ 10/600/500; Typ: Typ 10/600/500
Name (Deskové otopné těleso - VK připojení spodní pravé:Typ 10/600/500:...) | In | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
12776545 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OT01.18.0021 | 0021
12780892 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | OT01.18.0059 | 0059
12989979 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | OT01.18.0104 | 0104

# IfcBuildingElementProxy: Deskové otopné těleso - VK připojení spodní pravé:Typ 21/600/400 (5)
Type - Material: <Unnamed>
Type - Text - Typ tělesa: VK 21
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - Délka: 400 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; Jmenovitý poloměr: 7.5 mm; Jmenovitý průměr: 15 mm; Šířka: 66 mm; Výška: 600 mm
Type - Identifikační data - Kód sestavy: OT01; Název typu: Typ 21/600/400; Označení typu: 20; Popis sestavy: Deskové
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Deskové otopné těleso - VK připojení spodní pravé
Classification: OT01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.660567 m2; NetVolume: 0.0161073 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Odsazení od podlahy: 150 mm; Odsazení od stěny: 50 mm
Mechanické - Klasifikace systému: Zpětné vedení teplé vody,Přívod teplé vody; Průtok: 0 m3/s; Q: 0 W; Tlaková ztráta: 0 Pa
Kóty - Objem: 0.01584 m3
Jiné - Rodina: Deskové otopné těleso - VK připojení spodní pravé; Výběr hlavice: Termostatická hlavice.LH; Výběr šroubení: Šroubení pro otopná tělesa typu VK rohové.LH : Připojení tělesa G 1/2; Výběr ventilu: Radiátorový ventil integrovaný.LH : Připojení tělesa G 1/2; Id typu: 13019396; Rodina a typ: Deskové otopné těleso - VK připojení spodní pravé: Typ 21/600/400; Typ: Typ 21/600/400
Name (Deskové otopné těleso - VK připojení spodní pravé:Typ 21/600/400:...) | In | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
12780778 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | OT01.20.0057 | 0057
12780835 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | OT01.20.0058 | 0058
13019907 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | OT01.20.0178 | 0178 | Mechanické - Název systému: HT_přívodní vodní (65 °C) 3; Group: HT_přívodní vodní (65 °C) 3
13109617 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | OT01.20.0185 | 0185
13256670 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | OT01.20.0222 | 0222

# IfcBuildingElementProxy: Deskové otopné těleso - VK připojení spodní pravé:Typ 21/600/500 (3)
Type - Material: <Unnamed>
Type - Text - Typ tělesa: VK 21
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; Jmenovitý poloměr: 7.5 mm; Jmenovitý průměr: 15 mm; Šířka: 66 mm; Výška: 600 mm
Type - Identifikační data - Kód sestavy: OT01; Název typu: Typ 21/600/500; Označení typu: 17; Popis sestavy: Deskové
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Deskové otopné těleso - VK připojení spodní pravé
Classification: OT01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.793767 m2; NetVolume: 0.0200673 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Odsazení od podlahy: 150 mm
Mechanické - Klasifikace systému: Zpětné vedení teplé vody,Přívod teplé vody; Průtok: 0 m3/s; Q: 0 W; Tlaková ztráta: 0 Pa
Kóty - Objem: 0.0198 m3
Jiné - Rodina: Deskové otopné těleso - VK připojení spodní pravé; Výběr hlavice: Termostatická hlavice.LH; Výběr šroubení: Šroubení pro otopná tělesa typu VK rohové.LH : Připojení tělesa G 1/2; Výběr ventilu: Radiátorový ventil integrovaný.LH : Připojení tělesa G 1/2; Id typu: 13019490; Rodina a typ: Deskové otopné těleso - VK připojení spodní pravé: Typ 21/600/500; Typ: Typ 21/600/500
Name (Deskové otopné těleso - VK připojení spodní pravé:Typ 21/600/500:...) | In | Podlaží | Hostitel | Odsazení od stěny (mm) | Fáze vytvoření | Kód prvku | Označení
12776532 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 50 | Fáze 1 | OT01.17.0020 | 0020
12780975 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 50 | Fáze 2 | OT01.17.0060 | 0060
12806558 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 55.5606 | Fáze 1 | OT01.17.0073 | 0073

# IfcBuildingElementProxy: Deskové otopné těleso - VK připojení spodní pravé:Typ 21/600/600 (8)
Type - Material: <Unnamed>
Type - Text - Typ tělesa: VK 21
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - Délka: 600 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; Jmenovitý poloměr: 7.5 mm; Jmenovitý průměr: 15 mm; Šířka: 66 mm; Výška: 600 mm
Type - Identifikační data - Kód sestavy: OT01; Název typu: Typ 21/600/600; Označení typu: 13; Popis sestavy: Deskové
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Deskové otopné těleso - VK připojení spodní pravé
Classification: OT01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.926967 m2; NetVolume: 0.0240273 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD
Vazby - Odsazení od hostitele: 0 mm; Odsazení od podlahy: 150 mm; Odsazení od stěny: 50 mm; Výška od podlaží: 0 mm
Mechanické - Klasifikace systému: Zpětné vedení teplé vody,Přívod teplé vody; Průtok: 0 m3/s; Q: 0 W; Tlaková ztráta: 0 Pa
Kóty - Objem: 0.02376 m3
Jiné - Id typu: 12774972; Rodina: Deskové otopné těleso - VK připojení spodní pravé; Rodina a typ: Deskové otopné těleso - VK připojení spodní pravé: Typ 21/600/600; Typ: Typ 21/600/600; Výběr hlavice: Termostatická hlavice.LH; Výběr šroubení: Šroubení pro otopná tělesa typu VK rohové.LH : Připojení tělesa G 1/2; Výběr ventilu: Radiátorový ventil integrovaný.LH : Připojení tělesa G 1/2
Name (Deskové otopné těleso - VK připojení spodní pravé:Typ 21/600/600:...) | In | Hostitel | Podlaží | Fáze vytvoření | Kód prvku | Označení
12775714 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | OT01.13.0013 | 0013
12778082 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 4.NP_SO-102 | Fáze 1 | OT01.13.0033 | 0033
12780760 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 2 | OT01.13.0055 | 0055
12780769 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 2 | OT01.13.0056 | 0056
12780989 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 2 | OT01.13.0061 | 0061
12781052 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 2 | OT01.13.0062 | 0062
12999716 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | OT01.13.0159 | 0159
13299090 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 2 | OT01.13.0230 | 0230

# IfcBuildingElementProxy: Expanzní nádoba:Expanzní nádoba 50 (3)
In: 2.NP_SO-102
Type - Material: Color RGB 128-128-128, Color RGB-000-000-000, Color RGB-250-250-250, Color RGB-160-197-081
Type - Obecné - ETIM Article Class: EC010958; ETIM Name: Membrane pressure expansion vessel
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Materiály a povrchové úpravy - Reflex_item_color: Color RGB 128-128-128
Type - Kóty - D: 441 mm; Délka: 441 mm; DN: 20 mm; H: 492 mm; Jmenovitá velikost vstupu: 20 mm; Šířka: 441 mm; Výška: 492 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.11.14; Color: grey; Connection: R 3/4; Copyright: © CADprofi; Kód sestavy: EN02; Nadpis OmniClass: Expansion Vessels; Název typu: Expanzní nádoba 50; Označení typu: 39; PN: 6 bar; Popis: Membrane pressure expansion vessel; Popis sestavy: Expanzní nádoba; Revision: 2022; Volume: 0.05 m3
Type - Jiné - Kategorie: Mechanické zařízení; VLeg_b: no; VLeg_s: yes; VVent_s: yes; A: 26.9 mm; Ang1: 90 deg; AngVent: 90 deg; B1: 21.5 mm; D1: 409 mm; DL: 191.2 mm; H1: 21 mm; H2: 460 mm; H3: 227 mm; H4: 102.25 mm; HC1: 178.7 mm; HL: 365 mm; LC1: 230 mm; Název rodiny: Expanzní nádoba; Objem: 50 m3; RLG: 170 mm; RN: 340 mm; RO: 5.375 mm; RY: 368.1 mm; Scale: 0.7 mm; VTrans: no; W: 103.9 mm
Classification: EN02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.820167 m2; NetVolume: 0.0520008 m3
Text - CCI Funkční systém: H; CCI Komponenta: FLE; CCI Technický systém: HD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 2.NP_SO-102; Hostitel: Podlaží : 2.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Flow: 0 m3/s; Pressure Drop: 0 Pa
Kóty - Objem: 0.0519516 m3
Identifikační data - ID systému: 5; Komentáře: Tlaková expanzní nádoba pro primární okruh TČ, médium nemrznoucí směs
Jiné - Páteřní trasa: yes; Id typu: 12835217; Rodina: Expanzní nádoba; Rodina a typ: Expanzní nádoba: Expanzní nádoba 50; Typ: Expanzní nádoba 50
Name (Expanzní nádoba:Expanzní nádoba 50:...) | Klasifikace systému | ID pozice | Kód prvku | Označení
12890949 | Přívod teplé vody | 02 | EN02.39.0088 | 0088 | Mechanické - Název systému: HT_přívodní vodní (55 °C) 15; Group: HT_přívodní vodní (55 °C) 15
12903660 | Nedefinovaný | 03 | EN02.39.0090 | 0090
13391709 | Nedefinovaný | 04 | EN02.39.0238 | 0238

# IfcBuildingElementProxy: Expanzní nádoba‍:Expanzní nádoba 180, Expanzní nádoba‍:Expanzní nádoba 180:13208854
In: -1.PP_SO-102
Type - Material: RGB 128-128-128, Color RGB-000-000-000, Color RGB-250-250-250, Color RGB-160-197-081
Type - Obecné - ETIM Article Class: EC010958; ETIM Name: Membrane pressure expansion vessel
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Materiály a povrchové úpravy - Reflex_item_color: RGB 128-128-128
Type - Kóty - D: 480 mm; Délka: 480 mm; DN: 25 mm; H: 1151 mm; Jmenovitá velikost vstupu: 25 mm; Šířka: 480 mm; Výška: 1151 mm
Type - Identifikační data - Art. No.: 8200200; Číslo OmniClass: 23.75.70.11.14; Color: grey; Connection: G 1; Copyright: © CADprofi; Kód sestavy: EN02; Nadpis OmniClass: Expansion Vessels; Název typu: Expanzní nádoba 180; Označení typu: 57; PN: 6 bar; Popis: Membrane pressure expansion vessel; Popis sestavy: Expanzní nádoba; Revision: 2017; Volume: 0.18 m3
Type - Jiné - Kategorie: Mechanické zařízení; Ang2: 30 deg; Angle: 0 deg; AngVen: 60 deg; VLeg_1: yes; VLeg_2: no; VLeg_b: no; VLeg_m: no; VLeg_s: yes; VMem: yes; VTrans: yes; VVent_s: yes; A: 33.7 mm; AngVent: 65 deg; D1: 480 mm; DL: 225.75 mm; F: 136 mm; H1: 51 mm; H2: 1100 mm; H4: 120 mm; HC1: 220 mm; HL: 556 mm; HT: 1151 mm; LC1: 270 mm; LM: 236 mm; Název rodiny: Expanzní nádoba‍; Objem: 180 m3; RLG: 175.5 mm; RN: 351 mm; RT: 330 mm; RY: 432 mm; Scale: 0.75 mm; W: 705 mm
Classification: EN02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.9651 m2; NetVolume: 0.184815 m3
Text - CCI Funkční systém: H; CCI Komponenta: FLE; CCI Technický systém: HD
Vazby - Odsazení od hostitele: 0 mm; Podlaží: -1.PP_SO-102; Výška od podlaží: 0 mm; Hostitel: Podlaží : -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Flow: 0 m3/s; Klasifikace systému: Přívod teplé vody; Pressure Drop: 0 Pa
Kóty - Objem: 0.184732 m3
Identifikační data - ID pozice: 05; ID systému: 5; Kód prvku: EN02.57.0202; Komentáře: Tlaková expanzní nádoba vytápění, medium voda; Označení: 0202
Jiné - Páteřní trasa: yes; Rodina: Expanzní nádoba‍; Id typu: 12843447; Rodina a typ: Expanzní nádoba‍: Expanzní nádoba 180; Typ: Expanzní nádoba 180

# IfcBuildingElementProxy: Expanzní nádoba‍:Expanzní nádoba 220 (2)
In: 2.NP_SO-102
Type - Material: RGB 128-128-128, Color RGB-000-000-000, Color RGB-250-250-250, Color RGB-160-197-081
Type - Obecné - ETIM Article Class: EC010958; ETIM Name: Membrane pressure expansion vessel
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Materiály a povrchové úpravy - Reflex_item_color: RGB 128-128-128
Type - Kóty - D: 480 mm; Délka: 480 mm; DN: 25 mm; H: 1381 mm; Jmenovitá velikost vstupu: 25 mm; Šířka: 480 mm; Výška: 1381 mm
Type - Identifikační data - Art. No.: 8200250; Číslo OmniClass: 23.75.70.11.14; Color: grey; Connection: G 1; Copyright: © CADprofi; Kód sestavy: EN02; Nadpis OmniClass: Expansion Vessels; Název typu: Expanzní nádoba 220; Označení typu: 38; PN: 6 bar; Popis: Membrane pressure expansion vessel; Popis sestavy: Expanzní nádoba; Revision: 2017; Volume: 0.22 m3
Type - Jiné - Kategorie: Mechanické zařízení; A: 33.7 mm; Ang2: 30 deg; Angle: 0 deg; AngVen: 60 deg; AngVent: 65 deg; D1: 480 mm; DL: 225.75 mm; F: 136 mm; H1: 51 mm; H2: 1330 mm; H4: 120 mm; HC1: 220 mm; HL: 556 mm; HT: 1381 mm; LC1: 270 mm; LM: 236 mm; Název rodiny: Expanzní nádoba‍; Objem: 220 m3; RLG: 175.5 mm; RN: 351 mm; RT: 330 mm; RY: 432 mm; Scale: 0.75 mm; VLeg_1: yes; VLeg_2: no; VLeg_b: no; VLeg_m: no; VLeg_s: yes; VMem: yes; VTrans: yes; VVent_s: yes; W: 935 mm
Classification: EN02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.31193 m2; NetVolume: 0.226434 m3
Text - CCI Funkční systém: H; CCI Komponenta: FLE
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 2.NP_SO-102; Hostitel: Podlaží : 2.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Flow: 0 m3/s; Klasifikace systému: Přívod teplé vody; Pressure Drop: 0 Pa
Kóty - Objem: 0.226352 m3
Identifikační data - ID systému: 5
Jiné - Páteřní trasa: yes; Id typu: 12843449; Rodina: Expanzní nádoba‍; Rodina a typ: Expanzní nádoba‍: Expanzní nádoba 220; Typ: Expanzní nádoba 220
Name (Expanzní nádoba‍:Expanzní nádoba 220:...) | CCI Technický systém | ID pozice | Kód prvku | Komentáře | Označení
12863301 | HC | 01 | EN02.38.0086 | Tlaková expanzní nádoba chlazení, médium voda | 0086
12863324 | HD | 06 | EN02.38.0087 | Tlaková expanzní nádoba vytápění, medium voda | 0087 | Mechanické - Název systému: HT_PRIMÁR_vratné 4; Group: HT_PRIMÁR_vratné 4

# IfcBuildingElementProxy: FCU podstropní:Fan-coil podstropní (11)
Type - Material: Panel 2MB
Type - Vazby - Výchozí výška: 1219.2 mm
Type - Mechanické - Klasifikace: Žádné
Type - Materiály a povrchové úpravy - Panel 2MB: Panel 2MB
Type - Identifikační data - Číslo OmniClass: 23.75.70.21.21; Kód sestavy: FC04; Nadpis OmniClass: Local Air-Conditioning Units; Název typu: Fan-coil podstropní; Označení typu: 53; Popis sestavy: Podstropní
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: FCU podstropní
Classification: FC04 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.26464 m2; NetVolume: 0.165034 m3
Vlastnosti modelu - Airflow: 870.00 m3h; CoolingPowerSensible: 4.09 kW; CoolingPowerTotal: 5.29 kW; HeatingPowerTotal: 0.00 kW; SoundPowerLevelSum: 45.94 dBA
Text - CCI Funkční systém: H; CCI Komponenta: EQD; CCI Technický systém: HC
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Nedefinovaný
Grafika - MEPcube: no
Kóty - Objem: 0.165034 m3; Plocha: 1.63232 m2
Identifikační data - ID systému: 6; Komentáře: Podstropní FCU jednotka, Q=2,06 kW při druhém stupni otáček, Lw(A) = 39 dB(A)
Jiné - Páteřní trasa: yes; Id typu: 13168068; Rodina: FCU podstropní; Rodina a typ: FCU podstropní: Fan-coil podstropní; Typ: Fan-coil podstropní
Name (FCU podstropní:Fan-coil podstropní:...) | In | Podlaží = Vztažné podlaží | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Pracovní rovina | ID pozice | Kód prvku | Označení
13169771 | 3.NP_SO-102 | 3.NP_SO-102 | 3200 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 07 | FC04.53.0188 | 0188
13169872 | 3.NP_SO-102 | 3.NP_SO-102 | 3200 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 06 | FC04.53.0189 | 0189
13169880 | 3.NP_SO-102 | 3.NP_SO-102 | 3200 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 05 | FC04.53.0190 | 0190
13169888 | 3.NP_SO-102 | 3.NP_SO-102 | 3200 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 04 | FC04.53.0191 | 0191
13173260 | 1.NP_SO-102 | 1.NP_SO-102 | 2950 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 03 | FC04.53.0192 | 0192
13199416 | 3.NP_SO-102 | 3.NP_SO-102 | 3200 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 11 | FC04.53.0193 | 0193
13199417 | 3.NP_SO-102 | 3.NP_SO-102 | 3200 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 10 | FC04.53.0194 | 0194
13199418 | 3.NP_SO-102 | 3.NP_SO-102 | 3200 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 09 | FC04.53.0195 | 0195
13199420 | 3.NP_SO-102 | 3.NP_SO-102 | 3200 | Připojený model aplikace Revit : KVSUPS_DUSP_SO-102_D.1.1_ASR-Model.rvt | 08 | FC04.53.0196 | 0196
13210386 | 1.NP_SO-102 | 1.NP_SO-102 | 2950 | <nepřiřazeno> | 01 | FC04.53.0209 | 0209
13210450 | 1.NP_SO-102 | 1.NP_SO-102 | 2950 | <nepřiřazeno> | 02 | FC04.53.0210 | 0210

# IfcBuildingElementProxy: Předávací stanice:Předávací stanice, Předávací stanice:Předávací stanice:13202734
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - délka: 870 mm; šířka: 1270 mm; výška: 1620 mm
Type - Identifikační data - Číslo OmniClass: 23.75.00.00; Kód sestavy: VJ00; Nadpis OmniClass: Climate Control (HVAC); Název typu: Předávací stanice; Označení typu: 54; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Předávací stanice
Classification: VJ00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 9.1434 m2; NetVolume: 1.78994 m3
Text - CCI Funkční systém: H; CCI Komponenta: EGC; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no; Odsazení od hostitele: 0 mm; Podlaží: -1.PP_SO-102; Výška od podlaží: 0 mm; Hostitel: Podlaží : -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 1.78994 m3; Plocha: 4.5717 m2
Identifikační data - ID pozice: 04; ID systému: 2; Kód prvku: VJ00.54.0199; Komentáře: Předávací stanice, tlakově nezávislá; Označení: 0199
Jiné - Páteřní trasa: yes; Id typu: 13202718; Rodina: Předávací stanice; Rodina a typ: Předávací stanice: Předávací stanice; Typ: Předávací stanice

# IfcBuildingElementProxy: Radiátor z žebrových trubek_dvouřadé_F:Radiátor z žebrových trubek_dvouřadé_F 32x2.0x92 (2)
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Text - Typ tělesa: SPIRAL RAO2-F
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - DN přípojky: 16 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; připojení: 8 mm; Průměr: 32 mm; Průměr trubky: 32 mm; Průměr vinutí: 92 mm; r: 16 mm; r2: 46 mm; Šířka: 92 mm; Výška: 287 mm
Type - Identifikační data - Číslo OmniClass: 23.85.50.14; Kód sestavy: OT00; Nadpis OmniClass: Telephone and Intercommunication Equipment; Název typu: Radiátor z žebrových trubek_dvouřadé_F 32x2.0x92; Označení typu: 47; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Mechanické zařízení; Dvoutrubka: yes; Název rodiny: Radiátor z žebrových trubek_dvouřadé_F
Classification: OT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.32799 m2; NetVolume: 0.0275401 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 2.NP_SO-102; Hostitel: Podlaží : 2.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Nedefinovaný
Kóty - Délka: 2000 mm; Objem: 0.0275401 m3; Plocha: 0.663993 m2
Jiné - Rodina: Radiátor z žebrových trubek_dvouřadé_F; Id typu: 12988743; Rodina a typ: Radiátor z žebrových trubek_dvouřadé_F: Radiátor z žebrových trubek_dvouřadé_F 32x2.0x92; Typ: Radiátor z žebrových trubek_dvouřadé_F 32x2.0x92
Name (Radiátor z žebrových trubek_dvouřadé_F:Radiátor z žebrových trubek_dvouřadé_F 32x2.0x92:...) | Kód prvku | Označení
12992554 | OT00.47.0137 | 0137
12992630 | OT00.47.0138 | 0138

# IfcBuildingElementProxy: Radiátor z žebrových trubek_dvouřadé_F:Radiátor z žebrových trubek_dvouřadé_F 57x2.5x137 (67)
Type - Material: <Unnamed>
Type - Text - Typ tělesa: SPIRAL RAO2-F
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - DN přípojky: 16 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; připojení: 8 mm; Průměr: 57 mm; Průměr trubky: 57 mm; Průměr vinutí: 137 mm; r: 28.5 mm; r2: 68.5 mm; Šířka: 137 mm; Výška: 382 mm
Type - Identifikační data - Číslo OmniClass: 23.85.50.14; Kód sestavy: OT00; Nadpis OmniClass: Telephone and Intercommunication Equipment; Název typu: Radiátor z žebrových trubek_dvouřadé_F 57x2.5x137; Označení typu: 16; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Mechanické zařízení; Dvoutrubka: yes; Název rodiny: Radiátor z žebrových trubek_dvouřadé_F
Classification: OT00 Uniformat (Uniformat)
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Jiné - Id typu: 12988202; Rodina: Radiátor z žebrových trubek_dvouřadé_F; Rodina a typ: Radiátor z žebrových trubek_dvouřadé_F: Radiátor z žebrových trubek_dvouřadé_F 57x2.5x137; Typ: Radiátor z žebrových trubek_dvouřadé_F 57x2.5x137
Name (Radiátor z žebrových trubek_dvouřadé_F:Radiátor z žebrových trubek_dvouřadé_F 57x2.5x137:...) | In | NetSurfaceArea (m2) | NetVolume (m3) = Objem (m3) | Podlaží | Hostitel | Fáze vytvoření | Klasifikace systému | Délka (mm) | Plocha (m2) | Kód prvku | Označení
12776203 | 1.NP_SO-102 | 3.734 | 0.119996 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | Nedefinovaný | 4000 | 1.867 | OT00.16.0016 | 0016
