Properties of the parts of a building model (IFC4), part 48 of 72

# IfcPipeFitting: M_Koleno, obecné:Standardní (1543)
Name (M_Koleno, obecné:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm) | Group
13189327 | 2.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 2.NP_SO-102 | 2230 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0945 | 0945 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 5 | Izolace - Typ izolace: Tepelná
13189390 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 2.NP_SO-102 | 2200 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0946 | 0946 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13189415 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 2.NP_SO-102 | 2200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0947 | 0947 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13189717 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3250 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.0948 | 0948 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13206706 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 32 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0949 | 0949 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (65 °C) 32 | Mechanické – tok - Tlaková ztráta: 0 Pa
13206710 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 32 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0951 | 0951 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (65 °C) 32 | Mechanické – tok - Tlaková ztráta: 0 Pa
13206770 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 8 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0952 | 0952 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 8
13207380 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 8 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0953 | 0953 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 8
13207408 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 4 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0955 | 0955 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 4
13207998 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 36 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0956 | 0956 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 36
13208002 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 36 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0958 | 0958 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 36
13208034 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 31 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0959 | 0959 | yes | 33.3375 | 26.9875 | HT_přívodní vodní (65 °C) 31
13208038 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 31 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0961 | 0961 | yes | 33.3375 | 26.9875 | HT_přívodní vodní (65 °C) 31
13208259 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0962 | 0962 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13208288 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 6 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0963 | 0963 | yes | 33.3375 | 26.9875 | HT_vratné vodní (45 °C) 6
13208290 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 6 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0964 | 0964 | yes | 33.3375 | 26.9875 | HT_vratné vodní (45 °C) 6
13208342 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 4 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0966 | 0966 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 4
13208392 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0968 | 0968 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13208476 | -1.PP_SO-102 | 0 | ø65 mm-ø65 mm | HD | -1.PP_SO-102 | 1000 | Fáze 1 | HT_přívodní vodní (75 °C) | Přívod teplé vody | HT_přívodní vodní (75 °C) 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.0969 | 0969 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (75 °C) 1
13208502 | -1.PP_SO-102 | 0 | ø65 mm-ø65 mm | HD | -1.PP_SO-102 | 300 | Fáze 1 | HT_vratné vodní (65 °C) | Zpětné vedení teplé vody | HT_vratné vodní (65 °C) 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.0970 | 0970 | yes | 39.6875 | 33.3375 | HT_vratné vodní (65 °C) 1
13208506 | -1.PP_SO-102 | 0 | ø65 mm-ø65 mm | HD | -1.PP_SO-102 | 1000 | Fáze 1 | HT_vratné vodní (65 °C) | Zpětné vedení teplé vody | HT_vratné vodní (65 °C) 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.0971 | 0971 | yes | 39.6875 | 33.3375 | HT_vratné vodní (65 °C) 1
13208751 | -1.PP_SO-102 | 0 | ø65 mm-ø65 mm | HD | -1.PP_SO-102 | 300 | Fáze 1 | HT_přívodní vodní (75 °C) | Přívod teplé vody | HT_přívodní vodní (75 °C) 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.0972 | 0972 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (75 °C) 1
13213595 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0974 | 0974 | no | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 9
13215172 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 1800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0977 | 0977 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13215176 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 1800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0978 | 0978 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13215202 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 1800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0979 | 0979 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13215206 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 1800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0980 | 0980 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13216282 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 1000 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.0981 | 0981 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (55 °C) 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13216286 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2400 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.0983 | 0983 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (55 °C) 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13216312 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 1662 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.0984 | 0984 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (55 °C) 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13216606 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 32.5 | 65 | 0.000108828 | 16.4391 | 45 | ø65-ø65 | 11.0471 | 66.675 | TT01.01.0987 | 0987 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 7
13216928 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0988 | 0988 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13217024 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0990 | 0990 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13217456 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0992 | 0992 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 1
13217768 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0997 | 0997 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 9
13217848 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-102 | 2850 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0998 | 0998 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13218040 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1000 | 1000 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 1
13218042 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1001 | 1001 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 1
13218308 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1003 | 1003 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 9
13218310 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1004 | 1004 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 9
13218446 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1005 | 1005 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 9
13218711 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2900 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1006 | 1006 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13218723 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2900 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1007 | 1007 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13218782 | 2.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 2.NP_SO-102 | 1700 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1008 | 1008 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13219163 | 2.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 2.NP_SO-102 | 1700 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1009 | 1009 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39 | Izolace - Typ izolace: Tepelná
13219205 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1010 | 1010 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13219284 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1011 | 1011 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13219546 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 1000 | Fáze 1 | HT_přívodní vodní (45 °C) | Přívod teplé vody | HT_přívodní vodní (45 °C) 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1012 | 1012 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (45 °C) 5
13219713 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 704 | Fáze 1 | HT_přívodní vodní (45 °C) | Přívod teplé vody | HT_přívodní vodní (45 °C) 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1013 | 1013 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (45 °C) 5
13219721 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2500 | Fáze 1 | HT_přívodní vodní (45 °C) | Přívod teplé vody | HT_přívodní vodní (45 °C) 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1015 | 1015 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (45 °C) 5
13219725 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2500 | Fáze 1 | HT_přívodní vodní (45 °C) | Přívod teplé vody | HT_přívodní vodní (45 °C) 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1016 | 1016 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (45 °C) 5
13219966 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 1000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1017 | 1017 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13220009 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1019 | 1019 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13220013 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1020 | 1020 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13220596 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1021 | 1021 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3
13220942 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2750 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1022 | 1022 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13222480 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 300 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 13 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1023 | 1023 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (55 °C) 13
13222513 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 20 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1024 | 1024 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 20 | Mechanické – tok - Tlaková ztráta: 0 Pa
13222546 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 300 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 26 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1025 | 1025 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (55 °C) 26 | Mechanické – tok - Tlaková ztráta: 0 Pa
13222579 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 21 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1026 | 1026 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 21
13222652 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2900 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1027 | 1027 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13222656 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2900 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1028 | 1028 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13222685 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1029 | 1029 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 1
13222921 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1030 | 1030 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 23 | Mechanické – tok - Tlaková ztráta: 0 Pa
13222967 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1032 | 1032 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13223000 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2500 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 21 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1034 | 1034 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 21 | Mechanické – tok - Tlaková ztráta: 0 Pa
13223031 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2500 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 26 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1035 | 1035 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (55 °C) 26 | Mechanické – tok - Tlaková ztráta: 0 Pa
13223065 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 20 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1036 | 1036 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 20 | Mechanické – tok - Tlaková ztráta: 0 Pa
13223099 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2500 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 13 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1037 | 1037 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (55 °C) 13 | Mechanické – tok - Tlaková ztráta: 0 Pa
13223500 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 2.NP_SO-102 | 2200 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1038 | 1038 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13223504 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1039 | 1039 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13223508 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1040 | 1040 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13223795 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 2.NP_SO-102 | 2200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1041 | 1041 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13223799 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 2.NP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1042 | 1042 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13223814 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 2.NP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1043 | 1043 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13226191 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1044 | 1044 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (55 °C) 9
13226214 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1046 | 1046 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 1
13226279 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1048 | 1048 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 9
13226289 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1049 | 1049 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 9
13226313 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1050 | 1050 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 1
13226323 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1051 | 1051 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 1
13227700 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1054 | 1054 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 7
13227704 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1055 | 1055 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 7
13227858 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HD | 2.NP_SO-102 | 220 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1056 | 1056 | yes | 20.6375 | 14.2875 | HT_vratné vodní (45 °C) 7
13227862 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1058 | 1058 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 7
13227880 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1060 | 1060 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 7
13227969 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1061 | 1061 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 7 | Mechanické – tok - Tlaková ztráta: 0 Pa
13227971 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1062 | 1062 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 7 | Mechanické – tok - Tlaková ztráta: 0 Pa
13229897 | 2.NP_SO-102 | 0 | ø100 mm-ø100 mm | HC | 2.NP_SO-102 | 1000 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 3 | 50 | 100 | 0.000795477 | 58.7375 | 90 | ø100-ø100 | 41.91 | 104.775 | TT01.01.1063 | 1063 | yes | 58.7375 | 52.3875 | CL_přívodní vodní (10 °C) 3
13229899 | 2.NP_SO-102 | 0 | ø100 mm-ø100 mm | HC | 2.NP_SO-102 | 700 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 3 | 50 | 100 | 0.000795477 | 58.7375 | 90 | ø100-ø100 | 41.91 | 104.775 | TT01.01.1064 | 1064 | yes | 58.7375 | 52.3875 | CL_přívodní vodní (10 °C) 3
13229975 | 2.NP_SO-102 | 0 | ø100 mm-ø100 mm | HC | 2.NP_SO-102 | 1000 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 3 | 50 | 100 | 0.000795477 | 58.7375 | 90 | ø100-ø100 | 41.91 | 104.775 | TT01.01.1065 | 1065 | yes | 58.7375 | 52.3875 | CL_vratné vodní (15 °C) 3
13229977 | 2.NP_SO-102 | 0 | ø100 mm-ø100 mm | HC | 2.NP_SO-102 | 1700 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 3 | 50 | 100 | 0.000795477 | 58.7375 | 90 | ø100-ø100 | 41.91 | 104.775 | TT01.01.1066 | 1066 | yes | 58.7375 | 52.3875 | CL_vratné vodní (15 °C) 3
13230647 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1067 | 1067 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 12 | Mechanické – tok - Tlaková ztráta: 0 Pa
13231009 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1068 | 1068 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 12 | Mechanické – tok - Tlaková ztráta: 0 Pa
13231164 | 2.NP_SO-102 | 0 | ø22 mm-ø22 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 11 | 22 | 0.0000148067 | 18.9375 | 90 | ø22-ø22 | 10.07 | 25.175 | TT01.01.1069 | 1069 | yes | 18.9375 | 12.5875 | HT_vratné vodní (45 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13231169 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1071 | 1071 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13243334 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 1700 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1072 | 1072 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13243338 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 1700 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1073 | 1073 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13243422 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 1700 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1074 | 1074 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13243426 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 1700 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1075 | 1075 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13243649 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2900 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1076 | 1076 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13243653 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2900 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1077 | 1077 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13243678 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2900 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1078 | 1078 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13243682 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2900 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1079 | 1079 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13245487 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 2.NP_SO-102 | 3000 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 13 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1080 | 1080 | no | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 13
13245517 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 2550 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 6 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1081 | 1081 | yes | 39.6875 | 33.3375 | CL_vratné vodní (15 °C) 6 | Mechanické – tok - Tlaková ztráta: 0 Pa
13245519 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 2550 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 6 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1082 | 1082 | yes | 39.6875 | 33.3375 | CL_vratné vodní (15 °C) 6 | Mechanické – tok - Tlaková ztráta: 0 Pa
13245549 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 2700 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1083 | 1083 | yes | 39.6875 | 33.3375 | CL_vratné vodní (15 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13245551 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 2700 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1084 | 1084 | yes | 39.6875 | 33.3375 | CL_vratné vodní (15 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13245615 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 2500 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 6 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1085 | 1085 | yes | 39.6875 | 33.3375 | CL_přívodní vodní (10 °C) 6 | Mechanické – tok - Tlaková ztráta: 0 Pa
13245617 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 2500 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 6 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1086 | 1086 | yes | 39.6875 | 33.3375 | CL_přívodní vodní (10 °C) 6 | Mechanické – tok - Tlaková ztráta: 0 Pa
13245647 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 2.NP_SO-102 | 2600 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 12 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1087 | 1087 | no | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 12
13245774 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 2700 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1088 | 1088 | yes | 39.6875 | 33.3375 | CL_přívodní vodní (10 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13245776 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 2700 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1089 | 1089 | yes | 39.6875 | 33.3375 | CL_přívodní vodní (10 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13245868 | 2.NP_SO-102 | 0 | ø100 mm-ø100 mm | HC | 2.NP_SO-102 | 1000 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 50 | 100 | 0.000397733 | 24.3299 | 45 | ø100-ø100 | 17.3597 | 104.775 | TT01.01.1090 | 1090 | yes | 58.7375 | 52.3875 | CL_vratné vodní (15 °C) 1
13245892 | 2.NP_SO-102 | 0 | ø100 mm-ø100 mm | HC | 2.NP_SO-102 | 1000 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 2 | 50 | 100 | 0.000397733 | 24.3299 | 45 | ø100-ø100 | 17.3597 | 104.775 | TT01.01.1091 | 1091 | yes | 58.7375 | 52.3875 | CL_přívodní vodní (10 °C) 2
13246148 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2200 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1092 | 1092 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 25
13246455 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2400 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1094 | 1094 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13246585 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1096 | 1096 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 25
13246705 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2400 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1097 | 1097 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (55 °C) 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13246707 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2400 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1098 | 1098 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (55 °C) 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13246940 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2400 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1099 | 1099 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13246959 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1100 | 1100 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13247221 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 3000 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1102 | 1102 | yes | 39.6875 | 33.3375 | HT/CL_přívodní vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13247229 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 3000 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1103 | 1103 | yes | 39.6875 | 33.3375 | HT/CL_přívodní vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13247471 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 3000 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1104 | 1104 | yes | 39.6875 | 33.3375 | HT/CL_přívodní vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13247475 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 3000 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1105 | 1105 | yes | 39.6875 | 33.3375 | HT/CL_přívodní vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13248316 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 3000 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1106 | 1106 | yes | 20.6375 | 14.2875 | HT/CL_přívodní vodní 1
13248324 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 2650 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1107 | 1107 | yes | 20.6375 | 14.2875 | HT/CL_přívodní vodní 1
13248456 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 2650 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1108 | 1108 | yes | 20.6375 | 14.2875 | HT/CL_přívodní vodní 1
13248519 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 3000 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1109 | 1109 | yes | 39.6875 | 33.3375 | HT/CL_vratné vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13248526 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 3000 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1110 | 1110 | yes | 20.6375 | 14.2875 | HT/CL_vratné vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13248528 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 2650 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1111 | 1111 | yes | 20.6375 | 14.2875 | HT/CL_vratné vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13248540 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 2650 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1112 | 1112 | yes | 20.6375 | 14.2875 | HT/CL_vratné vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13248683 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 3000 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1113 | 1113 | yes | 39.6875 | 33.3375 | HT/CL_vratné vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13248685 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 3000 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1114 | 1114 | yes | 39.6875 | 33.3375 | HT/CL_vratné vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13248743 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 2450 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1115 | 1115 | yes | 39.6875 | 33.3375 | HT/CL_vratné vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13248747 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 2450 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1116 | 1116 | yes | 39.6875 | 33.3375 | HT/CL_vratné vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13248907 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1117 | 1117 | yes | 20.6375 | 14.2875 | CL_přívodní vodní (10 °C) 4
13248965 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1118 | 1118 | yes | 20.6375 | 14.2875 | CL_přívodní vodní (10 °C) 4
13249000 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1120 | 1120 | yes | 20.6375 | 14.2875 | CL_přívodní vodní (10 °C) 4
13249701 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1123 | 1123 | yes | 20.6375 | 14.2875 | CL_vratné vodní (15 °C) 11
13249800 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1125 | 1125 | yes | 20.6375 | 14.2875 | CL_vratné vodní (15 °C) 11
13249816 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1126 | 1126 | yes | 20.6375 | 14.2875 | CL_vratné vodní (15 °C) 11
13250105 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1129 | 1129 | yes | 20.6375 | 14.2875 | CL_vratné vodní (15 °C) 11
13250355 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1130 | 1130 | yes | 20.6375 | 14.2875 | CL_přívodní vodní (10 °C) 4
13250463 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1131 | 1131 | yes | 20.6375 | 14.2875 | CL_vratné vodní (15 °C) 11
13250540 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 3100 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1133 | 1133 | yes | 39.6875 | 33.3375 | HT/CL_vratné vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13250572 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 3100 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1135 | 1135 | yes | 39.6875 | 33.3375 | HT/CL_přívodní vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13250621 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 3100 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1136 | 1136 | yes | 39.6875 | 33.3375 | HT/CL_přívodní vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13250623 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 3100 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1137 | 1137 | yes | 39.6875 | 33.3375 | HT/CL_přívodní vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13250738 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 3100 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1138 | 1138 | yes | 39.6875 | 33.3375 | HT/CL_vratné vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13250740 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 3100 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1139 | 1139 | yes | 39.6875 | 33.3375 | HT/CL_vratné vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13250959 | 2.NP_SO-102 | 0 | ø100 mm-ø100 mm | HC | 2.NP_SO-102 | 1700 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 3 | 50 | 100 | 0.000795477 | 58.7375 | 90 | ø100-ø100 | 41.91 | 104.775 | TT01.01.1141 | 1141 | yes | 58.7375 | 52.3875 | CL_vratné vodní (15 °C) 3
13250996 | 2.NP_SO-102 | 0 | ø100 mm-ø100 mm | HC | 2.NP_SO-102 | 1700 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 3 | 50 | 100 | 0.000397733 | 24.3299 | 45 | ø100-ø100 | 17.3597 | 104.775 | TT01.01.1142 | 1142 | yes | 58.7375 | 52.3875 | CL_vratné vodní (15 °C) 3
13253882 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1143 | 1143 | no | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 9
13255797 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.1146 | 1146 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13255812 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.1147 | 1147 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13260201 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HC | 2.NP_SO-102 | 2800 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1152 | 1152 | yes | 46.0375 | 39.6875 | CL_přívodní vodní (10 °C) 4
13260533 | 2.NP_SO-102 | 0 | ø76 mm-ø76 mm | HC | 2.NP_SO-102 | 2500 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 38 | 76 | 0.000355255 | 45.9375 | 90 | ø76-ø76 | 31.67 | 79.175 | TT01.01.1153 | 1153 | yes | 45.9375 | 39.5875 | CL_vratné vodní (15 °C) 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13260573 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HC | 2.NP_SO-102 | 2800 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1154 | 1154 | yes | 46.0375 | 39.6875 | CL_přívodní vodní (10 °C) 4
13261012 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-102 | 3200 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1155 | 1155 | yes | 26.9875 | 20.6375 | CL_vratné vodní (15 °C) 8
13261557 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-102 | 3200 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1156 | 1156 | yes | 26.9875 | 20.6375 | CL_přívodní vodní (10 °C) 4
13267131 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2750 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1157 | 1157 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 9
13267227 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3200 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1158 | 1158 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 9
13267502 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3200 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1159 | 1159 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 9
13267659 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3200 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1160 | 1160 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 9
13267667 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 2700 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1161 | 1161 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 9
13267669 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 2700 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1162 | 1162 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 9
13267793 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3200 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1163 | 1163 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 9
13267797 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2800 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1164 | 1164 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 9
13268233 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2820 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1165 | 1165 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 9
13268441 | 1.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 1.NP_SO-102 | 2750 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 7.5 | 15 | 9.8572e-07 | 2.51568 | 19.9721 | ø15-ø15 | 1.11808 | 15.875 | TT01.01.1167 | 1167 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 9
13268444 | 1.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 1.NP_SO-102 | 2750 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 7.5 | 15 | 9.8572e-07 | 2.51568 | 19.9721 | ø15-ø15 | 1.11808 | 15.875 | TT01.01.1168 | 1168 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 9
13268452 | 1.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 1.NP_SO-102 | 2750 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1169 | 1169 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 9
13268462 | 1.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 1.NP_SO-102 | 2750 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1170 | 1170 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 9
13268526 | 1.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 1.NP_SO-102 | 2750 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1171 | 1171 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 9
13268528 | 1.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 1.NP_SO-102 | 2750 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1172 | 1172 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 9
13268669 | 1.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 1.NP_SO-102 | 2750 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1174 | 1174 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 9
13271207 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2700 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1177 | 1177 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 9
13271406 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2700 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1178 | 1178 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 9
13271410 | -2.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -2.PP_SO-102 | 3150 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1179 | 1179 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 9
13271598 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2700 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1180 | 1180 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 9
13271609 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2700 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1181 | 1181 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 9
13271629 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2700 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1182 | 1182 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 9
13271633 | -2.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -2.PP_SO-102 | 3150 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1183 | 1183 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 9
13273777 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1184 | 1184 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3
13278355 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 3000 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1185 | 1185 | yes | 39.6875 | 33.3375 | HT/CL_vratné vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
