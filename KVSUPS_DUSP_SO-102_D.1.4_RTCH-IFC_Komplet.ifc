Properties of the parts of a building model (IFC4), part 51 of 72

# IfcPipeFitting: M_Koleno, obecné:Standardní (1543)
Name (M_Koleno, obecné:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm) | Group
13404849 | 2.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 2.NP_SO-102 | 1950 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 40 | 80 | 0.000178912 | 19.0694 | 45 | ø80-ø80 | 13.1513 | 79.375 | TT01.01.1894 | 1894 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
13404854 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | -6050 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1895 | 1895 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 1
13404944 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | 3950 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.1897 | 1897 | yes | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13404948 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.1899 | 1899 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13405671 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2500 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 26 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1922 | 1922 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (55 °C) 26 | Mechanické – tok - Tlaková ztráta: 0 Pa
13405694 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2500 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 21 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1923 | 1923 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 21
13405852 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1924 | 1924 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13405927 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1925 | 1925 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13405929 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 900 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1926 | 1926 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13406001 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1927 | 1927 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13406041 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1928 | 1928 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13406045 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 900 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1929 | 1929 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13406455 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1930 | 1930 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13406459 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1931 | 1931 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13406461 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3250 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1932 | 1932 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13406465 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3250 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1933 | 1933 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13406467 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1934 | 1934 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3
13406471 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1935 | 1935 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3
13406473 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3250 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1936 | 1936 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3
13406477 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3250 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1937 | 1937 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3
13406576 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 20 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1938 | 1938 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 20 | Mechanické – tok - Tlaková ztráta: 0 Pa
13406595 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2500 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 13 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1939 | 1939 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (55 °C) 13
13406651 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1940 | 1940 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13406653 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3250 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1941 | 1941 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13406655 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1942 | 1942 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13406657 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1943 | 1943 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13406781 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1944 | 1944 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3
13406783 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 900 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1945 | 1945 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3
13406814 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2750 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1946 | 1946 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13406859 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2750 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1947 | 1947 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13406863 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 900 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1948 | 1948 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13407138 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1949 | 1949 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13408079 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-102 | 2350 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1954 | 1954 | yes | 26.9875 | 20.6375 | CL_vratné vodní (15 °C) 8
13408083 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-102 | 2350 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1955 | 1955 | yes | 26.9875 | 20.6375 | CL_vratné vodní (15 °C) 8
13408106 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 3000 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1956 | 1956 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 8
13408161 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-102 | 2300 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1960 | 1960 | yes | 26.9875 | 20.6375 | CL_přívodní vodní (10 °C) 4
13408165 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-102 | 2300 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1961 | 1961 | yes | 26.9875 | 20.6375 | CL_přívodní vodní (10 °C) 4
13408199 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 3000 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1962 | 1962 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 4
13409016 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 0 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1967 | 1967 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13409035 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 0 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1969 | 1969 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13409116 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 1800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1970 | 1970 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13409118 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 0 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1971 | 1971 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13409150 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | -500 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1973 | 1973 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13409169 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | -500 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1975 | 1975 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13409184 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 1800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1976 | 1976 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13409186 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | -500 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1977 | 1977 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13409327 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 0 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1979 | 1979 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13409355 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | -500 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1981 | 1981 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13409887 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 2300 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1983 | 1983 | yes | 39.6875 | 33.3375 | HT/CL_přívodní vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13409891 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 2300 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1985 | 1985 | yes | 39.6875 | 33.3375 | HT/CL_přívodní vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13413388 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2300 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000178912 | 19.0694 | 45 | ø80-ø80 | 13.1513 | 79.375 | TT01.01.2002 | 2002 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13413700 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000178912 | 19.0694 | 45 | ø80-ø80 | 13.1513 | 79.375 | TT01.01.2003 | 2003 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13413760 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000178912 | 19.0694 | 45 | ø80-ø80 | 13.1513 | 79.375 | TT01.01.2004 | 2004 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13413984 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000178912 | 19.0694 | 45 | ø80-ø80 | 13.1513 | 79.375 | TT01.01.2005 | 2005 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13414030 | -1.PP_SO-102 | 60 | ø200 mm-ø200 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2006 | 2006 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39 | Izolace - Typ izolace: Tepelná
13414033 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000178912 | 19.0694 | 45 | ø80-ø80 | 13.1513 | 79.375 | TT01.01.2007 | 2007 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13414099 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2300 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000178912 | 19.0694 | 45 | ø80-ø80 | 13.1513 | 79.375 | TT01.01.2008 | 2008 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13414140 | -1.PP_SO-102 | 60 | ø200 mm-ø200 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2009 | 2009 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13414143 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000178912 | 19.0694 | 45 | ø80-ø80 | 13.1513 | 79.375 | TT01.01.2010 | 2010 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13414593 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000178912 | 19.0694 | 45 | ø80-ø80 | 13.1513 | 79.375 | TT01.01.2011 | 2011 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13416198 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 3000 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2012 | 2012 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 4
13416206 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2750 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2014 | 2014 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 4
13416208 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2750 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2015 | 2015 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 4
13416233 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 3000 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2016 | 2016 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 8
13416241 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2750 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2018 | 2018 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 8
13416243 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2750 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2019 | 2019 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 8
13416308 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2020 | 2020 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13416344 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2021 | 2021 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13416380 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2022 | 2022 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13416388 | -1.PP_SO-102 | 60 | ø200 mm-ø200 mm | HD | -1.PP_SO-102 | 2150 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2023 | 2023 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13416391 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2150 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2024 | 2024 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13416415 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2025 | 2025 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13416423 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2150 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2026 | 2026 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13416425 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2150 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2027 | 2027 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13416755 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2350 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2028 | 2028 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13416788 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2350 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2029 | 2029 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13416798 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 3000 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2030 | 2030 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13416919 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2750 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2031 | 2031 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13416921 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2032 | 2032 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13416925 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2033 | 2033 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13416955 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 3000 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2034 | 2034 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13416959 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2750 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2035 | 2035 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13416963 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2750 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2036 | 2036 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13417807 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2037 | 2037 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 6 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13417810 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2038 | 2038 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 6 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13417813 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2450 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2039 | 2039 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 2 | Izolace - Typ izolace: Tepelná
13417816 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2450 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2040 | 2040 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 2 | Izolace - Typ izolace: Tepelná
13418108 | -1.PP_SO-102 | 60 | ø152 mm-ø152 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2041 | 2041 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8 | Izolace - Typ izolace: Tepelná
13418119 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2300 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2042 | 2042 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8 | Izolace - Typ izolace: Tepelná
13418122 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2300 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2043 | 2043 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8 | Izolace - Typ izolace: Tepelná
13418321 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 2320 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.2044 | 2044 | yes | 33.3375 | 26.9875 | CL_přívodní vodní (10 °C) 4
13418899 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2350 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2045 | 2045 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13418910 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2350 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2046 | 2046 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13418921 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 2320 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.2047 | 2047 | yes | 33.3375 | 26.9875 | CL_vratné vodní (15 °C) 8
13419277 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2049 | 2049 | no | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13419281 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2050 | 2050 | no | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13419309 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2052 | 2052 | no | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13419313 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2053 | 2053 | no | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13419355 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2600 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.2056 | 2056 | no | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 4
13419359 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2600 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.2057 | 2057 | no | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 4
13419393 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2600 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.2060 | 2060 | no | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 8
13419397 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2600 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.2061 | 2061 | no | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 8
13419825 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.01.2062 | 2062 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13420093 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.01.2063 | 2063 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13420244 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.01.2064 | 2064 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13420280 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 2800 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 25 | 50 | 0.0000599073 | 13.8088 | 45 | ø50-ø50 | 8.94287 | 53.975 | TT01.01.2065 | 2065 | yes | 33.3375 | 26.9875 | CL_vratné vodní (15 °C) 8
13420323 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 2800 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 25 | 50 | 0.0000599073 | 13.8088 | 45 | ø50-ø50 | 8.94287 | 53.975 | TT01.01.2066 | 2066 | yes | 33.3375 | 26.9875 | CL_přívodní vodní (10 °C) 4
13421811 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 3000 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 25 | 50 | 0.0000599073 | 13.8088 | 45 | ø50-ø50 | 8.94287 | 53.975 | TT01.01.2067 | 2067 | yes | 33.3375 | 26.9875 | CL_vratné vodní (15 °C) 8
13421827 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 3000 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 25 | 50 | 0.0000599073 | 13.8088 | 45 | ø50-ø50 | 8.94287 | 53.975 | TT01.01.2068 | 2068 | yes | 33.3375 | 26.9875 | CL_přívodní vodní (10 °C) 4
13421897 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.01.2069 | 2069 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13421901 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.01.2070 | 2070 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13421960 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2300 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.01.2071 | 2071 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13421964 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2300 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.01.2072 | 2072 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13422034 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 2300 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 25 | 50 | 0.0000599073 | 13.8088 | 45 | ø50-ø50 | 8.94287 | 53.975 | TT01.01.2073 | 2073 | yes | 33.3375 | 26.9875 | CL_vratné vodní (15 °C) 8
13422038 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 2300 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 25 | 50 | 0.0000599073 | 13.8088 | 45 | ø50-ø50 | 8.94287 | 53.975 | TT01.01.2074 | 2074 | yes | 33.3375 | 26.9875 | CL_vratné vodní (15 °C) 8
13422063 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 2300 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 25 | 50 | 0.0000599073 | 13.8088 | 45 | ø50-ø50 | 8.94287 | 53.975 | TT01.01.2075 | 2075 | yes | 33.3375 | 26.9875 | CL_přívodní vodní (10 °C) 4
13422067 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 2300 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 25 | 50 | 0.0000599073 | 13.8088 | 45 | ø50-ø50 | 8.94287 | 53.975 | TT01.01.2076 | 2076 | yes | 33.3375 | 26.9875 | CL_přívodní vodní (10 °C) 4
13422170 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 3000 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.01.2077 | 2077 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13422174 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 3000 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2078 | 2078 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13422757 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3100 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 32.5 | 65 | 0.0000725519 | 10.6342 | 30 | ø65-ø65 | 7.1462 | 66.675 | TT01.01.2079 | 2079 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (55 °C) 19
13422767 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2750 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 32.5 | 65 | 0.0000725519 | 10.6342 | 30 | ø65-ø65 | 7.1462 | 66.675 | TT01.01.2080 | 2080 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (55 °C) 19
13422813 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2750 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 32.5 | 65 | 0.0000725519 | 10.6342 | 30 | ø65-ø65 | 7.1462 | 66.675 | TT01.01.2081 | 2081 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (55 °C) 19
13422838 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3100 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 32.5 | 65 | 0.0000725519 | 10.6342 | 30 | ø65-ø65 | 7.1462 | 66.675 | TT01.01.2082 | 2082 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (55 °C) 19
13422964 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3100 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 32.5 | 65 | 0.0000725519 | 10.6342 | 30 | ø65-ø65 | 7.1462 | 66.675 | TT01.01.2083 | 2083 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 13
13422976 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3100 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 32.5 | 65 | 0.0000725519 | 10.6342 | 30 | ø65-ø65 | 7.1462 | 66.675 | TT01.01.2084 | 2084 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 13
13422980 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2750 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 32.5 | 65 | 0.0000725519 | 10.6342 | 30 | ø65-ø65 | 7.1462 | 66.675 | TT01.01.2085 | 2085 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 13
13422984 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2750 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 32.5 | 65 | 0.0000725519 | 10.6342 | 30 | ø65-ø65 | 7.1462 | 66.675 | TT01.01.2086 | 2086 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 13
13423131 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2250 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.00000354698 | 4.67906 | 30 | ø20-ø20 | 2.38207 | 22.225 | TT01.01.2087 | 2087 |  | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13423135 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2250 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.00000354698 | 4.67906 | 30 | ø20-ø20 | 2.38207 | 22.225 | TT01.01.2088 | 2088 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13426379 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 2320 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.2089 | 2089 | yes | 33.3375 | 26.9875 | CL_přívodní vodní (10 °C) 4
13426383 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 2800 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.2090 | 2090 | yes | 33.3375 | 26.9875 | CL_přívodní vodní (10 °C) 4
13426387 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 2800 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.2091 | 2091 | yes | 33.3375 | 26.9875 | CL_přívodní vodní (10 °C) 4
13426470 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 2320 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.2092 | 2092 | yes | 33.3375 | 26.9875 | CL_vratné vodní (15 °C) 8
13426474 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 2800 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.2093 | 2093 | yes | 33.3375 | 26.9875 | CL_vratné vodní (15 °C) 8
13426478 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 2800 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.2094 | 2094 | yes | 33.3375 | 26.9875 | CL_vratné vodní (15 °C) 8
13426527 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2350 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2095 | 2095 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13426531 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2096 | 2096 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13426535 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2097 | 2097 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13426593 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2350 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2098 | 2098 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13426597 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2099 | 2099 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13426601 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2100 | 2100 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13426742 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2101 | 2101 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13426821 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2102 | 2102 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13426832 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2150 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2103 | 2103 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13426836 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2104 | 2104 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13426840 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2105 | 2105 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39
13426962 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2150 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2106 | 2106 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13427271 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 2320 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.2109 | 2109 | yes | 33.3375 | 26.9875 | CL_vratné vodní (15 °C) 8
13427273 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 3000 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.2110 | 2110 | yes | 33.3375 | 26.9875 | CL_vratné vodní (15 °C) 8
13427277 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 3000 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.2111 | 2111 | yes | 33.3375 | 26.9875 | CL_vratné vodní (15 °C) 8
13427282 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 2320 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.2112 | 2112 | yes | 33.3375 | 26.9875 | CL_přívodní vodní (10 °C) 4
13427284 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 3000 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.2113 | 2113 | yes | 33.3375 | 26.9875 | CL_přívodní vodní (10 °C) 4
13427288 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 3000 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.2114 | 2114 | yes | 33.3375 | 26.9875 | CL_přívodní vodní (10 °C) 4
13427672 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2300 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2115 | 2115 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8 | Izolace - Typ izolace: Tepelná
13427683 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 2700 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2116 | 2116 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13427687 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2700 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2117 | 2117 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8 | Izolace - Typ izolace: Tepelná
13427711 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2118 | 2118 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23 | Izolace - Typ izolace: Tepelná
13427722 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2700 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2119 | 2119 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23 | Izolace - Typ izolace: Tepelná
13427727 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2700 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2120 | 2120 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23 | Izolace - Typ izolace: Tepelná
13427861 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2121 | 2121 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 2 | Izolace - Typ izolace: Tepelná
13427872 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2122 | 2122 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 2 | Izolace - Typ izolace: Tepelná
13427877 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2123 | 2123 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 2 | Izolace - Typ izolace: Tepelná
13427901 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2124 | 2124 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 6 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13427912 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2300 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2125 | 2125 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 6 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13427917 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2300 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2126 | 2126 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 6 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13428000 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2127 | 2127 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13428002 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2128 | 2128 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13428006 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2129 | 2129 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13430416 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2800 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2130 | 2130 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13430418 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2800 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2131 | 2131 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13431352 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HC | 2.NP_SO-102 | 2900 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2133 | 2133 | yes | 23.8125 | 17.4625 | CL_přívodní vodní (10 °C) 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13431408 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HC | 2.NP_SO-102 | 2900 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2135 | 2135 | yes | 23.8125 | 17.4625 | CL_vratné vodní (15 °C) 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13431459 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HC | 2.NP_SO-102 | 2900 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 16 | 32 | 0.0000179159 | 9.86346 | 45 | ø32-ø32 | 5.78656 | 34.925 | TT01.01.2136 | 2136 | yes | 23.8125 | 17.4625 | CL_vratné vodní (15 °C) 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13431461 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HC | 2.NP_SO-102 | 2900 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 16 | 32 | 0.0000179159 | 9.86346 | 45 | ø32-ø32 | 5.78656 | 34.925 | TT01.01.2137 | 2137 | yes | 23.8125 | 17.4625 | CL_vratné vodní (15 °C) 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13431543 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-102 | 3950 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.2138 | 2138 | no | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 12
13431564 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.2139 | 2139 |  | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 12
13431604 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.2142 | 2142 | no | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 9
13432293 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 2700 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.2143 | 2143 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13432301 | 1.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 1.NP_SO-102 | -900 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.2144 | 2144 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13432305 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.2145 | 2145 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13432330 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 2700 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.2146 | 2146 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13432338 | 1.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 1.NP_SO-102 | -900 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.2147 | 2147 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13432342 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.2148 | 2148 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13434252 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 12 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2149 | 2149 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 12 | Mechanické – tok - Tlaková ztráta: 0 Pa
13434254 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 12 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2150 | 2150 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 12 | Mechanické – tok - Tlaková ztráta: 0 Pa
13434293 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2153 | 2153 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13434295 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2154 | 2154 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13434604 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2155 | 2155 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13434606 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2156 | 2156 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13434657 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 12 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2157 | 2157 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 12 | Mechanické – tok - Tlaková ztráta: 0 Pa
