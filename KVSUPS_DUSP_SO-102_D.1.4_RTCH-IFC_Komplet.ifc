Properties of the parts of a building model (IFC4), part 65 of 72

# IfcPipeSegment: Typy trubek:Ocel_uhlíková (1186)
Name (Typy trubek:Ocel_uhlíková:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Tloušťka izolace (mm) | Celková velikost | Relativní drsnost | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) | Řez | Délka (mm) | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
13140374 | 3.NP_SO-102 | 405.075 | 0.000568237 | 0.0342324 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10789.2 | 0.0254516 | 20 | 432 | 405.075 | ø20 | 26.9 | 21.6 | TR02.02.1059 | 1059 | yes | HT_přívodní vodní (55 °C) 19 | 0
13140570 | 3.NP_SO-102 | 185.93 | 0.000568237 | 0.0157127 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2863.45 | 2850 | 2850 | 2836.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10839.2 | 0.0116823 | 20 | 444 | 185.93 | ø20 | 26.9 | 21.6 | TR02.02.1064 | 1064 | yes | HT_vratné vodní (45 °C) 13 | 0
13140745 | 3.NP_SO-102 | 2811.04 | 0.000568237 | 0.237558 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2782.54 | -28.5063 | 2782.54 | -28.5063 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7971.49 | 0.176623 | 20 | 432 | 2811.04 | ø20 | 26.9 | 21.6 | TR02.02.1065 | 1065 | yes | HT_přívodní vodní (55 °C) 19
13140782 | 3.NP_SO-102 | 2871.04 | 0.000568237 | 0.242629 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2832.54 | 2832.54 | -38.5063 | -38.5063 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7961.49 | 0.180393 | 20 | 444 | 2871.04 | ø20 | 26.9 | 21.6 | TR02.02.1066 | 1066 | yes | HT_vratné vodní (45 °C) 13
13140937 | 3.NP_SO-102 | 3706.78 | 0.000568237 | 0.313256 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10789.2 | 0.232904 | 20 | 427 | 3706.78 | ø20 | 26.9 | 21.6 | TR02.02.1069 | 1069 | yes | HT_přívodní vodní (55 °C) 19 | 0
13140945 | 3.NP_SO-102 | 385.075 | 0.000568237 | 0.0325422 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10789.2 | 0.024195 | 20 | 427 | 385.075 | ø20 | 26.9 | 21.6 | TR02.02.1070 | 1070 | yes | HT_přívodní vodní (55 °C) 19 | 0
13141026 | 3.NP_SO-102 | 235.075 | 0.000568237 | 0.0198659 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10789.2 | 0.0147702 | 20 | 438 | 235.075 | ø20 | 26.9 | 21.6 | TR02.02.1073 | 1073 | yes | HT_vratné vodní (45 °C) 13 | 0
13141430 | 3.NP_SO-102 | 2811.04 | 0.000568237 | 0.237558 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2782.54 | -28.5063 | 2782.54 | -28.5063 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7971.49 | 0.176623 | 20 | 427 | 2811.04 | ø20 | 26.9 | 21.6 | TR02.02.1076 | 1076 | yes | HT_přívodní vodní (55 °C) 19
13141475 | 3.NP_SO-102 | 2821.04 | 0.000568237 | 0.238403 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2782.54 | -38.5063 | 2782.54 | -38.5063 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7961.49 | 0.177251 | 20 | 438 | 2821.04 | ø20 | 26.9 | 21.6 | TR02.02.1077 | 1077 | yes | HT_vratné vodní (45 °C) 13
13141983 | 3.NP_SO-102 | 2825.08 | 0.000568237 | 0.238744 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 18 | 11269.2 | 0.177505 | 20 | 23 | 2825.08 | ø20 | 26.9 | 21.6 | TR02.02.1080 | 1080 | yes | HT_přívodní vodní (55 °C) 18; HT_přívodní vodní (65 °C) 15 | 0
13141996 | 3.NP_SO-102 | 2530 | 0.000568237 | 0.213807 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 18 | 11269.2 | 0.158965 | 20 | 23 | 2530 | ø20 | 26.9 | 21.6 | TR02.02.1081 | 1081 | yes | HT_přívodní vodní (55 °C) 18 | 0
13142006 | 3.NP_SO-102 | 345.075 | 0.000568237 | 0.0291619 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 18 | 11269.2 | 0.0216817 | 20 | 23 | 345.075 | ø20 | 26.9 | 21.6 | TR02.02.1082 | 1082 | yes | HT_přívodní vodní (55 °C) 18 | 0
13142041 | 3.NP_SO-102 | 2825.08 | 0.000568237 | 0.238744 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11269.2 | 0.177505 | 20 | 353 | 2825.08 | ø20 | 26.9 | 21.6 | TR02.02.1083 | 1083 | yes | HT_vratné vodní (45 °C) 1 | 0
13142050 | 3.NP_SO-102 | 2530 | 0.000568237 | 0.213807 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11269.2 | 0.158965 | 20 | 353 | 2530 | ø20 | 26.9 | 21.6 | TR02.02.1084 | 1084 | yes | HT_vratné vodní (45 °C) 1 | 0
13142059 | 3.NP_SO-102 | 195.075 | 0.000568237 | 0.0164856 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11269.2 | 0.0122569 | 20 | 353 | 195.075 | ø20 | 26.9 | 21.6 | TR02.02.1085 | 1085 | yes | HT_vratné vodní (45 °C) 1 | 0
13142236 | 3.NP_SO-102 | 3291.04 | 0.000568237 | 0.278122 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3262.54 | -28.5063 | 3262.54 | -28.5063 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 18 | 7971.49 | 0.206782 | 20 | 23 | 3291.04 | ø20 | 26.9 | 21.6 | TR02.02.1088 | 1088 | yes | HT_přívodní vodní (55 °C) 18
13142363 | 3.NP_SO-102 | 3301.04 | 0.000568237 | 0.278967 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3262.54 | -38.5063 | 3262.54 | -38.5063 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7961.49 | 0.207411 | 20 | 353 | 3301.04 | ø20 | 26.9 | 21.6 | TR02.02.1091 | 1091 | yes | HT_vratné vodní (45 °C) 1
13142873 | 3.NP_SO-102 | 631.063 | 0.000568237 | 0.0533304 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 20 | 10889.2 | 0.0396509 | 20 | 24 | 631.063 | ø20 | 26.9 | 21.6 | TR02.02.1092 | 1092 | yes | HT_přívodní vodní (55 °C) 20 | 0
13142882 | 3.NP_SO-102 | 3215.03 | 0.000568237 | 0.271698 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 20 | 10889.2 | 0.202006 | 20 | 24 | 3215.03 | ø20 | 26.9 | 21.6 | TR02.02.1093 | 1093 | yes | HT_přívodní vodní (55 °C) 20 | 0
13142892 | 3.NP_SO-102 | 1327.82 | 0.000568237 | 0.112213 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 20 | 10889.2 | 0.0834295 | 20 | 24 | 1327.82 | ø20 | 26.9 | 21.6 | TR02.02.1094 | 1094 | yes | HT_přívodní vodní (55 °C) 20 | 0
13142904 | 3.NP_SO-102 | 186.903 | 0.000568237 | 0.0157949 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 20 | 10889.2 | 0.0117434 | 20 | 24 | 186.903 | ø20 | 26.9 | 21.6 | TR02.02.1095 | 1095 | yes | HT_přívodní vodní (55 °C) 20 | 0
13142992 | 3.NP_SO-102 | 541.063 | 0.000568237 | 0.0457246 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10889.2 | 0.033996 | 20 | 352 | 541.063 | ø20 | 26.9 | 21.6 | TR02.02.1096 | 1096 | yes | HT_vratné vodní (45 °C) 1 | 0
13143001 | 3.NP_SO-102 | 3165.03 | 0.000568237 | 0.267473 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10889.2 | 0.198864 | 20 | 352 | 3165.03 | ø20 | 26.9 | 21.6 | TR02.02.1097 | 1097 | yes | HT_vratné vodní (45 °C) 1 | 0
13143010 | 3.NP_SO-102 | 1267.82 | 0.000568237 | 0.107142 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10889.2 | 0.0796596 | 20 | 352 | 1267.82 | ø20 | 26.9 | 21.6 | TR02.02.1098 | 1098 | yes | HT_vratné vodní (45 °C) 1 | 0
13143019 | 3.NP_SO-102 | 86.9026 | 0.000568237 | 0.00734404 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10889.2 | 0.00546025 | 20 | 352 | 86.9026 | ø20 | 26.9 | 21.6 | TR02.02.1099 | 1099 | yes | HT_vratné vodní (45 °C) 1 | 0
13143313 | 3.NP_SO-102 | 345.075 | 0.000568237 | 0.0291619 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3262.54 | 2917.46 | 3262.54 | 2917.46 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 20 | 10917.5 | 0.0216817 | 20 | 24 | 345.075 | ø20 | 26.9 | 21.6 | TR02.02.1100 | 1100 | yes | HT_přívodní vodní (65 °C) 15; HT_přívodní vodní (55 °C) 20
13143346 | 3.NP_SO-102 | 345.075 | 0.000568237 | 0.0291619 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3262.54 | 2917.46 | 3262.54 | 2917.46 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10917.5 | 0.0216817 | 20 | 352 | 345.075 | ø20 | 26.9 | 21.6 | TR02.02.1101 | 1101 | yes | HT_vratné vodní (45 °C) 1
13143686 | 3.NP_SO-102 | 2902.31 | 0.000891835 | 0.307273 | 0 | ø25 mm | 0.00367647 | HD | 3.NP_SO-102 | 2875.39 | -26.9188 | 2875.39 | -26.9188 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 20 | 7973.08 | 0.227947 | 25 | 36 | 2902.31 | ø25 | 33.7 | 27.2 | TR02.02.1103 | 1103 | yes | HT_přívodní vodní (55 °C) 20
13143829 | 3.NP_SO-102 | 2921.31 | 0.000568237 | 0.246876 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2882.54 | -38.7688 | 2882.54 | -38.7688 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7961.23 | 0.183551 | 20 | 352 | 2921.31 | ø20 | 26.9 | 21.6 | TR02.02.1105 | 1105 | yes | HT_vratné vodní (45 °C) 1
13144316 | 4.NP_SO-102 | 1916.2 | 0.000568237 | 0.161936 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 14889.2 | 0.120398 | 20 | 493 | 1916.2 | ø20 | 26.9 | 21.6 | TR02.02.1111 | 1111 | yes | HT_přívodní vodní (55 °C) 19 | 0
13144324 | 4.NP_SO-102 | 305.075 | 0.000568237 | 0.0257815 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 14889.2 | 0.0191684 | 20 | 493 | 305.075 | ø20 | 26.9 | 21.6 | TR02.02.1112 | 1112 | yes | HT_přívodní vodní (55 °C) 19 | 0
13144517 | 4.NP_SO-102 | 155.075 | 0.000568237 | 0.0131052 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 14889.2 | 0.00974365 | 20 | 491 | 155.075 | ø20 | 26.9 | 21.6 | TR02.02.1117 | 1117 | yes | HT_vratné vodní (45 °C) 13 | 0
13144646 | 4.NP_SO-102 | 2911.04 | 0.000568237 | 0.246009 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2882.54 | 2882.54 | -28.5062 | -28.5063 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 11971.5 | 0.182906 | 20 | 493 | 2911.04 | ø20 | 26.9 | 21.6 | TR02.02.1118 | 1118 | yes | HT_přívodní vodní (55 °C) 19
13144683 | 4.NP_SO-102 | 2921.04 | 0.000568237 | 0.246854 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2882.54 | 2882.54 | -38.5062 | -38.5063 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 11961.5 | 0.183535 | 20 | 491 | 2921.04 | ø20 | 26.9 | 21.6 | TR02.02.1119 | 1119 | yes | HT_vratné vodní (45 °C) 13
13144968 | 4.NP_SO-102 | 57.9313 | 0.000356274 | 0.00387652 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3287.3 | 3287.3 | 3229.37 | 3229.37 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 15229.4 | 0.00272995 | 15 | 530 | 57.9313 | ø15 | 21.3 | 16 | TR02.02.1120 | 1120 | yes | HT_vratné vodní (45 °C) 13
13144971 | 4.NP_SO-102 | 3044.2 | 0.000568237 | 0.257262 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 15189.2 | 0.191273 | 20 | 492 | 3044.2 | ø20 | 26.9 | 21.6 | TR02.02.1121 | 1121 | yes | HT_vratné vodní (45 °C) 13 | 0
13145118 | 4.NP_SO-102 | 495.075 | 0.000568237 | 0.0418382 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 14889.2 | 0.0311065 | 20 | 477 | 495.075 | ø20 | 26.9 | 21.6 | TR02.02.1124 | 1124 | yes | HT_přívodní vodní (55 °C) 19 | 0
13145189 | 4.NP_SO-102 | 345.075 | 0.000568237 | 0.0291619 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 14889.2 | 0.0216817 | 20 | 507 | 345.075 | ø20 | 26.9 | 21.6 | TR02.02.1126 | 1126 | yes | HT_vratné vodní (45 °C) 13 | 0
13145461 | 4.NP_SO-102 | 2907.31 | 0.000568237 | 0.245693 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2882.54 | 2882.54 | -24.7687 | -24.7688 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 11975.2 | 0.182671 | 20 | 477 | 2907.31 | ø20 | 26.9 | 21.6 | TR02.02.1128 | 1128 | yes | HT_přívodní vodní (55 °C) 19
13145546 | 4.NP_SO-102 | 2917.31 | 0.000568237 | 0.246538 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2882.54 | 2882.54 | -34.7687 | -34.7688 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 11965.2 | 0.1833 | 20 | 507 | 2917.31 | ø20 | 26.9 | 21.6 | TR02.02.1130 | 1130 | yes | HT_vratné vodní (45 °C) 13
13147088 | 4.NP_SO-102 | 1351.91 | 0.000568237 | 0.114248 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2863.45 | 2850 | 2850 | 2836.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 33 | 14839.2 | 0.084943 | 20 | 13 | 1351.91 | ø20 | 26.9 | 21.6 | TR02.02.1131 | 1131 | yes | HT_přívodní vodní (65 °C) 33 | 0
13147096 | 4.NP_SO-102 | 116.484 | 0.000568237 | 0.00984392 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2863.45 | 2850 | 2850 | 2836.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 22 | 14839.2 | 0.0073189 | 20 | 2 | 116.484 | ø20 | 26.9 | 21.6 | TR02.02.1132 | 1132 | yes | HT_přívodní vodní (65 °C) 35; HT_přívodní vodní (55 °C) 22 | 0
13147121 | 4.NP_SO-102 | 206.484 | 0.000568237 | 0.0174497 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2933.45 | 2920 | 2920 | 2906.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 14909.2 | 0.0129738 | 20 | 835 | 206.484 | ø20 | 26.9 | 21.6 | TR02.02.1133 | 1133 | yes | HT_vratné vodní (45 °C) 1 | 0
13147400 | 4.NP_SO-102 | 2934.69 | 0.000568237 | 0.248008 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2902.54 | -32.1562 | 2902.54 | -32.1563 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11967.8 | 0.184392 | 20 | 835 | 2934.69 | ø20 | 26.9 | 21.6 | TR02.02.1134 | 1134 | yes | HT_vratné vodní (45 °C) 1
13147445 | 4.NP_SO-102 | 2854.69 | 0.000568237 | 0.241247 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2832.54 | 2832.54 | -22.1562 | -22.1563 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 21 | 11977.8 | 0.179366 | 20 | 1 | 2854.69 | ø20 | 26.9 | 21.6 | TR02.02.1135 | 1135 | yes | HT_přívodní vodní (55 °C) 21
13147943 | 4.NP_SO-102 | 365.075 | 0.000568237 | 0.0308521 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3182.54 | 2817.46 | 3182.54 | 2817.46 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 23 | 14817.5 | 0.0229383 | 20 | 2 | 365.075 | ø20 | 26.9 | 21.6 | TR02.02.1140 | 1140 | yes | HT_přívodní vodní (65 °C) 28; HT_přívodní vodní (55 °C) 23
13148000 | 4.NP_SO-102 | 1379.2 | 0.000568237 | 0.116555 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 23 | 14789.2 | 0.0866577 | 20 | 2 | 1379.2 | ø20 | 26.9 | 21.6 | TR02.02.1142 | 1142 | yes | HT_přívodní vodní (55 °C) 23 | 0
13148008 | 4.NP_SO-102 | 1085.08 | 0.000568237 | 0.0916984 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 23 | 14789.2 | 0.0681773 | 20 | 2 | 1085.08 | ø20 | 26.9 | 21.6 | TR02.02.1143 | 1143 | yes | HT_přívodní vodní (55 °C) 23 | 0
13148016 | 4.NP_SO-102 | 565.075 | 0.000568237 | 0.0477538 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 23 | 14789.2 | 0.0355047 | 20 | 2 | 565.075 | ø20 | 26.9 | 21.6 | TR02.02.1144 | 1144 | yes | HT_přívodní vodní (55 °C) 23 | 0
13148026 | 4.NP_SO-102 | 205.075 | 0.000568237 | 0.0173307 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 23 | 14789.2 | 0.0128852 | 20 | 2 | 205.075 | ø20 | 26.9 | 21.6 | TR02.02.1145 | 1145 | yes | HT_přívodní vodní (55 °C) 23 | 0
13148091 | 4.NP_SO-102 | 2811.04 | 0.000568237 | 0.237558 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2782.54 | -28.5063 | 2782.54 | -28.5063 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 23 | 11971.5 | 0.176623 | 20 | 2 | 2811.04 | ø20 | 26.9 | 21.6 | TR02.02.1147 | 1147 | yes | HT_přívodní vodní (55 °C) 23
13148179 | 4.NP_SO-102 | 1229.2 | 0.000568237 | 0.103878 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 14789.2 | 0.0772329 | 20 | 484 | 1229.2 | ø20 | 26.9 | 21.6 | TR02.02.1148 | 1148 | yes | HT_vratné vodní (45 °C) 1 | 0
13148188 | 4.NP_SO-102 | 1085.08 | 0.000568237 | 0.0916984 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 14789.2 | 0.0681773 | 20 | 484 | 1085.08 | ø20 | 26.9 | 21.6 | TR02.02.1149 | 1149 | yes | HT_vratné vodní (45 °C) 1 | 0
13148197 | 4.NP_SO-102 | 565.075 | 0.000568237 | 0.0477538 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 14789.2 | 0.0355047 | 20 | 484 | 565.075 | ø20 | 26.9 | 21.6 | TR02.02.1150 | 1150 | yes | HT_vratné vodní (45 °C) 1 | 0
13148254 | 4.NP_SO-102 | 55.075 | 0.000568237 | 0.00465432 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 14789.2 | 0.00346046 | 20 | 484 | 55.075 | ø20 | 26.9 | 21.6 | TR02.02.1151 | 1151 | yes | HT_vratné vodní (45 °C) 1 | 0
13148467 | 4.NP_SO-102 | 365.075 | 0.000568237 | 0.0308521 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3182.54 | 3182.54 | 2817.46 | 2817.46 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 14817.5 | 0.0229383 | 20 | 484 | 365.075 | ø20 | 26.9 | 21.6 | TR02.02.1154 | 1154 | yes | HT_vratné vodní (45 °C) 1
13149026 | 4.NP_SO-102 | 284.413 | 0.000568237 | 0.0240354 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3283.45 | 3270 | 3270 | 3256.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 24 | 15259.2 | 0.0178702 | 20 | 6 | 284.413 | ø20 | 26.9 | 21.6 | TR02.02.1157 | 1157 | yes | HT_přívodní vodní (55 °C) 24 | 0
13149133 | 4.NP_SO-102 | 434.413 | 0.000568237 | 0.0367118 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3283.45 | 3270 | 3270 | 3256.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 15259.2 | 0.027295 | 20 | 797 | 434.413 | ø20 | 26.9 | 21.6 | TR02.02.1160 | 1160 | yes | HT_vratné vodní (45 °C) 1 | 0
13149246 | 4.NP_SO-102 | 3281.04 | 0.000568237 | 0.277277 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3252.54 | -28.5063 | 3252.54 | -28.5063 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 24 | 11971.5 | 0.206154 | 20 | 6 | 3281.04 | ø20 | 26.9 | 21.6 | TR02.02.1161 | 1161 | yes | HT_přívodní vodní (55 °C) 24
13149364 | 4.NP_SO-102 | 3291.04 | 0.000568237 | 0.278122 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3252.54 | -38.5063 | 3252.54 | -38.5063 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11961.5 | 0.206782 | 20 | 797 | 3291.04 | ø20 | 26.9 | 21.6 | TR02.02.1165 | 1165 | yes | HT_vratné vodní (45 °C) 1
13149447 | 4.NP_SO-102 | 4806.3 | 0.000568237 | 0.406175 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 18 | 15189.2 | 0.301989 | 20 | 24 | 4806.3 | ø20 | 26.9 | 21.6 | TR02.02.1168 | 1168 | yes | HT_přívodní vodní (55 °C) 9; HT_přívodní vodní (65 °C) 18 | 0
13149543 | 4.NP_SO-102 | 369.55 | 0.000568237 | 0.0312302 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3283.45 | 3270 | 3270 | 3256.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 15259.2 | 0.0232195 | 20 | 797 | 369.55 | ø20 | 26.9 | 21.6 | TR02.02.1169 | 1169 | yes | HT_vratné vodní (45 °C) 1 | 0
13149700 | 4.NP_SO-102 | 35.075 | 0.000568237 | 0.00296415 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3252.54 | 3217.46 | 3252.54 | 3217.46 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 15217.5 | 0.00220383 | 20 | 797 | 35.075 | ø20 | 26.9 | 21.6 | TR02.02.1170 | 1170 | yes | HT_vratné vodní (45 °C) 1
13149754 | 4.NP_SO-102 | 35.075 | 0.000568237 | 0.00296415 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3252.54 | 3217.46 | 3252.54 | 3217.46 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 18 | 15217.5 | 0.00220383 | 20 | 24 | 35.075 | ø20 | 26.9 | 21.6 | TR02.02.1171 | 1171 | yes | HT_přívodní vodní (65 °C) 18
13149897 | 4.NP_SO-102 | 1489.31 | 0.000356274 | 0.0996587 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 2860.65 | 2850 | 2850 | 2839.35 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 10 | 14842 | 0.0701821 | 15 | 304 | 1489.31 | ø15 | 21.3 | 16 | TR02.02.1172 | 1172 | yes | HT_přívodní vodní (65 °C) 10 | 0
13149981 | 4.NP_SO-102 | 2184.42 | 0.000568237 | 0.184603 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2933.45 | 2920 | 2920 | 2906.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 14909.2 | 0.137251 | 20 | 835 | 2184.42 | ø20 | 26.9 | 21.6 | TR02.02.1173 | 1173 | yes | HT_vratné vodní (45 °C) 1 | 0
13150046 | 3.NP_SO-102 | 1115.08 | 0.000356274 | 0.0746163 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 3935.71 | 3935.71 | 2820.64 | 2820.64 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10820.6 | 0.0525467 | 15 | 347 | 1115.08 | ø15 | 21.3 | 16 | TR02.02.1175 | 1175 | no | HT_přívodní vodní (55 °C) 9
13159555 | -1.PP_SO-102 | 3133.33 | 0.00285535 | 0.593571 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-102 | 2830.15 | 2800 | 2800 | 2769.85 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 31 | -1226.5 | 0.492182 | 50 | 94 | 3133.33 | ø50 | 60.3 | 53 | TR02.02.1179 | 1179 | yes | HT_přívodní vodní (65 °C) 31 | 0
13159703 | -1.PP_SO-102 | 333.325 | 0.00285535 | 0.0631444 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-102 | 3166.66 | 3166.66 | 2833.34 | 2833.34 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 31 | -1166.66 | 0.0523586 | 50 | 94 | 333.325 | ø50 | 60.3 | 53 | TR02.02.1180 | 1180 | yes | HT_přívodní vodní (65 °C) 31
13159713 | -1.PP_SO-102 | 1024.29 | 0.00285535 | 0.19404 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-102 | 3230.15 | 3200 | 3200 | 3169.85 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 31 | -826.5 | 0.160895 | 50 | 94 | 1024.29 | ø50 | 60.3 | 53 | TR02.02.1181 | 1181 | yes | HT_přívodní vodní (65 °C) 31 | 0
13159728 | -1.PP_SO-102 | 4386.66 | 0.00285535 | 0.831001 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-102 | 3230.15 | 3200 | 3200 | 3169.85 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 31 | -826.5 | 0.689055 | 50 | 94 | 4386.66 | ø50 | 60.3 | 53 | TR02.02.1182 | 1182 | yes | HT_přívodní vodní (65 °C) 31 | 0
13160111 | -1.PP_SO-102 | 3333.32 | 0.00285535 | 0.631459 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-102 | 2880.15 | 2850 | 2850 | 2819.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 6 | -1176.5 | 0.523597 | 50 | 187 | 3333.32 | ø50 | 60.3 | 53 | TR02.02.1183 | 1183 | yes | HT_vratné vodní (45 °C) 6 | 0
13160120 | -1.PP_SO-102 | 3552.38 | 0.00141175 | 0.473189 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 2871.2 | 2850 | 2850 | 2828.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 36 | -1167.95 | 0.357124 | 32 | 184 | 3552.38 | ø32 | 42.4 | 35.9 | TR02.02.1184 | 1184 | yes | HT_přívodní vodní (65 °C) 36 | 0
13160129 | -1.PP_SO-102 | 3752.38 | 0.00141175 | 0.49983 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 2871.2 | 2850 | 2850 | 2828.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 4 | -1167.95 | 0.37723 | 32 | 8 | 3752.38 | ø32 | 42.4 | 35.9 | TR02.02.1185 | 1185 | yes | HT_vratné vodní (45 °C) 4 | 0
13160138 | -1.PP_SO-102 | 3946.02 | 0.00183197 | 0.598766 | 0 | ø40 mm | 0.00239234 | HD | -1.PP_SO-102 | 2874.15 | 2850 | 2850 | 2825.85 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 32 | -1170.9 | 0.495872 | 40 | 2 | 3946.02 | ø40 | 48.3 | 41.8 | TR02.02.1186 | 1186 | yes | HT_přívodní vodní (65 °C) 32 | 0
13160147 | -1.PP_SO-102 | 4236.99 | 0.00183197 | 0.642916 | 0 | ø40 mm | 0.00239234 | HD | -1.PP_SO-102 | 2874.15 | 2850 | 2850 | 2825.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 8 | -1170.9 | 0.532436 | 40 | 186 | 4236.99 | ø40 | 48.3 | 41.8 | TR02.02.1187 | 1187 | yes | HT_vratné vodní (45 °C) 8 | 0
13160216 | -1.PP_SO-102 | 4187.51 | 0.00285535 | 0.793274 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-102 | 3230.15 | 3200 | 3200 | 3169.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 6 | -826.5 | 0.657773 | 50 | 187 | 4187.51 | ø50 | 60.3 | 53 | TR02.02.1188 | 1188 | yes | HT_vratné vodní (45 °C) 6 | 0
13160225 | -1.PP_SO-102 | 824.29 | 0.00285535 | 0.156152 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-102 | 3230.15 | 3200 | 3200 | 3169.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 6 | -826.5 | 0.129479 | 50 | 187 | 824.29 | ø50 | 60.3 | 53 | TR02.02.1189 | 1189 | yes | HT_vratné vodní (45 °C) 6 | 0
13160234 | -1.PP_SO-102 | 3997.04 | 0.00141175 | 0.53242 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 3221.2 | 3200 | 3200 | 3178.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 36 | -817.95 | 0.401826 | 32 | 184 | 3997.04 | ø32 | 42.4 | 35.9 | TR02.02.1190 | 1190 | yes | HT_přívodní vodní (65 °C) 36 | 0
13160243 | -1.PP_SO-102 | 3297.04 | 0.00141175 | 0.439177 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 3221.2 | 3200 | 3200 | 3178.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 4 | -817.95 | 0.331454 | 32 | 8 | 3297.04 | ø32 | 42.4 | 35.9 | TR02.02.1191 | 1191 | yes | HT_vratné vodní (45 °C) 4 | 0
13160252 | -1.PP_SO-102 | 3093.86 | 0.00183197 | 0.469459 | 0 | ø40 mm | 0.00239234 | HD | -1.PP_SO-102 | 3224.15 | 3200 | 3200 | 3175.85 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 32 | -820.9 | 0.388786 | 40 | 2 | 3093.86 | ø40 | 48.3 | 41.8 | TR02.02.1192 | 1192 | yes | HT_přívodní vodní (65 °C) 32 | 0
13160261 | -1.PP_SO-102 | 2893.01 | 0.00183197 | 0.438983 | 0 | ø40 mm | 0.00239234 | HD | -1.PP_SO-102 | 3224.15 | 3200 | 3200 | 3175.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 8 | -820.9 | 0.363547 | 40 | 186 | 2893.01 | ø40 | 48.3 | 41.8 | TR02.02.1193 | 1193 | yes | HT_vratné vodní (45 °C) 8 | 0
13160270 | -1.PP_SO-102 | 643.34 | 0.00141175 | 0.0856952 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 3221.2 | 3200 | 3200 | 3178.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 36 | -817.95 | 0.0646756 | 32 | 184 | 643.34 | ø32 | 42.4 | 35.9 | TR02.02.1194 | 1194 | yes | HT_přívodní vodní (65 °C) 36 | 0
13160279 | -1.PP_SO-102 | 443.34 | 0.00141175 | 0.0590545 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 3221.2 | 3200 | 3200 | 3178.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 4 | -817.95 | 0.0445694 | 32 | 8 | 443.34 | ø32 | 42.4 | 35.9 | TR02.02.1195 | 1195 | yes | HT_vratné vodní (45 °C) 4 | 0
13160288 | -1.PP_SO-102 | 236.99 | 0.00183197 | 0.0359606 | 0 | ø40 mm | 0.00239234 | HD | -1.PP_SO-102 | 3224.15 | 3200 | 3200 | 3175.85 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 32 | -820.9 | 0.0297811 | 40 | 2 | 236.99 | ø40 | 48.3 | 41.8 | TR02.02.1196 | 1196 | yes | HT_přívodní vodní (65 °C) 32 | 0
13160655 | -1.PP_SO-102 | 302.375 | 0.00141175 | 0.0402774 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 3176.19 | 3176.19 | 2873.81 | 2873.81 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 36 | -1126.19 | 0.0303981 | 32 | 184 | 302.375 | ø32 | 42.4 | 35.9 | TR02.02.1197 | 1197 | yes | HT_přívodní vodní (65 °C) 36
13160689 | -1.PP_SO-102 | 283.325 | 0.00285535 | 0.0536725 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-102 | 3166.66 | 3166.66 | 2883.34 | 2883.34 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 6 | -1116.66 | 0.0445046 | 50 | 187 | 283.325 | ø50 | 60.3 | 53 | TR02.02.1198 | 1198 | yes | HT_vratné vodní (45 °C) 6
13160750 | -1.PP_SO-102 | 302.375 | 0.00141175 | 0.0402774 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 3176.19 | 2873.81 | 3176.19 | 2873.81 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 4 | -1126.19 | 0.0303981 | 32 | 8 | 302.375 | ø32 | 42.4 | 35.9 | TR02.02.1199 | 1199 | yes | HT_vratné vodní (45 °C) 4
13160821 | -1.PP_SO-102 | 296.025 | 0.00183197 | 0.0449185 | 0 | ø40 mm | 0.00239234 | HD | -1.PP_SO-102 | 3173.01 | 3173.01 | 2876.99 | 2876.99 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 32 | -1123.01 | 0.0371996 | 40 | 2 | 296.025 | ø40 | 48.3 | 41.8 | TR02.02.1200 | 1200 | yes | HT_přívodní vodní (65 °C) 32
13163451 | -1.PP_SO-102 | 10843.9 | 0.00141175 | 1.44445 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2471.2 | 2450 | 2450 | 2428.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | -1567.95 | 1.09015 | 32 | 39 | 10843.9 | ø32 | 42.4 | 35.9 | TR02.02.1201 | 1201 | yes | HT_přívodní vodní (65 °C) 6 | 0 | Izolace - Typ izolace: Tepelná
13163463 | -1.PP_SO-102 | 102.375 | 0.00141175 | 0.0136367 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2471.2 | 2450 | 2450 | 2428.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | -1567.95 | 0.0102919 | 32 | 39 | 102.375 | ø32 | 42.4 | 35.9 | TR02.02.1202 | 1202 | yes | HT_přívodní vodní (65 °C) 6 | 0 | Izolace - Typ izolace: Tepelná
13163541 | -1.PP_SO-102 | 3890.51 | 0.00141175 | 0.51823 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2471.2 | 2450 | 2450 | 2428.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -1567.95 | 0.391117 | 32 | 146 | 3890.51 | ø32 | 42.4 | 35.9 | TR02.02.1203 | 1203 | yes | HT_vratné vodní (45 °C) 2 | 0 | Izolace - Typ izolace: Tepelná
13163785 | -1.PP_SO-102 | 2352.38 | 0.00141175 | 0.313345 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2426.19 | 73.8125 | 2426.19 | 73.8125 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | -3926.19 | 0.236487 | 32 | 39 | 2352.38 | ø32 | 42.4 | 35.9 | TR02.02.1204 | 1204 | yes | HT_přívodní vodní (65 °C) 6 | Izolace - Typ izolace: Tepelná
13163999 | -1.PP_SO-102 | 2352.38 | 0.00141175 | 0.313345 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2426.19 | 73.8125 | 2426.19 | 73.8125 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -3926.19 | 0.236487 | 32 | 146 | 2352.38 | ø32 | 42.4 | 35.9 | TR02.02.1205 | 1205 | yes | HT_vratné vodní (45 °C) 2 | Izolace - Typ izolace: Tepelná
13171876 | 3.NP_SO-102 | 4621.43 | 0.000356274 | 0.309247 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11362 | 0.21778 | 15 | 15 | 4621.42 | ø15 | 21.3 | 16 | TR02.02.1206 | 1206 | yes | CL_přívodní vodní (10 °C) 1 | 0
13171947 | 3.NP_SO-102 | 195.713 | 0.000356274 | 0.0130963 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11362 | 0.00922273 | 15 | 8 | 195.713 | ø15 | 21.3 | 16 | TR02.02.1207 | 1207 | yes | CL_přívodní vodní (10 °C) 1 | 0
13172089 | 3.NP_SO-102 | 4534.99 | 0.000356274 | 0.303463 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11362 | 0.213706 | 15 | 12 | 4534.99 | ø15 | 21.3 | 16 | TR02.02.1208 | 1208 | yes | CL_přívodní vodní (10 °C) 1 | 0
13172100 | 3.NP_SO-102 | 185.713 | 0.000356274 | 0.0124271 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11362 | 0.0087515 | 15 | 7 | 185.713 | ø15 | 21.3 | 16 | TR02.02.1209 | 1209 | yes | CL_přívodní vodní (10 °C) 1 | 0
13172180 | 3.NP_SO-102 | 2535.5 | 0.000356274 | 0.169665 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11362 | 0.119483 | 15 | 7 | 2535.5 | ø15 | 21.3 | 16 | TR02.02.1210 | 1210 | yes | CL_přívodní vodní (10 °C) 1 | 0
13172188 | 3.NP_SO-102 | 753.594 | 0.000356274 | 0.0504274 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11362 | 0.0355123 | 15 | 8 | 753.594 | ø15 | 21.3 | 16 | TR02.02.1211 | 1211 | yes | CL_přívodní vodní (10 °C) 1 | 0
13172202 | 3.NP_SO-102 | 4471.43 | 0.000356274 | 0.29921 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 11362 | 0.210711 | 15 | 13 | 4471.43 | ø15 | 21.3 | 16 | TR02.02.1212 | 1212 | yes | CL_vratné vodní (15 °C) 2 | 0
13172211 | 3.NP_SO-102 | 4534.99 | 0.000356274 | 0.303463 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 11362 | 0.213706 | 15 | 7 | 4534.99 | ø15 | 21.3 | 16 | TR02.02.1213 | 1213 | yes | CL_vratné vodní (15 °C) 2 | 0
13172238 | 3.NP_SO-102 | 45.7125 | 0.000356274 | 0.00305889 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 11362 | 0.00215415 | 15 | 22 | 45.7125 | ø15 | 21.3 | 16 | TR02.02.1214 | 1214 | yes | CL_vratné vodní (15 °C) 2 | 0
13172247 | 3.NP_SO-102 | 35.7125 | 0.000356274 | 0.00238973 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 11362 | 0.00168291 | 15 | 2 | 35.7125 | ø15 | 21.3 | 16 | TR02.02.1215 | 1215 | yes | CL_vratné vodní (15 °C) 2 | 0
13172489 | 3.NP_SO-102 | 2535.5 | 0.000356274 | 0.169665 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 11362 | 0.119483 | 15 | 2 | 2535.5 | ø15 | 21.3 | 16 | TR02.02.1216 | 1216 | yes | CL_vratné vodní (15 °C) 2 | 0
13172495 | 3.NP_SO-102 | 453.594 | 0.000356274 | 0.0303527 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 11362 | 0.0213751 | 15 | 22 | 453.594 | ø15 | 21.3 | 16 | TR02.02.1217 | 1217 | yes | CL_vratné vodní (15 °C) 2 | 0
13172563 | 3.NP_SO-102 | 327.46 | 0.000356274 | 0.0219123 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11362 | 0.0154312 | 15 | 14 | 327.46 | ø15 | 21.3 | 16 | TR02.02.1218 | 1218 | yes | CL_přívodní vodní (10 °C) 1 | 0
13172565 | 3.NP_SO-102 | 327.46 | 0.000356274 | 0.0219123 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11362 | 0.0154312 | 15 | 13 | 327.46 | ø15 | 21.3 | 16 | TR02.02.1219 | 1219 | yes | CL_přívodní vodní (10 °C) 1 | 0
13172567 | 3.NP_SO-102 | 2535.5 | 0.000356274 | 0.169665 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11362 | 0.119483 | 15 | 13 | 2535.5 | ø15 | 21.3 | 16 | TR02.02.1220 | 1220 | yes | CL_přívodní vodní (10 °C) 1 | 0
13172571 | 3.NP_SO-102 | 177.46 | 0.000356274 | 0.0118749 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 11362 | 0.00836259 | 15 | 9 | 177.46 | ø15 | 21.3 | 16 | TR02.02.1221 | 1221 | yes | CL_vratné vodní (15 °C) 2 | 0
13172573 | 3.NP_SO-102 | 177.46 | 0.000356274 | 0.0118749 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 11362 | 0.00836259 | 15 | 8 | 177.46 | ø15 | 21.3 | 16 | TR02.02.1222 | 1222 | yes | CL_vratné vodní (15 °C) 2 | 0
13172575 | 3.NP_SO-102 | 2535.5 | 0.000356274 | 0.169665 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 11362 | 0.119483 | 15 | 8 | 2535.5 | ø15 | 21.3 | 16 | TR02.02.1223 | 1223 | yes | CL_vratné vodní (15 °C) 2 | 0
13172602 | 3.NP_SO-102 | 327.46 | 0.000356274 | 0.0219123 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11362 | 0.0154312 | 15 | 11 | 327.46 | ø15 | 21.3 | 16 | TR02.02.1224 | 1224 | yes | CL_přívodní vodní (10 °C) 1 | 0
13172604 | 3.NP_SO-102 | 327.46 | 0.000356274 | 0.0219123 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11362 | 0.0154312 | 15 | 10 | 327.46 | ø15 | 21.3 | 16 | TR02.02.1225 | 1225 | yes | CL_přívodní vodní (10 °C) 1 | 0
13172606 | 3.NP_SO-102 | 2535.5 | 0.000356274 | 0.169665 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11362 | 0.119483 | 15 | 10 | 2535.5 | ø15 | 21.3 | 16 | TR02.02.1226 | 1226 | yes | CL_přívodní vodní (10 °C) 1 | 0
13172610 | 3.NP_SO-102 | 177.46 | 0.000356274 | 0.0118749 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 11362 | 0.00836259 | 15 | 6 | 177.46 | ø15 | 21.3 | 16 | TR02.02.1227 | 1227 | yes | CL_vratné vodní (15 °C) 2 | 0
13172612 | 3.NP_SO-102 | 177.46 | 0.000356274 | 0.0118749 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 11362 | 0.00836259 | 15 | 5 | 177.46 | ø15 | 21.3 | 16 | TR02.02.1228 | 1228 | yes | CL_vratné vodní (15 °C) 2 | 0
13172614 | 3.NP_SO-102 | 2535.5 | 0.000356274 | 0.169665 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 11362 | 0.119483 | 15 | 5 | 2535.5 | ø15 | 21.3 | 16 | TR02.02.1229 | 1229 | yes | CL_vratné vodní (15 °C) 2 | 0
13172657 | 3.NP_SO-102 | 453.594 | 0.000356274 | 0.0303527 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 11362 | 0.0213751 | 15 | 6 | 453.594 | ø15 | 21.3 | 16 | TR02.02.1230 | 1230 | yes | CL_vratné vodní (15 °C) 2 | 0
13172659 | 3.NP_SO-102 | 4876.27 | 0.000356274 | 0.3263 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 11362 | 0.229789 | 15 | 1 | 4876.27 | ø15 | 21.3 | 16 | TR02.02.1231 | 1231 | yes | CL_vratné vodní (15 °C) 2 | 0
13172678 | 3.NP_SO-102 | 753.594 | 0.000356274 | 0.0504274 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11362 | 0.0355123 | 15 | 11 | 753.594 | ø15 | 21.3 | 16 | TR02.02.1232 | 1232 | yes | CL_přívodní vodní (10 °C) 1 | 0
13172680 | 3.NP_SO-102 | 4876.27 | 0.000356274 | 0.3263 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11362 | 0.229789 | 15 | 51 | 4876.27 | ø15 | 21.3 | 16 | TR02.02.1233 | 1233 | yes | CL_přívodní vodní (10 °C) 1 | 0
13172699 | 3.NP_SO-102 | 453.594 | 0.000356274 | 0.0303527 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 11362 | 0.0213751 | 15 | 9 | 453.594 | ø15 | 21.3 | 16 | TR02.02.1234 | 1234 | yes | CL_vratné vodní (15 °C) 2 | 0
13172701 | 3.NP_SO-102 | 4037.91 | 0.000356274 | 0.2702 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 11362 | 0.190282 | 15 | 4 | 4037.91 | ø15 | 21.3 | 16 | TR02.02.1235 | 1235 | yes | CL_vratné vodní (15 °C) 2 | 0
13172720 | 3.NP_SO-102 | 753.594 | 0.000356274 | 0.0504274 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11362 | 0.0355123 | 15 | 14 | 753.594 | ø15 | 21.3 | 16 | TR02.02.1236 | 1236 | yes | CL_přívodní vodní (10 °C) 1 | 0
13172722 | 3.NP_SO-102 | 4037.91 | 0.000356274 | 0.2702 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11362 | 0.190282 | 15 | 9 | 4037.91 | ø15 | 21.3 | 16 | TR02.02.1237 | 1237 | yes | CL_přívodní vodní (10 °C) 1 | 0
13173073 | 3.NP_SO-102 | 327.46 | 0.000356274 | 0.0219123 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11362 | 0.0154312 | 15 | 16 | 327.46 | ø15 | 21.3 | 16 | TR02.02.1238 | 1238 | yes | CL_přívodní vodní (10 °C) 1 | 0
13173075 | 3.NP_SO-102 | 327.46 | 0.000356274 | 0.0219123 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11362 | 0.0154312 | 15 | 17 | 327.46 | ø15 | 21.3 | 16 | TR02.02.1239 | 1239 | yes | CL_přívodní vodní (10 °C) 1 | 0
13173079 | 3.NP_SO-102 | 177.46 | 0.000356274 | 0.0118749 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 11362 | 0.00836259 | 15 | 12 | 177.46 | ø15 | 21.3 | 16 | TR02.02.1240 | 1240 | yes | CL_vratné vodní (15 °C) 2 | 0
13173081 | 3.NP_SO-102 | 177.46 | 0.000356274 | 0.0118749 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 11362 | 0.00836259 | 15 | 11 | 177.46 | ø15 | 21.3 | 16 | TR02.02.1241 | 1241 | yes | CL_vratné vodní (15 °C) 2 | 0
13173083 | 3.NP_SO-102 | 2535.5 | 0.000356274 | 0.169665 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 11362 | 0.119483 | 15 | 11 | 2535.5 | ø15 | 21.3 | 16 | TR02.02.1242 | 1242 | yes | CL_vratné vodní (15 °C) 2 | 0
13173087 | 3.NP_SO-102 | 753.594 | 0.000356274 | 0.0504274 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11362 | 0.0355123 | 15 | 16 | 753.594 | ø15 | 21.3 | 16 | TR02.02.1243 | 1243 | yes | CL_přívodní vodní (10 °C) 1 | 0
13173134 | 3.NP_SO-102 | 2535.5 | 0.000356274 | 0.169665 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11362 | 0.119483 | 15 | 17 | 2535.5 | ø15 | 21.3 | 16 | TR02.02.1244 | 1244 | yes | CL_přívodní vodní (10 °C) 1 | 0
13173136 | 3.NP_SO-102 | 2803.55 | 0.000356274 | 0.187602 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 11362 | 0.132114 | 15 | 15 | 2803.55 | ø15 | 21.3 | 16 | TR02.02.1245 | 1245 | yes | CL_přívodní vodní (10 °C) 1 | 0
13173155 | 3.NP_SO-102 | 453.594 | 0.000356274 | 0.0303527 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 11362 | 0.0213751 | 15 | 12 | 453.594 | ø15 | 21.3 | 16 | TR02.02.1246 | 1246 | yes | CL_vratné vodní (15 °C) 2 | 0
13173157 | 3.NP_SO-102 | 2778.87 | 0.000356274 | 0.185951 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3380.65 | 3370 | 3370 | 3359.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 11362 | 0.130951 | 15 | 13 | 2778.87 | ø15 | 21.3 | 16 | TR02.02.1247 | 1247 | yes | CL_vratné vodní (15 °C) 2 | 0
13174072 | 1.NP_SO-102 | 482.538 | 0.000568237 | 0.0407787 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 2889.2 | 0.0303187 | 20 | 37 | 482.538 | ø20 | 26.9 | 21.6 | TR02.02.1248 | 1248 | yes | CL_přívodní vodní (10 °C) 1 | 0
13174237 | 1.NP_SO-102 | 5303.69 | 0.000568237 | 0.448209 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 2889.2 | 0.333241 | 20 | 42 | 5303.69 | ø20 | 26.9 | 21.6 | TR02.02.1249 | 1249 | yes | CL_přívodní vodní (10 °C) 1 | 0
13174245 | 1.NP_SO-102 | 1994.21 | 0.000568237 | 0.168528 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 2889.2 | 0.1253 | 20 | 42 | 1994.21 | ø20 | 26.9 | 21.6 | TR02.02.1250 | 1250 | yes | CL_přívodní vodní (10 °C) 1 | 0
13174253 | 1.NP_SO-102 | 382.538 | 0.000568237 | 0.0323278 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 2889.2 | 0.0240355 | 20 | 42 | 382.537 | ø20 | 26.9 | 21.6 | TR02.02.1251 | 1251 | yes | CL_přívodní vodní (10 °C) 1 | 0
13174287 | 1.NP_SO-102 | 252.538 | 0.000568237 | 0.0213417 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 2889.2 | 0.0158674 | 20 | 47 | 252.538 | ø20 | 26.9 | 21.6 | TR02.02.1252 | 1252 | yes | CL_přívodní vodní (10 °C) 1 | 0
13174296 | 1.NP_SO-102 | 1987.86 | 0.000568237 | 0.167992 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 2889.2 | 0.124901 | 20 | 47 | 1987.86 | ø20 | 26.9 | 21.6 | TR02.02.1253 | 1253 | yes | CL_přívodní vodní (10 °C) 1 | 0
13174305 | 1.NP_SO-102 | 7906.02 | 0.000568237 | 0.668129 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 2889.2 | 0.49675 | 20 | 40 | 7906.02 | ø20 | 26.9 | 21.6 | TR02.02.1254 | 1254 | yes | CL_přívodní vodní (10 °C) 1 | 0
13174393 | 2.NP_SO-102 | 3943.64 | 0.00141175 | 0.525307 | 0 | ø32 mm | 0.00278552 | HC | 2.NP_SO-102 | 2869.84 | -1073.81 | 2869.84 | -1073.81 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 2926.19 | 0.396458 | 32 | 30 | 3943.64 | ø32 | 42.4 | 35.9 | TR02.02.1255 | 1255 | yes | CL_vratné vodní (15 °C) 2
13174492 | 1.NP_SO-102 | 634.017 | 0.000568237 | 0.05358 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 2889.2 | 0.0398365 | 20 | 33 | 634.017 | ø20 | 26.9 | 21.6 | TR02.02.1256 | 1256 | yes | CL_vratné vodní (15 °C) 2 | 0
13174510 | 1.NP_SO-102 | 7604.54 | 0.000568237 | 0.642651 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 2889.2 | 0.477807 | 20 | 36 | 7604.54 | ø20 | 26.9 | 21.6 | TR02.02.1257 | 1257 | yes | CL_vratné vodní (15 °C) 2 | 0
13174537 | 1.NP_SO-102 | 1994.21 | 0.000568237 | 0.168528 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 2889.2 | 0.1253 | 20 | 38 | 1994.21 | ø20 | 26.9 | 21.6 | TR02.02.1258 | 1258 | yes | CL_vratné vodní (15 °C) 2 | 0
13174546 | 1.NP_SO-102 | 5603.69 | 0.000568237 | 0.473562 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 2889.2 | 0.352091 | 20 | 38 | 5603.69 | ø20 | 26.9 | 21.6 | TR02.02.1259 | 1259 | yes | CL_vratné vodní (15 °C) 2 | 0
13174555 | 1.NP_SO-102 | 1987.86 | 0.000568237 | 0.167992 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 2889.2 | 0.124901 | 20 | 43 | 1987.86 | ø20 | 26.9 | 21.6 | TR02.02.1260 | 1260 | yes | CL_vratné vodní (15 °C) 2 | 0
13174564 | 1.NP_SO-102 | 102.538 | 0.000568237 | 0.00866533 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 2889.2 | 0.00644262 | 20 | 43 | 102.538 | ø20 | 26.9 | 21.6 | TR02.02.1261 | 1261 | yes | CL_vratné vodní (15 °C) 2 | 0
13174573 | 1.NP_SO-102 | 222.538 | 0.000568237 | 0.0188064 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 2889.2 | 0.0139824 | 20 | 38 | 222.538 | ø20 | 26.9 | 21.6 | TR02.02.1262 | 1262 | yes | CL_vratné vodní (15 °C) 2 | 0
13174921 | 1.NP_SO-102 | 212.058 | 0.000568237 | 0.0179207 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 2889.2 | 0.013324 | 20 | 25 | 212.058 | ø20 | 26.9 | 21.6 | TR02.02.1263 | 1263 | yes | CL_přívodní vodní (10 °C) 1 | 0
13174927 | 1.NP_SO-102 | 1837.86 | 0.000568237 | 0.155315 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 2889.2 | 0.115476 | 20 | 37 | 1837.86 | ø20 | 26.9 | 21.6 | TR02.02.1264 | 1264 | yes | CL_přívodní vodní (10 °C) 1 | 0
13175040 | 1.NP_SO-102 | 2137.86 | 0.000568237 | 0.180668 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 2889.2 | 0.134326 | 20 | 33 | 2137.86 | ø20 | 26.9 | 21.6 | TR02.02.1265 | 1265 | yes | CL_vratné vodní (15 °C) 2 | 0
13175046 | 1.NP_SO-102 | 179.251 | 0.000568237 | 0.0151483 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 2889.2 | 0.0112627 | 20 | 29 | 179.251 | ø20 | 26.9 | 21.6 | TR02.02.1266 | 1266 | yes | CL_vratné vodní (15 °C) 2 | 0
13182810 | -1.PP_SO-102 | 3968.13 | 0.000356274 | 0.265531 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3934.06 | 3934.06 | -34.0625 | -34.0625 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 1 | -4034.06 | 0.186993 | 15 | 352 | 3968.13 | ø15 | 21.3 | 16 | TR02.02.1277 | 1277 | no | HT_přívodní vodní (65 °C) 1
13182846 | -1.PP_SO-102 | 3968.13 | 0.000356274 | 0.265531 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3924.06 | 3924.06 | -44.0625 | -44.0625 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -4044.06 | 0.186993 | 15 | 502 | 3968.13 | ø15 | 21.3 | 16 | TR02.02.1278 | 1278 | no | HT_vratné vodní (45 °C) 1
13186833 | -1.PP_SO-102 | 9362.77 | 0.00141175 | 1.24715 | 60 | ø152 mm | 0.00278552 | HD | -1.PP_SO-102 | 2621.2 | 2600 | 2600 | 2578.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -1417.95 | 0.941248 | 32 | 36 | 9362.77 | ø32 | 42.4 | 35.9 | TR02.02.1286 | 1286 | yes | HT_vratné vodní (45 °C) 23 | 0 | Izolace - Typ izolace: Tepelná
13187118 | -1.PP_SO-102 | 5905.89 | 0.00141175 | 0.786686 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2721.2 | 2700 | 2700 | 2678.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -1317.95 | 0.593725 | 32 | 36 | 5905.89 | ø32 | 42.4 | 35.9 | TR02.02.1287 | 1287 | yes | HT_vratné vodní (45 °C) 23 | 0 | Izolace - Typ izolace: Tepelná
13187184 | -1.PP_SO-102 | 847.587 | 0.00141175 | 0.112902 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 3321.2 | 3300 | 3300 | 3278.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -717.95 | 0.0852088 | 32 | 36 | 847.587 | ø32 | 42.4 | 35.9 | TR02.02.1288 | 1288 | yes | HT_vratné vodní (45 °C) 23 | 0
13187295 | -1.PP_SO-102 | 5909.86 | 0.00141175 | 0.787215 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2721.2 | 2700 | 2700 | 2678.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -1317.95 | 0.594124 | 32 | 55 | 5909.86 | ø32 | 42.4 | 35.9 | TR02.02.1289 | 1289 | yes | HT_přívodní vodní (65 °C) 8 | 0 | Izolace - Typ izolace: Tepelná
13187424 | -1.PP_SO-102 | 9366.32 | 0.00141175 | 1.24763 | 60 | ø152 mm | 0.00278552 | HD | -1.PP_SO-102 | 2621.2 | 2600 | 2600 | 2578.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -1417.95 | 0.941606 | 32 | 55 | 9366.32 | ø32 | 42.4 | 35.9 | TR02.02.1290 | 1290 | yes | HT_přívodní vodní (65 °C) 8 | 0 | Izolace - Typ izolace: Tepelná
13187710 | 1.NP_SO-102 | 6732.37 | 0.00141175 | 0.896776 | 0 | ø32 mm | 0.00278552 | HD | 1.NP_SO-102 | 6056.19 | 6056.19 | -676.188 | -676.188 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -676.187 | 0.676812 | 32 | 55 | 6732.37 | ø32 | 42.4 | 35.9 | TR02.02.1291 | 1291 | yes | HT_přívodní vodní (65 °C) 8
13187741 | 1.NP_SO-102 | 6732.37 | 0.00141175 | 0.896776 | 0 | ø32 mm | 0.00278552 | HD | 1.NP_SO-102 | 6056.19 | 6056.19 | -676.188 | -676.188 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -676.187 | 0.676812 | 32 | 36 | 6732.37 | ø32 | 42.4 | 35.9 | TR02.02.1292 | 1292 | yes | HT_vratné vodní (45 °C) 23
13187812 | 2.NP_SO-102 | 507.425 | 0.00141175 | 0.0675908 | 0 | ø32 mm | 0.00278552 | HD | 2.NP_SO-102 | 2101.2 | 2080 | 2080 | 2058.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 6062.05 | 0.051012 | 32 | 55 | 507.425 | ø32 | 42.4 | 35.9 | TR02.02.1293 | 1293 | yes | HT_přívodní vodní (65 °C) 8 | 0
13187946 | 2.NP_SO-102 | 357.587 | 0.00141175 | 0.0476319 | 0 | ø32 mm | 0.00278552 | HD | 2.NP_SO-102 | 2101.2 | 2080 | 2080 | 2058.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 6062.05 | 0.0359486 | 32 | 36 | 357.587 | ø32 | 42.4 | 35.9 | TR02.02.1294 | 1294 | yes | HT_vratné vodní (45 °C) 23 | 0
13188258 | 2.NP_SO-102 | 752.375 | 0.00141175 | 0.100219 | 0 | ø32 mm | 0.00278552 | HD | 2.NP_SO-102 | 2101.2 | 2080 | 2080 | 2058.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 6062.05 | 0.075637 | 32 | 55 | 752.375 | ø32 | 42.4 | 35.9 | TR02.02.1295 | 1295 | yes | HT_přívodní vodní (65 °C) 8 | 0
13188268 | 2.NP_SO-102 | 6740.27 | 0.00141175 | 0.897828 | 0 | ø32 mm | 0.00278552 | HD | 2.NP_SO-102 | 2221.2 | 2200 | 2200 | 2178.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 6182.05 | 0.677606 | 32 | 55 | 6740.27 | ø32 | 42.4 | 35.9 | TR02.02.1296 | 1296 | yes | HT_přívodní vodní (65 °C) 8 | 0
13188517 | 2.NP_SO-102 | 857.375 | 0.00141175 | 0.114205 | 0 | ø32 mm | 0.00278552 | HD | 2.NP_SO-102 | 2101.2 | 2080 | 2080 | 2058.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 6062.05 | 0.0861927 | 32 | 36 | 857.375 | ø32 | 42.4 | 35.9 | TR02.02.1297 | 1297 | yes | HT_vratné vodní (45 °C) 23 | 0
