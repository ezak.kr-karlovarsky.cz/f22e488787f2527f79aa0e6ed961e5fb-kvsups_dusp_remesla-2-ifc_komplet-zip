Properties of the parts of a building model (IFC4), part 52 of 72

# IfcPipeFitting: M_Koleno, obecné:Standardní (1543)
Name (M_Koleno, obecné:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm) | Group
13434659 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 12 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2158 | 2158 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 12 | Mechanické – tok - Tlaková ztráta: 0 Pa
13435599 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2900 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2159 | 2159 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13435601 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 3340 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2160 | 2160 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13435904 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2162 | 2162 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3
13435916 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2163 | 2163 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13435928 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2164 | 2164 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3
13435938 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2165 | 2165 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13435955 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2166 | 2166 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13435968 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2167 | 2167 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13435985 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2168 | 2168 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7 | Izolace - Typ izolace: Tepelná
13435998 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2169 | 2169 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13436008 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2170 | 2170 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13436021 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 6 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2171 | 2171 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 6 | Izolace - Typ izolace: Tepelná
13436038 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2172 | 2172 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
13436051 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2173 | 2173 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 5
13436065 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2174 | 2174 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7 | Izolace - Typ izolace: Tepelná
13436078 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2175 | 2175 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13436099 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2176 | 2176 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4
13436123 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2177 | 2177 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 1
13436133 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 3120 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2178 | 2178 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 5 | Izolace - Typ izolace: Tepelná
13436248 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 1000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2179 | 2179 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 7 | Mechanické – tok - Tlaková ztráta: 0 Pa
13437003 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 1662 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2181 | 2181 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13437944 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.2182 | 2182 | yes | 20.6375 | 14.2875 | HT_vratné vodní (45 °C) 9
13438118 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.2184 | 2184 | yes | 20.6375 | 14.2875 | HT_přívodní vodní (55 °C) 12
13438257 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-102 | 2530 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.2186 | 2186 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 12
13438261 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-102 | 2530 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.2188 | 2188 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 9
13438265 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-102 | 2530 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.2190 | 2190 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 9
13438377 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-102 | 2530 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.2191 | 2191 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 12
13438401 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-102 | 2530 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.2192 | 2192 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 12
13438409 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.2193 | 2193 | no | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 12
13438411 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.2194 | 2194 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 12
13438841 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.2195 | 2195 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 2
13438873 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HC | 2.NP_SO-102 | 4230.63 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2197 | 2197 | yes | 23.8125 | 17.4625 | CL_vratné vodní (15 °C) 2
13438877 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HC | 2.NP_SO-102 | 4230.63 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2198 | 2198 | yes | 23.8125 | 17.4625 | CL_vratné vodní (15 °C) 2
13438899 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HC | 2.NP_SO-102 | 4077.93 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2199 | 2199 | yes | 23.8125 | 17.4625 | CL_přívodní vodní (10 °C) 1
13438903 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HC | 2.NP_SO-102 | 4077.93 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2200 | 2200 | yes | 23.8125 | 17.4625 | CL_přívodní vodní (10 °C) 1
13439983 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HC | 1.NP_SO-102 | 2900 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2201 | 2201 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 2
13439985 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HC | 1.NP_SO-102 | 2900 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2202 | 2202 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 1
13440004 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HC | 2.NP_SO-102 | -1100 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2203 | 2203 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 2
13440158 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HC | 1.NP_SO-102 | 2900 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.01.2205 | 2205 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 2
13440205 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HC | 1.NP_SO-102 | 2900 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 10 | 20 | 0.00000532048 | 7.2332 | 45 | ø20-ø20 | 3.68236 | 22.225 | TT01.01.2206 | 2206 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 1
13440207 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HC | 2.NP_SO-102 | -1100 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2207 | 2207 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 1
13440851 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.2209 | 2209 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13440884 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 15 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.2210 | 2210 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 15
13444371 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HC | 2.NP_SO-102 | 2500 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2211 | 2211 | yes | 46.0375 | 39.6875 | CL_vratné vodní (15 °C) 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13444381 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HC | 2.NP_SO-102 | 2800 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2212 | 2212 | yes | 46.0375 | 39.6875 | CL_přívodní vodní (10 °C) 4
13444417 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HC | 2.NP_SO-102 | 2050 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2213 | 2213 | yes | 46.0375 | 39.6875 | CL_přívodní vodní (10 °C) 4
13444453 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HC | 2.NP_SO-102 | 2050 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2214 | 2214 | yes | 46.0375 | 39.6875 | CL_vratné vodní (15 °C) 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13444537 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HC | 2.NP_SO-102 | 2500 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2215 | 2215 | yes | 46.0375 | 39.6875 | CL_přívodní vodní (10 °C) 4
13444559 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HC | 2.NP_SO-102 | 2500 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2216 | 2216 | yes | 46.0375 | 39.6875 | CL_vratné vodní (15 °C) 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13445631 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HC | 2.NP_SO-102 | 2050 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2217 | 2217 | yes | 46.0375 | 39.6875 | CL_přívodní vodní (10 °C) 4
13445633 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HC | 2.NP_SO-102 | 2500 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2218 | 2218 | yes | 46.0375 | 39.6875 | CL_přívodní vodní (10 °C) 4
13445637 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HC | 2.NP_SO-102 | 2500 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2219 | 2219 | yes | 46.0375 | 39.6875 | CL_přívodní vodní (10 °C) 4
13445643 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HC | 2.NP_SO-102 | 2050 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2220 | 2220 | yes | 46.0375 | 39.6875 | CL_vratné vodní (15 °C) 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13445645 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HC | 2.NP_SO-102 | 2500 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2221 | 2221 | yes | 46.0375 | 39.6875 | CL_vratné vodní (15 °C) 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13445649 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HC | 2.NP_SO-102 | 2500 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2222 | 2222 | yes | 46.0375 | 39.6875 | CL_vratné vodní (15 °C) 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13445813 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2050 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.2225 | 2225 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 12
13445815 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2600 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.2226 | 2226 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 12
13445819 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2600 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.2227 | 2227 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 12
13445824 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2050 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.2228 | 2228 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 9
13445826 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.2229 | 2229 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 9
13445830 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.2230 | 2230 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 9
13446161 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2231 | 2231 |  | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13446169 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3250 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2232 | 2232 |  | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13446172 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3250 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2233 | 2233 |  | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13447051 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.2234 | 2234 |  | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13447055 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -160 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.2235 | 2235 |  | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13447120 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -160 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.2236 | 2236 |  | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13447130 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.2237 | 2237 |  | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13447152 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.2238 | 2238 |  | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13447156 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -160 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.2239 | 2239 |  | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13447226 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -160 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.2240 | 2240 |  | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13447236 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.2241 | 2241 |  | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13447801 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.2242 | 2242 |  | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13447812 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.2243 | 2243 |  | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13447816 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -160 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.2244 | 2244 |  | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13447820 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -160 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.2245 | 2245 |  | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13447848 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.2246 | 2246 |  | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13447859 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.2247 | 2247 |  | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13447863 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -160 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.2248 | 2248 |  | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13447867 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -160 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.2249 | 2249 |  | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13449376 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000179159 | 9.86346 | 45 | ø32-ø32 | 5.78656 | 34.925 | TT01.01.2250 | 2250 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13449384 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000179159 | 9.86346 | 45 | ø32-ø32 | 5.78656 | 34.925 | TT01.01.2251 | 2251 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13449397 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2252 | 2252 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13449416 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000179159 | 9.86346 | 45 | ø32-ø32 | 5.78656 | 34.925 | TT01.01.2253 | 2253 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13449424 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000179159 | 9.86346 | 45 | ø32-ø32 | 5.78656 | 34.925 | TT01.01.2254 | 2254 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13449437 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.2255 | 2255 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13450049 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2450 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2256 | 2256 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 4
13450057 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2680 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2257 | 2257 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 4
13450059 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2680 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2258 | 2258 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 4
13450090 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2450 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2259 | 2259 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 8
13450100 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2680 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2260 | 2260 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 8
13450131 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2450 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2261 | 2261 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13450139 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2680 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2262 | 2262 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13450141 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2680 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2263 | 2263 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13450172 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2450 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2264 | 2264 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13450180 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2680 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2265 | 2265 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13450182 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2680 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2266 | 2266 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13450247 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2680 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2267 | 2267 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 4
13450249 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2500 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2268 | 2268 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 4
13450256 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2500 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2269 | 2269 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 8
13450258 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2680 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2270 | 2270 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 8
13450262 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2680 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2271 | 2271 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 8
13450267 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2680 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2272 | 2272 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13450269 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2500 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2273 | 2273 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13450276 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2680 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2274 | 2274 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13450278 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2500 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.2275 | 2275 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13450636 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2276 | 2276 |  | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 7
13450638 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 40 | 80 | 0.000178912 | 19.0694 | 45 | ø80-ø80 | 13.1513 | 79.375 | TT01.01.2277 | 2277 |  | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 7
13450643 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 40 | 80 | 0.000178912 | 19.0694 | 45 | ø80-ø80 | 13.1513 | 79.375 | TT01.01.2278 | 2278 |  | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 7 | Izolace - Typ izolace: Tepelná
13450658 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2279 | 2279 |  | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 4
13450660 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 40 | 80 | 0.000178912 | 19.0694 | 45 | ø80-ø80 | 13.1513 | 79.375 | TT01.01.2280 | 2280 |  | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 4
13450664 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 40 | 80 | 0.000178912 | 19.0694 | 45 | ø80-ø80 | 13.1513 | 79.375 | TT01.01.2281 | 2281 |  | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13450908 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2282 | 2282 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 7 | Izolace - Typ izolace: Tepelná
13450912 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 2700 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2283 | 2283 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 7 | Izolace - Typ izolace: Tepelná
13450917 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 2700 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2284 | 2284 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 7 | Izolace - Typ izolace: Tepelná
13450923 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2285 | 2285 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13450927 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 2700 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2286 | 2286 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13450932 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 2700 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2287 | 2287 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13453436 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 40 | 80 | 0.000178912 | 19.0694 | 45 | ø80-ø80 | 13.1513 | 79.375 | TT01.01.2288 | 2288 |  | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 1
13453661 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2289 | 2289 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
13453664 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 40 | 80 | 0.000178912 | 19.0694 | 45 | ø80-ø80 | 13.1513 | 79.375 | TT01.01.2290 | 2290 |  | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 1
13453695 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 40 | 80 | 0.000178912 | 19.0694 | 45 | ø80-ø80 | 13.1513 | 79.375 | TT01.01.2291 | 2291 |  | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 5
13453703 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 40 | 80 | 0.000178912 | 19.0694 | 45 | ø80-ø80 | 13.1513 | 79.375 | TT01.01.2292 | 2292 |  | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 5
13454050 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2294 | 2294 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 1
13454052 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2295 | 2295 |  | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 1
13454119 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2297 | 2297 |  | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 1
13454123 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2298 | 2298 |  | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 1
13454127 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2299 | 2299 |  | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 1
13454183 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2300 | 2300 |  | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 5
13454187 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2301 | 2301 |  | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 5
13454191 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.2302 | 2302 |  | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 5
13454210 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2303 | 2303 |  | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
13454214 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2304 | 2304 |  | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
13454220 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2305 | 2305 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
13454242 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 3120 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2306 | 2306 |  | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 5
13454250 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2307 | 2307 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 5
13454252 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.2308 | 2308 |  | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 5

# IfcPipeFitting: M_Křížení, obecné:Standardní, M_Křížení, obecné:Standardní:13121560
In: 1.NP_SO-102
Type - Material: 0-128-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Není definováno; Tabulka koeficientů K: Converging/Diverging Tee/Wye
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; Kód sestavy: TT06; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 04; Popis: 2xT; Popis sestavy: Křížení
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Křížení, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT06 Uniformat (Uniformat); Group: HT_vratné vodní (45 °C) 32
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø16 mm-ø16 mm-ø16 mm-ø16 mm
Text - CCI Funkční systém: H; CCI Komponenta: XMB; CCI Technický systém: HD
Vazby - Podlaží: 1.NP_SO-102; Výška od podlaží: -58 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: HT_vratné vodní (45 °C); Klasifikace systému: Zpětné vedení teplé vody; Název systému: HT_vratné vodní (45 °C) 32
Grafika - Použít měřítko poznámky: no
Kóty - Jmenovitý poloměr: 8 mm; Jmenovitý průměr: 16 mm; Maximální velikost: 16 mm; Minimální velikost: 16 mm; Objem: 0.0000210433 m3; Od středu ke konci: 22.2875 mm; Úhel 1: 90.0419 deg; Úhel 2: 90.0419 deg; Velikost: ø16-ø16-ø16-ø16; Velikost značky: 7.67 mm; Vnější průměr tvarovky: 19.175 mm
Identifikační data - Kód prvku: TT06.04.0561; Označení: 0561
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 5278169; Rodina: M_Křížení, obecné; Rodina a typ: M_Křížení, obecné: Standardní; Štítek, od středu ke konci: 22.2875 mm; Úhel 3: 89.9581 deg; Úhel 4: 89.9581 deg; Úhel 5: 89.9581 deg; Úhel tvarovky 1 (sdílený): 90.0419 deg; Vnější poloměr tvarovky: 9.5875 mm

# IfcPipeFitting: M_Křížení, obecné:Standardní (6)
In: 3.NP_SO-102
Type - Material: 128-255-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Není definováno; Tabulka koeficientů K: Converging/Diverging Tee/Wye
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; Kód sestavy: TT06; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 04; Popis: 2xT; Popis sestavy: Křížení
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Křížení, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT06 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø15 mm-ø15 mm-ø15 mm-ø15 mm
Text - CCI Funkční systém: H; CCI Komponenta: XMB; CCI Technický systém: HC
Vazby - Podlaží: 3.NP_SO-102; Výška od podlaží: 3370 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Kóty - Úhel 1: 90 deg; Úhel 2: 90 deg; Jmenovitý poloměr: 7.5 mm; Jmenovitý průměr: 15 mm; Maximální velikost: 15 mm; Minimální velikost: 15 mm; Objem: 0.0000136716 m3; Od středu ke konci: 20.6375 mm; Velikost: ø15-ø15-ø15-ø15; Velikost značky: 6.35 mm; Vnější průměr tvarovky: 15.875 mm
Jiné - Páteřní trasa: yes; Typ: Standardní; Úhel tvarovky 1 (sdílený): 90 deg; Id typu: 5278169; Rodina: M_Křížení, obecné; Rodina a typ: M_Křížení, obecné: Standardní; Úhel 3: 90 deg; Úhel 4: 90 deg; Úhel 5: 90 deg; Štítek, od středu ke konci: 20.6375 mm; Vnější poloměr tvarovky: 7.9375 mm
Name (M_Křížení, obecné:Standardní:...) | Typ systému | Klasifikace systému | Název systému = Group | Kód prvku | Označení
13172661 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | TT06.04.0871 | 0871
13172682 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | TT06.04.0872 | 0872
13172703 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | TT06.04.0873 | 0873
13172724 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | TT06.04.0874 | 0874
13173138 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | TT06.04.0879 | 0879
13173159 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | TT06.04.0880 | 0880

# IfcPipeFitting: M_Křížení, obecné:Standardní, M_Křížení, obecné:Standardní:13121291
In: 1.NP_SO-102
Type - Material: 255-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Není definováno; Tabulka koeficientů K: Converging/Diverging Tee/Wye
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; Kód sestavy: TT06; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 04; Popis: 2xT; Popis sestavy: Křížení
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Křížení, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT06 Uniformat (Uniformat); Group: HT_přívodní vodní (55 °C) 9
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø16 mm-ø16 mm-ø16 mm-ø16 mm
Text - CCI Funkční systém: H; CCI Komponenta: XMB; CCI Technický systém: HD
Vazby - Podlaží: 1.NP_SO-102; Výška od podlaží: -50 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: HT_přívodní vodní (55 °C); Klasifikace systému: Přívod teplé vody; Název systému: HT_přívodní vodní (55 °C) 9
Grafika - Použít měřítko poznámky: no
Kóty - Úhel 1: 90 deg; Jmenovitý poloměr: 8 mm; Jmenovitý průměr: 16 mm; Maximální velikost: 16 mm; Minimální velikost: 16 mm; Objem: 0.0000210433 m3; Od středu ke konci: 22.2875 mm; Úhel 2: 90 deg; Velikost: ø16-ø16-ø16-ø16; Velikost značky: 7.67 mm; Vnější průměr tvarovky: 19.175 mm
Identifikační data - Kód prvku: TT06.04.0559; Označení: 0559
Jiné - Páteřní trasa: yes; Typ: Standardní; Úhel tvarovky 1 (sdílený): 90 deg; Id typu: 5278169; Rodina: M_Křížení, obecné; Rodina a typ: M_Křížení, obecné: Standardní; Štítek, od středu ke konci: 22.2875 mm; Úhel 3: 90 deg; Úhel 4: 90 deg; Úhel 5: 90 deg; Vnější poloměr tvarovky: 9.5875 mm

# IfcPipeFitting: M_Přechod, obecný:Standardní (221)
Type - Material: 0-128-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT03; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: Redukce; Popis sestavy: Redukce
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT03 Uniformat (Uniformat)
Text - CCI Funkční systém: H; CCI Komponenta: XMB
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Viditelnost 1: no
Name (M_Přechod, obecný:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Délka (mm) | Jmenovitý poloměr 1 (mm) | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Šířkové odsazení (mm) | Výškové odsazení (mm) | Viditelnost 2 | Viditelnost 3 | Max. vnější průměr tvarovky 12 (mm) | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm) | Group
13079000 | 2.NP_SO-102 | 0 | ø42 mm-ø40 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11.2937 | 21 | 20 | 42 | 40 | 42 | 40 | 0.0000165584 | 21 | 21 | 0.00273098 | ø42-ø40 | 18.07 | 16.51 | 45.175 | 41.275 | TT03.03.0213 | 0213 | yes | 3048 | 3048 | yes | no | 45.175 | 20.6375 | 22.5875 | HT_vratné vodní (45 °C) 1
13079887 | 1.NP_SO-102 | 40 | ø122 mm-ø100 mm | HD | 1.NP_SO-102 | 2900 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11.2937 | 21 | 10 | 42 | 20 | 42 | 20 | 0.0000104373 | 21 | 21 | 0.00200308 | ø42-ø20 | 18.07 | 8.89 | 45.175 | 22.225 | TT03.03.0226 | 0226 | yes | 3048 | 3048 | yes | no | 45.175 | 11.1125 | 22.5875 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13080021 | 2.NP_SO-102 | 40 | ø122 mm-ø120 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11.2937 | 21 | 20 | 42 | 40 | 42 | 40 | 0.0000165584 | 21 | 21 | 0.00273098 | ø42-ø40 | 18.07 | 16.51 | 45.175 | 41.275 | TT03.03.0229 | 0229 | yes | 3048 | 3048 | yes | no | 45.175 | 20.6375 | 22.5875 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13080024 | 2.NP_SO-102 | 40 | ø122 mm-ø120 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11.2937 | 21 | 20 | 42 | 40 | 42 | 40 | 0.0000165584 | 21 | 21 | 0.00273098 | ø42-ø40 | 18.07 | 16.51 | 45.175 | 41.275 | TT03.03.0230 | 0230 | yes | 3048 | 3048 | yes | no | 45.175 | 20.6375 | 22.5875 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13080035 | 2.NP_SO-102 | 40 | ø122 mm-ø120 mm | HD | 2.NP_SO-102 | 3064.71 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11.2937 | 21 | 20 | 42 | 40 | 42 | 40 | 0.0000165584 | 21 | 21 | 0.00273098 | ø42-ø40 | 18.07 | 16.51 | 45.175 | 41.275 | TT03.03.0231 | 0231 | yes | 3048 | 3048 | yes | no | 45.175 | 20.6375 | 22.5875 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13080039 | 1.NP_SO-102 | 40 | ø122 mm-ø120 mm | HD | 1.NP_SO-102 | 2935.29 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11.2937 | 21 | 20 | 42 | 40 | 42 | 40 | 0.0000165584 | 21 | 21 | 0.00273098 | ø42-ø40 | 18.07 | 16.51 | 45.175 | 41.275 | TT03.03.0232 | 0232 | yes | 3048 | 3048 | yes | no | 45.175 | 20.6375 | 22.5875 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13080052 | 2.NP_SO-102 | 40 | ø122 mm-ø120 mm | HD | 2.NP_SO-102 | 3135.29 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11.2937 | 21 | 20 | 42 | 40 | 42 | 40 | 0.0000165584 | 21 | 21 | 0.00273098 | ø42-ø40 | 18.07 | 16.51 | 45.175 | 41.275 | TT03.03.0233 | 0233 | yes | 3048 | 3048 | yes | no | 45.175 | 20.6375 | 22.5875 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13081319 | 2.NP_SO-102 | 40 | ø130 mm-ø120 mm | HD | 2.NP_SO-102 | 3289.69 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 13.4938 | 25 | 20 | 50 | 40 | 50 | 40 | 0.0000241362 | 25 | 25 | 0.00346833 | ø50-ø40 | 21.59 | 16.51 | 53.975 | 41.275 | TT03.03.0241 | 0241 | yes | 3048 | 3048 | yes | no | 53.975 | 20.6375 | 26.9875 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13083336 | 2.NP_SO-102 | 0 | ø80 mm-ø20 mm | HD | 2.NP_SO-102 | 3152.39 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 19.8438 | 40 | 10 | 80 | 20 | 80 | 20 | 0.0000443954 | 40 | 40 | 0.00584559 | ø80-ø20 | 31.75 | 8.89 | 79.375 | 22.225 | TT03.03.0256 | 0256 | yes | 3048 | 3048 | yes | no | 79.375 | 11.1125 | 39.6875 | HT_vratné vodní (45 °C) 1
13088743 | -1.PP_SO-102 | 0 | ø40 mm-ø20 mm | HD | -1.PP_SO-102 | 3233.34 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.0300 | 0300 | yes | 3048 | 3048 | yes | no | 41.275 | 11.1125 | 20.6375 | HT_vratné vodní (45 °C) 1
13088752 | -1.PP_SO-102 | 40 | ø120 mm-ø100 mm | HD | -1.PP_SO-102 | 3233.34 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.0301 | 0301 | yes | 3048 | 3048 | yes | no | 41.275 | 11.1125 | 20.6375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13088755 | 1.NP_SO-102 | 40 | ø120 mm-ø100 mm | HD | 1.NP_SO-102 | 2866.66 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.0302 | 0302 | yes | 3048 | 3048 | yes | no | 41.275 | 11.1125 | 20.6375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13099387 | 4.NP_SO-102 | 0 | ø40 mm-ø25 mm | HD | 4.NP_SO-102 | 3179.36 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10.3188 | 12.5 | 20 | 25 | 40 | 40 | 25 | 0.00000997107 | 12.5 | 15.4877 | 0.00191462 | ø40-ø25 | 11.43 | 16.51 | 28.575 | 41.275 | TT03.03.0373 | 0373 | yes | 3048 | 3050.99 | no | yes | 41.275 | 20.6375 | 14.2875 | HT_vratné vodní (45 °C) 1
13099672 | 4.NP_SO-102 | 0 | ø25 mm-ø15 mm | HD | 4.NP_SO-102 | 3173.01 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 12.5 | 12.5 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0376 | 0376 | yes | 3048 | 3048 | yes | no | 28.575 | 7.9375 | 14.2875 | HT_vratné vodní (45 °C) 1
13099757 | 4.NP_SO-102 | 0 | ø25 mm-ø15 mm | HD | 4.NP_SO-102 | 3273.01 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 12.5 | 12.5 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.0379 | 0379 | yes | 3048 | 3048 | yes | no | 28.575 | 7.9375 | 14.2875 | HT_přívodní vodní (55 °C) 9
13108309 | 4.NP_SO-102 | 0 | ø35 mm-ø15 mm | HD | 4.NP_SO-102 | 3168.21 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 24 | 9.54375 | 17.5 | 7.5 | 35 | 15 | 35 | 15 | 0.00000574685 | 17.5 | 17.5 | 0.00136084 | ø35-ø15 | 15.27 | 6.35 | 38.175 | 15.875 | TT03.03.0445 | 0445 | yes | 3048 | 3048 | yes | no | 38.175 | 7.9375 | 19.0875 | HT_vratné vodní (45 °C) 24
13128008 | 2.NP_SO-102 | 40 | ø120 mm-ø112 mm | HD | 2.NP_SO-102 | 3150 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 10.3188 | 16 | 20 | 32 | 40 | 40 | 32 | 0.000011757 | 16 | 16 | 0.00217103 | ø40-ø32 | 13.97 | 16.51 | 34.925 | 41.275 | TT03.03.0595 | 0595 | yes | 3048 | 3048 | no | yes | 41.275 | 20.6375 | 17.4625 | HT_vratné vodní (45 °C) 2 | Izolace - Typ izolace: Tepelná
13136221 | 2.NP_SO-102 | 0 | ø65 mm-ø40 mm | HD | 2.NP_SO-102 | 3053.96 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 16.6688 | 32.5 | 20 | 65 | 40 | 65 | 40 | 0.0000388042 | 32.5 | 32.5 | 0.00492645 | ø65-ø40 | 26.67 | 16.51 | 66.675 | 41.275 | TT03.03.0659 | 0659 | yes | 3048 | 3048 | yes | no | 66.675 | 20.6375 | 33.3375 | HT_vratné vodní (45 °C) 13
13136223 | 2.NP_SO-102 | 0 | ø65 mm-ø40 mm | HD | 2.NP_SO-102 | 3146.04 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 16.6688 | 32.5 | 20 | 65 | 40 | 65 | 40 | 0.0000388042 | 32.5 | 32.5 | 0.00492645 | ø65-ø40 | 26.67 | 16.51 | 66.675 | 41.275 | TT03.03.0660 | 0660 | yes | 3048 | 3048 | yes | no | 66.675 | 20.6375 | 33.3375 | HT_vratné vodní (45 °C) 13
13208344 | -1.PP_SO-102 | 0 | ø80 mm-ø32 mm | HD | -1.PP_SO-102 | 2826.19 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 4 | 19.8438 | 16 | 40 | 32 | 80 | 80 | 32 | 0.0000534029 | 16 | 16 | 0.00636724 | ø80-ø32 | 13.97 | 31.75 | 34.925 | 79.375 | TT03.03.0967 | 0967 | yes | 3048 | 3048 | no | yes | 79.375 | 39.6875 | 17.4625 | HT_vratné vodní (45 °C) 4
13217646 | 2.NP_SO-102 | 0 | ø42 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11.2937 | 21 | 20 | 42 | 40 | 42 | 40 | 0.0000165584 | 21 | 21 | 0.00273098 | ø42-ø40 | 18.07 | 16.51 | 45.175 | 41.275 | TT03.03.0993 | 0993 | yes | 3048 | 3048 | yes | no | 45.175 | 20.6375 | 22.5875 | HT_vratné vodní (45 °C) 1
13217648 | 2.NP_SO-102 | 0 | ø42 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11.2937 | 21 | 20 | 42 | 40 | 42 | 40 | 0.0000165584 | 21 | 21 | 0.00273098 | ø42-ø40 | 18.07 | 16.51 | 45.175 | 41.275 | TT03.03.0994 | 0994 | yes | 3048 | 3048 | yes | no | 45.175 | 20.6375 | 22.5875 | HT_vratné vodní (45 °C) 1
13217699 | 2.NP_SO-102 | 0 | ø42 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 11.2937 | 21 | 20 | 42 | 40 | 42 | 40 | 0.0000165584 | 21 | 21 | 0.00273098 | ø42-ø40 | 18.07 | 16.51 | 45.175 | 41.275 | TT03.03.0995 | 0995 | yes | 3048 | 3048 | yes | no | 45.175 | 20.6375 | 22.5875 | HT_přívodní vodní (55 °C) 9
13217701 | 2.NP_SO-102 | 0 | ø42 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 11.2937 | 21 | 20 | 42 | 40 | 42 | 40 | 0.0000165584 | 21 | 21 | 0.00273098 | ø42-ø40 | 18.07 | 16.51 | 45.175 | 41.275 | TT03.03.0996 | 0996 | yes | 3048 | 3048 | yes | no | 45.175 | 20.6375 | 22.5875 | HT_přívodní vodní (55 °C) 9
13222923 | 2.NP_SO-102 | 0 | ø125 mm-ø80 mm | HD | 2.NP_SO-102 | 2521.42 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 32.5438 | 62.5 | 40 | 125 | 80 | 125 | 80 | 0.000285995 | 62.5 | 62.5 | 0.0186138 | ø125-ø80 | 52.07 | 31.75 | 130.175 | 79.375 | TT03.03.1031 | 1031 | yes | 3048 | 3048 | yes | no | 130.175 | 39.6875 | 65.0875 | HT_vratné vodní (45 °C) 23 | Mechanické – tok - Tlaková ztráta: 0 Pa
