Properties of the parts of a building model (IFC4), part 45 of 72

# IfcPipeFitting: M_Koleno, obecné:Standardní (1543)
Name (M_Koleno, obecné:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm) | Group
13039277 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0096 | 0096 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13039287 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0097 | 0097 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13039731 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 4 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0099 | 0099 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 4
13039996 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2800 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0101 | 0101 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13040696 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0103 | 0103 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13040725 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0105 | 0105 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13041691 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0108 | 0108 | no | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 19
13042157 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2800 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0110 | 0110 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13042515 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2900 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0111 | 0111 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13042596 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2900 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0112 | 0112 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13042834 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 14 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0113 | 0113 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 14
13043017 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0115 | 0115 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13043027 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0116 | 0116 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13043064 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0118 | 0118 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13043074 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0119 | 0119 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13043839 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0123 | 0123 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13044595 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0125 | 0125 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13044754 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3200 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0127 | 0127 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13044932 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0128 | 0128 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13045111 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722939 | 15.9383 | 90.0029 | ø16-ø16 | 7.67039 | 19.175 | TT01.01.0129 | 0129 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13045504 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0132 | 0132 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13045885 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 2.NP_SO-102 | -4660 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0134 | 0134 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (55 °C) 19
13046002 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0135 | 0135 | no | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 19
13046012 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0136 | 0136 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13046056 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0139 | 0139 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13046137 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0141 | 0141 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13046167 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0143 | 0143 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13046208 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0145 | 0145 | no | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13046277 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0146 | 0146 | no | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 19
13046349 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0147 | 0147 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13046472 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0149 | 0149 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13047133 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-102 | -4050 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0151 | 0151 | no | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13047138 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0152 | 0152 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13047547 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | 3950 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0153 | 0153 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13047910 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0154 | 0154 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13047972 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0155 | 0155 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13048030 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0157 | 0157 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13048104 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | 3950 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0159 | 0159 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13048173 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0160 | 0160 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13048374 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 3150 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0161 | 0161 | yes | 20.6375 | 14.2875 | HT/CL_přívodní vodní 1
13048384 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 3150 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0162 | 0162 | yes | 20.6375 | 14.2875 | HT/CL_přívodní vodní 1
13049035 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 3150 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0163 | 0163 | yes | 20.6375 | 14.2875 | HT/CL_přívodní vodní 1
13049410 | 4.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 4.NP_SO-102 | 0 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0164 | 0164 | yes | 20.6375 | 14.2875 | HT/CL_přívodní vodní 1
13049979 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 3150 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0165 | 0165 | yes | 20.6375 | 14.2875 | HT/CL_přívodní vodní 1
13049981 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 3150 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0166 | 0166 | yes | 20.6375 | 14.2875 | HT/CL_přívodní vodní 1
13050445 | 2.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 2.NP_SO-102 | 3250 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.0167 | 0167 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13050499 | 2.NP_SO-102 | 60 | ø185 mm-ø185 mm | HD | 2.NP_SO-102 | 3250 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.0168 | 0168 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13052511 | -1.PP_SO-102 | 60 | ø200 mm-ø200 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0169 | 0169 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13055154 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 10 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0170 | 0170 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (65 °C) 10
13055174 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 10 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0171 | 0171 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (65 °C) 10
13055178 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 10 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0172 | 0172 | no | 14.2875 | 7.9375 | HT_přívodní vodní (65 °C) 10
13056742 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 3.NP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0173 | 0173 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13056746 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0174 | 0174 | no | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13057035 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 3.NP_SO-102 | -51.0366 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0176 | 0176 | no | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13057399 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 3.NP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0177 | 0177 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13059926 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 2700 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0179 | 0179 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13059928 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 2700 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0180 | 0180 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 3
13064928 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0181 | 0181 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 6 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13069810 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0189 | 0189 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 9
13073498 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 8 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0196 | 0196 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 8
13073549 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 6 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0197 | 0197 | yes | 33.3375 | 26.9875 | HT_vratné vodní (45 °C) 6
13073690 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 4 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0198 | 0198 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 4
13078570 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0199 | 0199 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13078581 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0200 | 0200 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13078589 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0201 | 0201 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13078599 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0202 | 0202 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13078720 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0203 | 0203 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13078741 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0204 | 0204 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13078760 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0205 | 0205 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13078762 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0206 | 0206 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13078783 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0207 | 0207 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 1
13078791 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0208 | 0208 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 1
13078994 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0211 | 0211 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 1
13078998 | 2.NP_SO-102 | 0 | ø42 mm-ø42 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 21 | 42 | 0.0000728541 | 28.9375 | 90 | ø42-ø42 | 18.07 | 45.175 | TT01.01.0212 | 0212 | yes | 28.9375 | 22.5875 | HT_vratné vodní (45 °C) 1
13079015 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0214 | 0214 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 1
13079123 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0215 | 0215 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13079127 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0216 | 0216 | no | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13079343 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0217 | 0217 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13079347 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0218 | 0218 | no | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13079552 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0219 | 0219 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13079562 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0220 | 0220 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13079617 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0221 | 0221 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13079627 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0222 | 0222 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13079729 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 2900 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0223 | 0223 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13079877 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 2900 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0224 | 0224 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13079959 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 2900 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0227 | 0227 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13080185 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0234 | 0234 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13081305 | 2.NP_SO-102 | 40 | ø130 mm-ø130 mm | HD | 2.NP_SO-102 | 3250 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0238 | 0238 | yes | 33.3375 | 26.9875 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13081757 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0243 | 0243 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13081875 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0246 | 0246 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13082319 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0248 | 0248 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13082936 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0251 | 0251 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13083010 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0252 | 0252 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13083249 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0254 | 0254 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13083433 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0257 | 0257 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13083454 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0258 | 0258 | yes | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13083577 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0259 | 0259 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13083613 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3250 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0261 | 0261 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13083670 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0263 | 0263 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13083700 | 1.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0264 | 0264 | no | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13083994 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0265 | 0265 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13084005 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3260 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0266 | 0266 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13085130 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0270 | 0270 | no | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13085284 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0271 | 0271 | no | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13085372 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 2700 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0273 | 0273 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13085908 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0276 | 0276 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13085956 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0277 | 0277 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13086046 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0279 | 0279 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13086233 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0280 | 0280 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13086485 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0283 | 0283 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13086870 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0286 | 0286 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13086939 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 21 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0287 | 0287 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 21
13087166 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0288 | 0288 | no | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13087237 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 2850 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0289 | 0289 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13087241 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 2850 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0290 | 0290 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13087287 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3070.78 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0291 | 0291 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13087291 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3070.78 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0292 | 0292 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13087314 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0293 | 0293 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13088035 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0295 | 0295 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13088723 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0298 | 0298 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13088725 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0299 | 0299 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13089063 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 2700 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0303 | 0303 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13089065 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0304 | 0304 | no | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13089169 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0305 | 0305 | no | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13089175 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 2700 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0306 | 0306 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13089179 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 2700 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0307 | 0307 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13089472 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0309 | 0309 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13089644 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0311 | 0311 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13090600 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 3.NP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0313 | 0313 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13090619 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0314 | 0314 | no | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13090640 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 3.NP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 18 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0315 | 0315 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 18
13090732 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 3.NP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000222098 | 5.91808 | 45 | ø15-ø15 | 2.63026 | 15.875 | TT01.01.0317 | 0317 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13090743 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 3.NP_SO-102 | 2724.91 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000222098 | 5.91808 | 45 | ø15-ø15 | 2.63026 | 15.875 | TT01.01.0318 | 0318 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13090888 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 3.NP_SO-102 | 2724.91 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000222098 | 5.91808 | 45 | ø15-ø15 | 2.63026 | 15.875 | TT01.01.0319 | 0319 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13090892 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 3.NP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000222098 | 5.91808 | 45 | ø15-ø15 | 2.63026 | 15.875 | TT01.01.0320 | 0320 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13091086 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0321 | 0321 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13092603 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0323 | 0323 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13092761 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0326 | 0326 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13093673 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0332 | 0332 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13094041 | 3.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 3.NP_SO-102 | 3350 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0334 | 0334 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (55 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13094089 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0336 | 0336 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13094716 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 21 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0338 | 0338 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 21 | Mechanické – tok - Tlaková ztráta: 0 Pa
13094807 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0339 | 0339 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13094946 | 1.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 1.NP_SO-102 | 3360 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0340 | 0340 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (55 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13095450 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0343 | 0343 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13096009 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 10 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0344 | 0344 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (65 °C) 10
13096011 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 10 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0345 | 0345 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (65 °C) 10
13096443 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0347 | 0347 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13096734 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0349 | 0349 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9
13096752 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0350 | 0350 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13096794 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0351 | 0351 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9
13096814 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3150 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0353 | 0353 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9
13096837 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0354 | 0354 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13096857 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3150 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0356 | 0356 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13097338 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0357 | 0357 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13097381 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0358 | 0358 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13097385 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0359 | 0359 | no | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13097508 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0361 | 0361 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13097511 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0362 | 0362 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13097618 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 2920 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0363 | 0363 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13098351 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0364 | 0364 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13098552 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0367 | 0367 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13099074 | 4.NP_SO-102 | 0 | ø25 mm-ø25 mm | HD | 4.NP_SO-102 | 3300 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0369 | 0369 | yes | 20.6375 | 14.2875 | HT_přívodní vodní (55 °C) 9
13099078 | 4.NP_SO-102 | 0 | ø25 mm-ø25 mm | HD | 4.NP_SO-102 | 3300 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0370 | 0370 | yes | 20.6375 | 14.2875 | HT_přívodní vodní (55 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13099385 | 4.NP_SO-102 | 0 | ø25 mm-ø25 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0372 | 0372 | yes | 20.6375 | 14.2875 | HT_vratné vodní (45 °C) 1
13099662 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0374 | 0374 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13099747 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0377 | 0377 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13099992 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0380 | 0380 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13100372 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0382 | 0382 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13100486 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0384 | 0384 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13101134 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0387 | 0387 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13102438 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0390 | 0390 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13102609 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0392 | 0392 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13103061 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0393 | 0393 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13103168 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0394 | 0394 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13103481 | 1.NP_SO-102 | 0 | ø25 mm-ø25 mm | HD | 1.NP_SO-102 | 3300 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0398 | 0398 | yes | 20.6375 | 14.2875 | HT_přívodní vodní (55 °C) 19
13103738 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0401 | 0401 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13104143 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0402 | 0402 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13104530 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2850 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0403 | 0403 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13104549 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0404 | 0404 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13104701 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0407 | 0407 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13104765 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2850 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0408 | 0408 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13104856 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0409 | 0409 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13104971 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0410 | 0410 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13105202 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3050 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0413 | 0413 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13105206 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3050 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0414 | 0414 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13105630 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3050 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0418 | 0418 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13105634 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3050 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0419 | 0419 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13105661 | 3.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 3.NP_SO-102 | 3150 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0420 | 0420 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (55 °C) 19
13106189 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0423 | 0423 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13106396 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0426 | 0426 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13106475 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0428 | 0428 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13106694 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0430 | 0430 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
