Properties of the parts of a building model (IFC4), part 20 of 72

# IfcSpace: Rozvodna RPO B0205:13373564, B0205
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.113186; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 34.8091 W; Specifikované výkonové zatížení: 45.2519 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00125277 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -2.PP_SO-102; Horní odsazení: 4000 mm; Podlaží: -2.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 3.23388 m2
Identifikační data - Číslo: B0205; Číslo místnosti: Neobsazené; Název: Rozvodna RPO; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Rozvodovna B0202:13373558, B0202
In: -2.PP_SO-102
LongName: Rozvodovna; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 62.5405 m3; NetVolume: 62.5405 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.547229; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 168.295 W; Specifikované výkonové zatížení: 218.784 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0060569 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -2.PP_SO-102; Horní odsazení: 4000 mm; Podlaží: -2.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 15.6351 m2
Identifikační data - Číslo: B0202; Číslo místnosti: Neobsazené; Název: Rozvodovna; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Rozvodovna CBS+UPS B0203:13373555, B0203
In: -2.PP_SO-102
LongName: Rozvodovna CBS+UPS; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 17.5074 m3; NetVolume: 17.5074 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.15319; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 47.112 W; Specifikované výkonové zatížení: 61.2456 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00169555 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -2.PP_SO-102; Horní odsazení: 4000 mm; Podlaží: -2.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 4.37685 m2
Identifikační data - Číslo: B0203; Číslo místnosti: Neobsazené; Název: Rozvodovna CBS+UPS; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Rytecká dílna B125:13255829, B125
In: 1.NP_SO-102
LongName: Rytecká dílna; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 519.832 m3; NetVolume: 519.832 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 4.54853; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 1398.86 W; Specifikované výkonové zatížení: 1818.51 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0503445 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 129.958 m2
Identifikační data - Číslo: B125; Číslo místnosti: Neobsazené; Název: Rytecká dílna; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Sborovna B324.1:13186355, B324.1
In: 3.NP_SO-102
LongName: Sborovna; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 159.459 m3; NetVolume: 159.459 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 1.39527; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 429.101 W; Specifikované výkonové zatížení: 557.832 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 20 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0154433 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 3.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 3.NP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 39.8648 m2
Identifikační data - Číslo: B324.1; Číslo místnosti: Neobsazené; Název: Sborovna; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Schodiště B0102:13251525, B0102
In: -1.PP_SO-102
LongName: Schodiště; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 79.401 m3; NetVolume: 79.401 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.694759; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 213.666 W; Specifikované výkonové zatížení: 277.766 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00768981 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 19.8503 m2
Identifikační data - Číslo: B0102; Číslo místnosti: Neobsazené; Název: Schodiště; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Schodiště B0103:13372705, B0103
In: -1.PP_SO-102
LongName: Schodiště; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 72.3796 m3; NetVolume: 72.3634 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.633321; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 194.772 W; Specifikované výkonové zatížení: 253.203 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0070098 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 18.0949 m2
Identifikační data - Číslo: B0103; Číslo místnosti: Neobsazené; Název: Schodiště; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Schodiště B0104:13256571, B0104
In: -1.PP_SO-102
LongName: Schodiště; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 80.4 m3; NetVolume: 80.4 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.7035; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 216.355 W; Specifikované výkonové zatížení: 281.261 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00778656 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 20.1 m2
Identifikační data - Číslo: B0104; Číslo místnosti: Neobsazené; Název: Schodiště; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Schodiště B0105:13251676, B0105
In: -1.PP_SO-102
LongName: Schodiště; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 75.6128 m3; NetVolume: 75.6128 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.661612; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 203.472 W; Specifikované výkonové zatížení: 264.514 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00732292 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 18.9032 m2
Identifikační data - Číslo: B0105; Číslo místnosti: Neobsazené; Název: Schodiště; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Schodiště B0106:13251639, B0106
In: -1.PP_SO-102
LongName: Schodiště; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 52.0402 m3; NetVolume: 52.0432 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.455351; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 140.039 W; Specifikované výkonové zatížení: 182.051 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00503997 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 13.01 m2
Identifikační data - Číslo: B0106; Číslo místnosti: Neobsazené; Název: Schodiště; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Schodiště B0201:13373561, B0201
In: -2.PP_SO-102
LongName: Schodiště; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 101.317 m3; NetVolume: 101.317 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.886523; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 272.642 W; Specifikované výkonové zatížení: 354.434 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00981231 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -2.PP_SO-102; Horní odsazení: 4000 mm; Podlaží: -2.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 25.3292 m2
Identifikační data - Číslo: B0201; Číslo místnosti: Neobsazené; Název: Schodiště; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Schodiště B102:13251968, B102
In: 1.NP_SO-102
LongName: Schodiště; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 84.24 m3; NetVolume: 84.24 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.7371; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 226.688 W; Specifikované výkonové zatížení: 294.694 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00815845 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 21.06 m2
Identifikační data - Číslo: B102; Číslo místnosti: Neobsazené; Název: Schodiště; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Schodiště B103:13252082, B103
In: 1.NP_SO-102
LongName: Schodiště; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 72.3823 m3; NetVolume: 72.3861 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.633345; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 194.779 W; Specifikované výkonové zatížení: 253.213 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00701006 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 18.0956 m2
Identifikační data - Číslo: B103; Číslo místnosti: Neobsazené; Název: Schodiště; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Schodiště B104:13255841, B104
In: 1.NP_SO-102
LongName: Schodiště; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 80.4 m3; NetVolume: 80.4 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.7035; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 216.355 W; Specifikované výkonové zatížení: 281.261 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00778656 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 20.1 m2
Identifikační data - Číslo: B104; Číslo místnosti: Neobsazené; Název: Schodiště; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Schodiště B105:13252064, B105
In: 1.NP_SO-102
LongName: Schodiště; PredefinedType: SPACE; Group: VZT 3:13325337
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 75.6133 m3; NetVolume: 75.6134 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.661617; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 203.474 W; Specifikované výkonové zatížení: 264.516 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: VZT 3
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00732298 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 18.9033 m2
Identifikační data - Číslo: B105; Číslo místnosti: Neobsazené; Název: Schodiště; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Schodiště B106:13252049, B106
In: 1.NP_SO-102
LongName: Schodiště; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 52.0402 m3; NetVolume: 52.0422 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.455351; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 140.039 W; Specifikované výkonové zatížení: 182.051 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00503997 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 13.01 m2
Identifikační data - Číslo: B106; Číslo místnosti: Neobsazené; Název: Schodiště; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Schodiště B202:13252607, B202
In: 2.NP_SO-102
LongName: Schodiště; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 84.24 m3; NetVolume: 84.24 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.7371; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 226.688 W; Specifikované výkonové zatížení: 294.694 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00815845 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 21.06 m2
Identifikační data - Číslo: B202; Číslo místnosti: Neobsazené; Název: Schodiště; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Schodiště B203:13252592, B203
In: 2.NP_SO-102
LongName: Schodiště; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 72.3823 m3; NetVolume: 72.387 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.633345; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 194.779 W; Specifikované výkonové zatížení: 253.213 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00701006 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 18.0956 m2
Identifikační data - Číslo: B203; Číslo místnosti: Neobsazené; Název: Schodiště; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Schodiště B204:13364442, B204
In: 2.NP_SO-102
LongName: Schodiště; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 84.84 m3; NetVolume: 84.84 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.74235; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 228.303 W; Specifikované výkonové zatížení: 296.793 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00821656 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 21.21 m2
Identifikační data - Číslo: B204; Číslo místnosti: Neobsazené; Název: Schodiště; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Schodiště B205:13253390, B205
In: 2.NP_SO-102
LongName: Schodiště; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 85.8503 m3; NetVolume: 85.8503 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.75119; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 231.021 W; Specifikované výkonové zatížení: 300.328 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0083144 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 21.4626 m2
Identifikační data - Číslo: B205; Číslo místnosti: Neobsazené; Název: Schodiště; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Schodiště B206:13252631, B206
In: 2.NP_SO-102
LongName: Schodiště; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 52.0402 m3; NetVolume: 52.0422 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.455351; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 140.039 W; Specifikované výkonové zatížení: 182.051 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00503997 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 13.01 m2
Identifikační data - Číslo: B206; Číslo místnosti: Neobsazené; Název: Schodiště; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Schodiště B302:13185887, B302
In: 3.NP_SO-102
LongName: Schodiště; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 84.24 m3; NetVolume: 84.24 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.7371; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 226.688 W; Specifikované výkonové zatížení: 294.694 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00815845 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 3.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 3.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 21.06 m2
Identifikační data - Číslo: B302; Číslo místnosti: Neobsazené; Název: Schodiště; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Schodiště B303:13185896, B303
In: 3.NP_SO-102
LongName: Schodiště; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 72.3823 m3; NetVolume: 72.387 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.633345; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 194.779 W; Specifikované výkonové zatížení: 253.213 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00701006 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 3.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 3.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 18.0956 m2
Identifikační data - Číslo: B303; Číslo místnosti: Neobsazené; Název: Schodiště; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Schodiště B304:13186337, B304
In: 3.NP_SO-102
LongName: Schodiště; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 84.84 m3; NetVolume: 84.84 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.74235; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 228.303 W; Specifikované výkonové zatížení: 296.793 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00821656 m3/s
