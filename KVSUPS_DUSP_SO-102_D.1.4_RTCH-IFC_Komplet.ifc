Properties of the parts of a building model (IFC4), part 71 of 72

# IfcPipeSegment: Typy trubek:Ocel_černá (499)
Name (Typy trubek:Ocel_černá:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Celková velikost | Tloušťka izolace (mm) | Relativní drsnost | CCI Technický systém | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Sklon | Spodní výška (mm) | Fáze vytvoření | Klasifikace systému | Název systému | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) | Řez | Typ systému | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group
13384541 | 4.NP_SO-102 | 15.3125 | 0.00454772 | 0.00366084 | ø65 mm | 0 | 0.00145138 | HD | 419 | 419 | 403.687 | STŘECHA_SO-102 |  | 403.687 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 16253.7 | 0.00312687 | 65 | 61 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.1984 | 1984 | yes | HT_PRIMÁR_přívodní 3
13384737 | 4.NP_SO-102 | 934.625 | 0.00454772 | 0.223446 | ø185 mm | 60 | 0.00145138 | HD | 4174.31 | 3239.69 | 4174.31 | 4.NP_SO-102 |  | 3239.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 15239.7 | 0.190854 | 65 | 56 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1985 | 1985 | yes | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13384830 | 4.NP_SO-102 | 980.012 | 0.00454772 | 0.234297 | ø65 mm | 0 | 0.00145138 | HD | 402.05 | 364 | 364 | STŘECHA_SO-102 | 0 | 325.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 16179.5 | 0.200122 | 65 | 56 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1986 | 1986 | yes | HT_PRIMÁR_vratné 3
13384838 | 4.NP_SO-102 | 15.3125 | 0.00454772 | 0.00366084 | ø65 mm | 0 | 0.00145138 | HD | 419 | 419 | 403.688 | STŘECHA_SO-102 |  | 403.687 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 16253.7 | 0.00312687 | 65 | 56 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1987 | 1987 | yes | HT_PRIMÁR_vratné 3
13385308 | 4.NP_SO-102 | 3840.26 | 0.00454772 | 0.918112 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 15165.5 | 0.784195 | 65 | 1 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1988 | 1988 | yes | HT_PRIMÁR_vratné 5
13385329 | 4.NP_SO-102 | 120.65 | 0.00454772 | 0.0288444 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 15165.5 | 0.0246372 | 65 | 56 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.1989 | 1989 | yes | HT_PRIMÁR_přívodní 1
13385657 | 4.NP_SO-102 | 2903.53 | 0.00454772 | 0.694161 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 15165.5 | 0.59291 | 65 | 54 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1990 | 1990 | yes | HT_PRIMÁR_vratné 7
13385659 | 4.NP_SO-102 | 2779.75 | 0.00454772 | 0.664569 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 15165.5 | 0.567635 | 65 | 67 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.1991 | 1991 | yes | HT_PRIMÁR_přívodní 4
13385661 | 4.NP_SO-102 | 390.938 | 0.00454772 | 0.0934635 | ø65 mm | 0 | 0.00145138 | HD | 2738.05 | 2700 | 2700 | 4.NP_SO-102 | 0 | 2661.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14665.5 | 0.0798308 | 65 | 67 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.1992 | 1992 | yes | HT_PRIMÁR_přívodní 4
13385663 | 4.NP_SO-102 | 135.811 | 0.00454772 | 0.032469 | ø65 mm | 0 | 0.00145138 | HD | 2738.05 | 2700 | 2700 | 4.NP_SO-102 | 0 | 2661.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 14665.5 | 0.027733 | 65 | 54 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1993 | 1993 | yes | HT_PRIMÁR_vratné 7
13385830 | 4.NP_SO-102 | 420.625 | 0.00454772 | 0.100561 | ø65 mm | 0 | 0.00145138 | HD | 3160.31 | 3160.31 | 2739.69 | 4.NP_SO-102 |  | 2739.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 14739.7 | 0.0858931 | 65 | 54 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1994 | 1994 | yes | HT_PRIMÁR_vratné 7
13385841 | 4.NP_SO-102 | 14.275 | 0.00454772 | 0.0034128 | ø185 mm | 60 | 0.00145138 | HD | 3153.96 | 3153.96 | 3139.69 | 4.NP_SO-102 |  | 3139.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 15139.7 | 0.00291501 | 65 | 55 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1995 | 1995 | yes | HT_PRIMÁR_vratné 7 | Izolace - Typ izolace: Tepelná
13385869 | 4.NP_SO-102 | 420.625 | 0.00454772 | 0.100561 | ø65 mm | 0 | 0.00145138 | HD | 3160.31 | 3160.31 | 2739.69 | 4.NP_SO-102 |  | 2739.69 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14739.7 | 0.0858931 | 65 | 67 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.1996 | 1996 | yes | HT_PRIMÁR_přívodní 4
13386173 | 4.NP_SO-102 | 1040.31 | 0.00454772 | 0.248713 | ø185 mm | 60 | 0.00145138 | HD | 4200 | 4200 | 3159.69 | 4.NP_SO-102 |  | 3159.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 15159.7 | 0.212435 | 65 | 67 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1997 | 1997 | yes | HT_PRIMÁR_vratné 5 | Izolace - Typ izolace: Tepelná
13386196 | 4.NP_SO-102 | 960.313 | 0.00454772 | 0.229587 | ø185 mm | 60 | 0.00145138 | HD | 4200 | 4200 | 3239.69 | 4.NP_SO-102 |  | 3239.69 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 15239.7 | 0.196099 | 65 | 70 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.1998 | 1998 | yes | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
13386282 | 4.NP_SO-102 | 212.574 | 0.00454772 | 0.0508212 | ø185 mm | 60 | 0.00145138 | HD | 3158.05 | 3120 | 3120 | 4.NP_SO-102 | 0 | 3081.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 15085.5 | 0.0434084 | 65 | 67 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1999 | 1999 | yes | HT_PRIMÁR_vratné 5 | Izolace - Typ izolace: Tepelná
13386697 | 4.NP_SO-102 | 71.1526 | 0.00454772 | 0.0170108 | ø65 mm | 0 | 0.00145138 | HD | 2838.05 | 2800 | 2800 | 4.NP_SO-102 | 0 | 2761.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14765.5 | 0.0145296 | 65 | 81 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2000 | 2000 | yes | HT_PRIMÁR_přívodní 4
13387078 | 4.NP_SO-102 | 71.1526 | 0.00454772 | 0.0170108 | ø185 mm | 60 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 15165.5 | 0.0145296 | 65 | 59 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2001 | 2001 | yes | HT_PRIMÁR_vratné 7 | Izolace - Typ izolace: Tepelná
13387511 | 4.NP_SO-102 | 13213 | 0.00620623 | 3.69023 | ø200 mm | 60 | 0.00123762 | HD | 3044.45 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2955.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14959.6 | 3.32079 | 80 | 18 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2002 | 2002 | yes | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13387545 | 4.NP_SO-102 | 13235.7 | 0.00620623 | 3.69658 | ø200 mm | 60 | 0.00123762 | HD | 3044.45 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2955.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 14959.6 | 3.32651 | 80 | 62 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2003 | 2003 | yes | HT_PRIMÁR_vratné 7 | Izolace - Typ izolace: Tepelná
13388152 | 4.NP_SO-102 | 212.574 | 0.00454772 | 0.0508212 | ø185 mm | 60 | 0.00145138 | HD | 2988.05 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2911.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14915.5 | 0.0434084 | 65 | 59 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2004 | 2004 | yes | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13390069 | 2.NP_SO-102 | 2863.44 | 0.00454772 | 0.684577 | ø65 mm | 0 | 0.00145138 | HC | 3038.05 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2961.95 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 7 | 6965.55 | 0.584724 | 65 | 3 | CL_přívodní vodní (10 °C) | ø65 | 76.1 | 68.9 | TR02.01.2005 | 2005 | yes | CL_přívodní vodní (10 °C) 7
13390118 | 2.NP_SO-102 | 3443.44 | 0.00454772 | 0.823241 | ø65 mm | 0 | 0.00145138 | HC | 3038.05 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2961.95 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 4 | 6965.55 | 0.703162 | 65 | 3 | CL_vratné vodní (15 °C) | ø65 | 76.1 | 68.9 | TR02.01.2006 | 2006 | yes | CL_vratné vodní (15 °C) 4
13390864 | 2.NP_SO-102 | 268.963 | 0.00620623 | 0.0751179 | ø80 mm | 0 | 0.00123762 | HD | 344.45 | 300 | 300 | 2.NP_SO-102 | 0 | 255.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 4259.6 | 0.0675976 | 80 | 2 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.2007 | 2007 | yes | HT_vratné vodní (45 °C) 23
13390873 | 2.NP_SO-102 | 2207.92 | 0.00620623 | 0.616646 | ø80 mm | 0 | 0.00123762 | HD | 2553.96 | 346.037 | 2553.96 | 2.NP_SO-102 |  | 346.037 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 4346.04 | 0.554912 | 80 | 2 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.2008 | 2008 | yes | HT_vratné vodní (45 °C) 23
13390899 | 2.NP_SO-102 | 303.963 | 0.00620623 | 0.084893 | ø80 mm | 0 | 0.00123762 | HD | 344.45 | 300 | 300 | 2.NP_SO-102 | 0 | 255.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 4259.6 | 0.0763941 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.2009 | 2009 | yes | HT_přívodní vodní (65 °C) 8
13390908 | 2.NP_SO-102 | 2257.92 | 0.00620623 | 0.63061 | ø80 mm | 0 | 0.00123762 | HD | 2603.96 | 346.037 | 2603.96 | 2.NP_SO-102 |  | 346.037 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 4346.04 | 0.567478 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.2010 | 2010 | yes | HT_přívodní vodní (65 °C) 8
13391132 | 2.NP_SO-102 | 272.925 | 0.00620623 | 0.0762246 | ø80 mm | 0 | 0.00123762 | HD | 1944.45 | 1900 | 1900 | 2.NP_SO-102 | 0 | 1855.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 5859.6 | 0.0685935 | 80 | 71 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2011 | 2011 | yes | HT_PRIMÁR_přívodní 1
13391279 | 2.NP_SO-102 | 13.9625 | 0.00620623 | 0.00389955 | ø80 mm | 0 | 0.00123762 | HD | 944.45 | 900 | 900 | 2.NP_SO-102 | 0 | 855.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 4859.6 | 0.00350916 | 80 | 71 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2012 | 2012 | yes | HT_PRIMÁR_přívodní 1
13391290 | 2.NP_SO-102 | 907.925 | 0.00620623 | 0.253572 | ø80 mm | 0 | 0.00123762 | HD | 1853.96 | 946.037 | 1853.96 | 2.NP_SO-102 |  | 946.037 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 4946.04 | 0.228186 | 80 | 71 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2013 | 2013 | yes | HT_PRIMÁR_přívodní 1
13391415 | 2.NP_SO-102 | 4305.66 | 0.00620623 | 1.20252 | ø200 mm | 60 | 0.00123762 | HD | 1944.45 | 1900 | 1900 | 2.NP_SO-102 | 0 | 1855.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 5859.6 | 1.08213 | 80 | 65 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2014 | 2014 | yes | HT_PRIMÁR_vratné 5 | Izolace - Typ izolace: Tepelná
13391424 | 2.NP_SO-102 | 22.925 | 0.00620623 | 0.00640267 | ø80 mm | 0 | 0.00123762 | HD | 1944.45 | 1900 | 1900 | 2.NP_SO-102 | 0 | 1855.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 5859.6 | 0.00576168 | 80 | 65 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2015 | 2015 | yes | HT_PRIMÁR_vratné 5
13391432 | 2.NP_SO-102 | 18.9625 | 0.00620623 | 0.00529599 | ø80 mm | 0 | 0.00123762 | HD | 944.45 | 900 | 900 | 2.NP_SO-102 | 0 | 855.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 4859.6 | 0.0047658 | 80 | 65 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2016 | 2016 | yes | HT_PRIMÁR_vratné 5
13391506 | 2.NP_SO-102 | 907.925 | 0.00620623 | 0.253572 | ø80 mm | 0 | 0.00123762 | HD | 1853.96 | 946.037 | 1853.96 | 2.NP_SO-102 |  | 946.037 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 4946.04 | 0.228186 | 80 | 65 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2017 | 2017 | yes | HT_PRIMÁR_vratné 5
13391642 | 2.NP_SO-102 | 288.081 | 0.00454772 | 0.0688731 | ø65 mm | 0 | 0.00145138 | HC | 2960.31 | 2960.31 | 2672.23 | 2.NP_SO-102 |  | 2672.23 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 4 | 6672.23 | 0.0588272 | 65 | 3 | CL_vratné vodní (15 °C) | ø65 | 76.1 | 68.9 | TR02.01.2018 | 2018 | yes | CL_vratné vodní (15 °C) 4
13391645 | 2.NP_SO-102 | 285.225 | 0.00620623 | 0.0796598 | ø80 mm | 0 | 0.00123762 | HD | 2644.45 | 2600 | 2600 | 2.NP_SO-102 | 0 | 2555.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 6559.6 | 0.0716849 | 80 | 3 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.2019 | 2019 | yes | HT_vratné vodní (45 °C) 23
13391680 | 2.NP_SO-102 | 238.081 | 0.00454772 | 0.0569193 | ø65 mm | 0 | 0.00145138 | HC | 2960.31 | 2960.31 | 2722.23 | 2.NP_SO-102 |  | 2722.23 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 7 | 6722.23 | 0.048617 | 65 | 3 | CL_přívodní vodní (10 °C) | ø65 | 76.1 | 68.9 | TR02.01.2020 | 2020 | yes | HT_přívodní vodní (65 °C) 8; CL_přívodní vodní (10 °C) 7
13391683 | 2.NP_SO-102 | 785.225 | 0.00620623 | 0.219304 | ø80 mm | 0 | 0.00123762 | HD | 2694.45 | 2650 | 2650 | 2.NP_SO-102 | 0 | 2605.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 6609.6 | 0.197349 | 80 | 3 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.2021 | 2021 | yes | HT_přívodní vodní (65 °C) 8
13391807 | 2.NP_SO-102 | 3412.12 | 0.00620623 | 0.952964 | ø80 mm | 0 | 0.00123762 | HD | 2644.45 | 2600 | 2600 | 2.NP_SO-102 | 0 | 2555.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 6559.6 | 0.85756 | 80 | 6 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.2024 | 2024 | yes | HT_vratné vodní (45 °C) 23
13391848 | 2.NP_SO-102 | 2822.12 | 0.00620623 | 0.788184 | ø80 mm | 0 | 0.00123762 | HD | 2694.45 | 2650 | 2650 | 2.NP_SO-102 | 0 | 2605.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 6609.6 | 0.709277 | 80 | 6 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.2027 | 2027 | yes | HT_přívodní vodní (65 °C) 8
13393491 | 4.NP_SO-102 | 141.863 | 0.00454772 | 0.033916 | ø185 mm | 60 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15165.5 | 0.028969 | 65 | 48 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2028 | 2028 | yes | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13393500 | 4.NP_SO-102 | 1867.87 | 0.00454772 | 0.446562 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15165.5 | 0.381426 | 65 | 48 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2029 | 2029 | yes | HT_PRIMÁR_přívodní 3
13393688 | 4.NP_SO-102 | 4830.62 | 0.00454772 | 1.15488 | ø185 mm | 60 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 15165.5 | 0.98643 | 65 | 56 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2030 | 2030 | yes | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13393697 | 4.NP_SO-102 | 1576.73 | 0.00454772 | 0.376956 | ø185 mm | 60 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 15165.5 | 0.321973 | 65 | 56 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2031 | 2031 | yes | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13393707 | 4.NP_SO-102 | 4045.64 | 0.00454772 | 0.967213 | ø185 mm | 60 | 0.00145138 | HD | 3138.05 | 3100 | 3100 | 4.NP_SO-102 | 0 | 3061.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 15065.5 | 0.826135 | 65 | 56 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2032 | 2032 | yes | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13393735 | 4.NP_SO-102 | 4463.5 | 0.00454772 | 1.06711 | ø185 mm | 60 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15165.5 | 0.911463 | 65 | 61 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2033 | 2033 | yes | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13393744 | 4.NP_SO-102 | 1626.73 | 0.00454772 | 0.38891 | ø185 mm | 60 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15165.5 | 0.332183 | 65 | 61 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2034 | 2034 | yes | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13393754 | 4.NP_SO-102 | 4513.1 | 0.00454772 | 1.07897 | ø185 mm | 60 | 0.00145138 | HD | 3138.05 | 3100 | 3100 | 4.NP_SO-102 | 0 | 3061.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15065.5 | 0.921591 | 65 | 61 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2035 | 2035 | yes | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13393814 | 4.NP_SO-102 | 4195.64 | 0.00454772 | 1.00307 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 15165.5 | 0.856765 | 65 | 48 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2036 | 2036 | yes | HT_PRIMÁR_vratné 3
13393840 | 4.NP_SO-102 | 1704.52 | 0.00454772 | 0.40751 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15165.5 | 0.34807 | 65 | 44 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2037 | 2037 | yes | HT_PRIMÁR_přívodní 3
13393850 | 4.NP_SO-102 | 4195.64 | 0.00454772 | 1.00307 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15165.5 | 0.856765 | 65 | 44 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2038 | 2038 | yes | HT_PRIMÁR_přívodní 3
13393988 | 4.NP_SO-102 | 1881.64 | 0.00454772 | 0.449855 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15165.5 | 0.384239 | 65 | 52 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2039 | 2039 | yes | HT_PRIMÁR_přívodní 3
13393996 | 4.NP_SO-102 | 1404.52 | 0.00454772 | 0.335787 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15165.5 | 0.286809 | 65 | 52 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2040 | 2040 | yes | HT_PRIMÁR_přívodní 3
13394008 | 4.NP_SO-102 | 3945.64 | 0.00454772 | 0.943306 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15165.5 | 0.805715 | 65 | 52 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2041 | 2041 | yes | HT_PRIMÁR_přívodní 3
13394036 | 4.NP_SO-102 | 71.1526 | 0.00454772 | 0.0170108 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 15165.5 | 0.0145296 | 65 | 59 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2042 | 2042 | yes | HT_PRIMÁR_vratné 3
13394046 | 4.NP_SO-102 | 854.524 | 0.00454772 | 0.204296 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 15165.5 | 0.174497 | 65 | 59 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2043 | 2043 | yes | HT_PRIMÁR_vratné 3
13394059 | 4.NP_SO-102 | 3445.64 | 0.00454772 | 0.823768 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 15165.5 | 0.703613 | 65 | 59 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2044 | 2044 | yes | HT_PRIMÁR_vratné 3
13394310 | 4.NP_SO-102 | 1754.52 | 0.00454772 | 0.419463 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 15165.5 | 0.35828 | 65 | 48 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2045 | 2045 | yes | HT_PRIMÁR_vratné 3
13394318 | 4.NP_SO-102 | 4621.75 | 0.00454772 | 1.10495 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 15165.5 | 0.943778 | 65 | 48 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2046 | 2046 | yes | HT_PRIMÁR_vratné 3
13394447 | 4.NP_SO-102 | 1439.89 | 0.00454772 | 0.344243 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 15165.5 | 0.294031 | 65 | 59 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2047 | 2047 | yes | HT_PRIMÁR_vratné 3
13395199 | 4.NP_SO-102 | 20.625 | 0.00454772 | 0.00493093 | ø185 mm | 60 | 0.00145138 | HD | 3160.31 | 3160.31 | 3139.69 | 4.NP_SO-102 |  | 3139.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 15139.7 | 0.0042117 | 65 | 56 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2048 | 2048 | yes | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13395215 | 4.NP_SO-102 | 20.625 | 0.00454772 | 0.00493093 | ø185 mm | 60 | 0.00145138 | HD | 3160.31 | 3160.31 | 3139.69 | 4.NP_SO-102 |  | 3139.69 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15139.7 | 0.0042117 | 65 | 61 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2049 | 2049 | yes | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13395420 | 4.NP_SO-102 | 120.625 | 0.00454772 | 0.0288384 | ø65 mm | 0 | 0.00145138 | HD | 3160.31 | 3160.31 | 3039.69 | 4.NP_SO-102 |  | 3039.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 15039.7 | 0.024632 | 65 | 59 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2050 | 2050 | yes | HT_PRIMÁR_vratné 3
13395451 | 4.NP_SO-102 | 20.625 | 0.00454772 | 0.00493093 | ø65 mm | 0 | 0.00145138 | HD | 3160.31 | 3160.31 | 3139.69 | 4.NP_SO-102 |  | 3139.69 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15139.7 | 0.0042117 | 65 | 52 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2051 | 2051 | yes | HT_PRIMÁR_přívodní 3
13395493 | 4.NP_SO-102 | 88.0812 | 0.00454772 | 0.021058 | ø65 mm | 0 | 0.00145138 | HD | 3160.31 | 3160.31 | 3072.23 | 4.NP_SO-102 |  | 3072.23 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 15072.2 | 0.0179865 | 65 | 50 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2052 | 2052 | yes | HT_PRIMÁR_vratné 3
13395496 | 4.NP_SO-102 | 2050.96 | 0.00620623 | 0.572808 | ø200 mm | 60 | 0.00123762 | HD | 3044.45 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2955.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 14959.6 | 0.515463 | 80 | 66 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2053 | 2053 | yes | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13395527 | 4.NP_SO-102 | 14.275 | 0.00454772 | 0.0034128 | ø65 mm | 0 | 0.00145138 | HD | 3160.31 | 3160.31 | 3146.04 | 4.NP_SO-102 |  | 3146.04 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15146 | 0.00291501 | 65 | 48 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2054 | 2054 | yes | HT_PRIMÁR_přívodní 3
13395530 | 4.NP_SO-102 | 2337.47 | 0.00620623 | 0.652825 | ø200 mm | 60 | 0.00123762 | HD | 3144.45 | 3100 | 3100 | 4.NP_SO-102 | 0 | 3055.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15059.6 | 0.58747 | 80 | 54 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2055 | 2055 | yes | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13395559 | 4.NP_SO-102 | 14.275 | 0.00454772 | 0.0034128 | ø185 mm | 60 | 0.00145138 | HD | 3060.31 | 3060.31 | 3046.04 | 4.NP_SO-102 |  | 3046.04 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 15046 | 0.00291501 | 65 | 56 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2056 | 2056 | yes | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13395562 | 4.NP_SO-102 | 481.731 | 0.00620623 | 0.134542 | ø200 mm | 60 | 0.00123762 | HD | 3044.45 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2955.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 14959.6 | 0.121072 | 80 | 65 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2057 | 2057 | yes | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13395597 | 4.NP_SO-102 | 174.587 | 0.00620623 | 0.0487601 | ø200 mm | 60 | 0.00123762 | HD | 3144.45 | 3100 | 3100 | 4.NP_SO-102 | 0 | 3055.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15059.6 | 0.0438786 | 80 | 60 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2058 | 2058 | yes | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13395608 | 4.NP_SO-102 | 481.731 | 0.00620623 | 0.134542 | ø200 mm | 60 | 0.00123762 | HD | 3144.45 | 3100 | 3100 | 4.NP_SO-102 | 0 | 3055.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15059.6 | 0.121072 | 80 | 50 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2059 | 2059 | yes | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13395627 | 4.NP_SO-102 | 88.0812 | 0.00454772 | 0.021058 | ø65 mm | 0 | 0.00145138 | HD | 3160.31 | 3160.31 | 3072.23 | 4.NP_SO-102 |  | 3072.23 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 15072.2 | 0.0179865 | 65 | 48 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2060 | 2060 | yes | HT_PRIMÁR_vratné 3
13395630 | 4.NP_SO-102 | 481.731 | 0.00620623 | 0.134542 | ø200 mm | 60 | 0.00123762 | HD | 3044.45 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2955.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 14959.6 | 0.121072 | 80 | 62 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2061 | 2061 | yes | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13395669 | 4.NP_SO-102 | 14.275 | 0.00454772 | 0.0034128 | ø65 mm | 0 | 0.00145138 | HD | 3160.31 | 3160.31 | 3146.04 | 4.NP_SO-102 |  | 3146.04 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15146 | 0.00291501 | 65 | 44 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2062 | 2062 | yes | HT_PRIMÁR_přívodní 3
13395672 | 4.NP_SO-102 | 481.731 | 0.00620623 | 0.134542 | ø200 mm | 60 | 0.00123762 | HD | 3144.45 | 3100 | 3100 | 4.NP_SO-102 | 0 | 3055.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15059.6 | 0.121072 | 80 | 57 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2063 | 2063 | yes | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13395859 | 4.NP_SO-102 | 3898.51 | 0.00454772 | 0.932037 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 15165.5 | 0.79609 | 65 | 56 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2064 | 2064 | yes | HT_PRIMÁR_přívodní 1
13396336 | 4.NP_SO-102 | 1638.83 | 0.00454772 | 0.391804 | ø65 mm | 0 | 0.00145138 | HD | 3158.05 | 3120 | 3120 | 4.NP_SO-102 | 0 | 3081.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 15085.5 | 0.334656 | 65 | 67 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2065 | 2065 | yes | HT_PRIMÁR_vratné 5
13396371 | 4.NP_SO-102 | 1430.59 | 0.00454772 | 0.342017 | ø185 mm | 60 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 15165.5 | 0.292131 | 65 | 70 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2066 | 2066 | yes | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
13396380 | 4.NP_SO-102 | 401.894 | 0.00454772 | 0.0960828 | ø185 mm | 60 | 0.00145138 | HD | 2838.05 | 2800 | 2800 | 4.NP_SO-102 | 0 | 2761.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 14765.5 | 0.0820681 | 65 | 70 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2067 | 2067 | yes | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
13396535 | 4.NP_SO-102 | 120.625 | 0.00454772 | 0.0288384 | ø65 mm | 0 | 0.00145138 | HD | 3160.31 | 3039.69 | 3160.31 | 4.NP_SO-102 |  | 3039.69 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 15039.7 | 0.024632 | 65 | 56 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2068 | 2068 | yes | HT_PRIMÁR_přívodní 1
13396822 | 4.NP_SO-102 | 705.988 | 0.00454772 | 0.168784 | ø65 mm | 0 | 0.00145138 | HD | 2838.05 | 2800 | 2800 | 4.NP_SO-102 | 0 | 2761.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 14765.5 | 0.144165 | 65 | 67 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2069 | 2069 | yes | HT_PRIMÁR_vratné 5
13396857 | 4.NP_SO-102 | 1400.63 | 0.00454772 | 0.334855 | ø65 mm | 0 | 0.00145138 | HD | 3038.05 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2961.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 14965.5 | 0.286013 | 65 | 56 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2070 | 2070 | yes | HT_PRIMÁR_přívodní 1
13396890 | 4.NP_SO-102 | 1700.63 | 0.00454772 | 0.406577 | ø65 mm | 0 | 0.00145138 | HD | 3038.05 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2961.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 14965.5 | 0.347274 | 65 | 1 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2071 | 2071 | yes | HT_PRIMÁR_vratné 5
13396938 | 4.NP_SO-102 | 120.625 | 0.00454772 | 0.0288384 | ø65 mm | 0 | 0.00145138 | HD | 3160.31 | 3039.69 | 3160.31 | 4.NP_SO-102 |  | 3039.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 15039.7 | 0.024632 | 65 | 1 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2072 | 2072 | yes | HT_PRIMÁR_vratné 5
13397312 | 4.NP_SO-102 | 266.531 | 0.00454772 | 0.0637209 | ø65 mm | 0 | 0.00145138 | HD | 3158.05 | 3120 | 3120 | 4.NP_SO-102 | 0 | 3081.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 15085.5 | 0.0544265 | 65 | 67 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2073 | 2073 | yes | HT_PRIMÁR_vratné 5
13397434 | 4.NP_SO-102 | 1973.8 | 0.00454772 | 0.471887 | ø65 mm | 0 | 0.00145138 | HD | 3038.05 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2961.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 14965.5 | 0.403057 | 65 | 56 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2074 | 2074 | yes | HT_PRIMÁR_přívodní 1
13397442 | 4.NP_SO-102 | 520.625 | 0.00454772 | 0.124469 | ø65 mm | 0 | 0.00145138 | HD | 3038.05 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2961.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 14965.5 | 0.106313 | 65 | 56 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2075 | 2075 | yes | HT_PRIMÁR_přívodní 1
13397481 | 4.NP_SO-102 | 2223.8 | 0.00454772 | 0.531656 | ø65 mm | 0 | 0.00145138 | HD | 3038.05 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2961.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 14965.5 | 0.454108 | 65 | 1 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2076 | 2076 | yes | HT_PRIMÁR_vratné 5
13397487 | 4.NP_SO-102 | 514.275 | 0.00454772 | 0.12295 | ø65 mm | 0 | 0.00145138 | HD | 2838.05 | 2800 | 2800 | 4.NP_SO-102 | 0 | 2761.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 14765.5 | 0.105017 | 65 | 1 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2077 | 2077 | yes | HT_PRIMÁR_vratné 5
13397594 | 4.NP_SO-102 | 1467.45 | 0.00454772 | 0.350831 | ø185 mm | 60 | 0.00145138 | HD | 2838.05 | 2800 | 2800 | 4.NP_SO-102 | 0 | 2761.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 14765.5 | 0.299659 | 65 | 70 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2078 | 2078 | yes | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
13397886 | 4.NP_SO-102 | 2374.53 | 0.00454772 | 0.567692 | ø65 mm | 0 | 0.00145138 | HD | 2988.05 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2911.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 6 | 14915.5 | 0.484888 | 65 | 65 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2079 | 2079 | yes | HT_PRIMÁR_vratné 6
13398353 | 4.NP_SO-102 | 1880.42 | 0.00454772 | 0.449562 | ø185 mm | 60 | 0.00145138 | HD | 2988.05 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2911.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14915.5 | 0.383988 | 65 | 59 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2080 | 2080 | yes | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13398499 | 4.NP_SO-102 | 1513.87 | 0.00454772 | 0.36193 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 15165.5 | 0.309138 | 65 | 59 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2081 | 2081 | yes | HT_PRIMÁR_vratné 7
13398565 | 4.NP_SO-102 | 1455.62 | 0.00454772 | 0.348004 | ø185 mm | 60 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 15165.5 | 0.297244 | 65 | 72 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2082 | 2082 | yes | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13398597 | 4.NP_SO-102 | 170.625 | 0.00454772 | 0.0407922 | ø65 mm | 0 | 0.00145138 | HD | 3160.31 | 2989.69 | 3160.31 | 4.NP_SO-102 |  | 2989.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 14989.7 | 0.0348422 | 65 | 59 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2083 | 2083 | yes | HT_PRIMÁR_vratné 7
13398630 | 4.NP_SO-102 | 170.625 | 0.00454772 | 0.0407922 | ø65 mm | 0 | 0.00145138 | HD | 3160.31 | 2989.69 | 3160.31 | 4.NP_SO-102 |  | 2989.69 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14989.7 | 0.0348422 | 65 | 72 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2084 | 2084 | yes | HT_PRIMÁR_přívodní 4
13398964 | 4.NP_SO-102 | 3851.85 | 0.00454772 | 0.920881 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 15165.5 | 0.78656 | 65 | 81 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2085 | 2085 | yes | HT_PRIMÁR_přívodní 4
13399012 | 4.NP_SO-102 | 3829.12 | 0.00454772 | 0.915447 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 15165.5 | 0.781919 | 65 | 72 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2086 | 2086 | yes | HT_PRIMÁR_vratné 7
13399248 | 4.NP_SO-102 | 3756.13 | 0.00454772 | 0.897999 | ø65 mm | 0 | 0.00145138 | HD | 2738.05 | 2700 | 2700 | 4.NP_SO-102 | 0 | 2661.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14665.5 | 0.767016 | 65 | 67 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2087 | 2087 | yes | HT_PRIMÁR_přívodní 4
13399450 | 4.NP_SO-102 | 3846.13 | 0.00454772 | 0.919515 | ø65 mm | 0 | 0.00145138 | HD | 2738.05 | 2700 | 2700 | 4.NP_SO-102 | 0 | 2661.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 14665.5 | 0.785394 | 65 | 54 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2088 | 2088 | yes | HT_PRIMÁR_vratné 7
13399903 | 4.NP_SO-102 | 2030.63 | 0.00454772 | 0.485472 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 15165.5 | 0.414661 | 65 | 67 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2089 | 2089 | yes | HT_PRIMÁR_přívodní 4
13399913 | 4.NP_SO-102 | 3101.85 | 0.00454772 | 0.741574 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 15165.5 | 0.633408 | 65 | 67 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2090 | 2090 | yes | HT_PRIMÁR_přívodní 4
13399937 | 4.NP_SO-102 | 2330.63 | 0.00454772 | 0.557195 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 15165.5 | 0.475922 | 65 | 54 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2091 | 2091 | yes | HT_PRIMÁR_vratné 7
13399945 | 4.NP_SO-102 | 3579.12 | 0.00454772 | 0.855678 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 15165.5 | 0.730868 | 65 | 54 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2092 | 2092 | yes | HT_PRIMÁR_vratné 7
13400421 | 4.NP_SO-102 | 1766.45 | 0.00454772 | 0.422314 | ø65 mm | 0 | 0.00145138 | HD | 2988.05 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2911.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14915.5 | 0.360715 | 65 | 72 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2093 | 2093 | yes | HT_PRIMÁR_přívodní 4
13400429 | 4.NP_SO-102 | 3761.85 | 0.00454772 | 0.899364 | ø65 mm | 0 | 0.00145138 | HD | 2988.05 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2911.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14915.5 | 0.768182 | 65 | 72 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2094 | 2094 | yes | HT_PRIMÁR_přívodní 4
13400466 | 4.NP_SO-102 | 1466.45 | 0.00454772 | 0.350591 | ø65 mm | 0 | 0.00145138 | HD | 2988.05 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2911.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 14915.5 | 0.299454 | 65 | 59 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2095 | 2095 | yes | HT_PRIMÁR_vratné 7
13400474 | 4.NP_SO-102 | 3765.31 | 0.00454772 | 0.900192 | ø65 mm | 0 | 0.00145138 | HD | 2988.05 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2911.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 14915.5 | 0.76889 | 65 | 59 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2096 | 2096 | yes | HT_PRIMÁR_vratné 7
13400665 | 4.NP_SO-102 | 1513.23 | 0.00620623 | 0.422626 | ø80 mm | 0 | 0.00123762 | HD | 2994.45 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2905.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 14909.6 | 0.380316 | 80 | 62 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2097 | 2097 | yes | HT_PRIMÁR_vratné 7
13400828 | 4.NP_SO-102 | 2930.63 | 0.00454772 | 0.70064 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 15165.5 | 0.598444 | 65 | 81 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2098 | 2098 | yes | HT_PRIMÁR_přívodní 4
13400852 | 4.NP_SO-102 | 2630.63 | 0.00454772 | 0.628917 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 15165.5 | 0.537183 | 65 | 72 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2099 | 2099 | yes | HT_PRIMÁR_vratné 7
13401143 | 4.NP_SO-102 | 1863.23 | 0.00620623 | 0.520377 | ø80 mm | 0 | 0.00123762 | HD | 2994.45 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2905.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14909.6 | 0.468281 | 80 | 18 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2100 | 2100 | yes | HT_PRIMÁR_přívodní 4
13401315 | 4.NP_SO-102 | 151.575 | 0.00620623 | 0.042333 | ø80 mm | 0 | 0.00123762 | HD | 3153.96 | 3153.96 | 3002.39 | 4.NP_SO-102 |  | 3002.39 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 15002.4 | 0.038095 | 80 | 64 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2101 | 2101 | yes | HT_PRIMÁR_přívodní 4
13401318 | 4.NP_SO-102 | 201.575 | 0.00620623 | 0.0562974 | ø80 mm | 0 | 0.00123762 | HD | 2994.45 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2905.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14909.6 | 0.0506613 | 80 | 84 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2102 | 2102 | yes | HT_PRIMÁR_přívodní 4
13401345 | 4.NP_SO-102 | 151.575 | 0.00620623 | 0.042333 | ø80 mm | 0 | 0.00123762 | HD | 3153.96 | 3153.96 | 3002.39 | 4.NP_SO-102 |  | 3002.39 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 15002.4 | 0.038095 | 80 | 82 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2103 | 2103 | yes | HT_PRIMÁR_přívodní 4
13401348 | 4.NP_SO-102 | 442.864 | 0.00620623 | 0.123686 | ø80 mm | 0 | 0.00123762 | HD | 2994.45 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2905.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14909.6 | 0.111304 | 80 | 57 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2104 | 2104 | yes | HT_PRIMÁR_přívodní 4
13401375 | 4.NP_SO-102 | 151.575 | 0.00620623 | 0.042333 | ø80 mm | 0 | 0.00123762 | HD | 3153.96 | 3153.96 | 3002.39 | 4.NP_SO-102 |  | 3002.39 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 15002.4 | 0.038095 | 80 | 60 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2105 | 2105 | yes | HT_PRIMÁR_vratné 7
13401575 | 4.NP_SO-102 | 151.575 | 0.00620623 | 0.042333 | ø80 mm | 0 | 0.00123762 | HD | 3153.96 | 3153.96 | 3002.39 | 4.NP_SO-102 |  | 3002.39 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 15002.4 | 0.038095 | 80 | 73 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2106 | 2106 | yes | HT_PRIMÁR_vratné 7
13401578 | 4.NP_SO-102 | 195.225 | 0.00620623 | 0.0545239 | ø80 mm | 0 | 0.00123762 | HD | 2994.45 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2905.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 14909.6 | 0.0490654 | 80 | 61 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2107 | 2107 | yes | HT_PRIMÁR_vratné 7
13401660 | 4.NP_SO-102 | 420.313 | 0.00454772 | 0.100486 | ø65 mm | 0 | 0.00145138 | HD | 2988.05 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2911.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 6 | 14915.5 | 0.0858293 | 65 | 65 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2108 | 2108 | yes | HT_PRIMÁR_vratné 6
13401705 | 4.NP_SO-102 | 788.081 | 0.00454772 | 0.188411 | ø65 mm | 0 | 0.00145138 | HD | 2988.05 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2911.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 14915.5 | 0.160929 | 65 | 59 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2109 | 2109 | yes | HT_PRIMÁR_vratné 7
13401745 | 4.NP_SO-102 | 932.526 | 0.00454772 | 0.222944 | ø65 mm | 0 | 0.00145138 | HD | 2838.05 | 2800 | 2800 | 4.NP_SO-102 | 0 | 2761.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14765.5 | 0.190425 | 65 | 59 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2110 | 2110 | yes | HT_PRIMÁR_přívodní 4
13402033 | 4.NP_SO-102 | 51.575 | 0.00620623 | 0.0144043 | ø80 mm | 0 | 0.00123762 | HD | 2897.61 | 2846.04 | 2897.61 | 4.NP_SO-102 |  | 2846.04 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14846 | 0.0129622 | 80 | 83 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2111 | 2111 | yes | HT_PRIMÁR_přívodní 4
13402036 | 4.NP_SO-102 | 247.586 | 0.00620623 | 0.0691477 | ø80 mm | 0 | 0.00123762 | HD | 2994.45 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2905.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14909.6 | 0.0622252 | 80 | 73 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2112 | 2112 | yes | HT_PRIMÁR_přívodní 4
13402076 | 4.NP_SO-102 | 70.625 | 0.00454772 | 0.0168847 | ø65 mm | 0 | 0.00145138 | HD | 2910.31 | 2910.31 | 2839.69 | 4.NP_SO-102 |  | 2839.69 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14839.7 | 0.0144219 | 65 | 59 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2113 | 2113 | yes | HT_PRIMÁR_přívodní 4
13402284 | 4.NP_SO-102 | 322.28 | 0.00454772 | 0.0770492 | ø65 mm | 0 | 0.00145138 | HD | 2738.05 | 2700 | 2700 | 4.NP_SO-102 | 0 | 2661.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14665.5 | 0.0658107 | 65 | 67 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2114 | 2114 | yes | HT_PRIMÁR_přívodní 4
13402295 | 4.NP_SO-102 | 420.625 | 0.00454772 | 0.100561 | ø65 mm | 0 | 0.00145138 | HD | 3160.31 | 2739.69 | 3160.31 | 4.NP_SO-102 |  | 2739.69 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14739.7 | 0.0858931 | 65 | 67 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2115 | 2115 | yes | HT_PRIMÁR_přívodní 4
13402318 | 4.NP_SO-102 | 572.28 | 0.00454772 | 0.136818 | ø65 mm | 0 | 0.00145138 | HD | 2738.05 | 2700 | 2700 | 4.NP_SO-102 | 0 | 2661.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 14665.5 | 0.116862 | 65 | 54 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2116 | 2116 | yes | HT_PRIMÁR_vratné 7
13402329 | 4.NP_SO-102 | 420.625 | 0.00454772 | 0.100561 | ø65 mm | 0 | 0.00145138 | HD | 3160.31 | 2739.69 | 3160.31 | 4.NP_SO-102 |  | 2739.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 14739.7 | 0.0858931 | 65 | 54 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2117 | 2117 | yes | HT_PRIMÁR_vratné 7
13402348 | 4.NP_SO-102 | 1471.76 | 0.00454772 | 0.351861 | ø185 mm | 60 | 0.00145138 | HD | 2838.05 | 2800 | 2800 | 4.NP_SO-102 | 0 | 2761.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 14765.5 | 0.300538 | 65 | 72 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2118 | 2118 | yes | HT_PRIMÁR_vratné 7 | Izolace - Typ izolace: Tepelná
13402358 | 4.NP_SO-102 | 320.625 | 0.00454772 | 0.0766535 | ø65 mm | 0 | 0.00145138 | HD | 3160.31 | 2839.69 | 3160.31 | 4.NP_SO-102 |  | 2839.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 14839.7 | 0.0654728 | 65 | 72 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2119 | 2119 | yes | HT_PRIMÁR_vratné 7
13402380 | 4.NP_SO-102 | 1530.01 | 0.00454772 | 0.365786 | ø65 mm | 0 | 0.00145138 | HD | 2838.05 | 2800 | 2800 | 4.NP_SO-102 | 0 | 2761.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14765.5 | 0.312432 | 65 | 81 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2120 | 2120 | yes | HT_PRIMÁR_přívodní 4
13402389 | 4.NP_SO-102 | 320.625 | 0.00454772 | 0.0766535 | ø65 mm | 0 | 0.00145138 | HD | 3160.31 | 2839.69 | 3160.31 | 4.NP_SO-102 |  | 2839.69 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14839.7 | 0.0654728 | 65 | 81 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2121 | 2121 | yes | HT_PRIMÁR_přívodní 4
13402542 | 4.NP_SO-102 | 1133.47 | 0.00620623 | 0.316565 | ø200 mm | 60 | 0.00123762 | HD | 2544.45 | 2500 | 2500 | 4.NP_SO-102 | 0 | 2455.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14459.6 | 0.284873 | 80 | 18 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2122 | 2122 | yes | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13402549 | 4.NP_SO-102 | 147.236 | 0.00620623 | 0.0411212 | ø200 mm | 60 | 0.00123762 | HD | 2544.45 | 2500 | 2500 | 4.NP_SO-102 | 0 | 2455.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14459.6 | 0.0370044 | 80 | 18 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2123 | 2123 | yes | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13402560 | 4.NP_SO-102 | 107.925 | 0.00620623 | 0.0301421 | ø200 mm | 60 | 0.00123762 | HD | 2653.96 | 2546.04 | 2653.96 | 4.NP_SO-102 |  | 2546.04 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14546 | 0.0271245 | 80 | 18 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2124 | 2124 | yes | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13402595 | 4.NP_SO-102 | 6064.89 | 0.00620623 | 1.69385 | ø200 mm | 60 | 0.00123762 | HD | 3044.45 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2955.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 14959.6 | 1.52427 | 80 | 65 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2125 | 2125 | yes | HT_PRIMÁR_vratné 5 | Izolace - Typ izolace: Tepelná
13402604 | 4.NP_SO-102 | 1000.44 | 0.00620623 | 0.279412 | ø200 mm | 60 | 0.00123762 | HD | 3044.45 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2955.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 14959.6 | 0.251439 | 80 | 65 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2126 | 2126 | yes | HT_PRIMÁR_vratné 5 | Izolace - Typ izolace: Tepelná
13402627 | 4.NP_SO-102 | 5916 | 0.00620623 | 1.65227 | ø200 mm | 60 | 0.00123762 | HD | 3044.45 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2955.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 14959.6 | 1.48685 | 80 | 71 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2127 | 2127 | yes | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
13402634 | 4.NP_SO-102 | 775.445 | 0.00620623 | 0.216572 | ø200 mm | 60 | 0.00123762 | HD | 3044.45 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2955.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 14959.6 | 0.19489 | 80 | 71 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2128 | 2128 | yes | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
13403455 | 4.NP_SO-102 | 120.625 | 0.00454772 | 0.0288384 | ø65 mm | 0 | 0.00145138 | HD | 2960.31 | 2960.31 | 2839.69 | 4.NP_SO-102 |  | 2839.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 14839.7 | 0.024632 | 65 | 1 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2129 | 2129 | yes | HT_PRIMÁR_vratné 5
13403475 | 4.NP_SO-102 | 228.081 | 0.00620623 | 0.0637003 | ø80 mm | 0 | 0.00123762 | HD | 2844.45 | 2800 | 2800 | 4.NP_SO-102 | 0 | 2755.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 14759.6 | 0.0573231 | 80 | 65 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2130 | 2130 | yes | HT_PRIMÁR_vratné 5
13403483 | 4.NP_SO-102 | 1717.45 | 0.00454772 | 0.4106 | ø65 mm | 0 | 0.00145138 | HD | 2838.05 | 2800 | 2800 | 4.NP_SO-102 | 0 | 2761.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 14765.5 | 0.35071 | 65 | 67 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2131 | 2131 | yes | HT_PRIMÁR_vratné 5
13404070 | 4.NP_SO-102 | 295.225 | 0.00620623 | 0.0824527 | ø80 mm | 0 | 0.00123762 | HD | 2994.45 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2905.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 14909.6 | 0.0741981 | 80 | 64 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2132 | 2132 | yes | HT_PRIMÁR_vratné 7
13404149 | 4.NP_SO-102 | 8677.92 | 0.00620623 | 2.42364 | ø80 mm | 0 | 0.00123762 | HD | 2953.96 | -5723.96 | 2953.96 | 4.NP_SO-102 |  | -5723.96 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 6276.04 | 2.181 | 80 | 65 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2133 | 2133 | yes | HT_PRIMÁR_vratné 5
13404184 | 4.NP_SO-102 | 8957.93 | 0.00620623 | 2.50184 | ø80 mm | 0 | 0.00123762 | HD | 2953.96 | -6003.96 | 2953.96 | 4.NP_SO-102 |  | -6003.96 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 5996.04 | 2.25137 | 80 | 71 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2134 | 2134 | yes | HT_PRIMÁR_přívodní 1
13404527 | 2.NP_SO-102 | 7575.19 | 0.00620623 | 2.11566 | ø200 mm | 60 | 0.00123762 | HD | 2274.45 | 2230 | 2230 | 2.NP_SO-102 | 0 | 2185.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 6189.6 | 1.90385 | 80 | 65 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2135 | 2135 | yes | HT_PRIMÁR_vratné 5 | Izolace - Typ izolace: Tepelná
13404536 | 2.NP_SO-102 | 208.689 | 0.00620623 | 0.0582841 | ø200 mm | 60 | 0.00123762 | HD | 2274.45 | 2230 | 2230 | 2.NP_SO-102 | 0 | 2185.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 6189.6 | 0.0524492 | 80 | 65 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2136 | 2136 | yes | HT_PRIMÁR_vratné 5 | Izolace - Typ izolace: Tepelná
13404546 | 2.NP_SO-102 | 878.394 | 0.00620623 | 0.245324 | ø200 mm | 60 | 0.00123762 | HD | 2274.45 | 2230 | 2230 | 2.NP_SO-102 | 0 | 2185.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 6189.6 | 0.220764 | 80 | 65 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.2137 | 2137 | yes | HT_PRIMÁR_vratné 5 | Izolace - Typ izolace: Tepelná
13404664 | 2.NP_SO-102 | 357.841 | 0.00620623 | 0.0999406 | ø200 mm | 60 | 0.00123762 | HD | 2247.95 | 1963.48 | 2216.52 | 2.NP_SO-102 | 100 | 1932.05 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 5934.92 | 0.0899353 | 80 | 71 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2138 | 2138 | yes | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
13404702 | 2.NP_SO-102 | 1219.71 | 0.00620623 | 0.340649 | ø200 mm | 60 | 0.00123762 | HD | 1994.45 | 1950 | 1950 | 2.NP_SO-102 | 0 | 1905.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 5909.6 | 0.306546 | 80 | 71 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.2139 | 2139 | yes | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
13405838 | 2.NP_SO-102 | 6390.32 | 0.00454772 | 1.52777 | ø65 mm | 0 | 0.00145138 | HD | 2838.05 | 2800 | 2800 | 2.NP_SO-102 | 0 | 2761.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 6765.55 | 1.30493 | 65 | 76 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2140 | 2140 | yes | HT_PRIMÁR_přívodní 4
13405844 | 2.NP_SO-102 | 760.625 | 0.00454772 | 0.181847 | ø65 mm | 0 | 0.00145138 | HD | 2838.05 | 2800 | 2800 | 2.NP_SO-102 | 0 | 2761.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 6765.55 | 0.155322 | 65 | 76 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2141 | 2141 | yes | HT_PRIMÁR_přívodní 4
13405854 | 2.NP_SO-102 | 25.3125 | 0.00454772 | 0.00605159 | ø65 mm | 0 | 0.00145138 | HD | 938.05 | 900 | 900 | 2.NP_SO-102 | 0 | 861.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 4865.55 | 0.0051689 | 65 | 76 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2142 | 2142 | yes | HT_PRIMÁR_přívodní 4
13405925 | 2.NP_SO-102 | 1820.63 | 0.00454772 | 0.435266 | ø65 mm | 0 | 0.00145138 | HD | 2760.31 | 939.687 | 2760.31 | 2.NP_SO-102 |  | 939.687 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 4939.69 | 0.371778 | 65 | 76 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2143 | 2143 | yes | HT_PRIMÁR_přívodní 4
13405987 | 2.NP_SO-102 | 1273.76 | 0.00454772 | 0.304525 | ø65 mm | 0 | 0.00145138 | HD | 2838.05 | 2800 | 2800 | 2.NP_SO-102 | 0 | 2761.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 6765.55 | 0.260107 | 65 | 67 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2144 | 2144 | yes | HT_PRIMÁR_vratné 7
13405995 | 2.NP_SO-102 | 198.845 | 0.00454772 | 0.0475388 | ø65 mm | 0 | 0.00145138 | HD | 2838.05 | 2800 | 2800 | 2.NP_SO-102 | 0 | 2761.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 6765.55 | 0.0406047 | 65 | 67 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2145 | 2145 | yes | HT_PRIMÁR_vratné 7
13406003 | 2.NP_SO-102 | 18.9203 | 0.00454772 | 0.00452337 | ø65 mm | 0 | 0.00145138 | HD | 938.05 | 900 | 900 | 2.NP_SO-102 | 0 | 861.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 4865.55 | 0.00386359 | 65 | 67 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2146 | 2146 | yes | HT_PRIMÁR_vratné 7
13406039 | 2.NP_SO-102 | 1820.63 | 0.00454772 | 0.435266 | ø65 mm | 0 | 0.00145138 | HD | 2760.31 | 939.687 | 2760.31 | 2.NP_SO-102 |  | 939.687 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 4939.69 | 0.371778 | 65 | 67 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2147 | 2147 | yes | HT_PRIMÁR_vratné 7
13406736 | 2.NP_SO-102 | 712.45 | 0.00454772 | 0.170329 | ø65 mm | 0 | 0.00145138 | HD | 2838.05 | 2800 | 2800 | 2.NP_SO-102 | 0 | 2761.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 6765.55 | 0.145485 | 65 | 62 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2148 | 2148 | yes | HT_PRIMÁR_přívodní 3
13406744 | 2.NP_SO-102 | 440.313 | 0.00454772 | 0.105268 | ø65 mm | 0 | 0.00145138 | HD | 938.05 | 900 | 900 | 2.NP_SO-102 | 0 | 861.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 4865.55 | 0.0899134 | 65 | 62 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2149 | 2149 | yes | HT_PRIMÁR_přívodní 3
13406779 | 2.NP_SO-102 | 1820.63 | 0.00454772 | 0.435266 | ø65 mm | 0 | 0.00145138 | HD | 2760.31 | 939.687 | 2760.31 | 2.NP_SO-102 |  | 939.687 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 4939.69 | 0.371778 | 65 | 62 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.2150 | 2150 | yes | HT_PRIMÁR_přívodní 3
13406800 | 2.NP_SO-102 | 1217.45 | 0.00454772 | 0.291062 | ø65 mm | 0 | 0.00145138 | HD | 2788.05 | 2750 | 2750 | 2.NP_SO-102 | 0 | 2711.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 6715.55 | 0.248608 | 65 | 70 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2151 | 2151 | yes | HT_PRIMÁR_vratné 3
13406808 | 2.NP_SO-102 | 200.625 | 0.00454772 | 0.0479645 | ø65 mm | 0 | 0.00145138 | HD | 2788.05 | 2750 | 2750 | 2.NP_SO-102 | 0 | 2711.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 6715.55 | 0.0409683 | 65 | 70 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2152 | 2152 | yes | HT_PRIMÁR_vratné 3
13406816 | 2.NP_SO-102 | 436.794 | 0.00454772 | 0.104427 | ø65 mm | 0 | 0.00145138 | HD | 938.05 | 900 | 900 | 2.NP_SO-102 | 0 | 861.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 4865.55 | 0.0891948 | 65 | 70 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2153 | 2153 | yes | HT_PRIMÁR_vratné 3
13406857 | 2.NP_SO-102 | 1770.63 | 0.00454772 | 0.423313 | ø65 mm | 0 | 0.00145138 | HD | 2710.31 | 939.687 | 2710.31 | 2.NP_SO-102 |  | 939.687 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 4939.69 | 0.361568 | 65 | 70 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.2154 | 2154 | yes | HT_PRIMÁR_vratné 3
13412861 | -1.PP_SO-102 | 3804.05 | 0.00620623 | 1.06242 | ø200 mm | 60 | 0.00123762 | HD | 2844.45 | 2800 | 2800 | -1.PP_SO-102 | 0 | 2755.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | -1240.4 | 0.956061 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.2182 | 2182 | yes | HT_přívodní vodní (65 °C) 5 | Izolace - Typ izolace: Tepelná
13413358 | -1.PP_SO-102 | 668.968 | 0.00620623 | 0.186834 | ø80 mm | 0 | 0.00123762 | HD | 2817.95 | 2786.52 | 2313.48 | -1.PP_SO-102 | 100 | 2282.05 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | -1715.08 | 0.16813 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.2183 | 2183 | yes | HT_přívodní vodní (65 °C) 5
13413717 | -1.PP_SO-102 | 668.968 | 0.00620623 | 0.186834 | ø80 mm | 0 | 0.00123762 | HD | 2817.95 | 2786.52 | 2313.48 | -1.PP_SO-102 | 100 | 2282.05 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | -1715.08 | 0.16813 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.2184 | 2184 | yes | HT_vratné vodní (45 °C) 39
13413959 | -1.PP_SO-102 | 668.968 | 0.00620623 | 0.186834 | ø80 mm | 0 | 0.00123762 | HD | 2817.95 | 2786.52 | 2313.48 | -1.PP_SO-102 | 100 | 2282.05 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | -1715.08 | 0.16813 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.2185 | 2185 | yes | HT_vratné vodní (45 °C) 39
13414074 | -1.PP_SO-102 | 668.968 | 0.00620623 | 0.186834 | ø80 mm | 0 | 0.00123762 | HD | 2817.95 | 2786.52 | 2313.48 | -1.PP_SO-102 | 100 | 2282.05 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | -1715.08 | 0.16813 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.2186 | 2186 | yes | HT_přívodní vodní (65 °C) 5
13416300 | -1.PP_SO-102 | 6170.24 | 0.00620623 | 1.72327 | ø80 mm | 0 | 0.00123762 | HD | 2844.45 | 2800 | 2800 | -1.PP_SO-102 | 0 | 2755.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | -1240.4 | 1.55075 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.2189 | 2189 | yes | HT_přívodní vodní (65 °C) 5
13416336 | -1.PP_SO-102 | 5919.94 | 0.00620623 | 1.65337 | ø80 mm | 0 | 0.00123762 | HD | 2844.45 | 2800 | 2800 | -1.PP_SO-102 | 0 | 2755.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | -1240.4 | 1.48784 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.2190 | 2190 | yes | HT_vratné vodní (45 °C) 39
13416378 | -1.PP_SO-102 | 557.925 | 0.00620623 | 0.155822 | ø80 mm | 0 | 0.00123762 | HD | 2753.96 | 2196.04 | 2753.96 | -1.PP_SO-102 |  | 2196.04 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | -1803.96 | 0.140222 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.2191 | 2191 | yes | HT_přívodní vodní (65 °C) 5
13416413 | -1.PP_SO-102 | 557.925 | 0.00620623 | 0.155822 | ø80 mm | 0 | 0.00123762 | HD | 2753.96 | 2196.04 | 2753.96 | -1.PP_SO-102 |  | 2196.04 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | -1803.96 | 0.140222 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.2192 | 2192 | yes | HT_vratné vodní (45 °C) 39
13422419 | 2.NP_SO-102 | 7528.57 | 0.00454772 | 1.79989 | ø65 mm | 0 | 0.00145138 | HD | 3138.05 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3061.95 | Fáze 2 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7065.55 | 1.53736 | 65 | 549 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.2228 | 2228 | yes | HT_vratné vodní (45 °C) 13
13422479 | 2.NP_SO-102 | 7278.57 | 0.00454772 | 1.74013 | ø65 mm | 0 | 0.00145138 | HD | 3138.05 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3061.95 | Fáze 2 | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7065.55 | 1.48631 | 65 | 529 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.2229 | 2229 | yes | HT_přívodní vodní (55 °C) 19
13422744 | 2.NP_SO-102 | 678.732 | 0.00454772 | 0.162268 | ø65 mm | 0 | 0.00145138 | HD | 3127.64 | 2755.32 | 3094.68 | 2.NP_SO-102 | 57.735 | 2722.36 | Fáze 2 | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 6725.48 | 0.138599 | 65 | 529 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.2230 | 2230 | yes | HT_přívodní vodní (55 °C) 19
13422761 | 2.NP_SO-102 | 1160.17 | 0.00454772 | 0.277367 | ø65 mm | 0 | 0.00145138 | HD | 2788.05 | 2750 | 2750 | 2.NP_SO-102 | 0 | 2711.95 | Fáze 2 | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 6715.55 | 0.23691 | 65 | 529 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.2231 | 2231 | yes | HT_přívodní vodní (55 °C) 19
