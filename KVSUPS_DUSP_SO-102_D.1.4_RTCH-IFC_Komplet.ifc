Properties of the parts of a building model (IFC4), part 25 of 72

# IfcSpace: Výtah nákl.-4 B0108-4:13252076, B0108-4
LongName: Výtah nákl.-4; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 19.5837 m3; NetVolume: 19.5837 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.171357; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 52.6992 W; Specifikované výkonové zatížení: 68.509 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00189663 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 4.89592 m2
Identifikační data - Číslo: B0108-4; Číslo místnosti: Neobsazené; Název: Výtah nákl.-4; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Výtah nákl.-5 B0108-5:13252718, B0108-5
In: 2.NP_SO-102
LongName: Výtah nákl.-5; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 19.5837 m3; NetVolume: 19.5837 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.171357; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 52.6992 W; Specifikované výkonové zatížení: 68.509 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00189663 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 4.89592 m2
Identifikační data - Číslo: B0108-5; Číslo místnosti: Neobsazené; Název: Výtah nákl.-5; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Výtah-2 B0149-2:13364100, B0149-2
In: 1.NP_SO-102
LongName: Výtah-2; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 9.728 m3; NetVolume: 9.728 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.08512; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 26.1778 W; Specifikované výkonové zatížení: 34.0312 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.000942134 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 2.432 m2
Identifikační data - Číslo: B0149-2; Číslo místnosti: Neobsazené; Název: Výtah-2; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: WC - Chlapci B121.4:13364137, B121.4
In: 1.NP_SO-102
LongName: WC - Chlapci; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 8.95 m3; NetVolume: 8.95 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.0783125; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 24.0842 W; Specifikované výkonové zatížení: 31.3095 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.000866787 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 2.2375 m2
Identifikační data - Číslo: B121.4; Číslo místnosti: Neobsazené; Název: WC - Chlapci; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: WC - Chlapci B121.5:13364144, B121.5
In: 1.NP_SO-102
LongName: WC - Chlapci; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 8.15 m3; NetVolume: 8.15 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.0713125; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 21.9315 W; Specifikované výkonové zatížení: 28.5109 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.000789309 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 2.0375 m2
Identifikační data - Číslo: B121.5; Číslo místnosti: Neobsazené; Název: WC - Chlapci; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: WC - Imobilní B108.4:13251971, B108.4
In: 1.NP_SO-102
LongName: WC - Imobilní; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 25.992 m3; NetVolume: 25.992 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.22743; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 69.9439 W; Specifikované výkonové zatížení: 90.9271 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00251727 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 6.498 m2
Identifikační data - Číslo: B108.4; Číslo místnosti: Neobsazené; Název: WC - Imobilní; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC - Imobilní B112:13255850, B112
In: 1.NP_SO-102
LongName: WC - Imobilní; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 15.48 m3; NetVolume: 15.48 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.13545; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 41.6563 W; Specifikované výkonové zatížení: 54.1532 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0014992 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 3.87 m2
Identifikační data - Číslo: B112; Číslo místnosti: Neobsazené; Název: WC - Imobilní; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: WC - Imobilní B212:13364509, B212
In: 2.NP_SO-102
LongName: WC - Imobilní; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 15.48 m3; NetVolume: 15.48 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.13545; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 41.6563 W; Specifikované výkonové zatížení: 54.1532 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0014992 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 3.87 m2
Identifikační data - Číslo: B212; Číslo místnosti: Neobsazené; Název: WC - Imobilní; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: WC - Imobilní B308.4:13185890, B308.4
In: 3.NP_SO-102
LongName: WC - Imobilní; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 26.106 m3; NetVolume: 26.106 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.228428; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 70.2507 W; Specifikované výkonové zatížení: 91.3259 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00252831 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 3.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 3.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 6.5265 m2
Identifikační data - Číslo: B308.4; Číslo místnosti: Neobsazené; Název: WC - Imobilní; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC - Imobilní B312:13186346, B312
In: 3.NP_SO-102
LongName: WC - Imobilní; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 15.48 m3; NetVolume: 15.48 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.13545; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 41.6563 W; Specifikované výkonové zatížení: 54.1532 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0014992 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 3.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 3.NP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 3.87 m2
Identifikační data - Číslo: B312; Číslo místnosti: Neobsazené; Název: WC - Imobilní; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: WC - Imobilní B412:13185215, B412
In: 4.NP_SO-102
LongName: WC - Imobilní; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 15.48 m3; NetVolume: 15.48 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.13545; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 41.6563 W; Specifikované výkonové zatížení: 54.1532 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0014992 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 4.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 4.NP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 3.87 m2
Identifikační data - Číslo: B412; Číslo místnosti: Neobsazené; Název: WC - Imobilní; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: WC - Imobilní muži B246:13252685, B246
In: 2.NP_SO-102
LongName: WC - Imobilní muži; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 15.48 m3; NetVolume: 15.48 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.13545; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 41.6563 W; Specifikované výkonové zatížení: 54.1532 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0014992 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 3.87 m2
Identifikační data - Číslo: B246; Číslo místnosti: Neobsazené; Název: WC - Imobilní muži; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC - Imobilní ženy B248:13252658, B248
In: 2.NP_SO-102
LongName: WC - Imobilní ženy; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 15.48 m3; NetVolume: 15.48 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.13545; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 41.6563 W; Specifikované výkonové zatížení: 54.1532 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0014992 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 3.87 m2
Identifikační data - Číslo: B248; Číslo místnosti: Neobsazené; Název: WC - Imobilní ženy; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC - Muži B0137.2:13251660, B0137.2
In: -1.PP_SO-102
LongName: WC - Muži; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 6.57 m3; NetVolume: 6.57 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.0574875; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 17.6797 W; Specifikované výkonové zatížení: 22.9836 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.000636289 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 4000 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 1.6425 m2
Identifikační data - Číslo: B0137.2; Číslo místnosti: Neobsazené; Název: WC - Muži; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC - Muži B109.1:13252025, B109.1
In: 1.NP_SO-102
LongName: WC - Muži; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 20.746 m3; NetVolume: 20.746 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.181528; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 55.827 W; Specifikované výkonové zatížení: 72.5751 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0020092 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 5.1865 m2
Identifikační data - Číslo: B109.1; Číslo místnosti: Neobsazené; Název: WC - Muži; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC - Muži B109.2:13252028, B109.2
In: 1.NP_SO-102
LongName: WC - Muži; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 45.76 m3; NetVolume: 45.76 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.4004; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 123.139 W; Specifikované výkonové zatížení: 160.081 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00443175 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 11.44 m2
Identifikační data - Číslo: B109.2; Číslo místnosti: Neobsazené; Název: WC - Muži; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC - Muži B110:13255844, B110
In: 1.NP_SO-102
LongName: WC - Muži; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 33.935 m3; NetVolume: 33.935 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.296931; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 91.3183 W; Specifikované výkonové zatížení: 118.714 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00328653 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 8.48375 m2
Identifikační data - Číslo: B110; Číslo místnosti: Neobsazené; Název: WC - Muži; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: WC - Muži B209.1:13252595, B209.1
In: 2.NP_SO-102
LongName: WC - Muži; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 21.758 m3; NetVolume: 21.758 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.190383; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 58.5503 W; Specifikované výkonové zatížení: 76.1154 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00210721 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 5.4395 m2
Identifikační data - Číslo: B209.1; Číslo místnosti: Neobsazené; Název: WC - Muži; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC - Muži B209.2:13252598, B209.2
In: 2.NP_SO-102
LongName: WC - Muži; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 47.424 m3; NetVolume: 47.424 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.41496; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 127.617 W; Specifikované výkonové zatížení: 165.902 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 15 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00459291 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 11.856 m2
Identifikační data - Číslo: B209.2; Číslo místnosti: Neobsazené; Název: WC - Muži; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC - Muži B210:13364505, B210
In: 2.NP_SO-102
LongName: WC - Muži; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 35.169 m3; NetVolume: 35.169 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.307729; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 94.639 W; Specifikované výkonové zatížení: 123.031 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00340604 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 8.79225 m2
Identifikační data - Číslo: B210; Číslo místnosti: Neobsazené; Název: WC - Muži; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: WC - Muži B247.1:13252688, B247.1
In: 2.NP_SO-102
LongName: WC - Muži; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 14.52 m3; NetVolume: 14.52 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.12705; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 39.073 W; Specifikované výkonové zatížení: 50.7949 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00140623 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 3.63 m2
Identifikační data - Číslo: B247.1; Číslo místnosti: Neobsazené; Název: WC - Muži; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC - Muži B247.2:13252679, B247.2
In: 2.NP_SO-102
LongName: WC - Muži; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 14.52 m3; NetVolume: 14.52 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.12705; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 39.073 W; Specifikované výkonové zatížení: 50.7949 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00140623 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 3.63 m2
Identifikační data - Číslo: B247.2; Číslo místnosti: Neobsazené; Název: WC - Muži; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC - Muži B247.3:13252682, B247.3
In: 2.NP_SO-102
LongName: WC - Muži; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 9.06258 m3; NetVolume: 9.06258 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.0792976; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 24.3872 W; Specifikované výkonové zatížení: 31.7034 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00087769 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 4000 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 4000 mm; Plocha: 2.26565 m2
Identifikační data - Číslo: B247.3; Číslo místnosti: Neobsazené; Název: WC - Muži; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC - Muži B309.1:13185945, B309.1
In: 3.NP_SO-102
LongName: WC - Muži; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 4000 mm; GrossVolume: 21.758 m3; NetVolume: 21.758 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.190383; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 58.5503 W; Specifikované výkonové zatížení: 76.1154 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Výpočtová vnitřní teplota chlazení: 666 C; Výpočtová vnitřní teplota vytápění: 18 C; Zóna: Výchozí
