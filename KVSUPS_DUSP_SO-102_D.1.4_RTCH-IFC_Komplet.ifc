Properties of the parts of a building model (IFC4), part 62 of 72

# IfcPipeSegment: Typy trubek:Kompozit PE-Xa_RAUTITAN flex (676)
Name (Typy trubek:Kompozit PE-Xa_RAUTITAN flex:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Relativní drsnost | Sklon | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Typ systému | Drsnost (mm) | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group
13259735 | 2.NP_SO-102 | 4285.29 | 0.000201032 | 0.215402 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 471 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1586 | 1586 | no | HT_přívodní vodní (55 °C) 9
13259755 | 2.NP_SO-102 | 4692.77 | 0.000201032 | 0.235884 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 634 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1587 | 1587 | no | HT_vratné vodní (45 °C) 1
13299187 | -1.PP_SO-102 | 4033.16 | 0.000201032 | 0.202729 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4055.8 | RAU–PE–Xa | 16 | 309 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1801 | 1801 | no | HT_přívodní vodní (55 °C) 19
13299197 | -1.PP_SO-102 | 3185.71 | 0.000201032 | 0.160131 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4055.8 | RAU–PE–Xa | 16 | 309 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1802 | 1802 | no | HT_přívodní vodní (55 °C) 19
13299225 | -1.PP_SO-102 | 3792.41 | 0.000201032 | 0.190628 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 142 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1803 | 1803 | no | HT_vratné vodní (45 °C) 13
13299233 | -1.PP_SO-102 | 3035.71 | 0.000201032 | 0.152592 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 142 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1804 | 1804 | no | HT_vratné vodní (45 °C) 13
13299383 | -1.PP_SO-102 | 87.8141 | 0.000201032 | 0.00441402 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4055.8 | RAU–PE–Xa | 16 | 349 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1805 | 1805 | no | HT_přívodní vodní (55 °C) 19
13299390 | -1.PP_SO-102 | 266.728 | 0.000201032 | 0.0134072 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4055.8 | RAU–PE–Xa | 16 | 525 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1806 | 1806 | no | HT_přívodní vodní (55 °C) 19
13299398 | -1.PP_SO-102 | 237.814 | 0.000201032 | 0.0119538 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 362 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1807 | 1807 | no | HT_vratné vodní (45 °C) 13
13299405 | -1.PP_SO-102 | 299.347 | 0.000201032 | 0.0150468 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 545 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1808 | 1808 | no | HT_vratné vodní (45 °C) 13
13316512 | 4.NP_SO-102 | 3271.63 | 0.000201032 | 0.16445 | ø16 mm | 0.0045 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.063 | Zpětné vedení teplé vody | Kov, měď | HT_vratné vodní (45 °C) 1 | 11933 | Cu | 16 | 757 | Kov, měď - Polotvrdá (R250) tl. 1 mm SANCO | Polotvrdá (R250) tl. 1 mm SANCO | ø16 | 14 | TR13.03.1838 | 1838 | no | HT_vratné vodní (45 °C) 1
13316520 | 4.NP_SO-102 | 4473.45 | 0.000201032 | 0.22486 | ø16 mm | 0.0045 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.063 | Zpětné vedení teplé vody | Kov, měď | HT_vratné vodní (45 °C) 1 | 11933 | Cu | 16 | 394 | Kov, měď - Polotvrdá (R250) tl. 1 mm SANCO | Polotvrdá (R250) tl. 1 mm SANCO | ø16 | 14 | TR13.03.1839 | 1839 | no | HT_vratné vodní (45 °C) 1
13316539 | 4.NP_SO-102 | 4473.45 | 0.000201032 | 0.22486 | ø16 mm | 0.0045 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.063 | Přívod teplé vody | Kov, měď | HT_přívodní vodní (65 °C) 34 | 11943 | Cu | 16 | 2 | Kov, měď - Polotvrdá (R250) tl. 1 mm SANCO | Polotvrdá (R250) tl. 1 mm SANCO | ø16 | 14 | TR13.03.1840 | 1840 | no | HT_přívodní vodní (65 °C) 34
13316545 | 4.NP_SO-102 | 3271.63 | 0.000201032 | 0.16445 | ø16 mm | 0.0045 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.063 | Přívod teplé vody | Kov, měď | HT_přívodní vodní (65 °C) 34 | 11943 | Cu | 16 | 8 | Kov, měď - Polotvrdá (R250) tl. 1 mm SANCO | Polotvrdá (R250) tl. 1 mm SANCO | ø16 | 14 | TR13.03.1841 | 1841 | no | HT_přívodní vodní (65 °C) 34
13342071 | 1.NP_SO-102 | 94.0625 | 0.000201032 | 0.0047281 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 1 | -55.8 | RAU–PE–Xa | 16 | 362 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1905 | 1905 | no | HT_přívodní vodní (65 °C) 1
13342500 | 1.NP_SO-102 | 852.679 | 0.000201032 | 0.0428603 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -55.8 | RAU–PE–Xa | 16 | 568 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1906 | 1906 | no | HT_přívodní vodní (55 °C) 9
13342508 | 1.NP_SO-102 | 11679 | 0.000201032 | 0.587051 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -55.8 | RAU–PE–Xa | 16 | 421 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1907 | 1907 | no | HT_přívodní vodní (55 °C) 9
13343197 | 1.NP_SO-102 | 6184.06 | 0.000201032 | 0.310845 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 532 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1908 | 1908 | no | HT_přívodní vodní (55 °C) 19
13343220 | 1.NP_SO-102 | 6034.06 | 0.000201032 | 0.303305 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 554 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1909 | 1909 | no | HT_vratné vodní (45 °C) 13
13343241 | 1.NP_SO-102 | 8204.53 | 0.000201032 | 0.412405 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 270 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1910 | 1910 | no | HT_přívodní vodní (55 °C) 19
13343262 | 1.NP_SO-102 | 8204.53 | 0.000201032 | 0.412405 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 57 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1911 | 1911 | no | HT_vratné vodní (45 °C) 13
13344752 | 3.NP_SO-102 | 5141.2 | 0.000201032 | 0.258425 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7934.2 | RAU–PE–Xa | 16 | 452 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1916 | 1916 | no | HT_vratné vodní (45 °C) 13
13372809 | -1.PP_SO-102 | 1937.07 | 0.000201032 | 0.097368 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4055.8 | RAU–PE–Xa | 16 | 307 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1962 | 1962 | no | HT_přívodní vodní (55 °C) 19
13372828 | -1.PP_SO-102 | 1937.07 | 0.000201032 | 0.097368 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 359 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1963 | 1963 | no | HT_vratné vodní (45 °C) 13
13373421 | -1.PP_SO-102 | 86.1641 | 0.000201032 | 0.00433108 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4055.8 | RAU–PE–Xa | 16 | 526 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1964 | 1964 | no | HT_přívodní vodní (55 °C) 19
13373428 | -1.PP_SO-102 | 1198.32 | 0.000201032 | 0.0602344 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4055.8 | RAU–PE–Xa | 16 | 348 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1965 | 1965 | no | HT_přívodní vodní (55 °C) 19
13373495 | -1.PP_SO-102 | 236.164 | 0.000201032 | 0.0118709 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 546 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1966 | 1966 | no | HT_vratné vodní (45 °C) 13
13373504 | -1.PP_SO-102 | 1106.45 | 0.000201032 | 0.0556163 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 361 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1967 | 1967 | no | HT_vratné vodní (45 °C) 13
13447036 | 1.NP_SO-102 | 330.908 | 0.000201032 | 0.0166333 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -152 | -160 | -160 | -168 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -165.8 | RAU–PE–Xa | 16 | 554 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.2310 | 2310 |  | HT_vratné vodní (45 °C) 13
13447049 | 1.NP_SO-102 | 68.125 | 0.000201032 | 0.00342434 | ø16 mm | 0.000862069 |  | 1.NP_SO-102 | -75.9375 | -144.063 | -75.9375 | -144.063 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -144.063 | RAU–PE–Xa | 16 | 554 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.2311 | 2311 |  | HT_vratné vodní (45 °C) 13
13447059 | 1.NP_SO-102 | 243.373 | 0.000201032 | 0.0122333 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 554 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.2312 | 2312 |  | HT_vratné vodní (45 °C) 13
13447118 | 1.NP_SO-102 | 68.125 | 0.000201032 | 0.00342434 | ø16 mm | 0.000862069 |  | 1.NP_SO-102 | -75.9375 | -75.9375 | -144.063 | -144.063 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -144.062 | RAU–PE–Xa | 16 | 554 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.2313 | 2313 |  | HT_vratné vodní (45 °C) 13
13447141 | 1.NP_SO-102 | 328.125 | 0.000201032 | 0.0164934 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -152 | -160 | -160 | -168 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -165.8 | RAU–PE–Xa | 16 | 532 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.2314 | 2314 |  | HT_přívodní vodní (55 °C) 19
13447150 | 1.NP_SO-102 | 78.125 | 0.000201032 | 0.00392699 | ø16 mm | 0.000862069 |  | 1.NP_SO-102 | -65.9375 | -144.062 | -65.9375 | -144.063 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -144.062 | RAU–PE–Xa | 16 | 532 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.2315 | 2315 |  | HT_přívodní vodní (55 °C) 19
13447160 | 1.NP_SO-102 | 96.1566 | 0.000201032 | 0.00483336 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 532 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.2316 | 2316 |  | HT_přívodní vodní (55 °C) 19
13447224 | 1.NP_SO-102 | 78.125 | 0.000201032 | 0.00392699 | ø16 mm | 0.000862069 |  | 1.NP_SO-102 | -65.9375 | -65.9375 | -144.063 | -144.063 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -144.062 | RAU–PE–Xa | 16 | 532 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.2317 | 2317 |  | HT_přívodní vodní (55 °C) 19
13447442 | 1.NP_SO-102 | 2638.13 | 0.000201032 | 0.132607 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 555 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.2318 | 2318 | no | HT_vratné vodní (45 °C) 13
13447459 | 1.NP_SO-102 | 2788.13 | 0.000201032 | 0.140146 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 533 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.2319 | 2319 | no | HT_přívodní vodní (55 °C) 19
13447788 | 1.NP_SO-102 | 577.799 | 0.000201032 | 0.0290433 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -152 | -160 | -160 | -168 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -165.8 | RAU–PE–Xa | 16 | 533 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.2320 | 2320 |  | HT_přívodní vodní (55 °C) 19
13447799 | 1.NP_SO-102 | 78.125 | 0.000201032 | 0.00392699 | ø16 mm | 0.000862069 |  | 1.NP_SO-102 | -65.9375 | -144.063 | -65.9375 | -144.063 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -144.063 | RAU–PE–Xa | 16 | 533 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.2321 | 2321 |  | HT_přívodní vodní (55 °C) 19
13447810 | 1.NP_SO-102 | 78.125 | 0.000201032 | 0.00392699 | ø16 mm | 0.000862069 |  | 1.NP_SO-102 | -65.9375 | -144.063 | -65.9375 | -144.063 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -144.063 | RAU–PE–Xa | 16 | 533 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.2322 | 2322 |  | HT_přívodní vodní (55 °C) 19
13447835 | 1.NP_SO-102 | 577.799 | 0.000201032 | 0.0290433 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -152 | -160 | -160 | -168 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -165.8 | RAU–PE–Xa | 16 | 555 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.2323 | 2323 |  | HT_vratné vodní (45 °C) 13
13447846 | 1.NP_SO-102 | 68.125 | 0.000201032 | 0.00342434 | ø16 mm | 0.000862069 |  | 1.NP_SO-102 | -75.9375 | -144.063 | -75.9375 | -144.063 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -144.063 | RAU–PE–Xa | 16 | 555 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.2324 | 2324 |  | HT_vratné vodní (45 °C) 13
13447857 | 1.NP_SO-102 | 68.125 | 0.000201032 | 0.00342434 | ø16 mm | 0.000862069 |  | 1.NP_SO-102 | -75.9375 | -144.063 | -75.9375 | -144.063 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -144.063 | RAU–PE–Xa | 16 | 555 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.2325 | 2325 |  | HT_vratné vodní (45 °C) 13

# IfcPipeSegment: Typy trubek:Ocel_uhlíková (1186)
Type - Material: 255-128-128
Type - Požární ochrana - Požární odolnost: A1
Type - Identifikační data - ID kategorie: TR; Kód sestavy: TR02; Název typu: Ocel_uhlíková; Označení typu: 02; Popis: OC; Popis sestavy: Ocel
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR02 Uniformat (Uniformat)
Mechanické – tok - Reynoldsovo číslo: 0; Stav průtoku: Laminární; Třecí faktor: 0; Tření: 0; Doplňkový průtok: 0 m3/s; Průtok: 0 m3/s; Rychlost: 0 m/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: H; CCI Komponenta: WPA
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Mechanické - Materiál: Kov, ocel; Úsek potrubí: Kov, ocel - ČERNÁ SVAŘOVANÁ; Výkaz/typ: ČERNÁ SVAŘOVANÁ; Drsnost: 0.1 mm; Popis úseku: FE; Typ přípoje: Obecné
Jiné - Rodina: Typy trubek; Id typu: 13308873; Rodina a typ: Typy trubek: Ocel_uhlíková; Typ: Ocel_uhlíková
Name (Typy trubek:Ocel_uhlíková:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Tloušťka izolace (mm) | Celková velikost | Relativní drsnost | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) | Řez | Délka (mm) | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
12978875 | 2.NP_SO-102 | 396.025 | 0.00183197 | 0.0600924 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 3073.01 | 3073.01 | 2676.99 | 2676.99 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6676.99 | 0.049766 | 40 | 238 | 396.025 | ø40 | 48.3 | 41.8 | TR02.02.0009 | 0009 | yes | HT_přívodní vodní (55 °C) 9
12978885 | 2.NP_SO-102 | 1513.13 | 0.00183197 | 0.229601 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 3124.15 | 3100 | 3100 | 3075.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7079.1 | 0.190146 | 40 | 238 | 1513.13 | ø40 | 48.3 | 41.8 | TR02.02.0010 | 0010 | yes | HT_přívodní vodní (55 °C) 9 | 0
12978897 | 2.NP_SO-102 | 1700.52 | 0.00183197 | 0.258036 | 40 | ø120 mm | 0.00239234 | HD | 2.NP_SO-102 | 3124.15 | 3100 | 3100 | 3075.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7079.1 | 0.213694 | 40 | 238 | 1700.52 | ø40 | 48.3 | 41.8 | TR02.02.0011 | 0011 | yes | HT_přívodní vodní (55 °C) 9 | 0 | Izolace - Typ izolace: Tepelná
12979010 | 2.NP_SO-102 | 1540.89 | 0.00285535 | 0.291903 | 40 | ø130 mm | 0.00188679 | HD | 2.NP_SO-102 | 3130.15 | 3100 | 3100 | 3069.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7073.5 | 0.242042 | 50 | 267 | 1540.89 | ø50 | 60.3 | 53 | TR02.02.0012 | 0012 | yes | HT_přívodní vodní (55 °C) 9 | 0 | Izolace - Typ izolace: Tepelná
12979050 | 2.NP_SO-102 | 25.8688 | 0.000568237 | 0.00218614 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3113.45 | 3100 | 3100 | 3086.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7089.2 | 0.00162538 | 20 | 388 | 25.8688 | ø20 | 26.9 | 21.6 | TR02.02.0013 | 0013 | yes | HT_přívodní vodní (55 °C) 19 | 0
12979250 | -1.PP_SO-102 | 2238.53 | 0.00141175 | 0.29818 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 2871.2 | 2850 | 2850 | 2828.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 36 | -1167.95 | 0.225041 | 32 | 184 | 2238.53 | ø32 | 42.4 | 35.9 | TR02.02.0014 | 0014 | yes | HT_přívodní vodní (65 °C) 36 | 0
12985708 | -1.PP_SO-102 | 2119.48 | 0.00285535 | 0.40151 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-102 | 2830.15 | 2800 | 2800 | 2769.85 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 31 | -1226.5 | 0.332927 | 50 | 94 | 2119.48 | ø50 | 60.3 | 53 | TR02.02.0015 | 0015 | yes | HT_přívodní vodní (65 °C) 31 | 0
12985754 | -1.PP_SO-102 | 2832.18 | 0.00183197 | 0.429752 | 0 | ø40 mm | 0.00239234 | HD | -1.PP_SO-102 | 2874.15 | 2850 | 2850 | 2825.85 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 32 | -1170.9 | 0.355902 | 40 | 2 | 2832.18 | ø40 | 48.3 | 41.8 | TR02.02.0016 | 0016 | yes | HT_přívodní vodní (65 °C) 32 | 0
13021067 | 2.NP_SO-102 | 5107.25 | 0.000568237 | 0.431608 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3273.45 | 3260 | 3260 | 3246.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7249.2 | 0.320898 | 20 | 281 | 5107.25 | ø20 | 26.9 | 21.6 | TR02.02.0031 | 0031 | yes | HT_přívodní vodní (55 °C) 9 | 0
13021300 | 2.NP_SO-102 | 238.881 | 0.000568237 | 0.0201876 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 12 | 7269.2 | 0.0150094 | 20 | 9 | 238.881 | ø20 | 26.9 | 21.6 | TR02.02.0034 | 0034 | yes | HT_přívodní vodní (65 °C) 12 | 0
13021888 | 2.NP_SO-102 | 606.82 | 0.000568237 | 0.0512817 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 12 | 7269.2 | 0.0381277 | 20 | 9 | 606.82 | ø20 | 26.9 | 21.6 | TR02.02.0035 | 0035 | yes | HT_přívodní vodní (65 °C) 12 | 0
13022062 | 2.NP_SO-102 | 3663.84 | 0.000568237 | 0.309627 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3263.45 | 3250 | 3250 | 3236.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7239.2 | 0.230206 | 20 | 250 | 3663.84 | ø20 | 26.9 | 21.6 | TR02.02.0036 | 0036 | yes | HT_přívodní vodní (55 °C) 9 | 0
13022845 | 3.NP_SO-102 | 581.681 | 0.000568237 | 0.0491571 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 11269.2 | 0.0365481 | 20 | 519 | 581.681 | ø20 | 26.9 | 21.6 | TR02.02.0039 | 0039 | yes | HT_přívodní vodní (55 °C) 9 | 0
13023390 | 2.NP_SO-102 | 652.375 | 0.000568237 | 0.0551315 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3926.19 | 3926.19 | 3273.81 | 3273.81 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7273.81 | 0.0409899 | 20 | 526 | 652.375 | ø20 | 26.9 | 21.6 | TR02.02.0045 | 0045 | yes | HT_přívodní vodní (55 °C) 9
13023578 | 1.NP_SO-102 | 3965.08 | 0.000356274 | 0.265327 | 0 | ø15 mm | 0.00625 | HD | 1.NP_SO-102 | 3929.36 | -35.7125 | 3929.36 | -35.7125 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | -35.7125 | 0.18685 | 15 | 23 | 3965.08 | ø15 | 21.3 | 16 | TR02.02.0049 | 0049 | yes | HT_přívodní vodní (55 °C) 9
13025309 | 3.NP_SO-102 | 3949.9 | 0.000356274 | 0.264311 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 3929.27 | 3929.27 | -20.6312 | -20.6313 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7979.37 | 0.186135 | 15 | 529 | 3949.9 | ø15 | 21.3 | 16 | TR02.02.0067 | 0067 | yes | HT_přívodní vodní (55 °C) 9
13025491 | 1.NP_SO-102 | 5118.37 | 0.000568237 | 0.432547 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 2889.2 | 0.321597 | 20 | 406 | 5118.37 | ø20 | 26.9 | 21.6 | TR02.02.0069 | 0069 | yes | HT_přívodní vodní (55 °C) 9 | 0
13025500 | 1.NP_SO-102 | 6906.05 | 0.000568237 | 0.583622 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 2889.2 | 0.43392 | 20 | 406 | 6906.05 | ø20 | 26.9 | 21.6 | TR02.02.0070 | 0070 | yes | HT_přívodní vodní (55 °C) 9 | 0
13025508 | 1.NP_SO-102 | 897.054 | 0.000568237 | 0.075809 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 2889.2 | 0.0563636 | 20 | 406 | 897.054 | ø20 | 26.9 | 21.6 | TR02.02.0071 | 0071 | yes | HT_přívodní vodní (55 °C) 9 | 0
13025646 | 1.NP_SO-102 | 241.735 | 0.000568237 | 0.0204287 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 2889.2 | 0.0151887 | 20 | 406 | 241.735 | ø20 | 26.9 | 21.6 | TR02.02.0072 | 0072 | yes | HT_přívodní vodní (55 °C) 9 | 0
13025741 | 1.NP_SO-102 | 2915.08 | 0.000568237 | 0.24635 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 2882.54 | -32.5375 | 2882.54 | -32.5375 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | -32.5375 | 0.18316 | 20 | 406 | 2915.08 | ø20 | 26.9 | 21.6 | TR02.02.0074 | 0074 | yes | HT_přívodní vodní (55 °C) 9
13026392 | 1.NP_SO-102 | 1101.91 | 0.000568237 | 0.0931213 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 2863.45 | 2850 | 2850 | 2836.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 21 | 2839.2 | 0.0692352 | 20 | 16 | 1101.91 | ø20 | 26.9 | 21.6 | TR02.02.0086 | 0086 | yes | HT_přívodní vodní (65 °C) 21 | 0
13026469 | 1.NP_SO-102 | 2865.08 | 0.000568237 | 0.242124 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 2832.54 | -32.5375 | 2832.54 | -32.5375 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 21 | -32.5375 | 0.180018 | 20 | 16 | 2865.08 | ø20 | 26.9 | 21.6 | TR02.02.0087 | 0087 | yes | HT_přívodní vodní (65 °C) 21
13026716 | 1.NP_SO-102 | 185.854 | 0.000568237 | 0.0157063 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3053.32 | 3053.32 | 2867.46 | 2867.46 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 21 | 2867.46 | 0.0116775 | 20 | 16 | 185.854 | ø20 | 26.9 | 21.6 | TR02.02.0095 | 0095 | yes | HT_přívodní vodní (65 °C) 21
13026726 | 1.NP_SO-102 | 2406.14 | 0.000568237 | 0.20334 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3084.23 | 3070.78 | 3070.78 | 3057.33 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 21 | 3059.98 | 0.151182 | 20 | 16 | 2406.14 | ø20 | 26.9 | 21.6 | TR02.02.0096 | 0096 | yes | HT_přívodní vodní (65 °C) 21 | 0
13026831 | 1.NP_SO-102 | 174.296 | 0.000568237 | 0.0147296 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3262.54 | 3262.54 | 3088.24 | 3088.24 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 21 | 3088.24 | 0.0109514 | 20 | 16 | 174.296 | ø20 | 26.9 | 21.6 | TR02.02.0097 | 0097 | yes | HT_přívodní vodní (65 °C) 21
13026893 | 1.NP_SO-102 | 1215.08 | 0.000568237 | 0.102685 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 23 | 3269.2 | 0.0763454 | 20 | 34 | 1215.08 | ø20 | 26.9 | 21.6 | TR02.02.0098 | 0098 | yes | HT_přívodní vodní (65 °C) 23 | 0
13027569 | 4.NP_SO-102 | 3573.32 | 0.00183197 | 0.542212 | 40 | ø120 mm | 0.00239234 | HD | 4.NP_SO-102 | 2886.66 | 2886.66 | -686.662 | -686.663 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11313.3 | 0.449037 | 40 | 342 | 3573.32 | ø40 | 48.3 | 41.8 | TR02.02.0106 | 0106 | yes | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13027803 | -1.PP_SO-102 | 1311.43 | 0.000356274 | 0.0877552 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3210.65 | 3200 | 3200 | 3189.35 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | -808 | 0.0617994 | 15 | 30 | 1311.43 | ø15 | 21.3 | 16 | TR02.02.0107 | 0107 | yes | HT_přívodní vodní (55 °C) 9 | 0
13027972 | -1.PP_SO-102 | 511.425 | 0.000356274 | 0.0342225 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3210.65 | 3200 | 3200 | 3189.35 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | -808 | 0.0241003 | 15 | 554 | 511.425 | ø15 | 21.3 | 16 | TR02.02.0108 | 0108 | yes | HT_přívodní vodní (55 °C) 9 | 0
13028095 | -1.PP_SO-102 | 6681.91 | 0.000356274 | 0.447126 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 2710.65 | 2700 | 2700 | 2689.35 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | -1308 | 0.314878 | 15 | 30 | 6681.91 | ø15 | 21.3 | 16 | TR02.02.0109 | 0109 | yes | HT_přívodní vodní (55 °C) 9 | 0
13028104 | -1.PP_SO-102 | 471.425 | 0.000356274 | 0.0315458 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3185.71 | 2714.29 | 3185.71 | 2714.29 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | -1285.71 | 0.0222154 | 15 | 30 | 471.425 | ø15 | 21.3 | 16 | TR02.02.0110 | 0110 | yes | HT_přívodní vodní (55 °C) 9
13028224 | 2.NP_SO-102 | 2028.19 | 0.00183197 | 0.307755 | 40 | ø120 mm | 0.00239234 | HD | 2.NP_SO-102 | 3124.15 | 3100 | 3100 | 3075.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7079.1 | 0.25487 | 40 | 250 | 2028.19 | ø40 | 48.3 | 41.8 | TR02.02.0111 | 0111 | yes | HT_vratné vodní (45 °C) 1 | 0 | Izolace - Typ izolace: Tepelná
13028359 | -1.PP_SO-102 | 3143.9 | 0.000356274 | 0.210377 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3110.65 | 3100 | 3100 | 3089.35 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | -908 | 0.148153 | 15 | 576 | 3143.9 | ø15 | 21.3 | 16 | TR02.02.0112 | 0112 | yes | HT_přívodní vodní (55 °C) 9 | 0
13028386 | -1.PP_SO-102 | 2721.43 | 0.000356274 | 0.182107 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 2685.71 | -35.7125 | 2685.71 | -35.7125 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | -4035.71 | 0.128244 | 15 | 576 | 2721.43 | ø15 | 21.3 | 16 | TR02.02.0113 | 0113 | yes | HT_přívodní vodní (55 °C) 9
13029279 | 2.NP_SO-102 | 946.702 | 0.00183197 | 0.143652 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2674.15 | 2650 | 2650 | 2625.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6629.1 | 0.118966 | 40 | 77 | 946.702 | ø40 | 48.3 | 41.8 | TR02.02.0118 | 0118 | yes | HT_přívodní vodní (55 °C) 9 | 0
13029311 | 2.NP_SO-102 | 487.837 | 0.000891835 | 0.0516482 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 2466.85 | 2450 | 2450 | 2433.15 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6436.4 | 0.0383147 | 25 | 458 | 487.837 | ø25 | 33.7 | 27.2 | TR02.02.0119 | 0119 | yes | HT_přívodní vodní (55 °C) 9 | 0
13029323 | 2.NP_SO-102 | 2713.81 | 0.000891835 | 0.287316 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 2766.85 | 2750 | 2750 | 2733.15 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6736.4 | 0.213142 | 25 | 565 | 2713.81 | ø25 | 33.7 | 27.2 | TR02.02.0120 | 0120 | yes | HT_přívodní vodní (55 °C) 9 | 0
13029366 | 2.NP_SO-102 | 6252.43 | 0.000891835 | 0.661955 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 2766.85 | 2750 | 2750 | 2733.15 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6736.4 | 0.491065 | 25 | 565 | 6252.43 | ø25 | 33.7 | 27.2 | TR02.02.0121 | 0121 | yes | HT_přívodní vodní (55 °C) 9 | 0
13029462 | 1.NP_SO-102 | 6654.69 | 0.000568237 | 0.56238 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 6632.54 | -22.1562 | 6632.54 | -22.1562 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | -22.1562 | 0.418127 | 20 | 557 | 6654.69 | ø20 | 26.9 | 21.6 | TR02.02.0122 | 0122 | yes | HT_přívodní vodní (55 °C) 9
13030757 | -1.PP_SO-102 | 3971.43 | 0.000356274 | 0.265752 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3935.71 | -35.7125 | 3935.71 | -35.7125 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | -4035.71 | 0.187149 | 15 | 552 | 3971.43 | ø15 | 21.3 | 16 | TR02.02.0131 | 0131 | no | HT_přívodní vodní (55 °C) 9
13031771 | 1.NP_SO-102 | 3960.48 | 0.000356274 | 0.265019 | 0 | ø15 mm | 0.00625 | HD | 1.NP_SO-102 | 3924.77 | 3924.77 | -35.7125 | -35.7125 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | -35.7125 | 0.186633 | 15 | 457 | 3960.48 | ø15 | 21.3 | 16 | TR02.02.0137 | 0137 | no | HT_přívodní vodní (55 °C) 9
13032586 | 3.NP_SO-102 | 368.753 | 0.00141175 | 0.0491192 | 0 | ø32 mm | 0.00278552 | HD | 3.NP_SO-102 | 3371.2 | 3350 | 3350 | 3328.8 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 11332 | 0.0370711 | 32 | 302 | 368.753 | ø32 | 42.4 | 35.9 | TR02.02.0144 | 0144 | yes | HT_přívodní vodní (55 °C) 9 | 0
13032946 | 1.NP_SO-102 | 1012.06 | 0.000356274 | 0.0677227 | 40 | ø95 mm | 0.00625 | HD | 1.NP_SO-102 | 3316.34 | 2304.29 | 3316.34 | 2304.29 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 2304.29 | 0.047692 | 15 | 576 | 1012.06 | ø15 | 21.3 | 16 | TR02.02.0145 | 0145 | yes | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13032954 | 1.NP_SO-102 | 471.425 | 0.000356274 | 0.0315458 | 40 | ø95 mm | 0.00625 | HD | 1.NP_SO-102 | 2300.65 | 2290 | 2290 | 2279.35 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 2282 | 0.0222154 | 15 | 576 | 471.425 | ø15 | 21.3 | 16 | TR02.02.0146 | 0146 | yes | HT_přívodní vodní (55 °C) 9 | 0 | Izolace - Typ izolace: Tepelná
13032964 | 1.NP_SO-102 | 3161.42 | 0.000356274 | 0.21155 | 40 | ø95 mm | 0.00625 | HD | 1.NP_SO-102 | 2275.71 | -885.712 | 2275.71 | -885.712 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | -885.712 | 0.148979 | 15 | 576 | 3161.42 | ø15 | 21.3 | 16 | TR02.02.0147 | 0147 | yes | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13033179 | 1.NP_SO-102 | 358.665 | 0.00141175 | 0.0477754 | 0 | ø32 mm | 0.00278552 | HD | 1.NP_SO-102 | 3381.2 | 3360 | 3360 | 3338.8 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 3342.05 | 0.0360569 | 32 | 303 | 358.665 | ø32 | 42.4 | 35.9 | TR02.02.0148 | 0148 | yes | HT_přívodní vodní (55 °C) 9 | 0
13033429 | 1.NP_SO-102 | 3653.48 | 0.00183197 | 0.554375 | 40 | ø120 mm | 0.00239234 | HD | 1.NP_SO-102 | 7046.82 | 3393.34 | 7046.82 | 3393.34 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 3393.34 | 0.45911 | 40 | 361 | 3653.48 | ø40 | 48.3 | 41.8 | TR02.02.0149 | 0149 | yes | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13033480 | 4.NP_SO-102 | 328.53 | 0.000891835 | 0.034782 | 0 | ø25 mm | 0.00367647 | HD | 4.NP_SO-102 | 3316.85 | 3300 | 3300 | 3283.15 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 15286.4 | 0.0258027 | 25 | 333 | 328.53 | ø25 | 33.7 | 27.2 | TR02.02.0150 | 0150 | yes | HT_přívodní vodní (55 °C) 9 | 0
13034204 | 4.NP_SO-102 | 219.55 | 0.000568237 | 0.0185539 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3283.45 | 3270 | 3270 | 3256.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 18 | 15259.2 | 0.0137947 | 20 | 24 | 219.55 | ø20 | 26.9 | 21.6 | TR02.02.0159 | 0159 | yes | HT_přívodní vodní (65 °C) 18 | 0
13038302 | 3.NP_SO-102 | 4089.68 | 0.00183197 | 0.620563 | 0 | ø40 mm | 0.00239234 | HD | 3.NP_SO-102 | 7273.01 | 7273.01 | 3183.34 | 3183.34 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 11183.3 | 0.513924 | 40 | 259 | 4089.68 | ø40 | 48.3 | 41.8 | TR02.02.0185 | 0185 | yes | HT_přívodní vodní (55 °C) 19
13038392 | 4.NP_SO-102 | 473.945 | 0.00183197 | 0.0719159 | 0 | ø40 mm | 0.00239234 | HD | 4.NP_SO-102 | 3324.15 | 3300 | 3300 | 3275.85 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 15279.1 | 0.0595577 | 40 | 509 | 473.945 | ø40 | 48.3 | 41.8 | TR02.02.0186 | 0186 | yes | HT_přívodní vodní (55 °C) 19 | 0
13038462 | 4.NP_SO-102 | 3292.06 | 0.000356274 | 0.220291 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3256.34 | -35.7125 | 3256.34 | -35.7125 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 11964.3 | 0.155134 | 15 | 515 | 3292.06 | ø15 | 21.3 | 16 | TR02.02.0187 | 0187 | no | HT_přívodní vodní (55 °C) 19
13038465 | 4.NP_SO-102 | 330.819 | 0.00183197 | 0.0501981 | 0 | ø40 mm | 0.00239234 | HD | 4.NP_SO-102 | 3324.15 | 3300 | 3300 | 3275.85 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 15279.1 | 0.0415719 | 40 | 259 | 330.819 | ø40 | 48.3 | 41.8 | TR02.02.0188 | 0188 | yes | HT_přívodní vodní (55 °C) 19 | 0
13039070 | 4.NP_SO-102 | 894.6 | 0.000356274 | 0.059863 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3310.65 | 3300 | 3300 | 3289.35 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 15292 | 0.042157 | 15 | 103 | 894.6 | ø15 | 21.3 | 16 | TR02.02.0192 | 0192 | yes | HT_přívodní vodní (55 °C) 19 | 0
13039079 | 4.NP_SO-102 | 4290.25 | 0.000356274 | 0.287086 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3310.65 | 3300 | 3300 | 3289.35 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 15292 | 0.202173 | 15 | 103 | 4290.25 | ø15 | 21.3 | 16 | TR02.02.0193 | 0193 | yes | HT_přívodní vodní (55 °C) 19 | 0
13039159 | 4.NP_SO-102 | 248.25 | 0.000356274 | 0.0166119 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3310.65 | 3300 | 3300 | 3289.35 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 15292 | 0.0116985 | 15 | 104 | 248.25 | ø15 | 21.3 | 16 | TR02.02.0194 | 0194 | yes | HT_přívodní vodní (55 °C) 19 | 0
13039168 | 4.NP_SO-102 | 8663.46 | 0.000356274 | 0.579723 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3310.65 | 3300 | 3300 | 3289.35 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 15292 | 0.408256 | 15 | 517 | 8663.46 | ø15 | 21.3 | 16 | TR02.02.0195 | 0195 | yes | HT_přívodní vodní (55 °C) 19 | 0
13039171 | 4.NP_SO-102 | 1387.3 | 0.000356274 | 0.0928325 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | -39.35 | -50 | -50 | -60.65 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 11942 | 0.065375 | 15 | 104 | 1387.3 | ø15 | 21.3 | 16 | TR02.02.0196 | 0196 | no | HT_přívodní vodní (55 °C) 19 | 0
13039205 | 4.NP_SO-102 | 3324.6 | 0.000356274 | 0.222469 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3287.3 | -37.3 | 3287.3 | -37.3 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 11962.7 | 0.156668 | 15 | 104 | 3324.6 | ø15 | 21.3 | 16 | TR02.02.0197 | 0197 | yes | HT_přívodní vodní (55 °C) 19
13039946 | 3.NP_SO-102 | 305.075 | 0.000568237 | 0.0257815 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10789.2 | 0.0191684 | 20 | 431 | 305.075 | ø20 | 26.9 | 21.6 | TR02.02.0204 | 0204 | yes | HT_přívodní vodní (55 °C) 19 | 0
13039994 | 3.NP_SO-102 | 2811.04 | 0.000568237 | 0.237558 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2782.54 | -28.5063 | 2782.54 | -28.5063 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7971.49 | 0.176623 | 20 | 431 | 2811.04 | ø20 | 26.9 | 21.6 | TR02.02.0206 | 0206 | yes | HT_přívodní vodní (55 °C) 19
13040012 | 3.NP_SO-102 | 2486.14 | 0.000568237 | 0.210101 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10789.2 | 0.156209 | 20 | 432 | 2486.14 | ø20 | 26.9 | 21.6 | TR02.02.0207 | 0207 | yes | HT_přívodní vodní (55 °C) 19 | 0
13040789 | 2.NP_SO-102 | 3811.08 | 0.00183197 | 0.578289 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 7116.66 | 7116.66 | 3305.58 | 3305.58 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7305.58 | 0.478915 | 40 | 75 | 3811.08 | ø40 | 48.3 | 41.8 | TR02.02.0215 | 0215 | yes | HT_přívodní vodní (55 °C) 19
13041118 | 3.NP_SO-102 | 3146.82 | 0.000356274 | 0.210572 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 3111.11 | -35.7125 | 3111.11 | -35.7125 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7964.29 | 0.14829 | 15 | 443 | 3146.82 | ø15 | 21.3 | 16 | TR02.02.0216 | 0216 | no | HT_přívodní vodní (55 °C) 19
13041127 | 3.NP_SO-102 | 377.235 | 0.00141175 | 0.0502491 | 0 | ø32 mm | 0.00278552 | HD | 3.NP_SO-102 | 3171.2 | 3150 | 3150 | 3128.8 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 11132 | 0.0379238 | 32 | 447 | 377.235 | ø32 | 42.4 | 35.9 | TR02.02.0217 | 0217 | yes | HT_přívodní vodní (55 °C) 19 | 0
13041172 | 3.NP_SO-102 | 320.385 | 0.00141175 | 0.0426764 | 0 | ø32 mm | 0.00278552 | HD | 3.NP_SO-102 | 3171.2 | 3150 | 3150 | 3128.8 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 11132 | 0.0322086 | 32 | 105 | 320.385 | ø32 | 42.4 | 35.9 | TR02.02.0218 | 0218 | yes | HT_přívodní vodní (55 °C) 19 | 0
13042042 | 3.NP_SO-102 | 215.075 | 0.000568237 | 0.0181757 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3032.54 | 3032.54 | 2817.46 | 2817.46 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10817.5 | 0.0135136 | 20 | 416 | 215.075 | ø20 | 26.9 | 21.6 | TR02.02.0222 | 0222 | yes | HT_přívodní vodní (55 °C) 19
13042051 | 3.NP_SO-102 | 509.432 | 0.000568237 | 0.0430515 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10789.2 | 0.0320086 | 20 | 416 | 509.432 | ø20 | 26.9 | 21.6 | TR02.02.0223 | 0223 | yes | HT_přívodní vodní (55 °C) 19 | 0
13042197 | 3.NP_SO-102 | 215.075 | 0.000568237 | 0.0181757 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3032.54 | 3032.54 | 2817.46 | 2817.46 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10817.5 | 0.0135136 | 20 | 427 | 215.075 | ø20 | 26.9 | 21.6 | TR02.02.0224 | 0224 | yes | HT_přívodní vodní (55 °C) 19
13042335 | 4.NP_SO-102 | 265.075 | 0.000568237 | 0.0224012 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3182.54 | 2917.46 | 3182.54 | 2917.46 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 14917.5 | 0.0166552 | 20 | 493 | 265.075 | ø20 | 26.9 | 21.6 | TR02.02.0225 | 0225 | yes | HT_přívodní vodní (55 °C) 19
13042344 | 4.NP_SO-102 | 1566.85 | 0.000568237 | 0.132413 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 15189.2 | 0.0984482 | 20 | 477 | 1566.85 | ø20 | 26.9 | 21.6 | TR02.02.0226 | 0226 | yes | HT_přívodní vodní (55 °C) 19 | 0
13042356 | 4.NP_SO-102 | 265.075 | 0.000568237 | 0.0224012 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3182.54 | 2917.46 | 3182.54 | 2917.46 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 14917.5 | 0.0166552 | 20 | 477 | 265.075 | ø20 | 26.9 | 21.6 | TR02.02.0227 | 0227 | yes | HT_přívodní vodní (55 °C) 19
13042365 | 4.NP_SO-102 | 1983.11 | 0.000568237 | 0.16759 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 14889.2 | 0.124602 | 20 | 477 | 1983.11 | ø20 | 26.9 | 21.6 | TR02.02.0228 | 0228 | yes | HT_přívodní vodní (55 °C) 19 | 0
13043801 | 2.NP_SO-102 | 6978.17 | 0.000568237 | 0.589717 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3263.45 | 3250 | 3250 | 3236.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7239.2 | 0.438451 | 20 | 381 | 6978.17 | ø20 | 26.9 | 21.6 | TR02.02.0240 | 0240 | yes | HT_přívodní vodní (55 °C) 19 | 0
13043810 | 2.NP_SO-102 | 447.691 | 0.000568237 | 0.0378338 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3263.45 | 3250 | 3250 | 3236.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7239.2 | 0.0281292 | 20 | 381 | 447.691 | ø20 | 26.9 | 21.6 | TR02.02.0241 | 0241 | yes | HT_přívodní vodní (55 °C) 19 | 0
13043821 | 2.NP_SO-102 | 3249.9 | 0.000356274 | 0.21747 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 3220.63 | -29.2688 | 3220.63 | -29.2688 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 3970.73 | 0.153148 | 15 | 387 | 3249.9 | ø15 | 21.3 | 16 | TR02.02.0242 | 0242 | no | HT_přívodní vodní (55 °C) 19
13043830 | 2.NP_SO-102 | 324.151 | 0.000568237 | 0.0273937 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3263.45 | 3250 | 3250 | 3236.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7239.2 | 0.020367 | 20 | 159 | 324.151 | ø20 | 26.9 | 21.6 | TR02.02.0243 | 0243 | yes | HT_přívodní vodní (55 °C) 19 | 0
13044178 | 2.NP_SO-102 | 2139.25 | 0.000568237 | 0.180786 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2833.45 | 2820 | 2820 | 2806.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 6809.2 | 0.134413 | 20 | 388 | 2139.25 | ø20 | 26.9 | 21.6 | TR02.02.0250 | 0250 | no | HT_přívodní vodní (55 °C) 19 | 0
13044746 | 1.NP_SO-102 | 2145.08 | 0.000568237 | 0.181278 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 3189.2 | 0.134779 | 20 | 375 | 2145.08 | ø20 | 26.9 | 21.6 | TR02.02.0257 | 0257 | yes | HT_přívodní vodní (55 °C) 19 | 0
13044756 | 1.NP_SO-102 | 906.138 | 0.000568237 | 0.0765766 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 3189.2 | 0.0569343 | 20 | 375 | 906.138 | ø20 | 26.9 | 21.6 | TR02.02.0258 | 0258 | yes | HT_přívodní vodní (55 °C) 19 | 0
13045398 | 1.NP_SO-102 | 447.929 | 0.000891835 | 0.047423 | 0 | ø25 mm | 0.00367647 | HD | 1.NP_SO-102 | 3316.85 | 3300 | 3300 | 3283.15 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 3286.4 | 0.0351802 | 25 | 274 | 447.929 | ø25 | 33.7 | 27.2 | TR02.02.0265 | 0265 | yes | HT_přívodní vodní (55 °C) 19 | 0
13045405 | 1.NP_SO-102 | 3660.24 | 0.00183197 | 0.555401 | 0 | ø40 mm | 0.00239234 | HD | 1.NP_SO-102 | 7002.35 | 3342.11 | 7002.35 | 3342.11 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 3342.11 | 0.45996 | 40 | 255 | 3660.24 | ø40 | 48.3 | 41.8 | TR02.02.0266 | 0266 | yes | HT_přívodní vodní (55 °C) 19
13045415 | 1.NP_SO-102 | 3295.14 | 0.000356274 | 0.220497 | 0 | ø15 mm | 0.00625 | HD | 1.NP_SO-102 | 3265.87 | -29.2688 | 3265.87 | -29.2688 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | -29.2687 | 0.15528 | 15 | 363 | 3295.14 | ø15 | 21.3 | 16 | TR02.02.0267 | 0267 | no | HT_přívodní vodní (55 °C) 19
13045424 | 1.NP_SO-102 | 333.738 | 0.000891835 | 0.0353335 | 0 | ø25 mm | 0.00367647 | HD | 1.NP_SO-102 | 3316.85 | 3300 | 3300 | 3283.15 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 3286.4 | 0.0262118 | 25 | 183 | 333.738 | ø25 | 33.7 | 27.2 | TR02.02.0268 | 0268 | yes | HT_přívodní vodní (55 °C) 19 | 0
13045619 | 1.NP_SO-102 | 3894.86 | 0.00141175 | 0.518809 | 0 | ø32 mm | 0.00278552 | HD | 1.NP_SO-102 | 3258.67 | -636.188 | 3258.67 | -636.188 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | -636.188 | 0.391554 | 32 | 358 | 3894.86 | ø32 | 42.4 | 35.9 | TR02.02.0272 | 0272 | yes | HT_přívodní vodní (55 °C) 19
13045996 | -1.PP_SO-102 | 2571.43 | 0.000356274 | 0.172069 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 2535.71 | -35.7125 | 2535.71 | -35.7125 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | -4035.71 | 0.121176 | 15 | 316 | 2571.43 | ø15 | 21.3 | 16 | TR02.02.0274 | 0274 | no | HT_přívodní vodní (55 °C) 19
13046206 | -1.PP_SO-102 | 2925.08 | 0.000568237 | 0.247195 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2882.54 | 2882.54 | -42.5375 | -42.5375 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | -4042.54 | 0.183788 | 20 | 524 | 2925.08 | ø20 | 26.9 | 21.6 | TR02.02.0290 | 0290 | yes | HT_přívodní vodní (55 °C) 19
13046239 | -1.PP_SO-102 | 1279.85 | 0.000356274 | 0.085642 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 2560.65 | 2550 | 2550 | 2539.35 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | -1458 | 0.0603113 | 15 | 316 | 1279.85 | ø15 | 21.3 | 16 | TR02.02.0291 | 0291 | no | HT_přívodní vodní (55 °C) 19 | 0
13046266 | -1.PP_SO-102 | 1324.54 | 0.000356274 | 0.0886326 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 2560.65 | 2550 | 2550 | 2539.35 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | -1458 | 0.0624174 | 15 | 306 | 1324.54 | ø15 | 21.3 | 16 | TR02.02.0292 | 0292 | yes | HT_přívodní vodní (55 °C) 19 | 0
13046275 | -1.PP_SO-102 | 2571.42 | 0.000356274 | 0.172069 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 2535.71 | 2535.71 | -35.7125 | -35.7125 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | -4035.71 | 0.121176 | 15 | 306 | 2571.42 | ø15 | 21.3 | 16 | TR02.02.0293 | 0293 | yes | HT_přívodní vodní (55 °C) 19
13047409 | 2.NP_SO-102 | 1516.87 | 0.000891835 | 0.160594 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 3016.85 | 3000 | 3000 | 2983.15 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6986.4 | 0.119135 | 25 | 565 | 1516.87 | ø25 | 33.7 | 27.2 | TR02.02.0299 | 0299 | yes | HT_přívodní vodní (55 °C) 9 | 0
13047489 | 2.NP_SO-102 | 906.281 | 0.000891835 | 0.0959495 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 3926.92 | 3926.92 | 3020.64 | 3020.64 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7020.64 | 0.0711792 | 25 | 565 | 906.281 | ø25 | 33.7 | 27.2 | TR02.02.0301 | 0301 | yes | HT_přívodní vodní (55 °C) 9
13048098 | 3.NP_SO-102 | 3952.19 | 0.000356274 | 0.264464 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 3929.27 | 3929.27 | -22.9187 | -22.9188 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7977.08 | 0.186242 | 15 | 543 | 3952.19 | ø15 | 21.3 | 16 | TR02.02.0308 | 0308 | no | HT_přívodní vodní (55 °C) 9
13048339 | 2.NP_SO-102 | 5662.8 | 0.000891835 | 0.59953 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 2666.85 | 2650 | 2650 | 2633.15 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 6636.4 | 0.444755 | 25 | 15 | 5662.8 | ø25 | 33.7 | 27.2 | TR02.02.0311 | 0311 | yes | HT/CL_přívodní vodní 1 | 0
13048358 | 2.NP_SO-102 | 2913.81 | 0.000891835 | 0.30849 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 3166.85 | 3150 | 3150 | 3133.15 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 7136.4 | 0.22885 | 25 | 34 | 2913.81 | ø25 | 33.7 | 27.2 | TR02.02.0312 | 0312 | yes | HT/CL_přívodní vodní 1 | 0
13048368 | 2.NP_SO-102 | 6252.43 | 0.000891835 | 0.661955 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 3166.85 | 3150 | 3150 | 3133.15 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 7136.4 | 0.491065 | 25 | 34 | 6252.43 | ø25 | 33.7 | 27.2 | TR02.02.0313 | 0313 | yes | HT/CL_přívodní vodní 1 | 0
13048376 | 2.NP_SO-102 | 1361.87 | 0.000891835 | 0.144184 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 3166.85 | 3150 | 3150 | 3133.15 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 7136.4 | 0.106961 | 25 | 34 | 1361.87 | ø25 | 33.7 | 27.2 | TR02.02.0314 | 0314 | yes | HT/CL_přívodní vodní 1 | 0
13048791 | 2.NP_SO-102 | 611.687 | 0.000891835 | 0.0647603 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 2766.85 | 2750 | 2750 | 2733.15 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6736.4 | 0.0480418 | 25 | 565 | 611.687 | ø25 | 33.7 | 27.2 | TR02.02.0315 | 0315 | yes | HT_přívodní vodní (55 °C) 9 | 0
13048800 | 2.NP_SO-102 | 253.281 | 0.000891835 | 0.0268153 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 2729.36 | 2729.36 | 2476.08 | 2476.08 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6476.08 | 0.0198927 | 25 | 565 | 253.281 | ø25 | 33.7 | 27.2 | TR02.02.0316 | 0316 | yes | HT_přívodní vodní (55 °C) 9
13049018 | 4.NP_SO-102 | 319.363 | 0.000891835 | 0.0338114 | 0 | ø25 mm | 0.00367647 | HE | 4.NP_SO-102 | 16.85 | 0 | 0 | -16.85 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 11986.4 | 0.0250827 | 25 | 34 | 319.363 | ø25 | 33.7 | 27.2 | TR02.02.0317 | 0317 | yes | HT/CL_přívodní vodní 1 | 0
13049033 | 2.NP_SO-102 | 4808.73 | 0.000891835 | 0.509108 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 7979.36 | 7979.36 | 3170.64 | 3170.64 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 7170.64 | 0.377676 | 25 | 34 | 4808.73 | ø25 | 33.7 | 27.2 | TR02.02.0318 | 0318 | yes | HT/CL_přívodní vodní 1
13049526 | 2.NP_SO-102 | 611.687 | 0.000891835 | 0.0647603 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 3166.85 | 3150 | 3150 | 3133.15 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 7136.4 | 0.0480418 | 25 | 34 | 611.687 | ø25 | 33.7 | 27.2 | TR02.02.0319 | 0319 | yes | HT/CL_přívodní vodní 1 | 0
13049927 | 2.NP_SO-102 | 198.725 | 0.000891835 | 0.0210393 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 2466.85 | 2450 | 2450 | 2433.15 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 6436.4 | 0.0156078 | 25 | 34 | 198.725 | ø25 | 33.7 | 27.2 | TR02.02.0320 | 0320 | yes | HT/CL_přívodní vodní 1 | 0
13049951 | 2.NP_SO-102 | 658.725 | 0.000891835 | 0.0697403 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 3129.36 | 3129.36 | 2470.64 | 2470.64 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 6470.64 | 0.0517361 | 25 | 34 | 658.725 | ø25 | 33.7 | 27.2 | TR02.02.0321 | 0321 | yes | HT/CL_přívodní vodní 1
13050086 | 2.NP_SO-102 | 532.538 | 0.000568237 | 0.0450041 | 0 | ø20 mm | 0.00462963 | HE | 2.NP_SO-102 | 2663.45 | 2650 | 2650 | 2636.55 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 6639.2 | 0.0334603 | 20 | 45 | 532.538 | ø20 | 26.9 | 21.6 | TR02.02.0322 | 0322 | yes | HT/CL_přívodní vodní 1 | 0
13054725 | 2.NP_SO-102 | 377.197 | 0.000568237 | 0.0318765 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3273.4 | 3259.95 | 3258.85 | 3245.4 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7248.05 | 0.0237 | 20 | 281 | 377.197 | ø20 | 26.9 | 21.6 | TR02.02.0328 | 0328 | yes | HT_přívodní vodní (55 °C) 9 | 0.290491
13055107 | 4.NP_SO-102 | 411.425 | 0.000356274 | 0.0275309 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 2810.65 | 2800 | 2800 | 2789.35 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 10 | 14792 | 0.0193879 | 15 | 304 | 411.425 | ø15 | 21.3 | 16 | TR02.02.0329 | 0329 | yes | HT_přívodní vodní (65 °C) 10 | 0
13055116 | 4.NP_SO-102 | 6671.43 | 0.000356274 | 0.446425 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 2810.65 | 2800 | 2800 | 2789.35 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 10 | 14792 | 0.314383 | 15 | 304 | 6671.43 | ø15 | 21.3 | 16 | TR02.02.0330 | 0330 | yes | HT_přívodní vodní (65 °C) 10 | 0
13055144 | 4.NP_SO-102 | 552.901 | 0.000356274 | 0.0369979 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 2810.65 | 2800 | 2800 | 2789.35 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 10 | 14792 | 0.0260549 | 15 | 304 | 552.901 | ø15 | 21.3 | 16 | TR02.02.0331 | 0331 | yes | HT_přívodní vodní (65 °C) 10 | 0
13055163 | 4.NP_SO-102 | 145.713 | 0.000356274 | 0.00975049 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | -39.35 | -50 | -50 | -60.65 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 10 | 11942 | 0.00686654 | 15 | 304 | 145.713 | ø15 | 21.3 | 16 | TR02.02.0332 | 0332 | no | HT_přívodní vodní (65 °C) 10 | 0
13055172 | 4.NP_SO-102 | 2821.43 | 0.000356274 | 0.188798 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 2785.71 | -35.7125 | 2785.71 | -35.7125 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 10 | 11964.3 | 0.132957 | 15 | 304 | 2821.43 | ø15 | 21.3 | 16 | TR02.02.0333 | 0333 | yes | HT_přívodní vodní (65 °C) 10
