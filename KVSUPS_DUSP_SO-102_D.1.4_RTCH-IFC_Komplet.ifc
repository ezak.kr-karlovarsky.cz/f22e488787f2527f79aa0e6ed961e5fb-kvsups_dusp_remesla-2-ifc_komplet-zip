Properties of the parts of a building model (IFC4), part 61 of 72

# IfcPipeSegment: Typy trubek:Kompozit PE-Xa_RAUTITAN flex (676)
Name (Typy trubek:Kompozit PE-Xa_RAUTITAN flex:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Relativní drsnost | Sklon | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Typ systému | Drsnost (mm) | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group
13121935 | 2.NP_SO-102 | 784.062 | 0.000201032 | 0.0394113 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 473 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0910 | 0910 | no | HT_přívodní vodní (55 °C) 9
13121954 | 2.NP_SO-102 | 824.48 | 0.000201032 | 0.0414429 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 476 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0911 | 0911 | no | HT_přívodní vodní (55 °C) 9
13121963 | 2.NP_SO-102 | 3029.06 | 0.000201032 | 0.152257 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 473 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0912 | 0912 | no | HT_přívodní vodní (55 °C) 9
13121997 | 2.NP_SO-102 | 974.48 | 0.000201032 | 0.0489827 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 57 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0913 | 0913 | no | HT_vratné vodní (45 °C) 1
13122008 | 2.NP_SO-102 | 934.062 | 0.000201032 | 0.0469511 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 641 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0914 | 0914 | no | HT_vratné vodní (45 °C) 1
13122111 | 2.NP_SO-102 | 3031.27 | 0.000201032 | 0.152368 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 641 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0915 | 0915 | no | HT_vratné vodní (45 °C) 1
13122119 | 2.NP_SO-102 | 157.713 | 0.000201032 | 0.00792749 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 640 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0916 | 0916 | no | HT_vratné vodní (45 °C) 1
13122282 | 2.NP_SO-102 | 1271.6 | 0.000201032 | 0.0639175 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 558 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0918 | 0918 | no | HT_přívodní vodní (55 °C) 9
13122362 | 2.NP_SO-102 | 1121.6 | 0.000201032 | 0.0563776 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 822 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0921 | 0921 | no | HT_vratné vodní (45 °C) 1
13122447 | 2.NP_SO-102 | 1780 | 0.000201032 | 0.0894726 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 638 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0923 | 0923 | no | HT_vratné vodní (45 °C) 1
13124455 | 1.NP_SO-102 | 6264.5 | 0.000201032 | 0.314888 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 560 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0932 | 0932 | no | HT_vratné vodní (45 °C) 1
13124490 | 1.NP_SO-102 | 3198.47 | 0.000201032 | 0.160773 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 570 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0933 | 0933 | no | HT_vratné vodní (45 °C) 1
13124536 | 1.NP_SO-102 | 1845.42 | 0.000201032 | 0.092761 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 21 | -55.8 | RAU–PE–Xa | 16 | 37 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0934 | 0934 | no | HT_přívodní vodní (65 °C) 21
13124588 | 1.NP_SO-102 | 4151.02 | 0.000201032 | 0.208653 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 21 | -55.8 | RAU–PE–Xa | 16 | 30 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0935 | 0935 | no | HT_přívodní vodní (65 °C) 21
13129472 | -1.PP_SO-102 | 74.804 | 0.000201032 | 0.00376006 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -4055.8 | RAU–PE–Xa | 16 | 399 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0954 | 0954 | no | HT_přívodní vodní (55 °C) 9
13129499 | -1.PP_SO-102 | 224.378 | 0.000201032 | 0.0112785 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -4065.8 | RAU–PE–Xa | 16 | 545 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0955 | 0955 | no | HT_vratné vodní (45 °C) 1
13129523 | -1.PP_SO-102 | 6967.18 | 0.000201032 | 0.350209 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -4065.8 | RAU–PE–Xa | 16 | 541 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0956 | 0956 | no | HT_vratné vodní (45 °C) 1
13129555 | -1.PP_SO-102 | 485.526 | 0.000201032 | 0.0244052 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -4055.8 | RAU–PE–Xa | 16 | 576 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0957 | 0957 | no | HT_přívodní vodní (55 °C) 9
13129801 | 2.NP_SO-102 | 478.333 | 0.000201032 | 0.0240436 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 14 | 3944.2 | RAU–PE–Xa | 16 | 2 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0958 | 0958 | no | HT_přívodní vodní (55 °C) 14
13129957 | 2.NP_SO-102 | 328.333 | 0.000201032 | 0.0165038 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 554 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0959 | 0959 | no | HT_vratné vodní (45 °C) 1
13130103 | 2.NP_SO-102 | 3973.79 | 0.000201032 | 0.199744 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 20 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0962 | 0962 | no | HT_přívodní vodní (55 °C) 9
13130213 | 2.NP_SO-102 | 493.125 | 0.000201032 | 0.0247872 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 511 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0965 | 0965 | no | HT_přívodní vodní (55 °C) 9
13130295 | 2.NP_SO-102 | 6431.51 | 0.000201032 | 0.323283 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 511 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0966 | 0966 | no | HT_přívodní vodní (55 °C) 9
13130357 | 2.NP_SO-102 | 343.125 | 0.000201032 | 0.0172473 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 680 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0968 | 0968 | no | HT_vratné vodní (45 °C) 1
13130577 | 2.NP_SO-102 | 3973.79 | 0.000201032 | 0.199744 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 268 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0969 | 0969 | no | HT_vratné vodní (45 °C) 1
13130762 | 2.NP_SO-102 | 562.941 | 0.000201032 | 0.0282965 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 14 | 3944.2 | RAU–PE–Xa | 16 | 6 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0970 | 0970 | no | HT_přívodní vodní (65 °C) 14
13130883 | 2.NP_SO-102 | 883.176 | 0.000201032 | 0.0443933 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 341 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0972 | 0972 | no | HT_přívodní vodní (55 °C) 9
13130985 | 2.NP_SO-102 | 783.176 | 0.000201032 | 0.0393667 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 463 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0974 | 0974 | no | HT_vratné vodní (45 °C) 1
13131071 | 2.NP_SO-102 | 6571.43 | 0.000201032 | 0.330316 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 378 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0975 | 0975 | no | HT_vratné vodní (45 °C) 1
13131115 | 2.NP_SO-102 | 312.941 | 0.000201032 | 0.0157302 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 379 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0976 | 0976 | no | HT_vratné vodní (45 °C) 1
13132089 | 1.NP_SO-102 | 5925.84 | 0.000201032 | 0.297865 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 599 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0978 | 0978 | no | HT_vratné vodní (45 °C) 1
13132093 | 1.NP_SO-102 | 168.125 | 0.000201032 | 0.00845088 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 16 | -55.8 | RAU–PE–Xa | 16 | 2 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0979 | 0979 | no | HT_přívodní vodní (55 °C) 16
13132124 | 1.NP_SO-102 | 318.125 | 0.000201032 | 0.0159907 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 599 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0980 | 0980 | no | HT_vratné vodní (45 °C) 1
13133092 | 1.NP_SO-102 | 1673.74 | 0.000201032 | 0.0841311 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 344 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0985 | 0985 | no | HT_přívodní vodní (55 °C) 19
13133117 | 1.NP_SO-102 | 1170.47 | 0.000201032 | 0.0588341 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 372 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0986 | 0986 | no | HT_přívodní vodní (55 °C) 19
13133508 | 1.NP_SO-102 | 373.082 | 0.000201032 | 0.0187532 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 344 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0989 | 0989 | no | HT_přívodní vodní (55 °C) 19
13133556 | 1.NP_SO-102 | 17.7125 | 0.000201032 | 0.000890327 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 327 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0990 | 0990 | no | HT_vratné vodní (45 °C) 13
13133596 | 1.NP_SO-102 | 23.0821 | 0.000201032 | 0.00116023 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 357 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0991 | 0991 | no | HT_vratné vodní (45 °C) 13
13133652 | 1.NP_SO-102 | 2328.72 | 0.000201032 | 0.117054 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 2 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0992 | 0992 | no | HT_přívodní vodní (55 °C) 19
13133719 | 1.NP_SO-102 | 1277.71 | 0.000201032 | 0.0642246 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 58 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0993 | 0993 | no | HT_vratné vodní (45 °C) 13
13133740 | 1.NP_SO-102 | 1278.11 | 0.000201032 | 0.0642448 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 271 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0994 | 0994 | no | HT_přívodní vodní (55 °C) 19
13133811 | 1.NP_SO-102 | 1336 | 0.000201032 | 0.0671545 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 273 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0995 | 0995 | no | HT_přívodní vodní (55 °C) 19
13133858 | 1.NP_SO-102 | 1336 | 0.000201032 | 0.0671545 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 61 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0997 | 0997 | no | HT_vratné vodní (45 °C) 13
13134259 | 2.NP_SO-102 | 2109.86 | 0.000201032 | 0.106053 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 3944.2 | RAU–PE–Xa | 16 | 178 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1003 | 1003 | no | HT_přívodní vodní (55 °C) 19
13134280 | 2.NP_SO-102 | 2409.86 | 0.000201032 | 0.121133 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 3934.2 | RAU–PE–Xa | 16 | 23 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1004 | 1004 | no | HT_vratné vodní (45 °C) 13
13134355 | 2.NP_SO-102 | 5544.02 | 0.000201032 | 0.278673 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 3934.2 | RAU–PE–Xa | 16 | 26 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1006 | 1006 | no | HT_vratné vodní (45 °C) 13
13134376 | 2.NP_SO-102 | 5844.02 | 0.000201032 | 0.293752 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 3944.2 | RAU–PE–Xa | 16 | 177 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1007 | 1007 | no | HT_přívodní vodní (55 °C) 19
13134380 | 2.NP_SO-102 | 308.125 | 0.000201032 | 0.0154881 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 3944.2 | RAU–PE–Xa | 16 | 158 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1008 | 1008 | no | HT_přívodní vodní (55 °C) 19
13134422 | 2.NP_SO-102 | 458.125 | 0.000201032 | 0.0230279 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 3934.2 | RAU–PE–Xa | 16 | 18 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1009 | 1009 | no | HT_vratné vodní (45 °C) 13
13136410 | 2.NP_SO-102 | 2194.21 | 0.000201032 | 0.110293 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 3944.2 | RAU–PE–Xa | 16 | 170 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1022 | 1022 | no | HT_přívodní vodní (55 °C) 19
13136449 | 2.NP_SO-102 | 518.125 | 0.000201032 | 0.0260438 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 3944.2 | RAU–PE–Xa | 16 | 337 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1024 | 1024 | no | HT_přívodní vodní (55 °C) 19
13136533 | 2.NP_SO-102 | 368.125 | 0.000201032 | 0.018504 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 3934.2 | RAU–PE–Xa | 16 | 344 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1026 | 1026 | no | HT_vratné vodní (45 °C) 13
13136564 | 2.NP_SO-102 | 6573.41 | 0.000201032 | 0.330416 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 3934.2 | RAU–PE–Xa | 16 | 344 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1027 | 1027 | no | HT_vratné vodní (45 °C) 13
13136858 | 2.NP_SO-102 | 2194.21 | 0.000201032 | 0.110293 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 3934.2 | RAU–PE–Xa | 16 | 347 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1030 | 1030 | no | HT_vratné vodní (45 °C) 13
13136864 | 2.NP_SO-102 | 5784.21 | 0.000201032 | 0.290746 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 3934.2 | RAU–PE–Xa | 16 | 5 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1031 | 1031 | no | HT_vratné vodní (45 °C) 13
13137567 | 2.NP_SO-102 | 6769.1 | 0.000201032 | 0.340252 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 340 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1034 | 1034 | no | HT_přívodní vodní (55 °C) 9
13137573 | 2.NP_SO-102 | 396.084 | 0.000201032 | 0.0199094 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 19 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1035 | 1035 | no | HT_přívodní vodní (55 °C) 9
13137592 | 2.NP_SO-102 | 6469.1 | 0.000201032 | 0.325172 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 448 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1036 | 1036 | no | HT_vratné vodní (45 °C) 1
13137598 | 2.NP_SO-102 | 696.084 | 0.000201032 | 0.034989 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 3 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1037 | 1037 | no | HT_vratné vodní (45 °C) 1
13139330 | 3.NP_SO-102 | 2330.28 | 0.000201032 | 0.117133 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 13 | 7944.2 | RAU–PE–Xa | 16 | 9 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1050 | 1050 | no | HT_přívodní vodní (65 °C) 13
13139334 | 3.NP_SO-102 | 526.267 | 0.000201032 | 0.0264531 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 17 | 7944.2 | RAU–PE–Xa | 16 | 11 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1051 | 1051 | no | HT_přívodní vodní (55 °C) 17
13139437 | 3.NP_SO-102 | 2330.28 | 0.000201032 | 0.117133 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 331 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1052 | 1052 | no | HT_vratné vodní (45 °C) 1
13139463 | 3.NP_SO-102 | 376.267 | 0.000201032 | 0.0189133 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 336 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1053 | 1053 | no | HT_vratné vodní (45 °C) 1
13139516 | 3.NP_SO-102 | 3849.27 | 0.000201032 | 0.193485 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 334 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1054 | 1054 | no | HT_vratné vodní (45 °C) 1
13140317 | 3.NP_SO-102 | 1382.79 | 0.000201032 | 0.0695067 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 7944.2 | RAU–PE–Xa | 16 | 342 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1058 | 1058 | no | HT_přívodní vodní (55 °C) 19
13140392 | 3.NP_SO-102 | 188.98 | 0.000201032 | 0.00949915 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 7944.2 | RAU–PE–Xa | 16 | 531 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1060 | 1060 | no | HT_přívodní vodní (55 °C) 19
13140447 | 3.NP_SO-102 | 647.713 | 0.000201032 | 0.0325576 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7934.2 | RAU–PE–Xa | 16 | 539 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1061 | 1061 | no | HT_vratné vodní (45 °C) 13
13140491 | 3.NP_SO-102 | 408.125 | 0.000201032 | 0.0205146 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7934.2 | RAU–PE–Xa | 16 | 456 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1062 | 1062 | no | HT_vratné vodní (45 °C) 13
13140548 | 3.NP_SO-102 | 1736 | 0.000201032 | 0.0872609 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7934.2 | RAU–PE–Xa | 16 | 450 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1063 | 1063 | no | HT_vratné vodní (45 °C) 13
13140856 | 3.NP_SO-102 | 2033.15 | 0.000314112 | 0.127746 | ø20 mm | 0.000694444 | 0 | 3.NP_SO-102 | -40 | -50 | -50 | -60 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 7942.8 | RAU–PE–Xa | 20 | 404 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.1067 | 1067 | no | HT_přívodní vodní (55 °C) 19
13140883 | 3.NP_SO-102 | 2333.15 | 0.000314112 | 0.146596 | ø20 mm | 0.000694444 | 0 | 3.NP_SO-102 | -50 | -60 | -60 | -70 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7932.8 | RAU–PE–Xa | 20 | 415 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.1068 | 1068 | no | HT_vratné vodní (45 °C) 13
13140962 | 3.NP_SO-102 | 227.012 | 0.000314112 | 0.0142636 | ø20 mm | 0.000694444 | 0 | 3.NP_SO-102 | -40 | -50 | -50 | -60 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 7942.8 | RAU–PE–Xa | 20 | 412 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.1071 | 1071 | no | HT_přívodní vodní (55 °C) 19
13140998 | 3.NP_SO-102 | 6013.95 | 0.000314112 | 0.377868 | ø20 mm | 0.000694444 | 0 | 3.NP_SO-102 | -40 | -50 | -50 | -60 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 7942.8 | RAU–PE–Xa | 20 | 402 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.1072 | 1072 | no | HT_přívodní vodní (55 °C) 19
13141081 | 3.NP_SO-102 | 377.012 | 0.000314112 | 0.0236884 | ø20 mm | 0.000694444 | 0 | 3.NP_SO-102 | -50 | -60 | -60 | -70 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7932.8 | RAU–PE–Xa | 20 | 423 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.1074 | 1074 | no | HT_vratné vodní (45 °C) 13
13141207 | 3.NP_SO-102 | 5713.95 | 0.000314112 | 0.359018 | ø20 mm | 0.000694444 | 0 | 3.NP_SO-102 | -50 | -60 | -60 | -70 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7932.8 | RAU–PE–Xa | 20 | 413 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.1075 | 1075 | no | HT_vratné vodní (45 °C) 13
13141901 | 3.NP_SO-102 | 1448.55 | 0.000201032 | 0.0728119 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 22 | 7944.2 | RAU–PE–Xa | 16 | 4 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1078 | 1078 | no | HT_přívodní vodní (65 °C) 22
13141925 | 3.NP_SO-102 | 1748.55 | 0.000201032 | 0.0878916 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 7 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1079 | 1079 | no | HT_vratné vodní (45 °C) 1
13142154 | 3.NP_SO-102 | 198.125 | 0.000201032 | 0.00995885 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 18 | 7944.2 | RAU–PE–Xa | 16 | 22 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1086 | 1086 | no | HT_přívodní vodní (55 °C) 18
13142193 | 3.NP_SO-102 | 5551.87 | 0.000201032 | 0.279067 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 22 | 7944.2 | RAU–PE–Xa | 16 | 10 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1087 | 1087 | no | HT_přívodní vodní (65 °C) 22
13142270 | 3.NP_SO-102 | 348.125 | 0.000201032 | 0.0174987 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 468 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1089 | 1089 | no | HT_vratné vodní (45 °C) 1
13142335 | 3.NP_SO-102 | 5251.87 | 0.000201032 | 0.263988 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 356 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1090 | 1090 | no | HT_vratné vodní (45 °C) 1
13143564 | 3.NP_SO-102 | 189.953 | 0.000201032 | 0.00954806 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 20 | 7944.2 | RAU–PE–Xa | 16 | 33 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1102 | 1102 | no | HT_přívodní vodní (55 °C) 20
13143721 | 3.NP_SO-102 | 339.953 | 0.000201032 | 0.0170879 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 740 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1104 | 1104 | no | HT_vratné vodní (45 °C) 1
13144156 | 3.NP_SO-102 | 2288.74 | 0.000201032 | 0.115045 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 15 | 7944.2 | RAU–PE–Xa | 16 | 33 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1106 | 1106 | no | HT_přívodní vodní (65 °C) 15
13144164 | 3.NP_SO-102 | 4827.15 | 0.000201032 | 0.242639 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 15 | 7944.2 | RAU–PE–Xa | 16 | 30 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1107 | 1107 | no | HT_přívodní vodní (65 °C) 15
13144183 | 3.NP_SO-102 | 1988.74 | 0.000201032 | 0.0999651 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 743 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1108 | 1108 | no | HT_vratné vodní (45 °C) 1
13144189 | 3.NP_SO-102 | 4824.77 | 0.000201032 | 0.242519 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 746 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1109 | 1109 | no | HT_vratné vodní (45 °C) 1
13144306 | 4.NP_SO-102 | 2356.11 | 0.000201032 | 0.118431 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 455 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1110 | 1110 | no | HT_přívodní vodní (55 °C) 19
13144359 | 4.NP_SO-102 | 1533.41 | 0.000201032 | 0.0770775 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 470 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1113 | 1113 | no | HT_vratné vodní (45 °C) 13
13144411 | 4.NP_SO-102 | 139.512 | 0.000201032 | 0.00701264 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 468 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1114 | 1114 | no | HT_přívodní vodní (55 °C) 19
13144456 | 4.NP_SO-102 | 308.125 | 0.000201032 | 0.0154881 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 481 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1115 | 1115 | no | HT_vratné vodní (45 °C) 13
13144501 | 4.NP_SO-102 | 389.967 | 0.000201032 | 0.0196019 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 468 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1116 | 1116 | no | HT_vratné vodní (45 °C) 13
13145061 | 4.NP_SO-102 | 1393.22 | 0.000201032 | 0.0700311 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 505 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1122 | 1122 | no | HT_přívodní vodní (55 °C) 19
13145086 | 4.NP_SO-102 | 1393.22 | 0.000201032 | 0.0700311 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 509 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1123 | 1123 | no | HT_vratné vodní (45 °C) 13
13145134 | 4.NP_SO-102 | 338.831 | 0.000201032 | 0.0170315 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 495 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1125 | 1125 | no | HT_přívodní vodní (55 °C) 19
13145331 | 4.NP_SO-102 | 488.831 | 0.000201032 | 0.0245713 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 521 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1127 | 1127 | no | HT_vratné vodní (45 °C) 13
13145495 | 4.NP_SO-102 | 6632.08 | 0.000201032 | 0.333365 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 512 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1129 | 1129 | no | HT_vratné vodní (45 °C) 13
13147681 | 4.NP_SO-102 | 3157.37 | 0.000201032 | 0.158707 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 34 | 11944.2 | RAU–PE–Xa | 16 | 11 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1136 | 1136 | no | HT_přívodní vodní (65 °C) 34
13147689 | 4.NP_SO-102 | 363.184 | 0.000201032 | 0.0182556 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 34 | 11944.2 | RAU–PE–Xa | 16 | 9 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1137 | 1137 | no | HT_přívodní vodní (65 °C) 34
13147737 | 4.NP_SO-102 | 8398.19 | 0.000201032 | 0.422139 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 481 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1138 | 1138 | no | HT_vratné vodní (45 °C) 1
13147745 | 4.NP_SO-102 | 213.184 | 0.000201032 | 0.0107158 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 482 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1139 | 1139 | no | HT_vratné vodní (45 °C) 1
13147996 | 4.NP_SO-102 | 1135.43 | 0.000201032 | 0.0570727 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 811 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1141 | 1141 | no | HT_vratné vodní (45 °C) 1
13148034 | 4.NP_SO-102 | 208.125 | 0.000201032 | 0.0104615 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 23 | 11944.2 | RAU–PE–Xa | 16 | 13 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1146 | 1146 | no | HT_přívodní vodní (55 °C) 23
13148265 | 4.NP_SO-102 | 358.125 | 0.000201032 | 0.0180013 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 810 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1152 | 1152 | no | HT_vratné vodní (45 °C) 1
13148390 | 4.NP_SO-102 | 6962.31 | 0.000201032 | 0.349964 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 815 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1153 | 1153 | no | HT_vratné vodní (45 °C) 1
13148818 | 4.NP_SO-102 | 6962.31 | 0.000201032 | 0.349964 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 2 | 11944.2 | RAU–PE–Xa | 16 | 24 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1155 | 1155 | no | HT_přívodní vodní (65 °C) 2
13148827 | 4.NP_SO-102 | 1158.33 | 0.000201032 | 0.0582239 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 2 | 11944.2 | RAU–PE–Xa | 16 | 27 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1156 | 1156 | no | HT_přívodní vodní (65 °C) 2
13149066 | 4.NP_SO-102 | 2419.72 | 0.000201032 | 0.121628 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 25 | 11944.2 | RAU–PE–Xa | 16 | 31 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1158 | 1158 | no | HT_přívodní vodní (65 °C) 25
13149076 | 4.NP_SO-102 | 738.125 | 0.000201032 | 0.0371022 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 24 | 11944.2 | RAU–PE–Xa | 16 | 2 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1159 | 1159 | no | HT_přívodní vodní (55 °C) 24
13149284 | 4.NP_SO-102 | 7618.42 | 0.000201032 | 0.382944 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 25 | 11944.2 | RAU–PE–Xa | 16 | 23 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1162 | 1162 | no | HT_přívodní vodní (65 °C) 25
13149301 | 4.NP_SO-102 | 588.125 | 0.000201032 | 0.0295624 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 781 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1163 | 1163 | no | HT_vratné vodní (45 °C) 1
13149334 | 4.NP_SO-102 | 6104.71 | 0.000201032 | 0.306856 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 776 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1164 | 1164 | no | HT_vratné vodní (45 °C) 1
13149394 | 4.NP_SO-102 | 61.775 | 0.000201032 | 0.00310515 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 781 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1166 | 1166 | no | HT_vratné vodní (45 °C) 1
13149400 | 4.NP_SO-102 | 7918.42 | 0.000201032 | 0.398023 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11934.2 | RAU–PE–Xa | 16 | 779 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1167 | 1167 | no | HT_vratné vodní (45 °C) 1
13150037 | 4.NP_SO-102 | 69.775 | 0.000201032 | 0.00350727 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 11944.2 | RAU–PE–Xa | 16 | 347 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1174 | 1174 | no | HT_přívodní vodní (55 °C) 9
13150051 | 4.NP_SO-102 | 964.063 | 0.000201032 | 0.0484591 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 11944.2 | RAU–PE–Xa | 16 | 347 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1176 | 1176 | no | HT_přívodní vodní (55 °C) 9
13150079 | 4.NP_SO-102 | 119.775 | 0.000201032 | 0.00602055 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 18 | 11944.2 | RAU–PE–Xa | 16 | 3 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1177 | 1177 | no | HT_vratné vodní (45 °C) 18
13150090 | 4.NP_SO-102 | 1114.06 | 0.000201032 | 0.0559989 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 18 | 11944.2 | RAU–PE–Xa | 16 | 3 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1178 | 1178 | no | HT_vratné vodní (45 °C) 18
13181922 | 1.NP_SO-102 | 6225.84 | 0.000201032 | 0.312945 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 29 | -55.8 | RAU–PE–Xa | 16 | 31 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1270 | 1270 | no | HT_přívodní vodní (65 °C) 29
13182227 | -1.PP_SO-102 | 122.049 | 0.000201032 | 0.00613486 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -4065.8 | RAU–PE–Xa | 16 | 502 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1271 | 1271 | no | HT_vratné vodní (45 °C) 1
13182312 | -1.PP_SO-102 | 1835.04 | 0.000201032 | 0.0922393 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -4065.8 | RAU–PE–Xa | 16 | 539 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1272 | 1272 | no | HT_vratné vodní (45 °C) 1
13182320 | -1.PP_SO-102 | 2706.06 | 0.000201032 | 0.136021 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -4065.8 | RAU–PE–Xa | 16 | 496 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1273 | 1273 | no | HT_vratné vodní (45 °C) 1
13182332 | -1.PP_SO-102 | 272.049 | 0.000201032 | 0.0136747 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 1 | -4055.8 | RAU–PE–Xa | 16 | 352 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1274 | 1274 | no | HT_přívodní vodní (55 °C) 9; HT_přívodní vodní (65 °C) 1
13182405 | -1.PP_SO-102 | 1789.9 | 0.000201032 | 0.0899701 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -4055.8 | RAU–PE–Xa | 16 | 393 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1275 | 1275 | no | HT_přívodní vodní (55 °C) 9
13182435 | -1.PP_SO-102 | 4837.27 | 0.000201032 | 0.243148 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -4055.8 | RAU–PE–Xa | 16 | 395 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1276 | 1276 | no | HT_přívodní vodní (55 °C) 9
13183093 | 1.NP_SO-102 | 112.049 | 0.000201032 | 0.0056322 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 1 | -55.8 | RAU–PE–Xa | 16 | 352 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1279 | 1279 | no | HT_přívodní vodní (65 °C) 1
13183442 | 1.NP_SO-102 | 262.049 | 0.000201032 | 0.013172 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 502 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1280 | 1280 | no | HT_vratné vodní (45 °C) 1
13183540 | 1.NP_SO-102 | 3674.18 | 0.000201032 | 0.184684 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 609 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1281 | 1281 | no | HT_vratné vodní (45 °C) 1
13183548 | 1.NP_SO-102 | 2752.39 | 0.000201032 | 0.13835 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 605 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1282 | 1282 | no | HT_vratné vodní (45 °C) 1
13183590 | 1.NP_SO-102 | 3731.32 | 0.000201032 | 0.187557 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 1 | -55.8 | RAU–PE–Xa | 16 | 362 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1283 | 1283 | no | HT_přívodní vodní (65 °C) 1
13183598 | 1.NP_SO-102 | 2452.39 | 0.000201032 | 0.123271 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 1 | -55.8 | RAU–PE–Xa | 16 | 358 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1284 | 1284 | no | HT_přívodní vodní (65 °C) 1
13183660 | 1.NP_SO-102 | 244.063 | 0.000201032 | 0.0122679 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -65.8 | RAU–PE–Xa | 16 | 609 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1285 | 1285 | no | HT_vratné vodní (45 °C) 1
13214389 | 2.NP_SO-102 | 2215.02 | 0.000201032 | 0.111339 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 650 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1339 | 1339 | no | HT_vratné vodní (45 °C) 1
13214418 | 2.NP_SO-102 | 2471.19 | 0.000201032 | 0.124216 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 51 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1340 | 1340 | no | HT_přívodní vodní (55 °C) 9
13255704 | 1.NP_SO-102 | 2166.39 | 0.000201032 | 0.108895 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 345 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1578 | 1578 | no | HT_přívodní vodní (55 °C) 19
13255711 | 1.NP_SO-102 | 6224.66 | 0.000201032 | 0.312885 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 267 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1579 | 1579 | no | HT_přívodní vodní (55 °C) 19
13255719 | 1.NP_SO-102 | 2316.39 | 0.000201032 | 0.116434 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 358 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1580 | 1580 | no | HT_vratné vodní (45 °C) 13
13255728 | 1.NP_SO-102 | 6574.66 | 0.000201032 | 0.330478 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -65.8 | RAU–PE–Xa | 16 | 10 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1581 | 1581 | no | HT_vratné vodní (45 °C) 13
13256696 | -1.PP_SO-102 | 314.362 | 0.000201032 | 0.0158016 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4055.8 | RAU–PE–Xa | 16 | 347 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1582 | 1582 | no | HT_přívodní vodní (55 °C) 19
13256698 | -1.PP_SO-102 | 164.362 | 0.000201032 | 0.00826176 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 360 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1583 | 1583 | no | HT_vratné vodní (45 °C) 13
13259574 | 2.NP_SO-102 | 6273.64 | 0.000201032 | 0.315348 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 373 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1584 | 1584 | no | HT_přívodní vodní (55 °C) 9
13259599 | 2.NP_SO-102 | 5823.64 | 0.000201032 | 0.292728 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 54 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.1585 | 1585 | no | HT_vratné vodní (45 °C) 1
