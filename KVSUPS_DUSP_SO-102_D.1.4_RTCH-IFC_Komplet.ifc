Properties of the parts of a building model (IFC4), part 29 of 72

# IfcBuildingElementProxy: Radiátor z žebrových trubek_dvouřadé_F:Radiátor z žebrových trubek_dvouřadé_F 57x2.5x137 (67)
Name (Radiátor z žebrových trubek_dvouřadé_F:Radiátor z žebrových trubek_dvouřadé_F 57x2.5x137:...) | In | NetSurfaceArea (m2) | NetVolume (m3) = Objem (m3) | Podlaží | Hostitel | Fáze vytvoření | Klasifikace systému | Délka (mm) | Plocha (m2) | Kód prvku | Označení
12776519 | 2.NP_SO-102 | 3.734 | 0.119996 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | Nedefinovaný | 4000 | 1.867 | OT00.16.0019 | 0019
12776841 | 2.NP_SO-102 | 3.734 | 0.119996 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | Nedefinovaný | 4000 | 1.867 | OT00.16.0024 | 0024
12777337 | 3.NP_SO-102 | 2.87321 | 0.0905155 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | Nedefinovaný | 3000 | 1.4366 | OT00.16.0028 | 0028
12778255 | 4.NP_SO-102 | 2.87321 | 0.0905155 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | Nedefinovaný | 3000 | 1.4366 | OT00.16.0034 | 0034
12779260 | 3.NP_SO-102 | 1.58201 | 0.0462941 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | Nedefinovaný | 1500 | 0.791007 | OT00.16.0046 | 0046
12779876 | 1.NP_SO-102 | 2.44281 | 0.075775 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | Nedefinovaný | 2500 | 1.22141 | OT00.16.0053 | 0053
12805506 | 4.NP_SO-102 | 4.5948 | 0.149477 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | Nedefinovaný | 5000 | 2.2974 | OT00.16.0069 | 0069
12805615 | 4.NP_SO-102 | 3.734 | 0.119996 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | Nedefinovaný | 4000 | 1.867 | OT00.16.0070 | 0070
12806367 | 4.NP_SO-102 | 2.87321 | 0.0905155 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | Nedefinovaný | 3000 | 1.4366 | OT00.16.0071 | 0071
12989258 | -1.PP_SO-102 | 3.734 | 0.119996 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | Nedefinovaný | 4000 | 1.867 | OT00.16.0099 | 0099
12989266 | -1.PP_SO-102 | 3.734 | 0.119996 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | Nedefinovaný | 4000 | 1.867 | OT00.16.0100 | 0100
12990216 | 1.NP_SO-102 | 4.5948 | 0.149477 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | Nedefinovaný | 5000 | 2.2974 | OT00.16.0108 | 0108
12990472 | 1.NP_SO-102 | 2.44281 | 0.075775 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | Nedefinovaný | 2500 | 1.22141 | OT00.16.0109 | 0109
12990480 | 1.NP_SO-102 | 2.87321 | 0.0905155 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | Nedefinovaný | 3000 | 1.4366 | OT00.16.0110 | 0110
12990490 | 1.NP_SO-102 | 2.87321 | 0.0905155 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | Nedefinovaný | 3000 | 1.4366 | OT00.16.0111 | 0111
12990510 | 1.NP_SO-102 | 2.44281 | 0.075775 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | Nedefinovaný | 2500 | 1.22141 | OT00.16.0113 | 0113
12990614 | 1.NP_SO-102 | 3.734 | 0.119996 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | Nedefinovaný | 4000 | 1.867 | OT00.16.0114 | 0114
12990628 | 1.NP_SO-102 | 3.734 | 0.119996 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | Nedefinovaný | 4000 | 1.867 | OT00.16.0115 | 0115
12990640 | 1.NP_SO-102 | 4.5948 | 0.149477 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | Nedefinovaný | 5000 | 2.2974 | OT00.16.0116 | 0116
12990804 | 1.NP_SO-102 | 3.734 | 0.119996 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | Přívod teplé vody,Nedefinovaný | 4000 | 1.867 | OT00.16.0117 | 0117 | Mechanické - Název systému: HT_přívodní vodní (55 °C) 8; Group: HT_přívodní vodní (55 °C) 8
12991029 | 1.NP_SO-102 | 2.44281 | 0.075775 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | Nedefinovaný | 2500 | 1.22141 | OT00.16.0118 | 0118
12991043 | 1.NP_SO-102 | 2.44281 | 0.075775 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | Nedefinovaný | 2500 | 1.22141 | OT00.16.0119 | 0119
12992021 | 2.NP_SO-102 | 3.734 | 0.119996 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | Nedefinovaný | 4000 | 1.867 | OT00.16.0125 | 0125
12992031 | 2.NP_SO-102 | 2.87321 | 0.0905155 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | Nedefinovaný | 3000 | 1.4366 | OT00.16.0126 | 0126
12992047 | 2.NP_SO-102 | 2.87321 | 0.0905155 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | Nedefinovaný | 3000 | 1.4366 | OT00.16.0127 | 0127
12992055 | 2.NP_SO-102 | 2.87321 | 0.0905155 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | Nedefinovaný | 3000 | 1.4366 | OT00.16.0128 | 0128
12992063 | 2.NP_SO-102 | 2.87321 | 0.0905155 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | Nedefinovaný | 3000 | 1.4366 | OT00.16.0129 | 0129
12992125 | 2.NP_SO-102 | 2.87321 | 0.0905155 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | Nedefinovaný | 3000 | 1.4366 | OT00.16.0130 | 0130
12992220 | 2.NP_SO-102 | 3.734 | 0.119996 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | Nedefinovaný | 4000 | 1.867 | OT00.16.0131 | 0131
12992228 | 2.NP_SO-102 | 3.734 | 0.119996 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | Nedefinovaný | 4000 | 1.867 | OT00.16.0132 | 0132
12992238 | 2.NP_SO-102 | 4.5948 | 0.149477 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | Nedefinovaný | 5000 | 2.2974 | OT00.16.0133 | 0133
12992248 | 2.NP_SO-102 | 4.5948 | 0.149477 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | Nedefinovaný | 5000 | 2.2974 | OT00.16.0134 | 0134
12992349 | 2.NP_SO-102 | 3.734 | 0.119996 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | Nedefinovaný | 4000 | 1.867 | OT00.16.0135 | 0135
12992357 | 2.NP_SO-102 | 3.734 | 0.119996 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | Nedefinovaný | 4000 | 1.867 | OT00.16.0136 | 0136
12992664 | 2.NP_SO-102 | 2.01241 | 0.0610346 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | Nedefinovaný | 2000 | 1.00621 | OT00.16.0139 | 0139
12992761 | 2.NP_SO-102 | 1.58201 | 0.0462941 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | Nedefinovaný | 1500 | 0.791007 | OT00.16.0140 | 0140
12998728 | 3.NP_SO-102 | 3.734 | 0.119996 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | Nedefinovaný | 4000 | 1.867 | OT00.16.0142 | 0142
12998808 | 3.NP_SO-102 | 2.87321 | 0.0905155 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | Nedefinovaný | 3000 | 1.4366 | OT00.16.0143 | 0143
12998860 | 3.NP_SO-102 | 3.734 | 0.119996 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | Nedefinovaný | 4000 | 1.867 | OT00.16.0144 | 0144
12998870 | 3.NP_SO-102 | 3.734 | 0.119996 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | Nedefinovaný | 4000 | 1.867 | OT00.16.0145 | 0145
12998880 | 3.NP_SO-102 | 2.87321 | 0.0905155 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | Nedefinovaný | 3000 | 1.4366 | OT00.16.0146 | 0146
12998890 | 3.NP_SO-102 | 2.87321 | 0.0905155 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | Nedefinovaný,Přívod teplé vody | 3000 | 1.4366 | OT00.16.0147 | 0147 | Mechanické - Název systému: HT_přívodní vodní (65 °C) 17,HT_přívodní vodní (65 °C) 16; Group: HT_přívodní vodní (65 °C) 17; HT_přívodní vodní (65 °C) 16
12998902 | 3.NP_SO-102 | 2.87321 | 0.0905155 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | Nedefinovaný | 3000 | 1.4366 | OT00.16.0148 | 0148
12998910 | 3.NP_SO-102 | 2.87321 | 0.0905155 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | Nedefinovaný | 3000 | 1.4366 | OT00.16.0149 | 0149
12998971 | 3.NP_SO-102 | 3.734 | 0.119996 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | Nedefinovaný | 4000 | 1.867 | OT00.16.0150 | 0150
12998979 | 3.NP_SO-102 | 3.734 | 0.119996 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | Nedefinovaný | 4000 | 1.867 | OT00.16.0151 | 0151
12998989 | 3.NP_SO-102 | 4.5948 | 0.149477 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | Nedefinovaný | 5000 | 2.2974 | OT00.16.0152 | 0152
12999165 | 3.NP_SO-102 | 2.87321 | 0.0905155 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | Nedefinovaný | 3000 | 1.4366 | OT00.16.0153 | 0153
12999175 | 3.NP_SO-102 | 2.87321 | 0.0905155 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | Nedefinovaný | 3000 | 1.4366 | OT00.16.0154 | 0154
12999185 | 3.NP_SO-102 | 2.87321 | 0.0905155 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | Nedefinovaný | 3000 | 1.4366 | OT00.16.0155 | 0155
12999252 | 3.NP_SO-102 | 2.87321 | 0.0905155 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | Nedefinovaný | 3000 | 1.4366 | OT00.16.0156 | 0156
12999285 | 3.NP_SO-102 | 3.734 | 0.119996 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | Nedefinovaný | 4000 | 1.867 | OT00.16.0157 | 0157
12999403 | 3.NP_SO-102 | 2.87321 | 0.0905155 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | Nedefinovaný | 3000 | 1.4366 | OT00.16.0158 | 0158
13006055 | 4.NP_SO-102 | 3.734 | 0.119996 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | Nedefinovaný | 4000 | 1.867 | OT00.16.0160 | 0160
13006577 | 4.NP_SO-102 | 3.734 | 0.119996 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | Nedefinovaný | 4000 | 1.867 | OT00.16.0161 | 0161
13006578 | 4.NP_SO-102 | 2.87321 | 0.0905155 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | Nedefinovaný | 3000 | 1.4366 | OT00.16.0162 | 0162
13007230 | 4.NP_SO-102 | 1.58201 | 0.0462941 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | Nedefinovaný | 1500 | 0.791007 | OT00.16.0163 | 0163
13007330 | 4.NP_SO-102 | 3.734 | 0.119996 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | Nedefinovaný | 4000 | 1.867 | OT00.16.0164 | 0164
13007505 | 4.NP_SO-102 | 2.44281 | 0.075775 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | Nedefinovaný | 2500 | 1.22141 | OT00.16.0165 | 0165
13007517 | 4.NP_SO-102 | 3.734 | 0.119996 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | Nedefinovaný | 4000 | 1.867 | OT00.16.0166 | 0166
13007525 | 4.NP_SO-102 | 3.734 | 0.119996 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | Nedefinovaný | 4000 | 1.867 | OT00.16.0167 | 0167
13007537 | 4.NP_SO-102 | 4.5948 | 0.149477 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | Nedefinovaný | 5000 | 2.2974 | OT00.16.0168 | 0168
13007553 | 4.NP_SO-102 | 4.5948 | 0.149477 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | Nedefinovaný | 5000 | 2.2974 | OT00.16.0169 | 0169
13036411 | 4.NP_SO-102 | 4.5948 | 0.149477 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | Nedefinovaný | 5000 | 2.2974 | OT00.16.0182 | 0182
13322772 | -1.PP_SO-102 | 2.01241 | 0.0610346 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | Nedefinovaný | 2000 | 1.00621 | OT00.16.0231 | 0231
13341454 | 1.NP_SO-102 | 2.87321 | 0.0905155 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | Nedefinovaný | 3000 | 1.4366 | OT00.16.0232 | 0232

# IfcBuildingElementProxy: Radiátor z žebrových trubek_dvouřadé_F:Radiátor z žebrových trubek_dvouřadé_F 76x2.5x156 (2)
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Text - Typ tělesa: SPIRAL RAO2-F
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - DN přípojky: 16 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; připojení: 8 mm; Průměr: 76 mm; Průměr trubky: 76 mm; Průměr vinutí: 156 mm; r: 38 mm; r2: 78 mm; Šířka: 156 mm; Výška: 456 mm
Type - Identifikační data - Číslo OmniClass: 23.85.50.14; Kód sestavy: OT00; Nadpis OmniClass: Telephone and Intercommunication Equipment; Název typu: Radiátor z žebrových trubek_dvouřadé_F 76x2.5x156; Označení typu: 46; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Mechanické zařízení; Dvoutrubka: yes; Název rodiny: Radiátor z žebrových trubek_dvouřadé_F
Classification: OT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.32229 m2; NetVolume: 0.118007 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 2.NP_SO-102; Hostitel: Podlaží : 2.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Nedefinovaný
Kóty - Délka: 3000 mm; Objem: 0.118007 m3; Plocha: 1.66114 m2
Jiné - Rodina: Radiátor z žebrových trubek_dvouřadé_F; Id typu: 12988741; Rodina a typ: Radiátor z žebrových trubek_dvouřadé_F: Radiátor z žebrových trubek_dvouřadé_F 76x2.5x156; Typ: Radiátor z žebrových trubek_dvouřadé_F 76x2.5x156
Name (Radiátor z žebrových trubek_dvouřadé_F:Radiátor z žebrových trubek_dvouřadé_F 76x2.5x156:...) | Kód prvku | Označení
12991587 | OT00.46.0121 | 0121
12991660 | OT00.46.0122 | 0122

# IfcBuildingElementProxy: Radiátor z žebrových trubek_dvouřadé_V:Radiátor z žebrových trubek_dvouřadé_V 57x2.5x137 1000 (7)
Type - Material: <Unnamed>
Type - Text - Typ tělesa: SPIRAL RAO2-V
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - Celková výška: 1000 mm; Délka: 1000 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; Průměr: 57 mm; Průměr trubky: 57 mm; Rozestup trubek: 200 mm; Šířka: 137 mm; Výška: 282 mm
Type - Identifikační data - Číslo OmniClass: 23.75.00.00; Kód sestavy: OT00; Nadpis OmniClass: Climate Control (HVAC); Název typu: Radiátor z žebrových trubek_dvouřadé_V 57x2.5x137 1000; Označení typu: 19; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Radiátor z žebrových trubek_dvouřadé_V
Classification: OT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.429707 m2; NetVolume: 0.00590493 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Mechanické - Klasifikace systému: Zpětné vedení teplé vody,Přívod teplé vody
Kóty - Dimenze potrubí: 15 mm; Objem: 0.00590493 m3; Odsazení od podlahy: 150 mm; Odsazení od stěny: 50 mm; Odsazení od stěny + 1/2 průměr trubky: 78.5 mm; Plocha: 0.214853 m2
Jiné - Rodina: Radiátor z žebrových trubek_dvouřadé_V; Id typu: 13016926; Rodina a typ: Radiátor z žebrových trubek_dvouřadé_V: Radiátor z žebrových trubek_dvouřadé_V 57x2.5x137 1000; Typ: Radiátor z žebrových trubek_dvouřadé_V 57x2.5x137 1000
Name (Radiátor z žebrových trubek_dvouřadé_V:Radiátor z žebrových trubek_dvouřadé_V 57x2.5x137 1000:...) | In | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
12776977 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OT00.19.0025 | 0025
12777052 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OT00.19.0026 | 0026
12777135 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OT00.19.0027 | 0027
12778776 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | OT00.19.0038 | 0038
12806450 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | OT00.19.0072 | 0072
13018099 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OT00.19.0177 | 0177
13259487 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | OT00.19.0223 | 0223

# IfcBuildingElementProxy: Radiátor z žebrových trubek_dvouřadé_V:Radiátor z žebrových trubek_dvouřadé_V 57x2.5x137 1500 (5)
Type - Material: <Unnamed>
Type - Text - Typ tělesa: SPIRAL RAO2-V
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - Celková výška: 1500 mm; Délka: 1500 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; Průměr: 57 mm; Průměr trubky: 57 mm; Rozestup trubek: 200 mm; Šířka: 137 mm; Výška: 282 mm
Type - Identifikační data - Číslo OmniClass: 23.75.00.00; Kód sestavy: OT00; Nadpis OmniClass: Climate Control (HVAC); Název typu: Radiátor z žebrových trubek_dvouřadé_V 57x2.5x137 1500; Označení typu: 15; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Radiátor z žebrových trubek_dvouřadé_V
Classification: OT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.608778 m2; NetVolume: 0.00845657 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD
Mechanické - Klasifikace systému: Zpětné vedení teplé vody,Přívod teplé vody
Kóty - Dimenze potrubí: 15 mm; Objem: 0.00845657 m3; Odsazení od podlahy: 150 mm; Odsazení od stěny: 50 mm; Odsazení od stěny + 1/2 průměr trubky: 78.5 mm; Plocha: 0.304389 m2
Jiné - Id typu: 13011506; Rodina: Radiátor z žebrových trubek_dvouřadé_V; Rodina a typ: Radiátor z žebrových trubek_dvouřadé_V: Radiátor z žebrových trubek_dvouřadé_V 57x2.5x137 1500; Typ: Radiátor z žebrových trubek_dvouřadé_V 57x2.5x137 1500
Name (Radiátor z žebrových trubek_dvouřadé_V:Radiátor z žebrových trubek_dvouřadé_V 57x2.5x137 1500:...) | In | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
12776152 | 1.NP_SO-102 | 0 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | OT00.15.0015 | 0015
12778827 | 4.NP_SO-102 | 640 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | OT00.15.0039 | 0039
12983075 | 4.NP_SO-102 | 640 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | OT00.15.0098 | 0098
13045265 | 1.NP_SO-102 | 0 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | OT00.15.0183 | 0183
13255628 | 1.NP_SO-102 | 0 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | OT00.15.0221 | 0221

# IfcBuildingElementProxy: Radiátor z žebrových trubek_dvouřadé_V:Radiátor z žebrových trubek_dvouřadé_V 57x2.5x137 2000 (2)
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Text - Typ tělesa: SPIRAL RAO2-V
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - Celková výška: 2000 mm; Délka: 2000 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; Průměr: 57 mm; Průměr trubky: 57 mm; Rozestup trubek: 200 mm; Šířka: 137 mm; Výška: 282 mm
Type - Identifikační data - Číslo OmniClass: 23.75.00.00; Kód sestavy: OT00; Nadpis OmniClass: Climate Control (HVAC); Název typu: Radiátor z žebrových trubek_dvouřadé_V 57x2.5x137 2000; Označení typu: 33; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Radiátor z žebrových trubek_dvouřadé_V
Classification: OT00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.787848 m2; NetVolume: 0.0110082 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 1.NP_SO-102; Hostitel: Podlaží : 1.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Zpětné vedení teplé vody,Přívod teplé vody
Kóty - Dimenze potrubí: 15 mm; Objem: 0.0110082 m3; Odsazení od podlahy: 150 mm; Odsazení od stěny: 50 mm; Odsazení od stěny + 1/2 průměr trubky: 78.5 mm; Plocha: 0.393924 m2
Jiné - Rodina: Radiátor z žebrových trubek_dvouřadé_V; Id typu: 13015246; Rodina a typ: Radiátor z žebrových trubek_dvouřadé_V: Radiátor z žebrových trubek_dvouřadé_V 57x2.5x137 2000; Typ: Radiátor z žebrových trubek_dvouřadé_V 57x2.5x137 2000
Name (Radiátor z žebrových trubek_dvouřadé_V:Radiátor z žebrových trubek_dvouřadé_V 57x2.5x137 2000:...) | Kód prvku | Označení
12821721 | OT00.33.0080 | 0080
12821829 | OT00.33.0081 | 0081

# IfcBuildingElementProxy: Radiátor z žebrových trubek_dvouřadé_V:Radiátor z žebrových trubek_dvouřadé_V 57x2.5x137 2500, Radiátor z žebrových trubek_dvouřadé_V:Radiátor z žebrových trubek_dvouřadé_V 57x2.5x137 2500:13016650
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Text - Typ tělesa: SPIRAL RAO2-V
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - Celková výška: 2500 mm; Délka: 2500 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; Průměr: 57 mm; Průměr trubky: 57 mm; Rozestup trubek: 200 mm; Šířka: 137 mm; Výška: 282 mm
Type - Identifikační data - Číslo OmniClass: 23.75.00.00; Kód sestavy: OT00; Nadpis OmniClass: Climate Control (HVAC); Název typu: Radiátor z žebrových trubek_dvouřadé_V 57x2.5x137 2500; Označení typu: 52; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Radiátor z žebrových trubek_dvouřadé_V
Classification: OT00 Uniformat (Uniformat); Group: HT_přívodní vodní (65 °C) 24
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.966919 m2; NetVolume: 0.0135598 m3
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD
Vazby - Odsazení od hostitele: 0 mm; Podlaží: -1.PP_SO-102; Výška od podlaží: 0 mm; Hostitel: Podlaží : -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Zpětné vedení teplé vody,Přívod teplé vody; Název systému: HT_přívodní vodní (65 °C) 24
Kóty - Dimenze potrubí: 15 mm; Objem: 0.0135598 m3; Odsazení od podlahy: 150 mm; Odsazení od stěny: 50 mm; Odsazení od stěny + 1/2 průměr trubky: 78.5 mm; Plocha: 0.48346 m2
Identifikační data - Kód prvku: OT00.52.0173; Označení: 0173
Jiné - Rodina: Radiátor z žebrových trubek_dvouřadé_V; Id typu: 13164074; Rodina a typ: Radiátor z žebrových trubek_dvouřadé_V: Radiátor z žebrových trubek_dvouřadé_V 57x2.5x137 2500; Typ: Radiátor z žebrových trubek_dvouřadé_V 57x2.5x137 2500

# IfcBuildingElementProxy: Radiátor z žebrových trubek_jednořadé_F:Radiátor z žebrových trubek_jednořadé_F 32x2.0x92 (4)
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Text - Typ tělesa: SPIRAL RA1-F
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - DN přípojky: 16 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; připojení: 8 mm; Průměr: 32 mm; Průměr trubky: 32 mm; Průměr vinutí: 92 mm; r: 16 mm; r2: 46 mm; Šířka: 92 mm; Výška: 192 mm
Type - Identifikační data - Číslo OmniClass: 23.85.50.14; Kód sestavy: OT00; Nadpis OmniClass: Telephone and Intercommunication Equipment; Název typu: Radiátor z žebrových trubek_jednořadé_F 32x2.0x92; Označení typu: 45; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Radiátor z žebrových trubek_jednořadé_F
Classification: OT00 Uniformat (Uniformat)
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 1.NP_SO-102; Hostitel: Podlaží : 1.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Přívod teplé vody,Zpětné vedení teplé vody
Jiné - Rodina: Radiátor z žebrových trubek_jednořadé_F; Id typu: 12988747; Rodina a typ: Radiátor z žebrových trubek_jednořadé_F: Radiátor z žebrových trubek_jednořadé_F 32x2.0x92; Typ: Radiátor z žebrových trubek_jednořadé_F 32x2.0x92
Name (Radiátor z žebrových trubek_jednořadé_F:Radiátor z žebrových trubek_jednořadé_F 32x2.0x92:...) | NetSurfaceArea (m2) | NetVolume (m3) = Objem (m3) | Délka (mm) | Plocha (m2) | Kód prvku | Označení
12990089 | 0.644213 | 0.0136031 | 2000 | 0.322106 | OT00.45.0106 | 0106
12990200 | 0.644213 | 0.0136031 | 2000 | 0.322106 | OT00.45.0107 | 0107
13123940 | 0.933239 | 0.0202504 | 3000 | 0.46662 | OT00.45.0186 | 0186
13124171 | 0.933239 | 0.0202504 | 3000 | 0.46662 | OT00.45.0187 | 0187

# IfcBuildingElementProxy: Radiátor z žebrových trubek_jednořadé_F:Radiátor z žebrových trubek_jednořadé_F 57x2.5x137 (40)
Type - Material: <Unnamed>
Type - Text - Typ tělesa: SPIRAL RA1-F
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - DN přípojky: 16 mm; Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; připojení: 8 mm; Průměr: 57 mm; Průměr trubky: 57 mm; Průměr vinutí: 137 mm; r: 28.5 mm; r2: 68.5 mm; Šířka: 137 mm; Výška: 237 mm
Type - Identifikační data - Číslo OmniClass: 23.85.50.14; Kód sestavy: OT00; Nadpis OmniClass: Telephone and Intercommunication Equipment; Název typu: Radiátor z žebrových trubek_jednořadé_F 57x2.5x137; Označení typu: 14; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Radiátor z žebrových trubek_jednořadé_F
Classification: OT00 Uniformat (Uniformat)
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Mechanické - Klasifikace systému: Přívod teplé vody,Zpětné vedení teplé vody
Jiné - Id typu: 12988745; Rodina: Radiátor z žebrových trubek_jednořadé_F; Rodina a typ: Radiátor z žebrových trubek_jednořadé_F: Radiátor z žebrových trubek_jednořadé_F 57x2.5x137; Typ: Radiátor z žebrových trubek_jednořadé_F 57x2.5x137
Name (Radiátor z žebrových trubek_jednořadé_F:Radiátor z žebrových trubek_jednořadé_F 57x2.5x137:...) | In | NetSurfaceArea (m2) | NetVolume (m3) = Objem (m3) | Hostitel | Podlaží | Fáze vytvoření | Délka (mm) | Plocha (m2) | Kód prvku | Označení
12775764 | 1.NP_SO-102 | 0.763725 | 0.0227364 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | 1500 | 0.381862 | OT00.14.0014 | 0014
12776305 | 1.NP_SO-102 | 2.70052 | 0.0890684 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | 6000 | 1.35026 | OT00.14.0017 | 0017
12776338 | 1.NP_SO-102 | 0.978924 | 0.0301066 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | 2000 | 0.489462 | OT00.14.0018 | 0018
12776642 | 2.NP_SO-102 | 0.763725 | 0.0227364 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | 1500 | 0.381862 | OT00.14.0022 | 0022
12776771 | 2.NP_SO-102 | 0.763725 | 0.0227364 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | 1500 | 0.381862 | OT00.14.0023 | 0023
12777346 | 3.NP_SO-102 | 1.40932 | 0.0448471 | Podlaží : 3.NP_SO-102 | 3.NP_SO-102 | Fáze 1 | 3000 | 0.704661 | OT00.14.0029 | 0029
12777470 | 3.NP_SO-102 | 0.763725 | 0.0227364 | Podlaží : 3.NP_SO-102 | 3.NP_SO-102 | Fáze 1 | 1500 | 0.381862 | OT00.14.0030 | 0030
12777482 | 3.NP_SO-102 | 0.763725 | 0.0227364 | Podlaží : 3.NP_SO-102 | 3.NP_SO-102 | Fáze 1 | 1500 | 0.381862 | OT00.14.0031 | 0031
12777494 | 3.NP_SO-102 | 0.978924 | 0.0301066 | Podlaží : 3.NP_SO-102 | 3.NP_SO-102 | Fáze 1 | 2000 | 0.489462 | OT00.14.0032 | 0032
12778448 | 4.NP_SO-102 | 0.763725 | 0.0227364 | Podlaží : 4.NP_SO-102 | 4.NP_SO-102 | Fáze 1 | 1500 | 0.381862 | OT00.14.0035 | 0035
12778506 | 4.NP_SO-102 | 0.763725 | 0.0227364 | Podlaží : 4.NP_SO-102 | 4.NP_SO-102 | Fáze 1 | 1500 | 0.381862 | OT00.14.0036 | 0036
12778721 | 4.NP_SO-102 | 2.27012 | 0.074328 | Podlaží : 4.NP_SO-102 | 4.NP_SO-102 | Fáze 1 | 5000 | 1.13506 | OT00.14.0037 | 0037
12778969 | 4.NP_SO-102 | 0.548526 | 0.0153662 | Podlaží : 4.NP_SO-102 | 4.NP_SO-102 | Fáze 2 | 1000 | 0.274263 | OT00.14.0040 | 0040
12779027 | 4.NP_SO-102 | 0.548526 | 0.0153662 | Podlaží : 4.NP_SO-102 | 4.NP_SO-102 | Fáze 2 | 1000 | 0.274263 | OT00.14.0041 | 0041
12779039 | 4.NP_SO-102 | 0.548526 | 0.0153662 | Podlaží : 4.NP_SO-102 | 4.NP_SO-102 | Fáze 2 | 1000 | 0.274263 | OT00.14.0042 | 0042
12779049 | 4.NP_SO-102 | 0.763725 | 0.0227364 | Podlaží : 4.NP_SO-102 | 4.NP_SO-102 | Fáze 2 | 1500 | 0.381862 | OT00.14.0043 | 0043
12779169 | 4.NP_SO-102 | 0.763725 | 0.0227364 | Podlaží : 4.NP_SO-102 | 4.NP_SO-102 | Fáze 2 | 1500 | 0.381862 | OT00.14.0044 | 0044
12779247 | 3.NP_SO-102 | 2.27012 | 0.074328 | Podlaží : 3.NP_SO-102 | 3.NP_SO-102 | Fáze 2 | 5000 | 1.13506 | OT00.14.0045 | 0045
12779359 | 3.NP_SO-102 | 0.333327 | 0.00799599 | Podlaží : 3.NP_SO-102 | 3.NP_SO-102 | Fáze 2 | 500 | 0.166663 | OT00.14.0047 | 0047
12779367 | 3.NP_SO-102 | 0.333327 | 0.00799599 | Podlaží : 3.NP_SO-102 | 3.NP_SO-102 | Fáze 2 | 500 | 0.166663 | OT00.14.0048 | 0048
12779377 | 3.NP_SO-102 | 0.333327 | 0.00799599 | Podlaží : 3.NP_SO-102 | 3.NP_SO-102 | Fáze 2 | 500 | 0.166663 | OT00.14.0049 | 0049
12779824 | 2.NP_SO-102 | 0.333327 | 0.00799599 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 2 | 500 | 0.166663 | OT00.14.0050 | 0050
12779832 | 2.NP_SO-102 | 0.333327 | 0.00799599 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 2 | 500 | 0.166663 | OT00.14.0051 | 0051
12779840 | 2.NP_SO-102 | 0.333327 | 0.00799599 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 2 | 500 | 0.166663 | OT00.14.0052 | 0052
12780141 | 1.NP_SO-102 | 0.548526 | 0.0153662 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 2 | 1000 | 0.274263 | OT00.14.0054 | 0054
12989728 | -1.PP_SO-102 | 0.763725 | 0.0227364 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 2 | 1500 | 0.381862 | OT00.14.0101 | 0101
12989812 | -1.PP_SO-102 | 1.40932 | 0.0448471 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | 3000 | 0.704661 | OT00.14.0102 | 0102
12989892 | -1.PP_SO-102 | 1.19412 | 0.0374769 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | 2500 | 0.597062 | OT00.14.0103 | 0103
12990043 | -1.PP_SO-102 | 0.978924 | 0.0301066 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | 2000 | 0.489462 | OT00.14.0105 | 0105
12990502 | 1.NP_SO-102 | 0.978924 | 0.0301066 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | 2000 | 0.489462 | OT00.14.0112 | 0112
12991454 | 1.NP_SO-102 | 1.40932 | 0.0448471 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | 3000 | 0.704661 | OT00.14.0120 | 0120
12991764 | 1.NP_SO-102 | 1.40932 | 0.0448471 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | 3000 | 0.704661 | OT00.14.0123 | 0123
12991837 | 2.NP_SO-102 | 1.19412 | 0.0374769 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | 2500 | 0.597062 | OT00.14.0124 | 0124
13017183 | 1.NP_SO-102 | 0.763725 | 0.0227364 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | 1500 | 0.381862 | OT00.14.0174 | 0174
13017351 | 1.NP_SO-102 | 0.548526 | 0.0153662 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 2 | 1000 | 0.274263 | OT00.14.0175 | 0175
13017393 | 1.NP_SO-102 | 0.548526 | 0.0153662 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 2 | 1000 | 0.274263 | OT00.14.0176 | 0176
13025096 | 3.NP_SO-102 | 0.978924 | 0.0301066 | Podlaží : 3.NP_SO-102 | 3.NP_SO-102 | Fáze 1 | 2000 | 0.489462 | OT00.14.0179 | 0179
13034023 | 4.NP_SO-102 | 2.27012 | 0.074328 | Podlaží : 4.NP_SO-102 | 4.NP_SO-102 | Fáze 1 | 5000 | 1.13506 | OT00.14.0180 | 0180
13034108 | 4.NP_SO-102 | 1.83972 | 0.0595875 | Podlaží : 4.NP_SO-102 | 4.NP_SO-102 | Fáze 1 | 4000 | 0.91986 | OT00.14.0181 | 0181
13105839 | 4.NP_SO-102 | 0.763725 | 0.0227364 | Podlaží : 4.NP_SO-102 | 4.NP_SO-102 | Fáze 2 | 1500 | 0.381862 | OT00.14.0184 | 0184

# IfcBuildingElementProxy: Rozdělovač podlahového vytápění:1150x895x150, Rozdělovač podlahového vytápění:1150x895x150:13209989
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - Délka: 1150 mm; hloubka skříně: 150 mm; Šířka: 150 mm; šířka skříně: 1150 mm; Výška: 895 mm; výška skříně: 895 mm
Type - Identifikační data - Číslo OmniClass: 23.75.00.00; Kód sestavy: RS01; Nadpis OmniClass: Climate Control (HVAC); Název typu: 1150x895x150; Označení typu: 60; Popis sestavy: Patrový
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Rozdělovač podlahového vytápění
Classification: RS01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.60816 m2; NetVolume: 0.0371604 m3
Text - CCI Funkční systém: H; CCI Komponenta: UCA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 2.NP_SO-102; Hostitel: Podlaží : 2.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0371604 m3; Plocha: 2.30408 m2
Identifikační data - ID pozice: 03; ID systému: 7; Kód prvku: RS01.60.0205; Komentáře: Rozdělovač podlahového vytápění; Označení: 0205
Jiné - Páteřní trasa: yes; Rodina: Rozdělovač podlahového vytápění; Id typu: 13209807; Rodina a typ: Rozdělovač podlahového vytápění: 1150x895x150; Typ: 1150x895x150

# IfcBuildingElementProxy: Rozdělovač podlahového vytápění:1300x895x150 (2)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - Délka: 1300 mm; hloubka skříně: 150 mm; Šířka: 150 mm; šířka skříně: 1300 mm; Výška: 895 mm; výška skříně: 895 mm
Type - Identifikační data - Číslo OmniClass: 23.75.00.00; Kód sestavy: RS01; Nadpis OmniClass: Climate Control (HVAC); Název typu: 1300x895x150; Označení typu: 58; Popis sestavy: Patrový
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Rozdělovač podlahového vytápění
Classification: RS01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.15476 m2; NetVolume: 0.0414564 m3
Text - CCI Funkční systém: H; CCI Komponenta: UCA
Vazby - Přesunout s blízkými prvky: no; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0414564 m3; Plocha: 2.57738 m2
Identifikační data - ID systému: 7
Jiné - Páteřní trasa: yes; Id typu: 13209801; Rodina: Rozdělovač podlahového vytápění; Rodina a typ: Rozdělovač podlahového vytápění: 1300x895x150; Typ: 1300x895x150
Name (Rozdělovač podlahového vytápění:1300x895x150:...) | In | CCI Technický systém | Podlaží | Hostitel | ID pozice | Kód prvku | Komentáře | Označení
13209827 | -1.PP_SO-102 | HD | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 01 | RS01.58.0203 | Rozdělovač podlahového vytápění | 0203
13210230 | 3.NP_SO-102 | HE | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 05 | RS01.58.0208 | Rozdělovač stropního vytápění/chlazení | 0208

# IfcBuildingElementProxy: Rozdělovač podlahového vytápění:550x895x150, Rozdělovač podlahového vytápění:550x895x150:13210097
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - Délka: 550 mm; hloubka skříně: 150 mm; Šířka: 150 mm; šířka skříně: 550 mm; Výška: 895 mm; výška skříně: 895 mm
Type - Identifikační data - Číslo OmniClass: 23.75.00.00; Kód sestavy: RS01; Nadpis OmniClass: Climate Control (HVAC); Název typu: 550x895x150; Označení typu: 61; Popis sestavy: Patrový
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Rozdělovač podlahového vytápění
Classification: RS01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.42176 m2; NetVolume: 0.0199764 m3
Text - CCI Funkční systém: H; CCI Komponenta: UCA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 2.NP_SO-102; Hostitel: Podlaží : 2.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0199764 m3; Plocha: 1.21088 m2
Identifikační data - ID pozice: 04; ID systému: 7; Kód prvku: RS01.61.0207; Komentáře: Rozdělovač stropního vytápění/chlazení; Označení: 0207
Jiné - Páteřní trasa: yes; Rodina: Rozdělovač podlahového vytápění; Id typu: 13209805; Rodina a typ: Rozdělovač podlahového vytápění: 550x895x150; Typ: 550x895x150

# IfcBuildingElementProxy: Rozdělovač podlahového vytápění:750x895x150 (2)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - Délka: 750 mm; hloubka skříně: 150 mm; Šířka: 150 mm; šířka skříně: 750 mm; Výška: 895 mm; výška skříně: 895 mm
Type - Identifikační data - Číslo OmniClass: 23.75.00.00; Kód sestavy: RS01; Nadpis OmniClass: Climate Control (HVAC); Název typu: 750x895x150; Označení typu: 59; Popis sestavy: Patrový
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Rozdělovač podlahového vytápění
Classification: RS01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.15056 m2; NetVolume: 0.0257044 m3
Text - CCI Funkční systém: H; CCI Komponenta: UCA; CCI Technický systém: HD
Vazby - Přesunout s blízkými prvky: no; Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.0257044 m3; Plocha: 1.57528 m2
Identifikační data - ID systému: 7; Komentáře: Rozdělovač podlahového vytápění
Jiné - Páteřní trasa: yes; Rodina: Rozdělovač podlahového vytápění; Id typu: 13209811; Rodina a typ: Rozdělovač podlahového vytápění: 750x895x150; Typ: 750x895x150
Name (Rozdělovač podlahového vytápění:750x895x150:...) | In | Podlaží | Hostitel | ID pozice | Kód prvku | Označení
13209970 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 06 | RS01.59.0204 | 0204
13210013 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 02 | RS01.59.0206 | 0206

# IfcBuildingElementProxy: Rozdělovač:DN 200 dl 1500 (3)
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Průtok: 0 m3/s; Tlaková ztráta: 0 Pa
Type - Kóty - b1: 150 mm; b2: 500 mm; b3: 500 mm; Délka: 1500 mm; Délka připojení: 100 mm; DN_in: 125 mm; DN1: 65 mm; DN2: 65 mm; DN3: 125 mm; Průměr: 219 mm; Šířka: 219 mm; Šířka zaoblení: 105 mm; Tloušťka příruby: 20 mm; Výška: 369 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.00; Copyright: Pro Spacetechnic vyrobil CADconsulting, v. 2011; Kód sestavy: RS00; Nadpis OmniClass: Distribution of Supplied Liquids/Gases; Název typu: DN 200 dl 1500; Označení typu: 36; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Mechanické zařízení; A: 46.2018 deg; B: 43.7982 deg; Název rodiny: Rozdělovač; Počet okruhů: 3; PS: 109.5 mm; r: 109.596 mm; r1: 32.5 mm; r2: 32.5 mm; r3: 62.5 mm; r4: 40 mm; rin: 62.5 mm; rp1: 72.5 mm; rp2: 72.5 mm; rp3: 102.5 mm; rp4: 80 mm; rp5: 80 mm; rpin: 102.5 mm; VH: 209.5 mm
Classification: RS00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.32656 m2; NetVolume: 0.0588481 m3
Text - CCI Funkční systém: H; CCI Komponenta: WPA
Vazby - Podlaží: 2.NP_SO-102; Hostitel: Podlaží : 2.NP_SO-102; Odsazení od hostitele: 1000 mm; Výška od podlaží: 1000 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Zpětné vedení teplé vody
Kóty - Objem: 0.0588481 m3; Plocha: 0.663282 m2
Identifikační data - ID systému: 4; Komentáře: Rozdělovač, 3 okruhy
Jiné - Páteřní trasa: yes; Id typu: 13201550; Rodina: Rozdělovač; Rodina a typ: Rozdělovač: DN 200 dl 1500; Typ: DN 200 dl 1500
Name (Rozdělovač:DN 200 dl 1500:...) | CCI Technický systém | Název systému | ID pozice | Kód prvku | Označení | Group
12860398 | HD | HT_přívodní vodní (55 °C) 13,HT_přívodní vodní (55 °C) 26,HT_přívodní vodní (65 °C) 8,HT_PRIMÁR_vratné 1 | 03 | RS00.36.0084 | 0084 | HT_přívodní vodní (55 °C) 13; HT_přívodní vodní (55 °C) 26; HT_přívodní vodní (65 °C) 8; HT_PRIMÁR_vratné 1
12903824 | HC | CL_přívodní vodní (10 °C) 5,CL_přívodní vodní (10 °C) 6,CL_přívodní vodní (10 °C) 7 | 02 | RS00.36.0091 | 0091 | CL_přívodní vodní (10 °C) 5; CL_přívodní vodní (10 °C) 6; CL_přívodní vodní (10 °C) 7
13200217 | HC | CL_přívodní vodní (10 °C) 1,CL_přívodní vodní (10 °C) 4,HT/CL_přívodní vodní 1 | 01 | RS00.36.0197 | 0197 | HT/CL_přívodní vodní 1; CL_přívodní vodní (10 °C) 1; CL_přívodní vodní (10 °C) 4

# IfcBuildingElementProxy: Rozdělovač‌:DN 200 dl 1500, Rozdělovač‌:DN 200 dl 1500:13204069
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Průtok: 0 m3/s; Tlaková ztráta: 0 Pa
Type - Kóty - b1: 150 mm; b2: 300 mm; b3: 300 mm; b4: 300 mm; b5: 300 mm; Délka: 1500 mm; Délka připojení: 150 mm; DN_in: 125 mm; DN1: 80 mm; DN2: 80 mm; DN3: 80 mm; DN4: 80 mm; Průměr: 219 mm; Šířka: 219 mm; Šířka zaoblení: 50 mm; Tloušťka příruby: 20 mm; Výška: 369 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.00; Copyright: Pro Spacetechnic vyrobil CADconsulting, v. 2011; Kód sestavy: RS00; Nadpis OmniClass: Distribution of Supplied Liquids/Gases; Název typu: DN 200 dl 1500; Označení typu: 55; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Mechanické zařízení; a: 120.375 mm; A_2: 65.4576 deg; B: 24.5424 deg; Název rodiny: Rozdělovač‌; Počet okruhů: 4; PS: 109.5 mm; r: 144.903 mm; r1: 40 mm; r2: 40 mm; r3: 40 mm; r4: 40 mm; rin: 62.5 mm; rp1: 80 mm; rp2: 80 mm; rp3: 80 mm; rp4: 80 mm; rp5: 80 mm; rpin: 102.5 mm; VH: 259.5 mm
Classification: RS00 Uniformat (Uniformat); Group: HT_přívodní vodní (65 °C) 5; HT_přívodní vodní (65 °C) 32
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.3453 m2; NetVolume: 0.0545469 m3
Text - CCI Funkční systém: H; CCI Komponenta: WPA; CCI Technický systém: HD
Vazby - Podlaží: -1.PP_SO-102; Hostitel: Podlaží : -1.PP_SO-102; Odsazení od hostitele: 1000 mm; Výška od podlaží: 1000 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Přívod teplé vody; Název systému: HT_přívodní vodní (65 °C) 5,HT_přívodní vodní (65 °C) 32
Kóty - Objem: 0.0545469 m3; Plocha: 0.672649 m2
Identifikační data - ID pozice: 04; ID systému: 4; Kód prvku: RS00.55.0200; Komentáře: Rozdělovač, 4 okruhy; Označení: 0200
Jiné - Hmotnost zařízení: 0; Páteřní trasa: yes; Typ: DN 200 dl 1500; Id typu: 13204047; Rodina: Rozdělovač‌; Rodina a typ: Rozdělovač‌: DN 200 dl 1500

# IfcBuildingElementProxy: Rozdělovač‍:DN 200 dl 2100, Rozdělovač‍:DN 200 dl 2100:12856536
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Průtok: 0 m3/s; Tlaková ztráta: 0 Pa
Type - Kóty - b1: 150 mm; b2: 300 mm; b3: 300 mm; b4: 300 mm; b5: 300 mm; b6: 300 mm; Délka: 2100 mm; Délka připojení: 150 mm; DN_in: 125 mm; DN1: 80 mm; DN2: 80 mm; DN3: 80 mm; DN4: 80 mm; DN5: 80 mm; DN6: 80 mm; Průměr: 219 mm; Šířka: 219 mm; Šířka zaoblení: 50 mm; Tloušťka příruby: 20 mm; Výška: 369 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.00; Copyright: Pro Spacetechnic vyrobil CADconsulting, v. 2011; Kód sestavy: RS00; Nadpis OmniClass: Distribution of Supplied Liquids/Gases; Název typu: DN 200 dl 2100; Označení typu: 34; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Mechanické zařízení; a: 120.375 mm; A_2: 65.4576 deg; B: 24.5424 deg; Název rodiny: Rozdělovač‍; Počet okruhů: 6; PS: 109.5 mm; r: 144.903 mm; r1: 40 mm; r2: 40 mm; r3: 40 mm; r4: 40 mm; r5: 40 mm; r6: 40 mm; rin: 62.5 mm; rp1: 80 mm; rp2: 80 mm; rp3: 80 mm; rp4: 80 mm; rp5: 80 mm; rp6: 80 mm; rpin: 102.5 mm; VH: 259.5 mm
Classification: RS00 Uniformat (Uniformat); Group: HT_přívodní vodní (55 °C) 28; HT/CL_přívodní vodní 1; HT_přívodní vodní (55 °C) 25; HT_přívodní vodní (55 °C) 12; HT_přívodní vodní (55 °C) 2; HT_přívodní vodní (55 °C) 9; HT_přívodní vodní (55 °C) 1
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.91563 m2; NetVolume: 0.0792776 m3
Text - CCI Funkční systém: H; CCI Komponenta: WPA; CCI Technický systém: HD
Vazby - Podlaží: 2.NP_SO-102; Hostitel: Podlaží : 2.NP_SO-102; Odsazení od hostitele: 1000 mm; Výška od podlaží: 1000 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Přívod teplé vody; Název systému: HT_přívodní vodní (55 °C) 28,HT/CL_přívodní vodní 1,HT_přívodní vodní (55 °C) 25,HT_přívodní vodní (55 °C) 12,HT_přívodní vodní (55 °C) 2,HT_přívodní vodní (55 °C) 9,HT_přívodní vodní (55 °C) 1
Kóty - Objem: 0.0792776 m3; Plocha: 0.957815 m2
Identifikační data - ID pozice: 05; ID systému: 4; Kód prvku: RS00.34.0082; Komentáře: Rozdělovač, 6 okruhů; Označení: 0082
Jiné - Hmotnost zařízení: 0; Id typu: 12856518; Páteřní trasa: yes; Rodina: Rozdělovač‍; Rodina a typ: Rozdělovač‍: DN 200 dl 2100; Typ: DN 200 dl 2100

# IfcBuildingElementProxy: SPLIT venkovní jednotka:SPLIT venkovní jednotka (3)
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - délka: 560 mm; šířka: 700 mm; výška: 1140 mm
Type - Identifikační data - Číslo OmniClass: 23.75.00.00; Kód sestavy: ML05; Nadpis OmniClass: Climate Control (HVAC); Název typu: SPLIT venkovní jednotka; Označení typu: 65; Popis sestavy: Venkovní kondenzační jednotka
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: SPLIT venkovní jednotka
Classification: ML05 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.6568 m2; NetVolume: 0.44688 m3
Text - CCI Funkční systém: H; CCI Komponenta: EGA; CCI Technický systém: HC
Vazby - Přesunout s blízkými prvky: no; Podlaží: -1.PP_SO-102; Hostitel: Podlaží : -1.PP_SO-102; Odsazení od hostitele: 2000 mm; Výška od podlaží: 2000 mm
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.44688 m3; Plocha: 1.8284 m2
Identifikační data - ID systému: 6; Komentáře: Split venkovní jednotka, chlazení serveroven
Jiné - Páteřní trasa: yes; Id typu: 13267014; Rodina: SPLIT venkovní jednotka; Rodina a typ: SPLIT venkovní jednotka: SPLIT venkovní jednotka; Typ: SPLIT venkovní jednotka
Name (SPLIT venkovní jednotka:SPLIT venkovní jednotka:...) | ID pozice | Kód prvku | Označení
13267030 | 12 | ML05.65.0226 | 0226
13267055 | 13 | ML05.65.0227 | 0227
13267063 | 14 | ML05.65.0228 | 0228

# IfcBuildingElementProxy: SPLIT vnitřní jednotka:SPLIT vnitřní jednotka (3)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - Hloubka: 215 mm; Šířka: 867 mm; Výška: 305 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.17.27; Kód sestavy: ML02; Nadpis OmniClass: Fan Coil Units; Název typu: SPLIT vnitřní jednotka; Označení typu: 64; Popis: L; Popis sestavy: Vnitřní podstropní jednotka
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: SPLIT vnitřní jednotka
Classification: ML02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.03283 m2; NetVolume: 0.0568535 m3
Mechanické – tok - Průtok_vzduch: 0.0277778 m3/s; Tlaková ztráta_vzduch: 40 Pa
Text - CCI Funkční systém: H; CCI Komponenta: EQD; CCI Technický systém: HC
Vazby - Přesunout s blízkými prvky: no
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Průtok: 0.00006 m3/s; Tlaková ztráta: 6000 Pa
Kóty - Objem: 0.0568535 m3; Plocha: 0.516415 m2
Identifikační data - ID systému: 6; Komentáře: Split vnitřní jednotka, chlazení serveroven
Jiné - Páteřní trasa: yes; Id typu: 13266183; Rodina: SPLIT vnitřní jednotka; Rodina a typ: SPLIT vnitřní jednotka: SPLIT vnitřní jednotka; Typ: SPLIT vnitřní jednotka
Name (SPLIT vnitřní jednotka:SPLIT vnitřní jednotka:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | ID pozice | Kód prvku | Označení
13266199 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2450 | 17 | ML02.64.0224 | 0224
13266220 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2800 | 16 | ML02.64.0225 | 0225
13271472 | -2.PP_SO-102 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 2900 | 15 | ML02.64.0229 | 0229

# IfcBuildingElementProxy: Sběrač:DN 200 dl 1500 (3)
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Průtok: 0 m3/s; Tlaková ztráta: 0 Pa
Type - Kóty - b1: 150 mm; b2: 500 mm; b3: 500 mm; Délka: 1500 mm; Délka připojení: 100 mm; DN_in: 125 mm; DN1: 65 mm; DN2: 65 mm; DN3: 125 mm; Průměr: 219 mm; Šířka: 219 mm; Šířka zaoblení: 105 mm; Tloušťka příruby: 20 mm; Výška: 369 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.00; Copyright: Pro Spacetechnic vyrobil CADconsulting, v. 2011; Kód sestavy: RS00; Nadpis OmniClass: Distribution of Supplied Liquids/Gases; Název typu: DN 200 dl 1500; Označení typu: 37; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Mechanické zařízení; Počet okruhů: 3; A: 46.2018 deg; B: 43.7982 deg; Název rodiny: Sběrač; PS: 109.5 mm; r: 109.596 mm; r1: 32.5 mm; r2: 32.5 mm; r3: 62.5 mm; r4: 40 mm; rin: 62.5 mm; rp1: 72.5 mm; rp2: 72.5 mm; rp3: 102.5 mm; rp4: 80 mm; rp5: 80 mm; rpin: 102.5 mm; VH: 209.5 mm
Classification: RS00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.32656 m2; NetVolume: 0.0588481 m3
Text - CCI Funkční systém: H; CCI Komponenta: WPA
Vazby - Podlaží: 2.NP_SO-102; Hostitel: Podlaží : 2.NP_SO-102; Odsazení od hostitele: 1000 mm; Výška od podlaží: 1000 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Zpětné vedení teplé vody
Kóty - Objem: 0.0588481 m3; Plocha: 0.663282 m2
Identifikační data - ID systému: 4; Komentáře: Sběrač, 3 okruhy
Jiné - Páteřní trasa: yes; Typ: DN 200 dl 1500; Id typu: 12853204; Rodina: Sběrač; Rodina a typ: Sběrač: DN 200 dl 1500
Name (Sběrač:DN 200 dl 1500:...) | CCI Technický systém | Název systému | ID pozice | Kód prvku | Označení | Group
12860437 | HD | HT_vratné vodní (45 °C) 20,HT_vratné vodní (45 °C) 21,HT_vratné vodní (45 °C) 23,HT_vratné vodní (45 °C) 5 | 03 | RS00.37.0085 | 0085 | HT_vratné vodní (45 °C) 20; HT_vratné vodní (45 °C) 21; HT_vratné vodní (45 °C) 23; HT_vratné vodní (45 °C) 5
12903825 | HC | CL_vratné vodní (15 °C) 5,CL_vratné vodní (15 °C) 6,CL_vratné vodní (15 °C) 4 | 02 | RS00.37.0092 | 0092 | CL_vratné vodní (15 °C) 5; CL_vratné vodní (15 °C) 6; CL_vratné vodní (15 °C) 4
13200218 | HC | CL_vratné vodní (15 °C) 2,CL_vratné vodní (15 °C) 8,HT/CL_vratné vodní 1 | 01 | RS00.37.0198 | 0198 | HT/CL_vratné vodní 1; CL_vratné vodní (15 °C) 2; CL_vratné vodní (15 °C) 8

# IfcBuildingElementProxy: Sběrač‌:DN 200 dl 1500, Sběrač‌:DN 200 dl 1500:13206068
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Průtok: 0 m3/s; Tlaková ztráta: 0 Pa
Type - Kóty - b1: 150 mm; b2: 300 mm; b3: 300 mm; b4: 300 mm; b5: 300 mm; Délka: 1500 mm; Délka připojení: 150 mm; DN_in: 125 mm; DN1: 80 mm; DN2: 80 mm; DN3: 80 mm; DN4: 80 mm; Průměr: 219 mm; Šířka: 219 mm; Šířka zaoblení: 50 mm; Tloušťka příruby: 20 mm; Výška: 369 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.00; Copyright: Pro Spacetechnic vyrobil CADconsulting, v. 2011; Kód sestavy: RS00; Nadpis OmniClass: Distribution of Supplied Liquids/Gases; Název typu: DN 200 dl 1500; Označení typu: 56; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Mechanické zařízení; Počet okruhů: 4; a: 120.375 mm; A_2: 65.4576 deg; B: 24.5424 deg; Název rodiny: Sběrač‌; PS: 109.5 mm; r: 144.903 mm; r1: 40 mm; r2: 40 mm; r3: 40 mm; r4: 40 mm; rin: 62.5 mm; rp1: 80 mm; rp2: 80 mm; rp3: 80 mm; rp4: 80 mm; rp5: 80 mm; rpin: 102.5 mm; VH: 259.5 mm
Classification: RS00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.3453 m2; NetVolume: 0.0545469 m3
Text - CCI Funkční systém: H; CCI Komponenta: WPA; CCI Technický systém: HD
Vazby - Podlaží: -1.PP_SO-102; Hostitel: Podlaží : -1.PP_SO-102; Odsazení od hostitele: 1000 mm; Výška od podlaží: 1000 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Přívod teplé vody
Kóty - Objem: 0.0545469 m3; Plocha: 0.672649 m2
Identifikační data - ID pozice: 04; ID systému: 4; Kód prvku: RS00.56.0201; Komentáře: Sběrač, 4 okruhy; Označení: 0201
Jiné - Hmotnost zařízení: 0; Páteřní trasa: yes; Typ: DN 200 dl 1500; Id typu: 13206046; Rodina: Sběrač‌; Rodina a typ: Sběrač‌: DN 200 dl 1500

# IfcBuildingElementProxy: Sběrač‍:DN 200 dl 2100, Sběrač‍:DN 200 dl 2100:12857599
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Průtok: 0 m3/s; Tlaková ztráta: 0 Pa
Type - Kóty - b1: 150 mm; b2: 300 mm; b3: 300 mm; b4: 300 mm; b5: 300 mm; b6: 300 mm; Délka: 2100 mm; Délka připojení: 150 mm; DN_in: 125 mm; DN1: 80 mm; DN2: 80 mm; DN3: 80 mm; DN4: 80 mm; DN5: 80 mm; DN6: 80 mm; Průměr: 219 mm; Šířka: 219 mm; Šířka zaoblení: 50 mm; Tloušťka příruby: 20 mm; Výška: 369 mm
Type - Identifikační data - Číslo OmniClass: 23.65.55.00; Copyright: Pro Spacetechnic vyrobil CADconsulting, v. 2011; Kód sestavy: RS00; Nadpis OmniClass: Distribution of Supplied Liquids/Gases; Název typu: DN 200 dl 2100; Označení typu: 35; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Mechanické zařízení; Počet okruhů: 6; A: 65.4576 deg; B: 24.5424 deg; Název rodiny: Sběrač‍; PS: 109.5 mm; r: 144.903 mm; r1: 40 mm; r2: 40 mm; r3: 40 mm; r4: 40 mm; r5: 40 mm; r6: 40 mm; rin: 62.5 mm; rp1: 80 mm; rp2: 80 mm; rp3: 80 mm; rp4: 80 mm; rp5: 80 mm; rp6: 80 mm; rpin: 102.5 mm; VH: 259.5 mm
Classification: RS00 Uniformat (Uniformat); Group: HT_vratné vodní (45 °C) 31; HT/CL_vratné vodní 1; HT_vratné vodní (45 °C) 26; HT_vratné vodní (45 °C) 9; HT_vratné vodní (45 °C) 10; HT_vratné vodní (45 °C) 1; HT_PRIMÁR_vratné 4
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.91563 m2; NetVolume: 0.0792776 m3
Text - CCI Funkční systém: H; CCI Komponenta: WPA; CCI Technický systém: HD
Vazby - Podlaží: 2.NP_SO-102; Hostitel: Podlaží : 2.NP_SO-102; Odsazení od hostitele: 1000 mm; Výška od podlaží: 1000 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Zpětné vedení teplé vody; Název systému: HT_vratné vodní (45 °C) 31,HT/CL_vratné vodní 1,HT_vratné vodní (45 °C) 26,HT_vratné vodní (45 °C) 9,HT_vratné vodní (45 °C) 10,HT_vratné vodní (45 °C) 1,HT_PRIMÁR_vratné 4
Kóty - Objem: 0.0792776 m3; Plocha: 0.957815 m2
Identifikační data - ID pozice: 05; ID systému: 4; Kód prvku: RS00.35.0083; Komentáře: Sběrač, 6 okruhy; Označení: 0083
Jiné - Páteřní trasa: yes; Typ: DN 200 dl 2100; Id typu: 12857581; Rodina: Sběrač‍; Rodina a typ: Sběrač‍: DN 200 dl 2100

# IfcBuildingElementProxy: Tepelné čerpadlo‍:Tepelné čerpadlo vzduch voda kompakt (10)
In: 4.NP_SO-102
Type - Material: <Unnamed>, bílá, červená heliotherm
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Maximální teplota: 58 C
Type - Kóty - Délka: 3900 mm; Jmenovitá velikost vstupu: 65 mm; Jmenovitá velikost výstupu: 65 mm; Šířka: 1136 mm; Výška: 1516 mm
Type - Identifikační data - Číslo OmniClass: 23.75.00.00; Kód sestavy: ZE06; Nadpis OmniClass: Climate Control (HVAC); Název typu: Tepelné čerpadlo vzduch voda kompakt; Označení typu: 63; Popis sestavy: Tepelné čerpadlo
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Tepelné čerpadlo‍
Classification: ZE06 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 80.6309 m2; NetVolume: 2.65836 m3
Energetická analýza - Chladící výkon: 55900 W; Topný výkon: 55500 W
Text - CCI Funkční systém: H; CCI Komponenta: EGA; CCI Technický systém: HE
Vazby - Hostitel: Podlaží : STŘECHA_SO-102; Odsazení od hostitele: 500 mm; Podlaží: STŘECHA_SO-102; Výška od podlaží: 500 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Zpětné vedení teplé vody,Přívod teplé vody
Kóty - Objem: 2.65836 m3; Plocha: 40.3155 m2
Identifikační data - ID systému: 1; Komentáře: Tepelné čerpadlo vzduch voda, topný výkon Qt=55,5kW, COP=4,2 (A2/w35), chladící výkon Qch=55,9 kW (A35/W18)
Jiné - Páteřní trasa: yes; Id typu: 13240494; Rodina: Tepelné čerpadlo‍; Rodina a typ: Tepelné čerpadlo‍: Tepelné čerpadlo vzduch voda kompakt; Typ: Tepelné čerpadlo vzduch voda kompakt
Name (Tepelné čerpadlo‍:Tepelné čerpadlo vzduch voda kompakt:...) | ID pozice | Kód prvku | Označení
13242452 | 01 | ZE06.63.0214 | 0214
13242454 | 02 | ZE06.63.0215 | 0215
13242456 | 03 | ZE06.63.0216 | 0216
13242458 | 04 | ZE06.63.0217 | 0217
13242460 | 07 | ZE06.63.0218 | 0218
13242462 | 06 | ZE06.63.0219 | 0219
13242464 | 05 | ZE06.63.0220 | 0220
13381357 | 08 | ZE06.63.0234 | 0234
13381396 | 09 | ZE06.63.0235 | 0235
13381397 | 10 | ZE06.63.0236 | 0236

# IfcBuildingElementProxy: Trubkové otopné těleso - střední připojení:TR 1500/450, Trubkové otopné těleso - střední připojení:TR 1500/450:12980713
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Text - Typ tělesa: TR
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Grafika - Napojení uprostřed: yes
Type - Kóty - Délka: 450 mm; Průměr trubky: 20 mm; Průměr trubky žebříku: 50 mm; Šířka: 47 mm; Výška: 1500 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.00.00; Kód sestavy: OT02; Model: Model; Nadpis OmniClass: Climate Control (HVAC); Název typu: TR 1500/450; Označení typu: 43; Popis: Otopné těleso; Popis sestavy: Trubkové; Výrobce: Výrobce
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Trubkové otopné těleso - střední připojení; Počet příček: 26; PZ: 25 mm
Classification: OT02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.18532 m2; NetVolume: 0.00939922 m3
Energetická analýza - Teplotní spád_Topení: 24; VÝKON TOPENÍ: 500 W
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 1.NP_SO-102; Hostitel: Podlaží : 1.NP_SO-102; Odsazení od podlahy: 150 mm; Odsazení od stěny: 50 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Přívod teplé vody,Zpětné vedení teplé vody; PRŮTOK_VYTÁPĚNÍ: 0.00000497572 m3/s; SPÁD TLAKU: 0.92 Pa
Kóty - Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; JMENOVITÝ PRŮMĚR: 15 mm; Objem: 0.00939922 m3
Identifikační data - Kód prvku: OT02.43.0096; Označení: 0096
Jiné - AP: 180 deg; AZ: 180 deg; Id typu: 12980986; ON: 200 mm; PP: 7.5 mm; Průměr připojení: 15 mm; Rodina: Trubkové otopné těleso - střední připojení; Rodina a typ: Trubkové otopné těleso - střední připojení: TR 1500/450; Typ: TR 1500/450; VN: 150 mm

# IfcBuildingElementProxy: Trubkové otopné těleso - střední připojení:TR 1500/600, Trubkové otopné těleso - střední připojení:TR 1500/600:13372867
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Text - Typ tělesa: TR
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Grafika - Napojení uprostřed: yes
Type - Kóty - Délka: 600 mm; Průměr trubky: 20 mm; Průměr trubky žebříku: 50 mm; Šířka: 47 mm; Výška: 1500 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.00.00; Kód sestavy: OT02; Model: Model; Nadpis OmniClass: Climate Control (HVAC); Název typu: TR 1500/600; Označení typu: 66; Popis: Otopné těleso; Popis sestavy: Trubkové; Výrobce: Výrobce
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Trubkové otopné těleso - střední připojení; Počet příček: 26; PZ: 25 mm
Classification: OT02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.43037 m2; NetVolume: 0.0106243 m3
Energetická analýza - Teplotní spád_Topení: 24; VÝKON TOPENÍ: 500 W
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD
Vazby - Odsazení od hostitele: 0 mm; Podlaží: -1.PP_SO-102; Výška od podlaží: 0 mm; Hostitel: Podlaží : -1.PP_SO-102; Odsazení od podlahy: 150 mm; Odsazení od stěny: 50 mm
Fázování - Fáze vytvoření: Fáze 2
Mechanické - Klasifikace systému: Přívod teplé vody,Zpětné vedení teplé vody; PRŮTOK_VYTÁPĚNÍ: 0.00000497572 m3/s; SPÁD TLAKU: 0.92 Pa
Kóty - Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; JMENOVITÝ PRŮMĚR: 15 mm; Objem: 0.0106243 m3
Identifikační data - Kód prvku: OT02.66.0233; Označení: 0233
Jiné - AP: 180 deg; AZ: 180 deg; Rodina: Trubkové otopné těleso - střední připojení; Id typu: 12918328; ON: 275 mm; PP: 7.5 mm; Průměr připojení: 15 mm; Rodina a typ: Trubkové otopné těleso - střední připojení: TR 1500/600; Typ: TR 1500/600; VN: 150 mm

# IfcBuildingElementProxy: Trubkové otopné těleso - střední připojení:TR 1820/750, Trubkové otopné těleso - střední připojení:TR 1820/750:12981799
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Text - Typ tělesa: TR
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Grafika - Napojení uprostřed: yes
Type - Kóty - Délka: 750 mm; Průměr trubky: 20 mm; Průměr trubky žebříku: 50 mm; Šířka: 47 mm; Výška: 1820 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.00.00; Kód sestavy: OT02; Model: Model; Nadpis OmniClass: Climate Control (HVAC); Název typu: TR 1820/750; Označení typu: 44; Popis: Otopné těleso; Popis sestavy: Trubkové; Výrobce: Výrobce
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Trubkové otopné těleso - střední připojení; Počet příček: 32; PZ: 25 mm
Classification: OT02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.04446 m2; NetVolume: 0.0144273 m3
Energetická analýza - Teplotní spád_Topení: 24; VÝKON TOPENÍ: 500 W
Text - CCI Funkční systém: H; CCI Komponenta: EPB; CCI Technický systém: HD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 2.NP_SO-102; Hostitel: Podlaží : 2.NP_SO-102; Odsazení od podlahy: 150 mm; Odsazení od stěny: 50 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Přívod teplé vody,Zpětné vedení teplé vody; PRŮTOK_VYTÁPĚNÍ: 0.00000497572 m3/s; SPÁD TLAKU: 0.92 Pa
Kóty - Jmenovitá velikost vstupu: 15 mm; Jmenovitá velikost výstupu: 15 mm; JMENOVITÝ PRŮMĚR: 15 mm; Objem: 0.0144273 m3
Identifikační data - Kód prvku: OT02.44.0097; Označení: 0097
Jiné - AP: 180 deg; AZ: 180 deg; Rodina: Trubkové otopné těleso - střední připojení; Id typu: 12981822; ON: 350 mm; PP: 7.5 mm; Průměr připojení: 15 mm; Rodina a typ: Trubkové otopné těleso - střední připojení: TR 1820/750; Typ: TR 1820/750; VN: 150 mm

# IfcBuildingElementProxy: Výměník tepla:Standardní (3)
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - Délka: 500 mm; Šířka: 400 mm; Výška: 980 mm
Type - Identifikační data - Kód sestavy: VI01; Název typu: Standardní; Označení typu: 42; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: Výměník tepla
Classification: VI01 Uniformat (Uniformat)
Text - CCI Funkční systém: H; CCI Komponenta: EGC; CCI Technický systém: HD
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: 2.NP_SO-102; Hostitel: Podlaží : 2.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Zpětné vedení teplé vody,Přívod teplé vody; Pokles tlaku vody 1: 0 Pa; Pokles tlaku vody 2: 0 Pa; Průtok vody 1: 0 m3/s; Průtok vody 2: 0 m3/s
