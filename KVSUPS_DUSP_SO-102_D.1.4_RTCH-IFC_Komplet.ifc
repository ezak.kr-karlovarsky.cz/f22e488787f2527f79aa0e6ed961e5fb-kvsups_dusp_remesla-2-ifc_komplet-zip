Properties of the parts of a building model (IFC4), part 69 of 72

# IfcPipeSegment: Typy trubek:Ocel_uhlíková (1186)
Name (Typy trubek:Ocel_uhlíková:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Tloušťka izolace (mm) | Celková velikost | Relativní drsnost | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) | Řez | Délka (mm) | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
13427269 | -1.PP_SO-102 | 613.325 | 0.00285535 | 0.116187 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 2966.66 | 2966.66 | 2353.34 | 2353.34 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1646.66 | 0.0963409 | 50 | 98 | 613.325 | ø50 | 60.3 | 53 | TR02.02.2256 | 2256 | yes | CL_vratné vodní (15 °C) 8
13427280 | -1.PP_SO-102 | 613.325 | 0.00285535 | 0.116187 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 2966.66 | 2966.66 | 2353.34 | 2353.34 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1646.66 | 0.0963409 | 50 | 119 | 613.325 | ø50 | 60.3 | 53 | TR02.02.2257 | 2257 | yes | CL_přívodní vodní (10 °C) 4
13427560 | -1.PP_SO-102 | 2122.37 | 0.00141175 | 0.282708 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2321.2 | 2300 | 2300 | 2278.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -1717.95 | 0.213364 | 32 | 36 | 2122.37 | ø32 | 42.4 | 35.9 | TR02.02.2258 | 2258 | yes | HT_vratné vodní (45 °C) 23 | 0 | Izolace - Typ izolace: Tepelná
13427580 | -1.PP_SO-102 | 2372.38 | 0.00141175 | 0.316009 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2321.2 | 2300 | 2300 | 2278.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -1717.95 | 0.238497 | 32 | 55 | 2372.38 | ø32 | 42.4 | 35.9 | TR02.02.2259 | 2259 | yes | HT_přívodní vodní (65 °C) 8 | 0 | Izolace - Typ izolace: Tepelná
13427670 | -1.PP_SO-102 | 352.375 | 0.00141175 | 0.0469376 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2676.19 | 2676.19 | 2323.81 | 2323.81 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -1676.19 | 0.0354246 | 32 | 55 | 352.375 | ø32 | 42.4 | 35.9 | TR02.02.2260 | 2260 | yes | HT_přívodní vodní (65 °C) 8 | Izolace - Typ izolace: Tepelná
13427709 | -1.PP_SO-102 | 352.375 | 0.00141175 | 0.0469376 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2676.19 | 2676.19 | 2323.81 | 2323.81 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -1676.19 | 0.0354246 | 32 | 36 | 352.375 | ø32 | 42.4 | 35.9 | TR02.02.2261 | 2261 | yes | HT_vratné vodní (45 °C) 23 | Izolace - Typ izolace: Tepelná
13427757 | -1.PP_SO-102 | 6789.77 | 0.00141175 | 0.904422 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2621.2 | 2600 | 2600 | 2578.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | -1417.95 | 0.682582 | 32 | 39 | 6789.77 | ø32 | 42.4 | 35.9 | TR02.02.2262 | 2262 | yes | HT_přívodní vodní (65 °C) 6 | 0 | Izolace - Typ izolace: Tepelná
13427776 | -1.PP_SO-102 | 6609.9 | 0.00141175 | 0.880462 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2621.2 | 2600 | 2600 | 2578.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -1417.95 | 0.664499 | 32 | 146 | 6609.9 | ø32 | 42.4 | 35.9 | TR02.02.2263 | 2263 | yes | HT_vratné vodní (45 °C) 2 | 0 | Izolace - Typ izolace: Tepelná
13427859 | -1.PP_SO-102 | 252.375 | 0.00141175 | 0.0336172 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2576.19 | 2323.81 | 2576.19 | 2323.81 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -1676.19 | 0.0253715 | 32 | 146 | 252.375 | ø32 | 42.4 | 35.9 | TR02.02.2264 | 2264 | yes | HT_vratné vodní (45 °C) 2 | Izolace - Typ izolace: Tepelná
13427899 | -1.PP_SO-102 | 252.375 | 0.00141175 | 0.0336172 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2576.19 | 2323.81 | 2576.19 | 2323.81 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | -1676.19 | 0.0253715 | 32 | 39 | 252.375 | ø32 | 42.4 | 35.9 | TR02.02.2265 | 2265 | yes | HT_přívodní vodní (65 °C) 6 | Izolace - Typ izolace: Tepelná
13431357 | 2.NP_SO-102 | 3943.64 | 0.00141175 | 0.525307 | 0 | ø32 mm | 0.00278552 | HC | 2.NP_SO-102 | 2869.84 | 2869.84 | -1073.81 | -1073.81 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 2926.19 | 0.396458 | 32 | 33 | 3943.64 | ø32 | 42.4 | 35.9 | TR02.02.2267 | 2267 | yes | CL_přívodní vodní (10 °C) 1
13431414 | 2.NP_SO-102 | 129.222 | 0.00141175 | 0.0172128 | 0 | ø32 mm | 0.00278552 | HC | 2.NP_SO-102 | 2921.2 | 2900 | 2900 | 2878.8 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 6882.05 | 0.0129908 | 32 | 10 | 129.222 | ø32 | 42.4 | 35.9 | TR02.02.2268 | 2268 | yes | CL_vratné vodní (15 °C) 2 | 0
13431430 | 2.NP_SO-102 | 395.779 | 0.00141175 | 0.0527192 | 0 | ø32 mm | 0.00278552 | HC | 2.NP_SO-102 | 2921.2 | 2900 | 2900 | 2878.8 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 6882.05 | 0.0397881 | 32 | 10 | 395.779 | ø32 | 42.4 | 35.9 | TR02.02.2269 | 2269 | yes | CL_vratné vodní (15 °C) 2 | 0
13431554 | 3.NP_SO-102 | 798.572 | 0.000356274 | 0.0534372 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | -39.35 | -50 | -50 | -60.65 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 7942 | 0.0376318 | 15 | 7 | 798.572 | ø15 | 21.3 | 16 | TR02.02.2270 | 2270 |  | HT_přívodní vodní (55 °C) 12 | 0
13431595 | 2.NP_SO-102 | 400.118 | 0.000891835 | 0.0423611 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 3016.85 | 3000 | 3000 | 2983.15 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 6986.4 | 0.0314252 | 25 | 130 | 400.118 | ø25 | 33.7 | 27.2 | TR02.02.2271 | 2271 | yes | HT_vratné vodní (45 °C) 9 | 0
13432217 | -1.PP_SO-102 | 217.775 | 0.000356274 | 0.0145726 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 2710.65 | 2700 | 2700 | 2689.35 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | -1308 | 0.0102624 | 15 | 576 | 217.775 | ø15 | 21.3 | 16 | TR02.02.2272 | 2272 | yes | HT_přívodní vodní (55 °C) 9 | 0
13432232 | -1.PP_SO-102 | 221.744 | 0.000356274 | 0.0148382 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 2710.65 | 2700 | 2700 | 2689.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -1308 | 0.0104494 | 15 | 838 | 221.744 | ø15 | 21.3 | 16 | TR02.02.2273 | 2273 | yes | HT_vratné vodní (45 °C) 1 | 0
13432291 | -1.PP_SO-102 | 371.425 | 0.000356274 | 0.0248542 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3085.71 | 3085.71 | 2714.29 | 2714.29 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | -1285.71 | 0.017503 | 15 | 576 | 371.425 | ø15 | 21.3 | 16 | TR02.02.2274 | 2274 | yes | HT_přívodní vodní (55 °C) 9
13432328 | -1.PP_SO-102 | 371.425 | 0.000356274 | 0.0248542 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3085.71 | 3085.71 | 2714.29 | 2714.29 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -1285.71 | 0.017503 | 15 | 838 | 371.425 | ø15 | 21.3 | 16 | TR02.02.2275 | 2275 | yes | HT_vratné vodní (45 °C) 1
13434282 | 3.NP_SO-102 | 20.0812 | 0.00183197 | 0.00304711 | 40 | ø120 mm | 0.00239234 | HD | 3.NP_SO-102 | -833.338 | -833.338 | -853.419 | -853.419 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7146.58 | 0.00252348 | 40 | 255 | 20.0812 | ø40 | 48.3 | 41.8 | TR02.02.2276 | 2276 | yes | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13434501 | 2.NP_SO-102 | 2418.75 | 0.000568237 | 0.204406 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7189.2 | 0.151974 | 20 | 555 | 2418.75 | ø20 | 26.9 | 21.6 | TR02.02.2277 | 2277 | yes | HT_vratné vodní (45 °C) 1 | 0
13434521 | 2.NP_SO-102 | 2320.67 | 0.000568237 | 0.196117 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 12 | 7269.2 | 0.145812 | 20 | 9 | 2320.67 | ø20 | 26.9 | 21.6 | TR02.02.2278 | 2278 | yes | HT_přívodní vodní (65 °C) 12 | 0
13434579 | 2.NP_SO-102 | 93.0142 | 0.000568237 | 0.00786052 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7189.2 | 0.00584425 | 20 | 555 | 93.0142 | ø20 | 26.9 | 21.6 | TR02.02.2279 | 2279 | yes | HT_vratné vodní (45 °C) 1 | 0
13434632 | 2.NP_SO-102 | 93.0142 | 0.000568237 | 0.00786052 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 12 | 7269.2 | 0.00584425 | 20 | 9 | 93.0142 | ø20 | 26.9 | 21.6 | TR02.02.2280 | 2280 | yes | HT_přívodní vodní (65 °C) 12 | 0
13435597 | -1.PP_SO-102 | 405.075 | 0.000568237 | 0.0342324 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3322.54 | 3322.54 | 2917.46 | 2917.46 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | -1082.54 | 0.0254516 | 20 | 551 | 405.075 | ø20 | 26.9 | 21.6 | TR02.02.2281 | 2281 | yes | HT_vratné vodní (45 °C) 13
13438359 | 2.NP_SO-102 | 3206.36 | 0.000356274 | 0.214556 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 2540.65 | 2530 | 2530 | 2519.35 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 6522 | 0.151096 | 15 | 37 | 3206.36 | ø15 | 21.3 | 16 | TR02.02.2282 | 2282 | yes | HT_přívodní vodní (55 °C) 12 | 0
13438367 | 2.NP_SO-102 | 31.425 | 0.000356274 | 0.00210283 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 2540.65 | 2530 | 2530 | 2519.35 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 6522 | 0.00148087 | 15 | 37 | 31.425 | ø15 | 21.3 | 16 | TR02.02.2283 | 2283 | yes | HT_přívodní vodní (55 °C) 12 | 0
13438399 | 2.NP_SO-102 | 541.425 | 0.000356274 | 0.03623 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 3085.71 | 3085.71 | 2544.29 | 2544.29 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 6544.29 | 0.0255141 | 15 | 37 | 541.425 | ø15 | 21.3 | 16 | TR02.02.2284 | 2284 | yes | HT_přívodní vodní (55 °C) 12
13438757 | 2.NP_SO-102 | 3092.54 | 0.00141175 | 0.411937 | 0 | ø32 mm | 0.00278552 | HC | 2.NP_SO-102 | 7346.98 | 4254.45 | 7346.98 | 4254.45 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 8254.45 | 0.310896 | 32 | 46 | 3092.54 | ø32 | 42.4 | 35.9 | TR02.02.2285 | 2285 | yes | CL_vratné vodní (15 °C) 2
13438792 | 2.NP_SO-102 | 1123.96 | 0.00141175 | 0.149715 | 0 | ø32 mm | 0.00278552 | HC | 2.NP_SO-102 | 4054.12 | 4054.12 | 2930.16 | 2930.16 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 6930.16 | 0.112992 | 32 | 53 | 1123.96 | ø32 | 42.4 | 35.9 | TR02.02.2286 | 2286 | yes | CL_přívodní vodní (10 °C) 1
13438851 | 2.NP_SO-102 | 1276.66 | 0.00141175 | 0.170055 | 0 | ø32 mm | 0.00278552 | HC | 2.NP_SO-102 | 4206.82 | 4206.82 | 2930.16 | 2930.16 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 6930.16 | 0.128344 | 32 | 46 | 1276.66 | ø32 | 42.4 | 35.9 | TR02.02.2287 | 2287 | yes | CL_vratné vodní (15 °C) 2
13438861 | 2.NP_SO-102 | 252.375 | 0.00141175 | 0.0336172 | 0 | ø32 mm | 0.00278552 | HC | 2.NP_SO-102 | 4251.83 | 4230.63 | 4230.63 | 4209.43 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 8212.68 | 0.0253715 | 32 | 46 | 252.375 | ø32 | 42.4 | 35.9 | TR02.02.2288 | 2288 | yes | CL_vratné vodní (15 °C) 2 | 0
13438887 | 2.NP_SO-102 | 252.375 | 0.00141175 | 0.0336172 | 0 | ø32 mm | 0.00278552 | HC | 2.NP_SO-102 | 4099.13 | 4077.93 | 4077.93 | 4056.73 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 8059.98 | 0.0253715 | 32 | 53 | 252.375 | ø32 | 42.4 | 35.9 | TR02.02.2289 | 2289 | yes | CL_přívodní vodní (10 °C) 1 | 0
13440100 | 1.NP_SO-102 | 1381.94 | 0.000568237 | 0.116786 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 2889.2 | 0.0868296 | 20 | 29 | 1381.94 | ø20 | 26.9 | 21.6 | TR02.02.2290 | 2290 | yes | CL_vratné vodní (15 °C) 2 | 0
13440178 | 1.NP_SO-102 | 1508.78 | 0.000568237 | 0.127506 | 0 | ø20 mm | 0.00462963 | HC | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 2889.2 | 0.0947997 | 20 | 25 | 1508.78 | ø20 | 26.9 | 21.6 | TR02.02.2291 | 2291 | yes | CL_přívodní vodní (10 °C) 1 | 0
13445671 | 2.NP_SO-102 | 12.0562 | 0.00183197 | 0.0018294 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2566.66 | 2554.61 | 2566.66 | 2554.61 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 6554.61 | 0.00151503 | 40 | 149 | 12.0562 | ø40 | 48.3 | 41.8 | TR02.02.2298 | 2298 | yes | HT_vratné vodní (45 °C) 9
13445692 | 2.NP_SO-102 | 12.0562 | 0.00183197 | 0.0018294 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2566.66 | 2566.66 | 2554.61 | 2554.61 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 6554.61 | 0.00151503 | 40 | 36 | 12.0562 | ø40 | 48.3 | 41.8 | TR02.02.2299 | 2299 | yes | HT_přívodní vodní (55 °C) 12
13445715 | 2.NP_SO-102 | 335.706 | 0.00183197 | 0.0509397 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2969.04 | 2633.34 | 2969.04 | 2633.34 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 6633.34 | 0.0421861 | 40 | 132 | 335.706 | ø40 | 48.3 | 41.8 | TR02.02.2300 | 2300 | yes | HT_vratné vodní (45 °C) 9
13445729 | 2.NP_SO-102 | 6964.07 | 0.00183197 | 1.05672 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2624.15 | 2600 | 2600 | 2575.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 6579.1 | 0.875131 | 40 | 151 | 6964.07 | ø40 | 48.3 | 41.8 | TR02.02.2301 | 2301 | yes | HT_vratné vodní (45 °C) 9 | 0
13445737 | 2.NP_SO-102 | 304.941 | 0.00183197 | 0.0462715 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2624.15 | 2600 | 2600 | 2575.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 6579.1 | 0.0383201 | 40 | 151 | 304.941 | ø40 | 48.3 | 41.8 | TR02.02.2302 | 2302 | yes | HT_vratné vodní (45 °C) 9 | 0
13445761 | 2.NP_SO-102 | 7224.65 | 0.00183197 | 1.09626 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2624.15 | 2600 | 2600 | 2575.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 6579.1 | 0.907877 | 40 | 38 | 7224.65 | ø40 | 48.3 | 41.8 | TR02.02.2303 | 2303 | yes | HT_přívodní vodní (55 °C) 12 | 0
13445769 | 2.NP_SO-102 | 217.886 | 0.00183197 | 0.0330617 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2624.15 | 2600 | 2600 | 2575.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 6579.1 | 0.0273803 | 40 | 38 | 217.886 | ø40 | 48.3 | 41.8 | TR02.02.2304 | 2304 | yes | HT_přívodní vodní (55 °C) 12 | 0
13445811 | 2.NP_SO-102 | 496.025 | 0.00183197 | 0.0752663 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2573.01 | 2573.01 | 2076.99 | 2076.99 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 6076.99 | 0.0623323 | 40 | 38 | 496.025 | ø40 | 48.3 | 41.8 | TR02.02.2305 | 2305 | yes | HT_přívodní vodní (55 °C) 12
13445822 | 2.NP_SO-102 | 496.025 | 0.00183197 | 0.0752663 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2573.01 | 2573.01 | 2076.99 | 2076.99 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 6076.99 | 0.0623323 | 40 | 151 | 496.025 | ø40 | 48.3 | 41.8 | TR02.02.2306 | 2306 | yes | HT_vratné vodní (45 °C) 9
13449360 | -1.PP_SO-102 | 300.151 | 0.00141175 | 0.0399811 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 2621.2 | 2600 | 2600 | 2578.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -1417.95 | 0.0301744 | 32 | 55 | 300.151 | ø32 | 42.4 | 35.9 | TR02.02.2326 | 2326 | yes | HT_přívodní vodní (65 °C) 8 | 0
13449378 | -1.PP_SO-102 | 752.885 | 0.00141175 | 0.100287 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 2621.2 | 2600 | 2600 | 2578.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -1417.95 | 0.0756883 | 32 | 55 | 752.885 | ø32 | 42.4 | 35.9 | TR02.02.2327 | 2327 | yes | HT_přívodní vodní (65 °C) 8 | 0
13449386 | -1.PP_SO-102 | 1778.56 | 0.00141175 | 0.236911 | 60 | ø152 mm | 0.00278552 | HD | -1.PP_SO-102 | 2621.2 | 2600 | 2600 | 2578.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -1417.95 | 0.178801 | 32 | 55 | 1778.56 | ø32 | 42.4 | 35.9 | TR02.02.2328 | 2328 | yes | HT_přívodní vodní (65 °C) 8 | 0 | Izolace - Typ izolace: Tepelná
13449406 | -1.PP_SO-102 | 260.273 | 0.00141175 | 0.0346693 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 2621.2 | 2600 | 2600 | 2578.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -1417.95 | 0.0261655 | 32 | 36 | 260.273 | ø32 | 42.4 | 35.9 | TR02.02.2329 | 2329 | yes | HT_vratné vodní (45 °C) 23 | 0
13449418 | -1.PP_SO-102 | 1031.08 | 0.00141175 | 0.137344 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 2621.2 | 2600 | 2600 | 2578.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -1417.95 | 0.103656 | 32 | 36 | 1031.08 | ø32 | 42.4 | 35.9 | TR02.02.2330 | 2330 | yes | HT_vratné vodní (45 °C) 23 | 0
13449426 | -1.PP_SO-102 | 2000.36 | 0.00141175 | 0.266456 | 60 | ø152 mm | 0.00278552 | HD | -1.PP_SO-102 | 2621.2 | 2600 | 2600 | 2578.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -1417.95 | 0.201099 | 32 | 36 | 2000.36 | ø32 | 42.4 | 35.9 | TR02.02.2331 | 2331 | yes | HT_vratné vodní (45 °C) 23 | 0 | Izolace - Typ izolace: Tepelná
13449655 | -1.PP_SO-102 | 8205.08 | 0.000568237 | 0.693401 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2463.45 | 2450 | 2450 | 2436.55 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1560.8 | 0.51554 | 20 | 131 | 8205.08 | ø20 | 26.9 | 21.6 | TR02.02.2332 | 2332 | yes | CL_přívodní vodní (10 °C) 4 | 0
13449701 | -1.PP_SO-102 | 8205.08 | 0.000568237 | 0.693401 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2463.45 | 2450 | 2450 | 2436.55 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1560.8 | 0.51554 | 20 | 105 | 8205.08 | ø20 | 26.9 | 21.6 | TR02.02.2333 | 2333 | yes | CL_vratné vodní (15 °C) 8 | 0
13449746 | -1.PP_SO-102 | 8205.08 | 0.000568237 | 0.693401 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2463.45 | 2450 | 2450 | 2436.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1560.8 | 0.51554 | 20 | 142 | 8205.08 | ø20 | 26.9 | 21.6 | TR02.02.2334 | 2334 | yes | HT_vratné vodní (45 °C) 26 | 0
13449776 | -1.PP_SO-102 | 8205.08 | 0.000568237 | 0.693401 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2463.45 | 2450 | 2450 | 2436.55 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1560.8 | 0.51554 | 20 | 41 | 8205.08 | ø20 | 26.9 | 21.6 | TR02.02.2335 | 2335 | yes | HT_přívodní vodní (65 °C) 27 | 0
13450047 | -1.PP_SO-102 | 195.075 | 0.000568237 | 0.0164856 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2662.54 | 2662.54 | 2467.46 | 2467.46 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1532.54 | 0.0122569 | 20 | 131 | 195.075 | ø20 | 26.9 | 21.6 | TR02.02.2336 | 2336 | yes | CL_přívodní vodní (10 °C) 4
13450088 | -1.PP_SO-102 | 195.075 | 0.000568237 | 0.0164856 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2662.54 | 2662.54 | 2467.46 | 2467.46 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1532.54 | 0.0122569 | 20 | 105 | 195.075 | ø20 | 26.9 | 21.6 | TR02.02.2337 | 2337 | yes | CL_vratné vodní (15 °C) 8
13450129 | -1.PP_SO-102 | 195.075 | 0.000568237 | 0.0164856 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2662.54 | 2662.54 | 2467.46 | 2467.46 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1532.54 | 0.0122569 | 20 | 142 | 195.075 | ø20 | 26.9 | 21.6 | TR02.02.2338 | 2338 | yes | HT_vratné vodní (45 °C) 26
13450170 | -1.PP_SO-102 | 195.075 | 0.000568237 | 0.0164856 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2662.54 | 2662.54 | 2467.46 | 2467.46 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1532.54 | 0.0122569 | 20 | 41 | 195.075 | ø20 | 26.9 | 21.6 | TR02.02.2339 | 2339 | yes | HT_přívodní vodní (65 °C) 27
13450245 | -1.PP_SO-102 | 145.075 | 0.000568237 | 0.0122601 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2662.54 | 2517.46 | 2662.54 | 2517.46 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1482.54 | 0.00911533 | 20 | 131 | 145.075 | ø20 | 26.9 | 21.6 | TR02.02.2340 | 2340 | yes | CL_přívodní vodní (10 °C) 4
13450254 | -1.PP_SO-102 | 145.075 | 0.000568237 | 0.0122601 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2662.54 | 2662.54 | 2517.46 | 2517.46 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1482.54 | 0.00911533 | 20 | 105 | 145.075 | ø20 | 26.9 | 21.6 | TR02.02.2341 | 2341 | yes | CL_vratné vodní (15 °C) 8
13450265 | -1.PP_SO-102 | 145.075 | 0.000568237 | 0.0122601 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2662.54 | 2517.46 | 2662.54 | 2517.46 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1482.54 | 0.00911533 | 20 | 142 | 145.075 | ø20 | 26.9 | 21.6 | TR02.02.2342 | 2342 | yes | HT_vratné vodní (45 °C) 26
13450274 | -1.PP_SO-102 | 145.075 | 0.000568237 | 0.0122601 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2662.54 | 2517.46 | 2662.54 | 2517.46 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1482.54 | 0.00911533 | 20 | 41 | 145.075 | ø20 | 26.9 | 21.6 | TR02.02.2343 | 2343 | yes | HT_přívodní vodní (65 °C) 27

# IfcPipeSegment: Typy trubek:Ocel_černá (499)
Type - Material: 255-128-128
Type - Požární ochrana - Požární odolnost: A1
Type - Identifikační data - ID kategorie: TR; Kód sestavy: TR02; Název typu: Ocel_černá; Označení typu: 01; Popis: OC; Popis sestavy: Ocel
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR02 Uniformat (Uniformat)
Mechanické – tok - Doplňkový průtok: 0 m3/s; Průtok: 0 m3/s; Reynoldsovo číslo: 0; Rychlost: 0 m/s; Stav průtoku: Laminární; Tlaková ztráta: 0 Pa; Třecí faktor: 0; Tření: 0
Text - CCI Funkční systém: H; CCI Komponenta: WPA
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Mechanické - Drsnost: 0.1 mm; Materiál: Kov, ocel; Popis úseku: FE; Typ přípoje: Obecné; Úsek potrubí: Kov, ocel - ČERNÁ SVAŘOVANÁ; Výkaz/typ: ČERNÁ SVAŘOVANÁ
Jiné - Id typu: 12487561; Rodina: Typy trubek; Rodina a typ: Typy trubek: Ocel_černá; Typ: Ocel_černá
Name (Typy trubek:Ocel_černá:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Celková velikost | Tloušťka izolace (mm) | Relativní drsnost | CCI Technický systém | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Sklon | Spodní výška (mm) | Fáze vytvoření | Klasifikace systému | Název systému | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) | Řez | Typ systému | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group
12976914 | -1.PP_SO-102 | 2597.96 | 0.00620623 | 0.725577 | ø200 mm | 60 | 0.00123762 | HD | 2844.45 | 2800 | 2800 | -1.PP_SO-102 | 0 | 2755.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | -1240.4 | 0.652938 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.0001 | 0001 | yes | HT_přívodní vodní (65 °C) 5 | Izolace - Typ izolace: Tepelná
12976925 | -1.PP_SO-102 | 1085.15 | 0.00620623 | 0.303068 | ø200 mm | 60 | 0.00123762 | HD | 2344.45 | 2300 | 2300 | -1.PP_SO-102 | 0 | 2255.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | -1740.4 | 0.272727 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.0002 | 0002 | yes | HT_přívodní vodní (65 °C) 5 | Izolace - Typ izolace: Tepelná
12977026 | -1.PP_SO-102 | 773.494 | 0.00620623 | 0.216027 | ø200 mm | 60 | 0.00123762 | HD | 2844.45 | 2800 | 2800 | -1.PP_SO-102 | 0 | 2755.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | -1240.4 | 0.1944 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.0003 | 0003 | yes | HT_přívodní vodní (65 °C) 5 | Izolace - Typ izolace: Tepelná
12977266 | 1.NP_SO-102 | 7337.92 | 0.00620623 | 2.04939 | ø200 mm | 60 | 0.00123762 | HD | 6183.96 | 6183.96 | -1153.96 | 1.NP_SO-102 |  | -1153.96 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | -1153.96 | 1.84422 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.0004 | 0004 | yes | HT_přívodní vodní (65 °C) 5 | Izolace - Typ izolace: Tepelná
12977731 | 2.NP_SO-102 | 7007.81 | 0.00620623 | 1.9572 | ø200 mm | 60 | 0.00123762 | HD | 2274.45 | 2230 | 2230 | 2.NP_SO-102 | 0 | 2185.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 6189.6 | 1.76126 | 80 | 71 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.0005 | 0005 | yes | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
12977772 | 2.NP_SO-102 | 7441.23 | 0.00620623 | 2.07824 | ø200 mm | 60 | 0.00123762 | HD | 2274.45 | 2230 | 2230 | 2.NP_SO-102 | 0 | 2185.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 6189.6 | 1.87018 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.0006 | 0006 | yes | HT_přívodní vodní (65 °C) 5 | Izolace - Typ izolace: Tepelná
12978744 | 2.NP_SO-102 | 357.925 | 0.00620623 | 0.099964 | ø80 mm | 0 | 0.00123762 | HD | 3053.96 | 3053.96 | 2696.04 | 2.NP_SO-102 |  | 2696.04 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6696.04 | 0.0899564 | 80 | 359 | HT_přívodní vodní (55 °C) | ø80 | 88.9 | 80.8 | TR02.01.0007 | 0007 | yes | HT_přívodní vodní (55 °C) 9
12978827 | 2.NP_SO-102 | 53.0688 | 0.00620623 | 0.0148214 | ø80 mm | 0 | 0.00123762 | HD | 2694.45 | 2650 | 2650 | 2.NP_SO-102 | 0 | 2605.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6609.6 | 0.0133376 | 80 | 241 | HT_přívodní vodní (55 °C) | ø80 | 88.9 | 80.8 | TR02.01.0008 | 0008 | yes | HT_přívodní vodní (55 °C) 9
13022269 | 2.NP_SO-102 | 17746.4 | 0.00620623 | 4.95635 | ø200 mm | 60 | 0.00123762 | HD | 3144.45 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3055.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7059.6 | 4.46016 | 80 | 342 | HT_přívodní vodní (55 °C) | ø80 | 88.9 | 80.8 | TR02.01.0037 | 0037 | yes | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13022797 | 2.NP_SO-102 | 39.4362 | 0.00620623 | 0.011014 | ø80 mm | 0 | 0.00123762 | HD | 3144.45 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3055.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7059.6 | 0.00991139 | 80 | 360 | HT_přívodní vodní (55 °C) | ø80 | 88.9 | 80.8 | TR02.01.0038 | 0038 | yes | HT_přívodní vodní (55 °C) 9
13043751 | 2.NP_SO-102 | 46.0062 | 0.00454772 | 0.010999 | ø65 mm | 0 | 0.00145138 | HD | 3192.04 | 3192.04 | 3146.04 | 2.NP_SO-102 |  | 3146.04 | Fáze 2 | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7146.04 | 0.00939464 | 65 | 335 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.0239 | 0239 | yes | HT_přívodní vodní (55 °C) 19
13044010 | 2.NP_SO-102 | 7389.37 | 0.00454772 | 1.76661 | ø65 mm | 0 | 0.00145138 | HD | 3138.05 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3061.95 | Fáze 2 | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7065.55 | 1.50893 | 65 | 529 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.0247 | 0247 | yes | HT_přívodní vodní (55 °C) 19
13050358 | 2.NP_SO-102 | 1159.27 | 0.00454772 | 0.277152 | ø65 mm | 0 | 0.00145138 | HD | 3288.05 | 3250 | 3250 | 2.NP_SO-102 | 0 | 3211.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 7215.55 | 0.236727 | 65 | 76 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.0323 | 0323 | yes | HT_PRIMÁR_přívodní 4
13050443 | 2.NP_SO-102 | 7144.43 | 0.00620623 | 1.99535 | ø200 mm | 60 | 0.00123762 | HD | 10454 | 10454 | 3309.53 | 2.NP_SO-102 |  | 3309.53 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 7309.53 | 1.79559 | 80 | 18 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.0324 | 0324 | yes | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13050528 | 2.NP_SO-102 | 827.333 | 0.00454772 | 0.197795 | ø65 mm | 0 | 0.00145138 | HD | 3288.05 | 3250 | 3250 | 2.NP_SO-102 | 0 | 3211.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 7215.55 | 0.168944 | 65 | 62 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.0325 | 0325 | yes | HT_PRIMÁR_přívodní 3
13050536 | 2.NP_SO-102 | 5620.19 | 0.00454772 | 1.34365 | ø65 mm | 0 | 0.00145138 | HD | 3288.05 | 3250 | 3250 | 2.NP_SO-102 | 0 | 3211.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 7215.55 | 1.14766 | 65 | 62 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.0326 | 0326 | yes | HT_PRIMÁR_přívodní 3
13053908 | -1.PP_SO-102 | 13587.7 | 0.00620623 | 3.79488 | ø200 mm | 60 | 0.00123762 | HD | 2844.45 | 2800 | 2800 | -1.PP_SO-102 | 0 | 2755.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | -1240.4 | 3.41497 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.0327 | 0327 | yes | HT_přívodní vodní (65 °C) 5 | Izolace - Typ izolace: Tepelná
13055235 | 4.NP_SO-102 | 1753.47 | 0.00620623 | 0.489724 | ø200 mm | 60 | 0.00123762 | HD | 2744.45 | 2700 | 2700 | 4.NP_SO-102 | 0 | 2655.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 14659.6 | 0.440696 | 80 | 54 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.0334 | 0334 | yes | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13055247 | 2.NP_SO-102 | 7344.43 | 0.00620623 | 2.05121 | ø200 mm | 60 | 0.00123762 | HD | 10654 | 10654 | 3309.53 | 2.NP_SO-102 |  | 3309.53 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 7309.53 | 1.84586 | 80 | 54 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.0335 | 0335 | yes | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13055559 | 4.NP_SO-102 | 2091.63 | 0.00620623 | 0.584167 | ø200 mm | 60 | 0.00123762 | HD | 2744.45 | 2700 | 2700 | 4.NP_SO-102 | 0 | 2655.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 14659.6 | 0.525684 | 80 | 54 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.0336 | 0336 | yes | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13055646 | 4.NP_SO-102 | 1390.55 | 0.00620623 | 0.388365 | ø200 mm | 60 | 0.00123762 | HD | 2744.45 | 2700 | 2700 | 4.NP_SO-102 | 0 | 2655.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14659.6 | 0.349484 | 80 | 18 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.0337 | 0337 | yes | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13058188 | 2.NP_SO-102 | 7344.43 | 0.00620623 | 2.05121 | ø200 mm | 60 | 0.00123762 | HD | 10654 | 10654 | 3309.53 | 2.NP_SO-102 | 2987419 | 3309.53 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 7309.53 | 1.84586 | 80 | 62 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.0346 | 0346 | yes | HT_PRIMÁR_vratné 7 | Izolace - Typ izolace: Tepelná
13058200 | 2.NP_SO-102 | 7344.43 | 0.00620623 | 2.05121 | ø200 mm | 60 | 0.00123762 | HD | 10654 | 3309.53 | 10654 | 2.NP_SO-102 | 327148 | 3309.52 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 7309.52 | 1.84586 | 80 | 66 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.0347 | 0347 | yes | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13058645 | 4.NP_SO-102 | 1383.47 | 0.00620623 | 0.386387 | ø200 mm | 60 | 0.00123762 | HD | 2744.45 | 2700 | 2700 | 4.NP_SO-102 | 0 | 2655.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 14659.6 | 0.347705 | 80 | 62 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.0348 | 0348 | yes | HT_PRIMÁR_vratné 7 | Izolace - Typ izolace: Tepelná
13058757 | 4.NP_SO-102 | 2130.11 | 0.00620623 | 0.594914 | ø200 mm | 60 | 0.00123762 | HD | 2744.45 | 2700 | 2700 | 4.NP_SO-102 | 0 | 2655.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 14659.6 | 0.535356 | 80 | 62 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.0349 | 0349 | yes | HT_PRIMÁR_vratné 7 | Izolace - Typ izolace: Tepelná
13059306 | 4.NP_SO-102 | 2003.47 | 0.00620623 | 0.559545 | ø200 mm | 60 | 0.00123762 | HD | 2744.45 | 2700 | 2700 | 4.NP_SO-102 | 0 | 2655.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 14659.6 | 0.503528 | 80 | 66 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.0350 | 0350 | yes | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13059315 | 4.NP_SO-102 | 2339.37 | 0.00620623 | 0.653356 | ø200 mm | 60 | 0.00123762 | HD | 2744.45 | 2700 | 2700 | 4.NP_SO-102 | 0 | 2655.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 14659.6 | 0.587947 | 80 | 66 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.0351 | 0351 | yes | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13070097 | 2.NP_SO-102 | 250.789 | 0.00620623 | 0.0700422 | ø80 mm | 0 | 0.00123762 | HD | 3144.45 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3055.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7059.6 | 0.0630301 | 80 | 275 | HT_přívodní vodní (55 °C) | ø80 | 88.9 | 80.8 | TR02.01.0361 | 0361 | yes | HT_přívodní vodní (55 °C) 9
13075130 | -1.PP_SO-102 | 13687.7 | 0.00620623 | 3.82281 | ø200 mm | 60 | 0.00123762 | HD | 2844.45 | 2800 | 2800 | -1.PP_SO-102 | 0 | 2755.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | -1240.4 | 3.4401 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.0365 | 0365 | yes | HT_vratné vodní (45 °C) 39 | Izolace - Typ izolace: Tepelná
13075140 | -1.PP_SO-102 | 2547.96 | 0.00620623 | 0.711613 | ø200 mm | 60 | 0.00123762 | HD | 2844.45 | 2800 | 2800 | -1.PP_SO-102 | 0 | 2755.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | -1240.4 | 0.640372 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.0366 | 0366 | yes | HT_vratné vodní (45 °C) 39 | Izolace - Typ izolace: Tepelná
13075150 | -1.PP_SO-102 | 3554.05 | 0.00620623 | 0.992601 | ø200 mm | 60 | 0.00123762 | HD | 2844.45 | 2800 | 2800 | -1.PP_SO-102 | 0 | 2755.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | -1240.4 | 0.89323 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.0367 | 0367 | yes | HT_vratné vodní (45 °C) 39 | Izolace - Typ izolace: Tepelná
13077644 | 1.NP_SO-102 | 7337.92 | 0.00620623 | 2.04939 | ø200 mm | 60 | 0.00123762 | HD | 6183.96 | 6183.96 | -1153.96 | 1.NP_SO-102 |  | -1153.96 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | -1153.96 | 1.84422 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.0368 | 0368 | yes | HT_vratné vodní (45 °C) 39 | Izolace - Typ izolace: Tepelná
13078781 | 2.NP_SO-102 | 357.925 | 0.00620623 | 0.099964 | ø80 mm | 0 | 0.00123762 | HD | 3053.96 | 3053.96 | 2696.04 | 2.NP_SO-102 |  | 2696.04 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6696.04 | 0.0899564 | 80 | 279 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.0377 | 0377 | yes | HT_vratné vodní (45 °C) 1
13078875 | 2.NP_SO-102 | 349.877 | 0.00620623 | 0.0977164 | ø200 mm | 60 | 0.00123762 | HD | 3144.45 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3055.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7059.6 | 0.0879338 | 80 | 256 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.0380 | 0380 | yes | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13082085 | 2.NP_SO-102 | 89.4362 | 0.00620623 | 0.0249784 | ø200 mm | 60 | 0.00123762 | HD | 3144.45 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3055.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7059.6 | 0.0224778 | 80 | 461 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.0418 | 0418 | yes | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13083328 | 2.NP_SO-102 | 12703.9 | 0.00620623 | 3.54805 | ø200 mm | 60 | 0.00123762 | HD | 3144.45 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3055.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7059.6 | 3.19284 | 80 | 279 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.0439 | 0439 | yes | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13091565 | 2.NP_SO-102 | 7191.23 | 0.00620623 | 2.00842 | ø200 mm | 60 | 0.00123762 | HD | 2274.45 | 2230 | 2230 | 2.NP_SO-102 | 0 | 2185.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 6189.6 | 1.80735 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.0535 | 0535 | yes | HT_vratné vodní (45 °C) 39 | Izolace - Typ izolace: Tepelná
13100862 | 2.NP_SO-102 | 7040.28 | 0.00454772 | 1.68316 | ø65 mm | 0 | 0.00145138 | HD | 3138.05 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3061.95 | Fáze 2 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7065.55 | 1.43765 | 65 | 549 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.0636 | 0636 | yes | HT_vratné vodní (45 °C) 13
13125740 | 2.NP_SO-102 | 437.925 | 0.00620623 | 0.122307 | ø200 mm | 60 | 0.00123762 | HD | 2183.96 | 2183.96 | 1746.04 | 2.NP_SO-102 |  | 1746.04 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 5746.04 | 0.110063 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.0937 | 0937 | yes | HT_přívodní vodní (65 °C) 5 | Izolace - Typ izolace: Tepelná
13125807 | 2.NP_SO-102 | 437.925 | 0.00620623 | 0.122307 | ø200 mm | 60 | 0.00123762 | HD | 2183.96 | 2183.96 | 1746.04 | 2.NP_SO-102 |  | 1746.04 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 5746.04 | 0.110063 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.0938 | 0938 | yes | HT_vratné vodní (45 °C) 39 | Izolace - Typ izolace: Tepelná
13126342 | 2.NP_SO-102 | 6120.19 | 0.00454772 | 1.46318 | ø65 mm | 0 | 0.00145138 | HD | 3288.05 | 3250 | 3250 | 2.NP_SO-102 | 0 | 3211.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 7215.55 | 1.24976 | 65 | 76 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.0940 | 0940 | yes | HT_PRIMÁR_přívodní 4
13126399 | 2.NP_SO-102 | 370.625 | 0.00454772 | 0.0886072 | ø65 mm | 0 | 0.00145138 | HD | 3210.31 | 2839.69 | 3210.31 | 2.NP_SO-102 |  | 2839.69 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 6839.69 | 0.0756829 | 65 | 76 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.0941 | 0941 | yes | HT_PRIMÁR_přívodní 4
13127047 | 2.NP_SO-102 | 5870.19 | 0.00454772 | 1.40342 | ø65 mm | 0 | 0.00145138 | HD | 3288.05 | 3250 | 3250 | 2.NP_SO-102 | 0 | 3211.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 7215.55 | 1.19871 | 65 | 67 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.0942 | 0942 | yes | HT_PRIMÁR_vratné 7
13127088 | 2.NP_SO-102 | 5245.63 | 0.00454772 | 1.2541 | ø65 mm | 0 | 0.00145138 | HD | 3038.05 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2961.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 6965.55 | 1.07118 | 65 | 70 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.0943 | 0943 | yes | HT_PRIMÁR_vratné 3
13127090 | 2.NP_SO-102 | 978.245 | 0.00454772 | 0.233874 | ø65 mm | 0 | 0.00145138 | HD | 3288.05 | 3250 | 3250 | 2.NP_SO-102 | 0 | 3211.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 7215.55 | 0.199761 | 65 | 67 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.0944 | 0944 | yes | HT_PRIMÁR_vratné 7
13128161 | 2.NP_SO-102 | 370.625 | 0.00454772 | 0.0886072 | ø65 mm | 0 | 0.00145138 | HD | 3210.31 | 3210.31 | 2839.69 | 2.NP_SO-102 |  | 2839.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 6839.69 | 0.0756829 | 65 | 67 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.0947 | 0947 | yes | HT_PRIMÁR_vratné 7
13128191 | 2.NP_SO-102 | 370.625 | 0.00454772 | 0.0886072 | ø65 mm | 0 | 0.00145138 | HD | 3210.31 | 2839.69 | 3210.31 | 2.NP_SO-102 |  | 2839.69 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 6839.69 | 0.0756829 | 65 | 62 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.0948 | 0948 | yes | HT_PRIMÁR_přívodní 3
13128204 | 2.NP_SO-102 | 170.625 | 0.00454772 | 0.0407922 | ø65 mm | 0 | 0.00145138 | HD | 2960.31 | 2789.69 | 2960.31 | 2.NP_SO-102 |  | 2789.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 6789.69 | 0.0348422 | 65 | 70 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.0949 | 0949 | yes | HT_PRIMÁR_vratné 3
13128318 | 2.NP_SO-102 | 690.625 | 0.00454772 | 0.165111 | ø65 mm | 0 | 0.00145138 | HD | 2838.05 | 2800 | 2800 | 2.NP_SO-102 | 0 | 2761.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 6765.55 | 0.141028 | 65 | 62 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.0950 | 0950 | yes | HT_PRIMÁR_přívodní 3
13128395 | 2.NP_SO-102 | 915.625 | 0.00454772 | 0.218903 | ø65 mm | 0 | 0.00145138 | HD | 2788.05 | 2750 | 2750 | 2.NP_SO-102 | 0 | 2711.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 6715.55 | 0.186974 | 65 | 70 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.0951 | 0951 | yes | HT_PRIMÁR_vratné 3
13128404 | 2.NP_SO-102 | 465.625 | 0.00454772 | 0.111319 | ø65 mm | 0 | 0.00145138 | HD | 2838.05 | 2800 | 2800 | 2.NP_SO-102 | 0 | 2761.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 6765.55 | 0.0950823 | 65 | 67 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.0952 | 0952 | yes | HT_PRIMÁR_vratné 7
13135941 | 2.NP_SO-102 | 34.9435 | 0.00454772 | 0.00835412 | ø65 mm | 0 | 0.00145138 | HD | 3053.96 | 3053.96 | 3019.02 | 2.NP_SO-102 |  | 3019.02 | Fáze 2 | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7019.02 | 0.00713558 | 65 | 334 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.1016 | 1016 | yes | HT_přívodní vodní (55 °C) 19
13136030 | 2.NP_SO-102 | 1501.65 | 0.00454772 | 0.359008 | ø65 mm | 0 | 0.00145138 | HD | 3138.05 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3061.95 | Fáze 2 | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7065.55 | 0.306643 | 65 | 333 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.1017 | 1017 | yes | HT_přívodní vodní (55 °C) 19
13136235 | 2.NP_SO-102 | 1880.8 | 0.00454772 | 0.449653 | ø65 mm | 0 | 0.00145138 | HD | 3138.05 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3061.95 | Fáze 2 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7065.55 | 0.384067 | 65 | 340 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1020 | 1020 | yes | HT_vratné vodní (45 °C) 13
13137634 | 2.NP_SO-102 | 17796.4 | 0.00620623 | 4.97032 | ø200 mm | 60 | 0.00123762 | HD | 3144.45 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3055.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7059.6 | 4.47272 | 80 | 9 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1039 | 1039 | yes | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13180508 | 4.NP_SO-102 | 788.081 | 0.00620623 | 0.220101 | ø200 mm | 60 | 0.00123762 | HD | 3044.45 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2955.55 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 14959.6 | 0.198066 | 80 | 61 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.1267 | 1267 | yes | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13180573 | 4.NP_SO-102 | 207.925 | 0.00620623 | 0.0580709 | ø200 mm | 60 | 0.00123762 | HD | 2953.96 | 2953.96 | 2746.04 | 4.NP_SO-102 |  | 2746.04 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 14746 | 0.0522573 | 80 | 66 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.1268 | 1268 | yes | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13180608 | 4.NP_SO-102 | 307.925 | 0.00620623 | 0.0859996 | ø200 mm | 60 | 0.00123762 | HD | 3053.96 | 3053.96 | 2746.04 | 4.NP_SO-102 |  | 2746.04 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 14746 | 0.07739 | 80 | 54 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.1269 | 1269 | yes | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13189256 | 2.NP_SO-102 | 237.925 | 0.00620623 | 0.0664495 | ø200 mm | 60 | 0.00123762 | HD | 2183.96 | 2183.96 | 1946.04 | 2.NP_SO-102 |  | 1946.04 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 5946.04 | 0.0597971 | 80 | 71 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.1301 | 1301 | yes | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
13189311 | 2.NP_SO-102 | 237.925 | 0.00620623 | 0.0664495 | ø200 mm | 60 | 0.00123762 | HD | 2183.96 | 2183.96 | 1946.04 | 2.NP_SO-102 |  | 1946.04 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 5946.04 | 0.0597971 | 80 | 65 | HT_PRIMÁR_vratné | ø80 | 88.9 | 80.8 | TR02.01.1302 | 1302 | yes | HT_PRIMÁR_vratné 5 | Izolace - Typ izolace: Tepelná
13202937 | -1.PP_SO-102 | 520 | 0.00454772 | 0.124319 | ø65 mm | 0 | 0.00145138 | HE | 1538.05 | 1500 | 1500 | -1.PP_SO-102 | 0 | 1461.95 | Fáze 1 | Přívod teplé vody | HT/CL_přívodní chladivový 1 | -2534.45 | 0.106186 | 65 | 1 | HT/CL_přívodní chladivový | ø65 | 76.1 | 68.9 | TR02.01.1304 | 1304 | yes | HT/CL_přívodní chladivový 1
13202955 | -1.PP_SO-102 | 520 | 0.00454772 | 0.124319 | ø65 mm | 0 | 0.00145138 | HE | 1538.05 | 1500 | 1500 | -1.PP_SO-102 | 0 | 1461.95 | Fáze 1 | Zpětné vedení teplé vody | HT/CL_vratné chladivový 1 | -2534.45 | 0.106186 | 65 | 1 | HT/CL_vratné chladivový | ø65 | 76.1 | 68.9 | TR02.01.1305 | 1305 | yes | HT/CL_vratné chladivový 1
13206450 | -1.PP_SO-102 | 2378.93 | 0.00454772 | 0.568743 | ø65 mm | 0 | 0.00145138 | HD | 338.05 | 300 | 300 | -1.PP_SO-102 | 0 | 261.95 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (75 °C) 1 | -3734.45 | 0.485786 | 65 | 1 | HT_přívodní vodní (75 °C) | ø65 | 76.1 | 68.9 | TR02.01.1306 | 1306 | yes | HT_přívodní vodní (75 °C) 1
13206524 | -1.PP_SO-102 | 400.203 | 0.00454772 | 0.0956785 | ø65 mm | 0 | 0.00145138 | HD | 338.05 | 300 | 300 | -1.PP_SO-102 | 0 | 261.95 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (65 °C) 1 | -3734.45 | 0.0817228 | 65 | 2 | HT_vratné vodní (65 °C) | ø65 | 76.1 | 68.9 | TR02.01.1307 | 1307 | yes | HT_vratné vodní (65 °C) 1
13206704 | -1.PP_SO-102 | 1543.67 | 0.00620623 | 0.431128 | ø80 mm | 0 | 0.00123762 | HD | 2803.17 | 2803.17 | 1259.5 | -1.PP_SO-102 |  | 1259.5 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 32 | -2740.5 | 0.387966 | 80 | 1 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.1310 | 1310 | yes | HT_přívodní vodní (65 °C) 32
13206815 | -1.PP_SO-102 | 1543.67 | 0.00620623 | 0.431128 | ø80 mm | 0 | 0.00123762 | HD | 2803.17 | 1259.5 | 2803.17 | -1.PP_SO-102 |  | 1259.5 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 8 | -2740.5 | 0.387966 | 80 | 1 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1313 | 1313 | yes | HT_vratné vodní (45 °C) 8
13206883 | -1.PP_SO-102 | 1546.84 | 0.00620623 | 0.432014 | ø80 mm | 0 | 0.00123762 | HD | 2806.34 | 1259.5 | 2806.34 | -1.PP_SO-102 |  | 1259.5 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 4 | -2740.5 | 0.388764 | 80 | 1 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1314 | 1314 | yes | HT_vratné vodní (45 °C) 4
13206894 | -1.PP_SO-102 | 1537.32 | 0.00620623 | 0.429354 | ø80 mm | 0 | 0.00123762 | HD | 2796.82 | 2796.82 | 1259.5 | -1.PP_SO-102 |  | 1259.5 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 6 | -2740.5 | 0.38637 | 80 | 1 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1315 | 1315 | yes | HT_vratné vodní (45 °C) 6
13206905 | -1.PP_SO-102 | 1494.46 | 0.00620623 | 0.417385 | ø80 mm | 0 | 0.00123762 | HD | 2753.96 | 2753.96 | 1259.5 | -1.PP_SO-102 |  | 1259.5 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | -2740.5 | 0.375599 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1316 | 1316 | yes | HT_vratné vodní (45 °C) 39
13207928 | -1.PP_SO-102 | 1546.84 | 0.00620623 | 0.432014 | ø80 mm | 0 | 0.00123762 | HD | 2806.34 | 2806.34 | 1259.5 | -1.PP_SO-102 |  | 1259.5 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 36 | -2740.5 | 0.388764 | 80 | 1 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.1319 | 1319 | yes | HT_přívodní vodní (65 °C) 36
13207939 | -1.PP_SO-102 | 1487.32 | 0.00620623 | 0.41539 | ø80 mm | 0 | 0.00123762 | HD | 2746.82 | 2746.82 | 1259.5 | -1.PP_SO-102 |  | 1259.5 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 31 | -2740.5 | 0.373804 | 80 | 1 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.1320 | 1320 | yes | HT_přívodní vodní (65 °C) 31
13207950 | -1.PP_SO-102 | 1493.67 | 0.00620623 | 0.417163 | ø80 mm | 0 | 0.00123762 | HD | 2753.17 | 2753.17 | 1259.5 | -1.PP_SO-102 |  | 1259.5 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 40 | -2740.5 | 0.3754 | 80 | 1 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.1321 | 1321 | yes | HT_přívodní vodní (65 °C) 40
13208114 | -1.PP_SO-102 | 3169.93 | 0.00620623 | 0.885323 | ø80 mm | 0 | 0.00123762 | HD | 2844.45 | 2800 | 2800 | -1.PP_SO-102 | 0 | 2755.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | -1240.4 | 0.796691 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1328 | 1328 | yes | HT_vratné vodní (45 °C) 39
13208162 | -1.PP_SO-102 | 3089.93 | 0.00620623 | 0.86298 | ø80 mm | 0 | 0.00123762 | HD | 2844.45 | 2800 | 2800 | -1.PP_SO-102 | 0 | 2755.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | -1240.4 | 0.776585 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.1329 | 1329 | yes | HT_přívodní vodní (65 °C) 5
13208205 | -1.PP_SO-102 | 1494.46 | 0.00620623 | 0.417385 | ø80 mm | 0 | 0.00123762 | HD | 2753.96 | 2753.96 | 1259.5 | -1.PP_SO-102 |  | 1259.5 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | -2740.5 | 0.375599 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.1330 | 1330 | yes | HT_přívodní vodní (65 °C) 5
13208461 | -1.PP_SO-102 | 202.672 | 0.00454772 | 0.0484539 | ø65 mm | 0 | 0.00145138 | HD | 1038.05 | 1000 | 1000 | -1.PP_SO-102 | 0 | 961.95 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (75 °C) 1 | -3034.45 | 0.0413864 | 65 | 1 | HT_přívodní vodní (75 °C) | ø65 | 76.1 | 68.9 | TR02.01.1331 | 1331 | yes | HT_přívodní vodní (75 °C) 1
13208470 | -1.PP_SO-102 | 620.625 | 0.00454772 | 0.148376 | ø65 mm | 0 | 0.00145138 | HD | 960.313 | 960.313 | 339.687 | -1.PP_SO-102 |  | 339.687 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (75 °C) 1 | -3660.31 | 0.126734 | 65 | 1 | HT_přívodní vodní (75 °C) | ø65 | 76.1 | 68.9 | TR02.01.1332 | 1332 | yes | HT_přívodní vodní (75 °C) 1
13208491 | -1.PP_SO-102 | 334.049 | 0.00454772 | 0.0798628 | ø65 mm | 0 | 0.00145138 | HD | 1038.05 | 1000 | 1000 | -1.PP_SO-102 | 0 | 961.95 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (65 °C) 1 | -3034.45 | 0.0682139 | 65 | 1 | HT_vratné vodní (65 °C) | ø65 | 76.1 | 68.9 | TR02.01.1333 | 1333 | yes | HT_vratné vodní (65 °C) 1
13208500 | -1.PP_SO-102 | 620.625 | 0.00454772 | 0.148376 | ø65 mm | 0 | 0.00145138 | HD | 960.313 | 960.313 | 339.687 | -1.PP_SO-102 |  | 339.687 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (65 °C) 1 | -3660.31 | 0.126734 | 65 | 1 | HT_vratné vodní (65 °C) | ø65 | 76.1 | 68.9 | TR02.01.1334 | 1334 | yes | HT_vratné vodní (65 °C) 1
13208963 | -1.PP_SO-102 | 62.702 | 0.00454772 | 0.0149905 | ø65 mm | 0 | 0.00145138 | HD | 338.05 | 300 | 300 | -1.PP_SO-102 | 0 | 261.95 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (65 °C) 1 | -3734.45 | 0.012804 | 65 | 3 | HT_vratné vodní (65 °C) | ø65 | 76.1 | 68.9 | TR02.01.1335 | 1335 | yes | HT_vratné vodní (65 °C) 1
13208972 | -1.PP_SO-102 | 1886.65 | 0.00454772 | 0.451052 | ø65 mm | 0 | 0.00145138 | HD | 338.05 | 300 | 300 | -1.PP_SO-102 | 0 | 261.95 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (65 °C) 1 | -3734.45 | 0.385261 | 65 | 1 | HT_vratné vodní (65 °C) | ø65 | 76.1 | 68.9 | TR02.01.1336 | 1336 | yes | HT_vratné vodní (65 °C) 1
13215986 | 2.NP_SO-102 | 5627.08 | 0.00620623 | 1.57157 | ø80 mm | 0 | 0.00123762 | HD | 2694.45 | 2650 | 2650 | 2.NP_SO-102 | 0 | 2605.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6609.6 | 1.41424 | 80 | 514 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1346 | 1346 | yes | HT_vratné vodní (45 °C) 1
13216023 | 2.NP_SO-102 | 6006.23 | 0.00620623 | 1.67747 | ø80 mm | 0 | 0.00123762 | HD | 2694.45 | 2650 | 2650 | 2.NP_SO-102 | 0 | 2605.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6609.6 | 1.50953 | 80 | 354 | HT_přívodní vodní (55 °C) | ø80 | 88.9 | 80.8 | TR02.01.1347 | 1347 | yes | HT_přívodní vodní (55 °C) 9
13216261 | 2.NP_SO-102 | 417.297 | 0.00454772 | 0.0997654 | ø65 mm | 0 | 0.00145138 | HD | 2438.05 | 2400 | 2400 | 2.NP_SO-102 | 0 | 2361.95 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 1 | 6365.55 | 0.0852135 | 65 | 2 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.1352 | 1352 | yes | HT_přívodní vodní (55 °C) 1
13216278 | 2.NP_SO-102 | 25.3999 | 0.0138908 | 0.0106129 | ø125 mm | 0 | 0.0008 | HD | 1066.5 | 1000 | 1000 | 2.NP_SO-102 | 0 | 933.5 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 1 | 4937.5 | 0.00997453 | 125 | 1 | HT_přívodní vodní (55 °C) | ø125 | 133 | 125 | TR02.01.1353 | 1353 | yes | HT_přívodní vodní (55 °C) 1
13216279 | 2.NP_SO-102 | 1320.62 | 0.00454772 | 0.315729 | ø65 mm | 0 | 0.00145138 | HD | 2360.31 | 2360.31 | 1039.69 | 2.NP_SO-102 |  | 1039.69 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 1 | 5039.69 | 0.269676 | 65 | 2 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.1354 | 1354 | yes | HT_přívodní vodní (55 °C) 1
13216308 | 2.NP_SO-102 | 25.3997 | 0.00915951 | 0.00861793 | ø100 mm | 0 | 0.001 | HD | 1716 | 1662 | 1662 | 2.NP_SO-102 | 0 | 1608 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 1 | 5612 | 0.00797956 | 100 | 3 | HT_přívodní vodní (55 °C) | ø100 | 108 | 100 | TR02.01.1355 | 1355 | yes | HT_přívodní vodní (55 °C) 1
13216309 | 2.NP_SO-102 | 658.625 | 0.00454772 | 0.157461 | ø65 mm | 0 | 0.00145138 | HD | 2360.31 | 2360.31 | 1701.69 | 2.NP_SO-102 |  | 1701.69 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 1 | 5701.69 | 0.134494 | 65 | 2 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.1356 | 1356 | yes | HT_přívodní vodní (55 °C) 1
13216367 | 2.NP_SO-102 | 2020.62 | 0.00454772 | 0.483081 | ø65 mm | 0 | 0.00145138 | HD | 3060.31 | 3060.31 | 1039.69 | 2.NP_SO-102 |  | 1039.69 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 5039.69 | 0.412619 | 65 | 10 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1357 | 1357 | yes | HT_vratné vodní (45 °C) 7
13216503 | 2.NP_SO-102 | 97.3671 | 0.00454772 | 0.0232781 | ø65 mm | 0 | 0.00145138 | HD | 338.05 | 300 | 300 | 2.NP_SO-102 | 0 | 261.95 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 4265.55 | 0.0198827 | 65 | 9 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1358 | 1358 | yes | HT_vratné vodní (45 °C) 7
13216514 | 2.NP_SO-102 | 164.062 | 0.00454772 | 0.0392231 | ø65 mm | 0 | 0.00145138 | HD | 338.05 | 300 | 300 | 2.NP_SO-102 | 0 | 261.95 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 4265.55 | 0.033502 | 65 | 9 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1359 | 1359 | yes | HT_vratné vodní (45 °C) 7
13216960 | 2.NP_SO-102 | 53.8625 | 0.00620623 | 0.0150431 | ø80 mm | 0 | 0.00123762 | HD | 2694.45 | 2650 | 2650 | 2.NP_SO-102 | 0 | 2605.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6609.6 | 0.0135371 | 80 | 359 | HT_přívodní vodní (55 °C) | ø80 | 88.9 | 80.8 | TR02.01.1361 | 1361 | yes | HT_přívodní vodní (55 °C) 9
13216976 | 2.NP_SO-102 | 251.575 | 0.00620623 | 0.0702618 | ø80 mm | 0 | 0.00123762 | HD | 2603.96 | 2352.39 | 2603.96 | 2.NP_SO-102 |  | 2352.39 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6352.39 | 0.0632277 | 80 | 354 | HT_přívodní vodní (55 °C) | ø80 | 88.9 | 80.8 | TR02.01.1362 | 1362 | yes | HT_přívodní vodní (55 °C) 9
13217054 | 2.NP_SO-102 | 53.0688 | 0.00620623 | 0.0148214 | ø80 mm | 0 | 0.00123762 | HD | 2694.45 | 2650 | 2650 | 2.NP_SO-102 | 0 | 2605.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6609.6 | 0.0133376 | 80 | 241 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1364 | 1364 | yes | HT_vratné vodní (45 °C) 1
13217197 | 2.NP_SO-102 | 53.8625 | 0.00620623 | 0.0150431 | ø80 mm | 0 | 0.00123762 | HD | 2694.45 | 2650 | 2650 | 2.NP_SO-102 | 0 | 2605.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6609.6 | 0.0135371 | 80 | 279 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1365 | 1365 | yes | HT_vratné vodní (45 °C) 1
13217213 | 2.NP_SO-102 | 251.575 | 0.00620623 | 0.0702618 | ø80 mm | 0 | 0.00123762 | HD | 2603.96 | 2352.39 | 2603.96 | 2.NP_SO-102 |  | 2352.39 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6352.39 | 0.0632277 | 80 | 514 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1366 | 1366 | yes | HT_vratné vodní (45 °C) 1
13218558 | 2.NP_SO-102 | 300 | 0.00620623 | 0.0837863 | ø80 mm | 0 | 0.00123762 | HD | 1706.45 | 1662 | 1662 | 2.NP_SO-102 | 0 | 1617.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 5621.6 | 0.0753982 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.1384 | 1384 | yes | HT_přívodní vodní (65 °C) 5
13218579 | 2.NP_SO-102 | 5594.2 | 0.00620623 | 1.56239 | ø80 mm | 0 | 0.00123762 | HD | 2944.45 | 2900 | 2900 | 2.NP_SO-102 | 0 | 2855.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 6859.6 | 1.40598 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.1385 | 1385 | yes | HT_přívodní vodní (65 °C) 5
13218707 | 2.NP_SO-102 | 1145.92 | 0.00620623 | 0.320043 | ø80 mm | 0 | 0.00123762 | HD | 2853.96 | 2853.96 | 1708.04 | 2.NP_SO-102 |  | 1708.04 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 5708.04 | 0.288002 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.1386 | 1386 | yes | HT_přívodní vodní (65 °C) 5
13218772 | 2.NP_SO-102 | 1107.93 | 0.00620623 | 0.30943 | ø80 mm | 0 | 0.00123762 | HD | 2853.96 | 1746.04 | 2853.96 | 2.NP_SO-102 |  | 1746.04 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 5746.04 | 0.278452 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.1387 | 1387 | yes | HT_přívodní vodní (65 °C) 5
13218954 | 2.NP_SO-102 | 139.725 | 0.00620623 | 0.0390234 | ø80 mm | 0 | 0.00123762 | HD | 344.45 | 300 | 300 | 2.NP_SO-102 | 0 | 255.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 4259.6 | 0.0351167 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1388 | 1388 | yes | HT_vratné vodní (45 °C) 39
13219098 | 2.NP_SO-102 | 2507.93 | 0.00620623 | 0.700432 | ø80 mm | 0 | 0.00123762 | HD | 2853.96 | 2853.96 | 346.037 | 2.NP_SO-102 |  | 346.037 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 4346.04 | 0.63031 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1389 | 1389 | yes | HT_vratné vodní (45 °C) 39
13219111 | 2.NP_SO-102 | 5612.4 | 0.00620623 | 1.56747 | ø80 mm | 0 | 0.00123762 | HD | 2944.45 | 2900 | 2900 | 2.NP_SO-102 | 0 | 2855.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 6859.6 | 1.41055 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1390 | 1390 | yes | HT_vratné vodní (45 °C) 39
