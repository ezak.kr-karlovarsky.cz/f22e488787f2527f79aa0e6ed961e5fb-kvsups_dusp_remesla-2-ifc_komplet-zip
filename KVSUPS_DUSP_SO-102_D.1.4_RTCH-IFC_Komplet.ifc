Properties of the parts of a building model (IFC4), part 43 of 72

# IfcDistributionPort (10261)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_13395451_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395453_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395451_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395461_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395453_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13405125_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395493_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13405194_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395493_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395509_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395495_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395562_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395495_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395496_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395495_3 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13405194_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395527_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395529_3 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395527_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395541_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395529_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13405134_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395529_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13405137_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395530_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13405137_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395559_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395561_3 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395559_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395578_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395561_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13405140_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395561_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13405143_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395562_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13405143_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395597_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13405158_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395597_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13405125_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395607_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395672_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395607_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395608_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395607_3 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13405197_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395608_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13405134_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395627_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13405200_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395627_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395641_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395629_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395630_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395629_3 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13405200_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395630_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13405140_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395669_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395671_3 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395669_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395683_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395671_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13405158_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395671_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13405161_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395672_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13405161_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395859_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13395867_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13395859_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13396537_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13396336_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13403266_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13396336_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13403268_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13396371_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454210_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13396371_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13436123_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13396380_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454214_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13396380_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454220_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13396535_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13396537_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13396535_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13396541_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13396541_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13396857_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13396822_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13454250_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13396822_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13454252_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13396857_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13396871_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13396871_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13397434_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13396890_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13403463_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13396890_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13396950_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13396938_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13396940_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13396938_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13396950_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13397312_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13454242_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13397312_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13403268_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13397434_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454050_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13397442_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454050_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13397442_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454052_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13397481_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13403459_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13397481_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13403463_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13397487_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13403478_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13397487_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13403482_3 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13397594_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454040_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13397594_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454220_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13397886_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 6
Port_13436021_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 6
Port_13397886_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 6
Port_13404067_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 6
Port_13398353_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402080_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13398353_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402084_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13398499_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13398599_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13398499_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13399203_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13398565_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13407138_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13398565_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13435998_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13398597_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13398599_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13398597_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13398603_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13398603_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13400466_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13398630_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13407138_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13398630_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13398636_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13398636_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13400421_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13398964_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401325_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13398964_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405303_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13399012_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401385_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13399012_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13405309_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13399248_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13399289_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13399248_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402305_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13399450_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13399456_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13399450_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13402339_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13399903_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401355_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13399903_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402297_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13399913_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401355_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13399913_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405305_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13399937_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401585_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13399937_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13402331_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13399945_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401585_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13399945_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13405311_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13400421_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401303_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13400429_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401303_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13400429_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405313_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13400466_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401051_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13400474_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401051_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13400474_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13404103_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13400665_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13404069_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13400665_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13450636_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13400828_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401325_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13400828_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402391_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13400852_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401385_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13400852_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13402360_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401143_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401347_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401143_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13450658_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401315_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401317_3 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401315_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401327_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401317_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401348_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401317_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401318_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401318_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401830_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401327_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405303_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401345_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401347_3 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401345_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401357_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401347_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402036_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401348_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402035_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401357_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405305_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401375_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401377_3 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401375_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401387_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401377_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401578_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401377_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13405307_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401387_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13405309_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401575_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401577_3 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401575_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401587_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401577_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13404070_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401577_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401578_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401587_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13405311_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401660_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 6
Port_13404067_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 6
Port_13401660_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 6
Port_13401705_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13404103_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401705_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13405307_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13401745_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405315_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401745_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402078_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13401830_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405313_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402033_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402035_3 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402033_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402039_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402035_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402036_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402039_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405315_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402076_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402078_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402076_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402080_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402284_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402301_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402284_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402305_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402295_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402297_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402295_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402301_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402318_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13402335_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13402318_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13402339_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13402329_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13402331_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13402329_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13402335_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13402348_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13402364_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13402348_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13436065_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13402358_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13402360_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13402358_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13402364_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13402380_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402395_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402380_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402399_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402389_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402391_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402389_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402395_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402505_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402542_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402542_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402574_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402549_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402568_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402549_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402574_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402560_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13450932_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402560_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402568_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402595_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13402612_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13402595_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13453695_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13402604_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13402612_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13402604_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13404151_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13402627_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13453661_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13402627_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13453664_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13402634_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13453661_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13402634_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13404186_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13403455_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13403478_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13403455_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13403459_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13403475_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13404910_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13403475_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13454191_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13403482_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13404910_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13403482_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13403483_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13403483_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13454250_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13404069_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13404070_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13404069_3 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13404149_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13404151_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13404149_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13404252_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13404184_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13404186_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13404184_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13404854_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13404252_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13404546_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13404527_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13404544_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13404536_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13404544_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13404536_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13404554_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13404546_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13404554_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13404664_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13404672_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13404664_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13404849_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13404702_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13404849_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13404702_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13404854_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13404944_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13404946_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13405838_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13406459_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405838_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405852_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405844_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405852_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405844_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405927_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405854_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405929_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405854_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405925_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405927_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405925_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405929_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13405987_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13406657_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13405987_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13406001_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13405995_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13406001_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13405995_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13406041_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13406003_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13406045_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13406003_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13406039_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13406041_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13406039_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13406045_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13406736_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13406781_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13406744_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13406783_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13406744_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13406779_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13406781_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13406779_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13406783_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13406800_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13406814_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13406808_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13406814_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13406808_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13406859_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13406816_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13406863_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13406816_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13406857_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13406859_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13406857_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13406863_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13408063_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13408073_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13408063_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13408083_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13408065_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13408066_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13408065_3 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13408073_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13408066_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13421811_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13408145_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13408155_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13408145_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13408165_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13408147_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13408148_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13408147_3 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13408155_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13408148_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13421827_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
InPort_13408377_0 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
OutPort_13431594_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13408999_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409016_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13408999_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409010_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409012_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409010_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409016_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409012_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409032_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409012_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409013_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409013_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409323_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409020_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409035_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409020_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409029_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409031_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409029_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409035_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409031_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409032_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409103_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409118_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409103_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409114_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409116_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409114_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409118_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409135_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409150_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409135_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409144_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409146_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409144_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409150_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409146_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409166_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409146_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409147_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409147_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409351_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409154_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409169_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409154_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409163_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409165_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409163_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409169_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409165_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409166_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409173_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409186_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409173_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409182_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409184_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409182_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409186_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
OutPort_13409218_1 | SOURCE | PIPE | DOMESTICHOTWATER
InPort_13409218_2 | SINK | PIPE | HEATING
InPort_13409218_3 | SINK | PIPE | DOMESTICHOTWATER
OutPort_13409218_4 | SOURCE | PIPE | HEATING
InPort_13409218_5 | SINK | PIPE | DOMESTICCOLDWATER
Port_13409312_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409327_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409312_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409321_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409323_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409321_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409327_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409323_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409324_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409340_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409355_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409340_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409349_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409351_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409349_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409355_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409351_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409352_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
InPort_13409887_2 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13409889_2 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13412861_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13414140_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13414143_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13412861_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13413358_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13413388_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13413700_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13413358_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13426873_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13413700_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
Port_13413717_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13413760_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13413717_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13414593_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13413959_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13413984_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13413959_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13414033_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
InPort_13414099_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13414074_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13414074_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13414143_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
Port_13414593_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13426726_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13416196_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13416198_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13416196_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13416208_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13416198_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13416200_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13416231_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13416233_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13416231_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13416243_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13416233_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13416235_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13416308_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13416300_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13416300_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13416380_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
Port_13416336_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13416344_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13416336_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13416415_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
InPort_13416380_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13416378_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13416378_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13416391_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
Port_13416413_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13416415_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13416413_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13416425_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13416632_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13416921_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13416632_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13416925_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13416753_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13416755_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13416753_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13416925_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13416786_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13416788_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13416786_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13416798_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13416788_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13418221_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13416917_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13416919_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13416917_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13416921_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13416936_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13416963_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13416942_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13416959_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13416942_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13416963_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13416953_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13416955_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13416953_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13416959_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13418106_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13418108_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13418106_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13418122_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13418119_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13427580_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13418170_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13418910_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13418170_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13426593_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13418178_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13419301_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13418178_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13419825_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13418221_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13418899_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13418229_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13418899_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13418229_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13426527_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13418237_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13419269_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13418237_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13420244_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13418268_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13427271_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13418268_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13418921_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13418276_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13418921_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13418276_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13426470_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13418284_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13419379_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13418284_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13420280_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13418307_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13427282_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13418307_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13418321_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13418315_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13418321_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13418315_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13426379_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13418323_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13419341_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13418323_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13420323_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13419267_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13419269_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13419267_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13419281_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13419269_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13426506_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13419299_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13419301_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13419299_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13419313_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13419301_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13426572_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13419339_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13419349_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13419339_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13419359_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13419341_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13426354_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13419341_3 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13419349_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13419377_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13419387_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13419377_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13419397_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13419379_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13426451_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13419379_3 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13419387_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13419658_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13419825_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13419658_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13420093_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13419687_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13421964_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13419687_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13420244_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13419712_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13422038_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13419712_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13420280_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13419740_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13422067_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13419740_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13420323_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13419845_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13422063_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13419845_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13422067_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13419905_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13421960_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13419905_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13421964_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13419927_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13420093_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13419927_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13421897_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13419977_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13422034_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13419977_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13422038_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13421657_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13421897_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13421657_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13421901_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13421686_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13422170_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13421686_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13421960_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13421711_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13421811_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13421711_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13422034_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13421744_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13421827_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13421744_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13422063_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13422419_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13422964_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13422479_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13422838_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13422744_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13422757_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13422744_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13422767_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13422761_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13422767_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13422761_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13422813_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13422803_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13422813_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13422803_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13422838_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13422901_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13422984_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13422901_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13422976_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13422903_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13422980_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13422903_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13422984_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13422905_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13422980_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13422905_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13422964_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13426354_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13426387_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13426364_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13426383_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13426364_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13426387_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13426377_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13426379_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13426377_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13426383_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13426451_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13426478_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13426459_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13426474_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13426459_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13426478_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13426468_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13426470_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13426468_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13426474_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13426506_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13426535_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13426516_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13426531_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13426516_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13426535_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13426525_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13426527_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13426525_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13426531_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13426572_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
