Properties of the parts of a building model (IFC4), part 32 of 72

# IfcDistributionPort (10261)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_12990472_5 | SOURCEANDSINK | PIPE
Port_12990480_3 | SOURCEANDSINK | PIPE
Port_12990480_4 | SOURCEANDSINK | PIPE
Port_12990480_5 | SOURCEANDSINK | PIPE
Port_12990490_3 | SOURCEANDSINK | PIPE
Port_12990490_4 | SOURCEANDSINK | PIPE
Port_12990490_5 | SOURCEANDSINK | PIPE
InPort_12990502_1 | SINK | PIPE | HEATING
OutPort_12990502_2 | SOURCE | PIPE | HEATING
Port_12990510_3 | SOURCEANDSINK | PIPE
Port_12990510_4 | SOURCEANDSINK | PIPE
Port_12990510_5 | SOURCEANDSINK | PIPE
Port_12990614_3 | SOURCEANDSINK | PIPE
Port_12990614_4 | SOURCEANDSINK | PIPE
Port_12990614_5 | SOURCEANDSINK | PIPE
Port_12990628_3 | SOURCEANDSINK | PIPE
Port_12990628_4 | SOURCEANDSINK | PIPE
Port_12990628_5 | SOURCEANDSINK | PIPE
Port_12990640_3 | SOURCEANDSINK | PIPE
Port_12990640_4 | SOURCEANDSINK | PIPE
Port_12990640_5 | SOURCEANDSINK | PIPE
Port_12990804_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 8
Port_12990804_4 | SOURCEANDSINK | PIPE
Port_12990804_5 | SOURCEANDSINK | PIPE
Port_12991029_3 | SOURCEANDSINK | PIPE
Port_12991029_4 | SOURCEANDSINK | PIPE
Port_12991029_5 | SOURCEANDSINK | PIPE
Port_12991043_3 | SOURCEANDSINK | PIPE
Port_12991043_4 | SOURCEANDSINK | PIPE
Port_12991043_5 | SOURCEANDSINK | PIPE
InPort_12991454_1 | SINK | PIPE | HEATING
OutPort_12991454_2 | SOURCE | PIPE | HEATING
Port_12991587_3 | SOURCEANDSINK | PIPE
Port_12991587_4 | SOURCEANDSINK | PIPE
Port_12991587_5 | SOURCEANDSINK | PIPE
Port_12991660_3 | SOURCEANDSINK | PIPE
Port_12991660_4 | SOURCEANDSINK | PIPE
Port_12991660_5 | SOURCEANDSINK | PIPE
InPort_12991764_1 | SINK | PIPE | HEATING
OutPort_12991764_2 | SOURCE | PIPE | HEATING
InPort_12991837_1 | SINK | PIPE | HEATING
OutPort_12991837_2 | SOURCE | PIPE | HEATING
Port_12992021_3 | SOURCEANDSINK | PIPE
Port_12992021_4 | SOURCEANDSINK | PIPE
Port_12992021_5 | SOURCEANDSINK | PIPE
Port_12992031_3 | SOURCEANDSINK | PIPE
Port_12992031_4 | SOURCEANDSINK | PIPE
Port_12992031_5 | SOURCEANDSINK | PIPE
Port_12992047_3 | SOURCEANDSINK | PIPE
Port_12992047_4 | SOURCEANDSINK | PIPE
Port_12992047_5 | SOURCEANDSINK | PIPE
Port_12992055_3 | SOURCEANDSINK | PIPE
Port_12992055_4 | SOURCEANDSINK | PIPE
Port_12992055_5 | SOURCEANDSINK | PIPE
Port_12992063_3 | SOURCEANDSINK | PIPE
Port_12992063_4 | SOURCEANDSINK | PIPE
Port_12992063_5 | SOURCEANDSINK | PIPE
Port_12992125_3 | SOURCEANDSINK | PIPE
Port_12992125_4 | SOURCEANDSINK | PIPE
Port_12992125_5 | SOURCEANDSINK | PIPE
Port_12992220_3 | SOURCEANDSINK | PIPE
Port_12992220_4 | SOURCEANDSINK | PIPE
Port_12992220_5 | SOURCEANDSINK | PIPE
Port_12992228_3 | SOURCEANDSINK | PIPE
Port_12992228_4 | SOURCEANDSINK | PIPE
Port_12992228_5 | SOURCEANDSINK | PIPE
Port_12992238_3 | SOURCEANDSINK | PIPE
Port_12992238_4 | SOURCEANDSINK | PIPE
Port_12992238_5 | SOURCEANDSINK | PIPE
Port_12992248_3 | SOURCEANDSINK | PIPE
Port_12992248_4 | SOURCEANDSINK | PIPE
Port_12992248_5 | SOURCEANDSINK | PIPE
Port_12992349_3 | SOURCEANDSINK | PIPE
Port_12992349_4 | SOURCEANDSINK | PIPE
Port_12992349_5 | SOURCEANDSINK | PIPE
Port_12992357_3 | SOURCEANDSINK | PIPE
Port_12992357_4 | SOURCEANDSINK | PIPE
Port_12992357_5 | SOURCEANDSINK | PIPE
Port_12992554_3 | SOURCEANDSINK | PIPE
Port_12992554_4 | SOURCEANDSINK | PIPE
Port_12992554_5 | SOURCEANDSINK | PIPE
Port_12992630_3 | SOURCEANDSINK | PIPE
Port_12992630_4 | SOURCEANDSINK | PIPE
Port_12992630_5 | SOURCEANDSINK | PIPE
Port_12992664_3 | SOURCEANDSINK | PIPE
Port_12992664_4 | SOURCEANDSINK | PIPE
Port_12992664_5 | SOURCEANDSINK | PIPE
Port_12992761_3 | SOURCEANDSINK | PIPE
Port_12992761_4 | SOURCEANDSINK | PIPE
Port_12992761_5 | SOURCEANDSINK | PIPE
Port_12998728_3 | SOURCEANDSINK | PIPE
Port_12998728_4 | SOURCEANDSINK | PIPE
Port_12998728_5 | SOURCEANDSINK | PIPE
Port_12998808_3 | SOURCEANDSINK | PIPE
Port_12998808_4 | SOURCEANDSINK | PIPE
Port_12998808_5 | SOURCEANDSINK | PIPE
Port_12998860_3 | SOURCEANDSINK | PIPE
Port_12998860_4 | SOURCEANDSINK | PIPE
Port_12998860_5 | SOURCEANDSINK | PIPE
Port_12998870_3 | SOURCEANDSINK | PIPE
Port_12998870_4 | SOURCEANDSINK | PIPE
Port_12998870_5 | SOURCEANDSINK | PIPE
Port_12998880_3 | SOURCEANDSINK | PIPE
Port_12998880_4 | SOURCEANDSINK | PIPE
Port_12998880_5 | SOURCEANDSINK | PIPE
Port_12998890_3 | SOURCEANDSINK | PIPE
Port_12998890_4 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 17
Port_12998890_5 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 16
Port_12998902_3 | SOURCEANDSINK | PIPE
Port_12998902_4 | SOURCEANDSINK | PIPE
Port_12998902_5 | SOURCEANDSINK | PIPE
Port_12998910_3 | SOURCEANDSINK | PIPE
Port_12998910_4 | SOURCEANDSINK | PIPE
Port_12998910_5 | SOURCEANDSINK | PIPE
Port_12998971_3 | SOURCEANDSINK | PIPE
Port_12998971_4 | SOURCEANDSINK | PIPE
Port_12998971_5 | SOURCEANDSINK | PIPE
Port_12998979_3 | SOURCEANDSINK | PIPE
Port_12998979_4 | SOURCEANDSINK | PIPE
Port_12998979_5 | SOURCEANDSINK | PIPE
Port_12998989_3 | SOURCEANDSINK | PIPE
Port_12998989_4 | SOURCEANDSINK | PIPE
Port_12998989_5 | SOURCEANDSINK | PIPE
Port_12999165_3 | SOURCEANDSINK | PIPE
Port_12999165_4 | SOURCEANDSINK | PIPE
Port_12999165_5 | SOURCEANDSINK | PIPE
Port_12999175_3 | SOURCEANDSINK | PIPE
Port_12999175_4 | SOURCEANDSINK | PIPE
Port_12999175_5 | SOURCEANDSINK | PIPE
Port_12999185_3 | SOURCEANDSINK | PIPE
Port_12999185_4 | SOURCEANDSINK | PIPE
Port_12999185_5 | SOURCEANDSINK | PIPE
Port_12999252_3 | SOURCEANDSINK | PIPE
Port_12999252_4 | SOURCEANDSINK | PIPE
Port_12999252_5 | SOURCEANDSINK | PIPE
Port_12999285_3 | SOURCEANDSINK | PIPE
Port_12999285_4 | SOURCEANDSINK | PIPE
Port_12999285_5 | SOURCEANDSINK | PIPE
Port_12999403_3 | SOURCEANDSINK | PIPE
Port_12999403_4 | SOURCEANDSINK | PIPE
Port_12999403_5 | SOURCEANDSINK | PIPE
OutPort_12999716_1 | SOURCE | PIPE | HEATING
InPort_12999716_2 | SINK | PIPE | HEATING
Port_13006055_3 | SOURCEANDSINK | PIPE
Port_13006055_4 | SOURCEANDSINK | PIPE
Port_13006055_5 | SOURCEANDSINK | PIPE
Port_13006577_3 | SOURCEANDSINK | PIPE
Port_13006577_4 | SOURCEANDSINK | PIPE
Port_13006577_5 | SOURCEANDSINK | PIPE
Port_13006578_3 | SOURCEANDSINK | PIPE
Port_13006578_4 | SOURCEANDSINK | PIPE
Port_13006578_5 | SOURCEANDSINK | PIPE
Port_13007230_3 | SOURCEANDSINK | PIPE
Port_13007230_4 | SOURCEANDSINK | PIPE
Port_13007230_5 | SOURCEANDSINK | PIPE
Port_13007330_3 | SOURCEANDSINK | PIPE
Port_13007330_4 | SOURCEANDSINK | PIPE
Port_13007330_5 | SOURCEANDSINK | PIPE
Port_13007505_3 | SOURCEANDSINK | PIPE
Port_13007505_4 | SOURCEANDSINK | PIPE
Port_13007505_5 | SOURCEANDSINK | PIPE
Port_13007517_3 | SOURCEANDSINK | PIPE
Port_13007517_4 | SOURCEANDSINK | PIPE
Port_13007517_5 | SOURCEANDSINK | PIPE
Port_13007525_3 | SOURCEANDSINK | PIPE
Port_13007525_4 | SOURCEANDSINK | PIPE
Port_13007525_5 | SOURCEANDSINK | PIPE
Port_13007537_3 | SOURCEANDSINK | PIPE
Port_13007537_4 | SOURCEANDSINK | PIPE
Port_13007537_5 | SOURCEANDSINK | PIPE
Port_13007553_3 | SOURCEANDSINK | PIPE
Port_13007553_4 | SOURCEANDSINK | PIPE
Port_13007553_5 | SOURCEANDSINK | PIPE
OutPort_13016650_1 | SOURCE | PIPE | HEATING
InPort_13016650_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 24
InPort_13017183_1 | SINK | PIPE | HEATING
OutPort_13017183_2 | SOURCE | PIPE | HEATING
InPort_13017351_1 | SINK | PIPE | HEATING
OutPort_13017351_2 | SOURCE | PIPE | HEATING
InPort_13017393_1 | SINK | PIPE | HEATING
OutPort_13017393_2 | SOURCE | PIPE | HEATING
OutPort_13018099_1 | SOURCE | PIPE | HEATING
InPort_13018099_2 | SINK | PIPE | HEATING
OutPort_13019907_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 3
InPort_13019907_2 | SINK | PIPE | HEATING
Port_13020541_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
Port_13020776_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
Port_13020541_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
Port_13020567_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
Port_13020567_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
Port_13020596_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
Port_13020586_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
Port_13020596_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
Port_13020586_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
Port_13020702_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
Port_13020596_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
Port_13020597_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
Port_13020597_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
Port_13020651_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
Port_13020651_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
Port_13020777_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
Port_13020694_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
Port_13020702_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
Port_13020694_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
InPort_13020767_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
OutPort_13020776_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
InPort_13130063_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
OutPort_13020767_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
Port_13020776_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
Port_13020777_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 11
Port_13020846_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13020846_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13137205_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13020863_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13020874_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13020863_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13020874_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13137567_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13020883_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13020891_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13020883_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13020891_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13137573_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13020891_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13130103_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13020983_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
Port_13020983_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
Port_13021000_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
Port_13021000_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
Port_13021031_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
Port_13021002_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
Port_13042834_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
Port_13021002_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
Port_13021022_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
Port_13021030_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
Port_13021022_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
Port_13021030_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
Port_13042966_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
Port_13021030_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
Port_13021031_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
InPort_13021067_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13131356_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13131360_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13021067_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13021163_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
OutPort_13130761_3 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
InPort_13130809_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
OutPort_13021163_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
Port_13021184_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
Port_13130761_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
Port_13021184_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
Port_13042834_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 14
InPort_13333604_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
OutPort_13021300_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
InPort_13021300_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
OutPort_13333636_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
InPort_13434254_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
OutPort_13021888_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
InPort_13021888_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
OutPort_13130055_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
Port_13022062_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13362456_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13022062_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13362462_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13022269_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13362100_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13022269_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13137706_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13022797_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13137706_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13022797_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13070129_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13022845_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13096443_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13023342_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13022845_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13023139_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 17
OutPort_13139329_3 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 17
InPort_13139585_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 17
OutPort_13023139_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 17
InPort_13139130_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13023342_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023349_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 13
Port_13023349_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 13
Port_13023366_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 13
Port_13023358_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 13
Port_13023376_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 13
Port_13023358_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 13
Port_13023366_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 13
Port_13023368_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 13
Port_13023376_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 13
Port_13023368_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 13
Port_13023376_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 13
Port_13139330_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 13
Port_13023381_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13315103_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023381_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023401_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023389_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023390_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023389_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13315135_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023389_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13315103_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023390_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13362456_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023395_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023401_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023395_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023430_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023581_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023430_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13311901_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023432_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023581_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023432_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023578_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023583_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023578_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13047133_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023583_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13315105_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13023583_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13311901_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13023678_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
OutPort_13142192_3 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
InPort_13142246_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
OutPort_13023678_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
Port_13024072_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13024072_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13024087_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13024087_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13024115_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13024089_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13024678_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13024089_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13024106_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13024114_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13024106_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13024114_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13089314_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13024114_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13024115_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13024628_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13089313_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13024628_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13024678_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13141901_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13024821_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 13
Port_13139329_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 13
Port_13024821_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 13
Port_13024901_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 13
Port_13024893_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 13
Port_13024901_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 13
Port_13024893_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 13
Port_13025031_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13025031_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13025046_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13025046_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13144164_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
InPort_13025096_1 | SINK | PIPE | HEATING
OutPort_13025096_2 | SOURCE | PIPE | HEATING
Port_13025167_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13025295_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13025167_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13025208_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13025176_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13440884_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13025176_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13025203_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13025208_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13025203_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13144163_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
InPort_13025209_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
OutPort_13025208_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
InPort_13143696_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
OutPort_13025209_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
Port_13025274_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13143436_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13025274_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13025287_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13025295_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13025287_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13025295_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13025296_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13025296_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13440884_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13025300_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13404944_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13025300_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13404948_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13025309_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13315135_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13025309_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13404946_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13025314_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13404948_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13025314_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13079959_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13025491_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13025491_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13311490_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13025500_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13079959_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13025516_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13025500_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13025508_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13025516_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13025652_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13025508_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13025646_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13025652_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13025743_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13025646_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13025654_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13311481_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13025759_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13025654_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13025741_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13025743_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13025747_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13025741_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13311481_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13025747_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13025751_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13026181_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13025751_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13025917_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
InPort_13026251_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13025759_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13025768_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13025977_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13025768_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13025917_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13025978_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13025977_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13026031_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13025977_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13025978_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13026022_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13026164_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13026022_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13026031_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13026164_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13026034_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026110_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026034_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026046_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026530_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026046_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026110_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026531_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026175_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13026181_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13026175_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13026181_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13026232_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13026185_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13026250_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13026185_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13026232_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
Port_13026250_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 20
InPort_13026251_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13026250_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13026392_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
OutPort_13026711_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
InPort_13026724_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
OutPort_13026392_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
InPort_13026711_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
OutPort_13026469_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
InPort_13026469_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
OutPort_13026580_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026530_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026602_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026530_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026531_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
InPort_13026580_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
OutPort_13311804_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026585_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13124535_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026585_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026613_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026593_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026601_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026593_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026601_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13124536_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026601_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026602_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026605_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026613_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026605_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
InPort_13026623_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
OutPort_13086816_3 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
InPort_13086939_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
OutPort_13026623_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026630_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13086816_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13026630_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13124535_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
InPort_13026716_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
OutPort_13026724_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
InPort_13026732_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
OutPort_13026716_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
InPort_13026726_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
OutPort_13026732_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
InPort_13026839_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
OutPort_13026726_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
InPort_13026831_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
OutPort_13026839_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
InPort_13094716_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
OutPort_13026831_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
InPort_13132244_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 23
OutPort_13026893_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 23
InPort_13026893_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 23
OutPort_13181948_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 23
InPort_13181919_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 29
OutPort_13026901_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 29
InPort_13026901_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 29
OutPort_13182012_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 29
InPort_13182014_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 29
OutPort_13026918_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 29
InPort_13026918_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 29
Port_13026937_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13026972_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13026937_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13026953_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13026947_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13026953_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13026947_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13026966_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13026972_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13026966_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13026972_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13026973_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13026973_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13182951_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13027118_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13124587_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13027118_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
Port_13027569_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13091088_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13027569_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097412_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13027803_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13027811_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13027803_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028106_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13027811_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13069783_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13027972_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13323076_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13027972_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13323080_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028095_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028110_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028095_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13089063_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028104_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028106_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028104_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028110_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028224_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13080021_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13028224_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13080024_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13028359_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13432301_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028359_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13432305_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028386_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13033153_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028386_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028392_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028392_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13129555_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028457_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13046468_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028457_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13046472_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028611_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13046516_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028611_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028663_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028663_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13046472_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028698_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13129554_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13028698_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13029279_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13113118_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13029279_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13327809_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13029311_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13312922_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13029311_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13312926_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13029323_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13316434_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13029323_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13029354_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13029354_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13029366_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13029366_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13339234_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13029462_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13327807_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13029462_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13327811_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030549_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13121276_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030549_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030566_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030566_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030616_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030607_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13119540_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030607_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13119668_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030616_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13119540_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030646_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030646_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030664_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030653_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030664_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030653_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030672_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030672_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030744_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030714_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030743_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030714_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030759_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030743_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031857_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030743_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030744_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030748_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030763_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030748_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030886_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030757_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030759_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030757_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030763_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030878_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030886_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13030878_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031581_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031598_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031581_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031590_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031598_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031590_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031606_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031606_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13121796_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031608_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13121220_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031608_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13121462_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031672_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13121291_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031672_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13121462_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031771_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13342503_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031771_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13312483_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031777_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13312483_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031777_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13312469_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031856_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13121171_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031856_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031857_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031856_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13342508_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031931_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13312469_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031931_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031945_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031945_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13032531_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031947_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13032528_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13031947_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13032530_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13032340_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13032528_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13032340_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13032530_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13032550_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13032530_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13032531_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13032550_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13032586_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13093530_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13094041_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13032586_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13032946_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13066655_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13032946_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13032960_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13032954_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13032960_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13032954_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13032975_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13032964_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13032975_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13032964_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13432301_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13033153_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13432217_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13033179_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13094171_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13094946_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13033179_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13033191_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13066655_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13033191_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13033429_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13033191_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13311827_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13033429_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13070122_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13033480_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13099749_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13099078_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13033480_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13033557_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
OutPort_13149283_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
InPort_13149256_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
OutPort_13033557_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13033807_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13033807_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13033822_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13033822_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13149066_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13033824_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13033892_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13033824_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13033854_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13033846_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13033854_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13033846_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13033884_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13033892_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13033884_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13033892_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13033916_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13033916_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13149065_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
InPort_13034023_1 | SINK | PIPE | HEATING
OutPort_13034023_2 | SOURCE | PIPE | HEATING
InPort_13034108_1 | SINK | PIPE | HEATING
OutPort_13034108_2 | SOURCE | PIPE | HEATING
Port_13034174_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13034174_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13149281_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13034183_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13149281_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13034183_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13149283_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
InPort_13034204_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 18
OutPort_13149034_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 18
InPort_13149756_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 18
OutPort_13034204_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 18
Port_13034684_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 2
Port_13034684_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 2
Port_13148790_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 2
Port_13035461_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 2
Port_13148724_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 2
Port_13035461_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 2
Port_13035498_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 2
Port_13148724_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 2
Port_13035498_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 2
Port_13035507_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13035507_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13147646_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13035533_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13035548_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13035533_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13035548_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13316545_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13035550_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13146857_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13035550_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13035576_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13035668_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13035576_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13035668_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13035832_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13035668_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13316539_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13035832_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13146857_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13035855_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13316542_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13035855_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13316544_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13035920_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13145060_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13035920_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13145140_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036050_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036050_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036088_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036088_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13105931_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036411_3 | SOURCEANDSINK | PIPE
Port_13036411_4 | SOURCEANDSINK | PIPE
Port_13036411_5 | SOURCEANDSINK | PIPE
Port_13036422_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036430_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036422_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036430_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036841_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036430_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13106028_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036452_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13144305_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036452_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13144419_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036761_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036840_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036761_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036775_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036767_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036775_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036767_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036823_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036823_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036844_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036830_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036840_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036830_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036844_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036840_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13036841_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13037688_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13037688_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13037797_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13037697_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13037826_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13037697_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13037799_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13037736_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13037736_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13037799_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13037797_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13145061_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13037806_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13037814_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13037806_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
