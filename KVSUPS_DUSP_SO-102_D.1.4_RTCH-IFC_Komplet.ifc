Properties of the parts of a building model (IFC4), part 60 of 72

# IfcPipeSegment: Typy trubek:Kompozit PE-Xa_RAUTITAN flex (676)
Name (Typy trubek:Kompozit PE-Xa_RAUTITAN flex:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Relativní drsnost | Sklon | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Typ systému | Drsnost (mm) | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group
13103919 | 3.NP_SO-102 | 5599.16 | 0.000201032 | 0.281445 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7934.2 | RAU–PE–Xa | 16 | 456 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0677 | 0677 | no | HT_vratné vodní (45 °C) 13
13103952 | 3.NP_SO-102 | 277.712 | 0.000201032 | 0.0139594 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7934.2 | RAU–PE–Xa | 16 | 449 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0678 | 0678 | no | HT_vratné vodní (45 °C) 13
13103963 | 3.NP_SO-102 | 600 | 0.000201032 | 0.0301593 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 44 | 7944.2 | RAU–PE–Xa | 16 | 1 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0679 | 0679 | no | HT_přívodní vodní (65 °C) 44
13103974 | 3.NP_SO-102 | 284.063 | 0.000201032 | 0.0142785 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7934.2 | RAU–PE–Xa | 16 | 450 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0680 | 0680 | no | HT_vratné vodní (45 °C) 13
13104332 | 3.NP_SO-102 | 5452.63 | 0.000201032 | 0.274079 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 7944.2 | RAU–PE–Xa | 16 | 341 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0681 | 0681 | no | HT_přívodní vodní (55 °C) 19
13104376 | 3.NP_SO-102 | 7630.23 | 0.000201032 | 0.383537 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7934.2 | RAU–PE–Xa | 16 | 349 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0683 | 0683 | no | HT_vratné vodní (45 °C) 13
13104568 | 3.NP_SO-102 | 5096.9 | 0.000201032 | 0.256198 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7934.2 | RAU–PE–Xa | 16 | 14 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0685 | 0685 | no | HT_vratné vodní (45 °C) 13
13104579 | 3.NP_SO-102 | 427.712 | 0.000201032 | 0.0214992 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7934.2 | RAU–PE–Xa | 16 | 15 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0686 | 0686 | no | HT_vratné vodní (45 °C) 13
13104590 | 3.NP_SO-102 | 5984.06 | 0.000201032 | 0.300792 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7934.2 | RAU–PE–Xa | 16 | 14 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0687 | 0687 | no | HT_vratné vodní (45 °C) 13
13104647 | 3.NP_SO-102 | 1252.5 | 0.000201032 | 0.0629576 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7934.2 | RAU–PE–Xa | 16 | 350 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0688 | 0688 | no | HT_vratné vodní (45 °C) 13
13104662 | 3.NP_SO-102 | 1635.51 | 0.000201032 | 0.0822098 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7934.2 | RAU–PE–Xa | 16 | 12 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0689 | 0689 | no | HT_vratné vodní (45 °C) 13
13104893 | 3.NP_SO-102 | 7678.54 | 0.000314112 | 0.482457 | ø20 mm | 0.000694444 | 0 | 3.NP_SO-102 | -50 | -60 | -60 | -70 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7932.8 | RAU–PE–Xa | 20 | 417 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0692 | 0692 | no | HT_vratné vodní (45 °C) 13
13104990 | 3.NP_SO-102 | 5940.17 | 0.000201032 | 0.298586 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7934.2 | RAU–PE–Xa | 16 | 1 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0693 | 0693 | no | HT_vratné vodní (45 °C) 13
13105001 | 3.NP_SO-102 | 897.679 | 0.000201032 | 0.0451223 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7934.2 | RAU–PE–Xa | 16 | 462 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0694 | 0694 | no | HT_vratné vodní (45 °C) 13
13105066 | 3.NP_SO-102 | 296.175 | 0.000201032 | 0.0148874 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 7934.2 | RAU–PE–Xa | 16 | 6 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0695 | 0695 | no | HT_vratné vodní (45 °C) 13
13105889 | 4.NP_SO-102 | 427.712 | 0.000201032 | 0.0214992 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 472 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0704 | 0704 | no | HT_přívodní vodní (55 °C) 19
13105931 | 4.NP_SO-102 | 4001.77 | 0.000201032 | 0.201151 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 452 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0705 | 0705 | no | HT_přívodní vodní (55 °C) 19
13106028 | 4.NP_SO-102 | 1214.79 | 0.000201032 | 0.0610622 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 457 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0706 | 0706 | no | HT_přívodní vodní (55 °C) 19
13106044 | 4.NP_SO-102 | 284.063 | 0.000201032 | 0.0142785 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 103 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0707 | 0707 | no | HT_vratné vodní (45 °C) 13
13106074 | 4.NP_SO-102 | 277.712 | 0.000201032 | 0.0139594 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 485 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0708 | 0708 | no | HT_vratné vodní (45 °C) 13
13106085 | 4.NP_SO-102 | 277.713 | 0.000201032 | 0.0139594 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 480 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0709 | 0709 | no | HT_vratné vodní (45 °C) 13
13106096 | 4.NP_SO-102 | 284.062 | 0.000201032 | 0.0142785 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 474 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0710 | 0710 | no | HT_vratné vodní (45 °C) 13
13106118 | 4.NP_SO-102 | 134.063 | 0.000201032 | 0.00673872 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 477 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0711 | 0711 | no | HT_vratné vodní (45 °C) 13
13106138 | 4.NP_SO-102 | 7314.33 | 0.000201032 | 0.367659 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 481 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0713 | 0713 | no | HT_vratné vodní (45 °C) 13
13106240 | 4.NP_SO-102 | 3904.22 | 0.000201032 | 0.196248 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 103 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0714 | 0714 | no | HT_vratné vodní (45 °C) 13
13106414 | 4.NP_SO-102 | 708.717 | 0.000201032 | 0.035624 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 474 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0715 | 0715 | no | HT_vratné vodní (45 °C) 13
13106424 | 4.NP_SO-102 | 1402.12 | 0.000201032 | 0.0704783 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 477 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0716 | 0716 | no | HT_vratné vodní (45 °C) 13
13106472 | 4.NP_SO-102 | 8820.15 | 0.000201032 | 0.443349 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 472 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0717 | 0717 | no | HT_vratné vodní (45 °C) 13
13106562 | 4.NP_SO-102 | 334.063 | 0.000201032 | 0.0167918 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 509 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0718 | 0718 | no | HT_vratné vodní (45 °C) 13
13106573 | 4.NP_SO-102 | 4056.75 | 0.000201032 | 0.203914 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 516 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0719 | 0719 | no | HT_vratné vodní (45 °C) 13
13106584 | 4.NP_SO-102 | 327.713 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 520 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0720 | 0720 | no | HT_vratné vodní (45 °C) 13
13106595 | 4.NP_SO-102 | 327.713 | 0.000201032 | 0.0164726 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 519 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0721 | 0721 | no | HT_vratné vodní (45 °C) 13
13106606 | 4.NP_SO-102 | 334.062 | 0.000201032 | 0.0167918 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 516 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0722 | 0722 | no | HT_vratné vodní (45 °C) 13
13106617 | 4.NP_SO-102 | 6701.37 | 0.000201032 | 0.336847 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 521 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0723 | 0723 | no | HT_vratné vodní (45 °C) 13
13106777 | 4.NP_SO-102 | 5434.4 | 0.000201032 | 0.273163 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 514 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0725 | 0725 | no | HT_vratné vodní (45 °C) 13
13108050 | 4.NP_SO-102 | 5869.36 | 0.000201032 | 0.295026 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 14 | 11934.2 | RAU–PE–Xa | 16 | 1 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0739 | 0739 | no | HT_vratné vodní (45 °C) 14
13108061 | 4.NP_SO-102 | 1517.71 | 0.000201032 | 0.0762886 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 113 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0740 | 0740 | no | HT_vratné vodní (45 °C) 13
13108161 | 4.NP_SO-102 | 12.7125 | 0.000201032 | 0.000639 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 528 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0741 | 0741 | no | HT_vratné vodní (45 °C) 13
13108194 | 4.NP_SO-102 | 297.933 | 0.000201032 | 0.0149758 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | 11934.2 | RAU–PE–Xa | 16 | 529 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0742 | 0742 | no | HT_vratné vodní (45 °C) 13
13109406 | -1.PP_SO-102 | 835.712 | 0.000201032 | 0.0420075 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 126 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0757 | 0757 | no | HT_vratné vodní (45 °C) 13
13109428 | -1.PP_SO-102 | 504.216 | 0.000201032 | 0.0253447 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 148 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0758 | 0758 | no | HT_vratné vodní (45 °C) 13
13109439 | -1.PP_SO-102 | 6124.84 | 0.000201032 | 0.307868 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 148 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0759 | 0759 | no | HT_vratné vodní (45 °C) 13
13109461 | -1.PP_SO-102 | 829.362 | 0.000201032 | 0.0416883 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 127 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0760 | 0760 | no | HT_vratné vodní (45 °C) 13
13109523 | -1.PP_SO-102 | 5813.94 | 0.000201032 | 0.29224 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 126 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0761 | 0761 | no | HT_vratné vodní (45 °C) 13
13109531 | -1.PP_SO-102 | 670.783 | 0.000201032 | 0.0337173 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 159 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0762 | 0762 | no | HT_vratné vodní (45 °C) 13
13109584 | -1.PP_SO-102 | 8373.9 | 0.000201032 | 0.420918 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 149 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0763 | 0763 | no | HT_vratné vodní (45 °C) 13
13109710 | -1.PP_SO-102 | 1010.99 | 0.000201032 | 0.0508177 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4055.8 | RAU–PE–Xa | 16 | 346 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0764 | 0764 | no | HT_přívodní vodní (55 °C) 19
13109776 | -1.PP_SO-102 | 575.201 | 0.000201032 | 0.0289127 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 139 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0766 | 0766 | no | HT_vratné vodní (45 °C) 13
13109787 | -1.PP_SO-102 | 991.026 | 0.000201032 | 0.0498144 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 144 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0767 | 0767 | no | HT_vratné vodní (45 °C) 13
13109809 | -1.PP_SO-102 | 2607.71 | 0.000201032 | 0.131078 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 143 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0768 | 0768 | no | HT_vratné vodní (45 °C) 13
13109959 | -1.PP_SO-102 | 1010.99 | 0.000201032 | 0.0508177 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 140 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0769 | 0769 | no | HT_vratné vodní (45 °C) 13
13111802 | -1.PP_SO-102 | 6289.14 | 0.000201032 | 0.316127 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 175 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0778 | 0778 | no | HT_vratné vodní (45 °C) 13
13111813 | -1.PP_SO-102 | 4262.55 | 0.000201032 | 0.214259 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 160 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0779 | 0779 | no | HT_vratné vodní (45 °C) 13
13111833 | -1.PP_SO-102 | 427.829 | 0.000201032 | 0.0215051 | ø16 mm | 0.000862069 | 2.33802 | -1.PP_SO-102 | -42.0022 | -50 | -60 | -67.9978 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 163 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0780 | 0780 | no | HT_vratné vodní (45 °C) 13
13111844 | -1.PP_SO-102 | 434.063 | 0.000201032 | 0.0218184 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 162 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0781 | 0781 | no | HT_vratné vodní (45 °C) 13
13111855 | -1.PP_SO-102 | 3819.75 | 0.000201032 | 0.192001 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 162 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0782 | 0782 | no | HT_vratné vodní (45 °C) 13
13111988 | -1.PP_SO-102 | 563.915 | 0.000201032 | 0.0283455 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 363 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0784 | 0784 | no | HT_vratné vodní (45 °C) 13
13112009 | -1.PP_SO-102 | 495.57 | 0.000201032 | 0.0249101 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 161 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0785 | 0785 | no | HT_vratné vodní (45 °C) 13
13112721 | -1.PP_SO-102 | 993.243 | 0.000201032 | 0.0499258 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 176 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0794 | 0794 | no | HT_vratné vodní (45 °C) 13
13112729 | -1.PP_SO-102 | 412.304 | 0.000201032 | 0.0207246 | ø16 mm | 0.000862069 | 2.42611 | -1.PP_SO-102 | -42.0024 | -50 | -60 | -67.9976 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4065.8 | RAU–PE–Xa | 16 | 322 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0795 | 0795 | no | HT_přívodní vodní (55 °C) 19
13112847 | -1.PP_SO-102 | 1581.1 | 0.000201032 | 0.0794746 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4065.8 | RAU–PE–Xa | 16 | 201 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0796 | 0796 | no | HT_přívodní vodní (55 °C) 19
13112863 | -1.PP_SO-102 | 6289.14 | 0.000201032 | 0.316127 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4065.8 | RAU–PE–Xa | 16 | 321 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0797 | 0797 | no | HT_přívodní vodní (55 °C) 19
13112999 | -1.PP_SO-102 | 1453.46 | 0.000201032 | 0.0730588 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 13 | -4065.8 | RAU–PE–Xa | 16 | 160 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0798 | 0798 | no | HT_vratné vodní (45 °C) 13
13114692 | 2.NP_SO-102 | 266.166 | 0.000201032 | 0.013379 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 528 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0819 | 0819 | no | HT_vratné vodní (45 °C) 1
13114707 | 2.NP_SO-102 | 2094.06 | 0.000201032 | 0.105259 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 15 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0820 | 0820 | no | HT_vratné vodní (45 °C) 1
13114761 | 2.NP_SO-102 | 3044.06 | 0.000201032 | 0.153011 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 528 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0821 | 0821 | no | HT_vratné vodní (45 °C) 1
13114847 | 2.NP_SO-102 | 370.871 | 0.000201032 | 0.018642 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 529 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0822 | 0822 | no | HT_vratné vodní (45 °C) 1
13114878 | 2.NP_SO-102 | 319.362 | 0.000201032 | 0.0160529 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 530 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0823 | 0823 | no | HT_vratné vodní (45 °C) 1
13114889 | 2.NP_SO-102 | 319.362 | 0.000201032 | 0.0160529 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 531 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0824 | 0824 | no | HT_vratné vodní (45 °C) 1
13114934 | 2.NP_SO-102 | 369.221 | 0.000201032 | 0.0185591 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 653 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0825 | 0825 | no | HT_vratné vodní (45 °C) 1
13114945 | 2.NP_SO-102 | 2114.57 | 0.000201032 | 0.10629 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 13 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0826 | 0826 | no | HT_vratné vodní (45 °C) 1
13114975 | 2.NP_SO-102 | 2482.34 | 0.000201032 | 0.124776 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 17 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0827 | 0827 | no | HT_vratné vodní (45 °C) 1
13115013 | 2.NP_SO-102 | 2558.73 | 0.000201032 | 0.128616 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 527 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0828 | 0828 | no | HT_vratné vodní (45 °C) 1
13115049 | 2.NP_SO-102 | 1586.01 | 0.000201032 | 0.0797217 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 648 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0829 | 0829 | no | HT_vratné vodní (45 °C) 1
13115086 | 2.NP_SO-102 | 2471.19 | 0.000201032 | 0.124216 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 644 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0830 | 0830 | no | HT_vratné vodní (45 °C) 1
13115128 | 2.NP_SO-102 | 519.221 | 0.000201032 | 0.0260989 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 55 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0831 | 0831 | no | HT_přívodní vodní (55 °C) 9
13115139 | 2.NP_SO-102 | 1945.71 | 0.000201032 | 0.0978022 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 481 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0832 | 0832 | no | HT_přívodní vodní (55 °C) 9
13115150 | 2.NP_SO-102 | 469.362 | 0.000201032 | 0.0235927 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 13 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0833 | 0833 | no | HT_přívodní vodní (55 °C) 9
13115161 | 2.NP_SO-102 | 469.362 | 0.000201032 | 0.0235927 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 53 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0834 | 0834 | no | HT_přívodní vodní (55 °C) 9
13115172 | 2.NP_SO-102 | 520.871 | 0.000201032 | 0.0261818 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 6 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0835 | 0835 | no | HT_přívodní vodní (55 °C) 9
13115183 | 2.NP_SO-102 | 2894.06 | 0.000201032 | 0.145471 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 3 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0836 | 0836 | no | HT_přívodní vodní (55 °C) 9
13115243 | 2.NP_SO-102 | 1964.57 | 0.000201032 | 0.09875 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 54 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0837 | 0837 | no | HT_přívodní vodní (55 °C) 9
13115319 | 2.NP_SO-102 | 266.166 | 0.000201032 | 0.013379 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 3 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0838 | 0838 | no | HT_přívodní vodní (55 °C) 9
13115380 | 2.NP_SO-102 | 2215.02 | 0.000201032 | 0.111339 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 482 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0839 | 0839 | no | HT_přívodní vodní (55 °C) 9
13115505 | 2.NP_SO-102 | 585.075 | 0.000201032 | 0.0294091 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 16 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0840 | 0840 | no | HT_vratné vodní (45 °C) 1
13115514 | 2.NP_SO-102 | 2445.71 | 0.000201032 | 0.122935 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 3934.2 | RAU–PE–Xa | 16 | 15 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0841 | 0841 | no | HT_vratné vodní (45 °C) 1
13115599 | 2.NP_SO-102 | 735.075 | 0.000201032 | 0.0369489 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 45 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0843 | 0843 | no | HT_přívodní vodní (55 °C) 9
13115669 | 2.NP_SO-102 | 2093.17 | 0.000201032 | 0.105214 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 481 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0845 | 0845 | no | HT_přívodní vodní (55 °C) 9
13115677 | 2.NP_SO-102 | 1586.01 | 0.000201032 | 0.0797217 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 479 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0846 | 0846 | no | HT_přívodní vodní (55 °C) 9
13116099 | 2.NP_SO-102 | 2482.34 | 0.000201032 | 0.124776 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 2 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0849 | 0849 | no | HT_přívodní vodní (55 °C) 9
13116120 | 2.NP_SO-102 | 2558.73 | 0.000201032 | 0.128616 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 52 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0850 | 0850 | no | HT_přívodní vodní (55 °C) 9
13117034 | 3.NP_SO-102 | 4211.42 | 0.000201032 | 0.211689 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 724 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0853 | 0853 | no | HT_vratné vodní (45 °C) 1
13117045 | 3.NP_SO-102 | 15398.8 | 0.000201032 | 0.774027 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 724 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0854 | 0854 | no | HT_vratné vodní (45 °C) 1
13117056 | 3.NP_SO-102 | 4774.3 | 0.000201032 | 0.239983 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 725 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0855 | 0855 | no | HT_vratné vodní (45 °C) 1
13117067 | 3.NP_SO-102 | 7270.56 | 0.000201032 | 0.365458 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 725 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0856 | 0856 | no | HT_vratné vodní (45 °C) 1
13117078 | 3.NP_SO-102 | 1923.28 | 0.000201032 | 0.0966745 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 725 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0857 | 0857 | no | HT_vratné vodní (45 °C) 1
13117231 | 3.NP_SO-102 | 977.89 | 0.000201032 | 0.0491541 | ø16 mm | 0.000862069 | 0.216817 | 3.NP_SO-102 | -42 | -50 | -52.1202 | -60.1202 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7942.08 | RAU–PE–Xa | 16 | 22 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0858 | 0858 | no | HT_vratné vodní (45 °C) 1
13117302 | 4.NP_SO-102 | 775.125 | 0.000201032 | 0.038962 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11944.2 | RAU–PE–Xa | 16 | 736 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0859 | 0859 | no | HT_vratné vodní (45 °C) 1
13117313 | 4.NP_SO-102 | 5110.02 | 0.000201032 | 0.256857 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 11944.2 | RAU–PE–Xa | 16 | 736 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0860 | 0860 | no | HT_vratné vodní (45 °C) 1
13117768 | 3.NP_SO-102 | 3591.21 | 0.000201032 | 0.180514 | ø16 mm | 0.000862069 | 0.216728 | 3.NP_SO-102 | -44.2169 | -52.2169 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | 7934.2 | RAU–PE–Xa | 16 | 522 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0862 | 0862 | no | HT_vratné vodní (45 °C) 1
13118408 | 1.NP_SO-102 | 134.062 | 0.000201032 | 0.00673872 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 28 | -65.8 | RAU–PE–Xa | 16 | 8 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0866 | 0866 | no | HT_vratné vodní (45 °C) 28
13118430 | 1.NP_SO-102 | 2737.59 | 0.000201032 | 0.137606 | ø16 mm | 0.000862069 | 0.0730569 | 1.NP_SO-102 | -50 | -58 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | -65.8 | RAU–PE–Xa | 16 | 1 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0867 | 0867 | no | HT_vratné vodní (45 °C) 32
13118452 | 1.NP_SO-102 | 653.272 | 0.000201032 | 0.032837 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | -65.8 | RAU–PE–Xa | 16 | 18 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0868 | 0868 | no | HT_vratné vodní (45 °C) 32
13118463 | 1.NP_SO-102 | 182.631 | 0.000201032 | 0.00918004 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -50 | -58 | -58 | -66 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | -63.8 | RAU–PE–Xa | 16 | 32 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0869 | 0869 | no | HT_vratné vodní (45 °C) 32
13118474 | 1.NP_SO-102 | 2089.24 | 0.000201032 | 0.105017 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -50 | -58 | -58 | -66 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | -63.8 | RAU–PE–Xa | 16 | 32 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0870 | 0870 | no | HT_vratné vodní (45 °C) 32
13118677 | 1.NP_SO-102 | 8115.12 | 0.000201032 | 0.40791 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | -65.8 | RAU–PE–Xa | 16 | 11 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0871 | 0871 | no | HT_vratné vodní (45 °C) 32
13118842 | 1.NP_SO-102 | 503.072 | 0.000201032 | 0.0252871 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -55.8 | RAU–PE–Xa | 16 | 567 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0872 | 0872 | no | HT_přívodní vodní (55 °C) 9
13118902 | 2.NP_SO-102 | 539.08 | 0.000201032 | 0.0270971 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | 3934.2 | RAU–PE–Xa | 16 | 6 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0873 | 0873 | no | HT_vratné vodní (45 °C) 32
13118924 | 2.NP_SO-102 | 704.391 | 0.000201032 | 0.0354065 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | 3934.2 | RAU–PE–Xa | 16 | 22 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0874 | 0874 | no | HT_vratné vodní (45 °C) 32
13118994 | 2.NP_SO-102 | 4521.78 | 0.000201032 | 0.227289 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | 3934.2 | RAU–PE–Xa | 16 | 6 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0875 | 0875 | no | HT_vratné vodní (45 °C) 32
13119065 | 2.NP_SO-102 | 513.793 | 0.000201032 | 0.025826 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | 3934.2 | RAU–PE–Xa | 16 | 5 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0876 | 0876 | no | HT_vratné vodní (45 °C) 32
13119071 | 2.NP_SO-102 | 691.981 | 0.000201032 | 0.0347828 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | 3934.2 | RAU–PE–Xa | 16 | 22 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0877 | 0877 | no | HT_vratné vodní (45 °C) 32
13119157 | 1.NP_SO-102 | 145.103 | 0.000201032 | 0.0072937 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -55.8 | RAU–PE–Xa | 16 | 568 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0878 | 0878 | no | HT_přívodní vodní (55 °C) 9
13119564 | -1.PP_SO-102 | 742.538 | 0.000314112 | 0.046655 | ø20 mm | 0.000694444 | 0 | -1.PP_SO-102 | -40 | -50 | -50 | -60 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -4057.2 | RAU–PE–Xa | 20 | 381 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0880 | 0880 | no | HT_přívodní vodní (55 °C) 9
13119703 | -1.PP_SO-102 | 3845.08 | 0.000314112 | 0.241593 | ø20 mm | 0.000694444 | 0 | -1.PP_SO-102 | -50 | -60 | -60 | -70 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | -4067.2 | RAU–PE–Xa | 20 | 47 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0881 | 0881 | no | HT_vratné vodní (45 °C) 32
13119714 | -1.PP_SO-102 | 5556.88 | 0.000314112 | 0.349149 | ø20 mm | 0.000694444 | 0 | -1.PP_SO-102 | -50 | -60 | -60 | -70 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | -4067.2 | RAU–PE–Xa | 20 | 47 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0882 | 0882 | no | HT_vratné vodní (45 °C) 32
13119725 | -1.PP_SO-102 | 896.008 | 0.000314112 | 0.0562978 | ø20 mm | 0.000694444 | 0 | -1.PP_SO-102 | -50 | -60 | -60 | -70 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | -4067.2 | RAU–PE–Xa | 20 | 47 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0883 | 0883 | no | HT_vratné vodní (45 °C) 32
13119827 | -1.PP_SO-102 | 409.664 | 0.000314112 | 0.02574 | ø20 mm | 0.000694444 | 0 | -1.PP_SO-102 | -50 | -60 | -60 | -70 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | -4067.2 | RAU–PE–Xa | 20 | 43 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0884 | 0884 | no | HT_vratné vodní (45 °C) 32
13119849 | -1.PP_SO-102 | 354.996 | 0.000314112 | 0.022305 | ø20 mm | 0.000694444 | 0 | -1.PP_SO-102 | -50 | -60 | -60 | -70 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | -4067.2 | RAU–PE–Xa | 20 | 44 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0885 | 0885 | no | HT_vratné vodní (45 °C) 32
13119856 | -1.PP_SO-102 | 365.248 | 0.000314112 | 0.0229492 | ø20 mm | 0.000694444 | 0 | -1.PP_SO-102 | -50 | -60 | -60 | -70 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | -4067.2 | RAU–PE–Xa | 20 | 47 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0886 | 0886 | no | HT_vratné vodní (45 °C) 32
13120056 | 1.NP_SO-102 | 653.502 | 0.000201032 | 0.0328486 | ø16 mm | 0.000862069 | 1.5304 | 1.NP_SO-102 | -42.0009 | -50 | -60 | -67.9991 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 28 | -65.7993 | RAU–PE–Xa | 16 | 13 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0887 | 0887 | no | HT_vratné vodní (45 °C) 28
13120090 | 1.NP_SO-102 | 127.713 | 0.000201032 | 0.00641953 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 28 | -65.8 | RAU–PE–Xa | 16 | 12 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0888 | 0888 | no | HT_vratné vodní (45 °C) 28
13120325 | 1.NP_SO-102 | 1938.65 | 0.000201032 | 0.0974474 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 28 | -65.8 | RAU–PE–Xa | 16 | 8 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0890 | 0890 | no | HT_vratné vodní (45 °C) 28
13120394 | -1.PP_SO-102 | 157.608 | 0.000201032 | 0.00792223 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 28 | -4055.8 | RAU–PE–Xa | 16 | 13 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0891 | 0891 | no | HT_vratné vodní (45 °C) 28
13120406 | -1.PP_SO-102 | 19.0625 | 0.000201032 | 0.000958186 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 28 | -4055.8 | RAU–PE–Xa | 16 | 13 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0892 | 0892 | no | HT_vratné vodní (45 °C) 28
13120424 | 1.NP_SO-102 | 275.994 | 0.000201032 | 0.013873 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | -65.8 | RAU–PE–Xa | 16 | 9 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0893 | 0893 | no | HT_vratné vodní (45 °C) 32
13120460 | 1.NP_SO-102 | 6612.91 | 0.000201032 | 0.332401 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | -65.8 | RAU–PE–Xa | 16 | 12 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0894 | 0894 | no | HT_vratné vodní (45 °C) 32
13120476 | 1.NP_SO-102 | 4989.28 | 0.000201032 | 0.250789 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | -65.8 | RAU–PE–Xa | 16 | 18 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0895 | 0895 | no | HT_vratné vodní (45 °C) 32
13120812 | -1.PP_SO-102 | 3954.69 | 0.000314112 | 0.248481 | ø20 mm | 0.000694444 |  | -1.PP_SO-102 | 3922.16 | -32.5375 | 3922.16 | -32.5375 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -4032.54 | RAU–PE–Xa | 20 | 381 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0896 | 0896 | yes | HT_přívodní vodní (55 °C) 9
13120927 | 1.NP_SO-102 | 10.7125 | 0.000201032 | 0.000538469 | ø16 mm | 0.000862069 |  | 1.NP_SO-102 | -25 | -25 | -35.7125 | -35.7125 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | -35.7125 | RAU–PE–Xa | 16 | 30 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0897 | 0897 | yes | HT_vratné vodní (45 °C) 32
13121027 | 1.NP_SO-102 | 320.869 | 0.000201032 | 0.0161287 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -50 | -58 | -58 | -66 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | -63.8 | RAU–PE–Xa | 16 | 71 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0898 | 0898 | no | HT_vratné vodní (45 °C) 32
13121171 | 1.NP_SO-102 | 2887.59 | 0.000201032 | 0.145146 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -55.8 | RAU–PE–Xa | 16 | 12 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0899 | 0899 | no | HT_přívodní vodní (55 °C) 9
13121556 | -1.PP_SO-102 | 3956.69 | 0.000314112 | 0.248606 | ø20 mm | 0.000694444 |  | -1.PP_SO-102 | 3914.16 | 3914.16 | -42.5375 | -42.5375 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | -4042.54 | RAU–PE–Xa | 20 | 47 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0900 | 0900 | yes | HT_vratné vodní (45 °C) 32
13121558 | 1.NP_SO-102 | 206.85 | 0.000201032 | 0.0103974 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -50 | -58 | -58 | -66 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | -63.8 | RAU–PE–Xa | 16 | 71 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0901 | 0901 | no | HT_vratné vodní (45 °C) 32
13121699 | 1.NP_SO-102 | 289.801 | 0.000201032 | 0.014567 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -55.8 | RAU–PE–Xa | 16 | 437 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0902 | 0902 | no | HT_přívodní vodní (55 °C) 9
13121715 | 1.NP_SO-102 | 154.792 | 0.000201032 | 0.00778068 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | -65.8 | RAU–PE–Xa | 16 | 62 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0903 | 0903 | no | HT_vratné vodní (45 °C) 32
13121761 | 1.NP_SO-102 | 3538.24 | 0.000201032 | 0.177851 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -50 | -58 | -58 | -66 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | -63.8 | RAU–PE–Xa | 16 | 71 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0904 | 0904 | no | HT_vratné vodní (45 °C) 32
13121771 | 1.NP_SO-102 | 10015 | 0.000201032 | 0.50341 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -50 | -58 | -58 | -66 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 32 | -63.8 | RAU–PE–Xa | 16 | 32 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0905 | 0905 | no | HT_vratné vodní (45 °C) 32
13121786 | 1.NP_SO-102 | 311.059 | 0.000201032 | 0.0156355 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -55.8 | RAU–PE–Xa | 16 | 63 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0906 | 0906 | no | HT_přívodní vodní (55 °C) 9
13121796 | 1.NP_SO-102 | 12945.9 | 0.000201032 | 0.650734 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -55.8 | RAU–PE–Xa | 16 | 428 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0907 | 0907 | no | HT_přívodní vodní (55 °C) 9
13121830 | 2.NP_SO-102 | 307.712 | 0.000201032 | 0.0154673 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 372 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0908 | 0908 | no | HT_přívodní vodní (55 °C) 9
13121839 | 2.NP_SO-102 | 1530 | 0.000201032 | 0.0769062 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 469 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0909 | 0909 | no | HT_přívodní vodní (55 °C) 9
