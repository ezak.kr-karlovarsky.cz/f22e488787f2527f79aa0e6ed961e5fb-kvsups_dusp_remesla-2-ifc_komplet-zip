Properties of the parts of a building model (IFC4), part 54 of 72

# IfcPipeFitting: M_Přechod, obecný:Standardní (221)
Name (M_Přechod, obecný:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Délka (mm) | Jmenovitý poloměr 1 (mm) | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Šířkové odsazení (mm) | Výškové odsazení (mm) | Viditelnost 2 | Viditelnost 3 | Max. vnější průměr tvarovky 12 (mm) | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm) | Group
13335762 | 2.NP_SO-102 | 0 | ø42 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11.2937 | 21 | 20 | 42 | 40 | 42 | 40 | 0.0000165584 | 21 | 21 | 0.00273098 | ø42-ø40 | 18.07 | 16.51 | 45.175 | 41.275 | TT03.03.1643 | 1643 | yes | 3048 | 3048 | yes | no | 45.175 | 20.6375 | 22.5875 | HT_vratné vodní (45 °C) 1
13335797 | 2.NP_SO-102 | 0 | ø42 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 11.2937 | 21 | 20 | 42 | 40 | 42 | 40 | 0.0000165584 | 21 | 21 | 0.00273098 | ø42-ø40 | 18.07 | 16.51 | 45.175 | 41.275 | TT03.03.1646 | 1646 | yes | 3048 | 3048 | yes | no | 45.175 | 20.6375 | 22.5875 | HT_přívodní vodní (55 °C) 9
13342505 | 1.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1681 | 1681 | no | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13362110 | 2.NP_SO-102 | 40 | ø160 mm-ø100 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 19.8438 | 40 | 10 | 80 | 20 | 80 | 20 | 0.0000443954 | 40 | 40 | 0.00584559 | ø80-ø20 | 31.75 | 8.89 | 79.375 | 22.225 | TT03.03.1737 | 1737 | yes | 3048 | 3048 | yes | no | 79.375 | 11.1125 | 39.6875 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13391652 | 2.NP_SO-102 | 0 | ø80 mm-ø65 mm | HD | 2.NP_SO-102 | 2652.39 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 19.8438 | 40 | 32.5 | 80 | 65 | 80 | 65 | 0.0000832537 | 40 | 40 | 0.00829731 | ø80-ø65 | 31.75 | 26.67 | 79.375 | 66.675 | TT03.03.1786 | 1786 | yes | 3048 | 3048 | yes | no | 79.375 | 33.3375 | 39.6875 | HT_vratné vodní (45 °C) 23; CL_vratné vodní (15 °C) 4
13391690 | 2.NP_SO-102 | 0 | ø80 mm-ø65 mm | HD | 2.NP_SO-102 | 2702.39 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 19.8438 | 40 | 32.5 | 80 | 65 | 80 | 65 | 0.0000832537 | 40 | 40 | 0.00829731 | ø80-ø65 | 31.75 | 26.67 | 79.375 | 66.675 | TT03.03.1790 | 1790 | yes | 3048 | 3048 | yes | no | 79.375 | 33.3375 | 39.6875 | HT_přívodní vodní (65 °C) 8
13404910 | 4.NP_SO-102 | 0 | ø80 mm-ø65 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 19.8438 | 32.5 | 40 | 65 | 80 | 80 | 65 | 0.0000832732 | 32.5 | 32.5 | 0.00829731 | ø80-ø65 | 26.67 | 31.75 | 66.675 | 79.375 | TT03.03.1896 | 1896 | yes | 3048 | 3048 | no | yes | 79.375 | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 5
13404946 | 3.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 3.NP_SO-102 | 3929.27 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 4.79375 | 7.5 | 8 | 15 | 16 | 16 | 15 | 0.00000114935 | 7.5 | 7.5 | 0.000434165 | ø16-ø15 | 6.35 | 7.67 | 15.875 | 19.175 | TT03.03.1898 | 1898 | yes | 3048 | 3048 | no | yes | 19.175 | 9.5875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13405122 | 4.NP_SO-102 | 60 | ø200 mm-ø185 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 19.8438 | 32.5 | 40 | 65 | 80 | 80 | 65 | 0.0000832732 | 32.5 | 32.5 | 0.00829731 | ø80-ø65 | 26.67 | 31.75 | 66.675 | 79.375 | TT03.03.1900 | 1900 | yes | 3048 | 3048 | no | yes | 79.375 | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13405125 | 4.NP_SO-102 | 60 | ø200 mm-ø185 mm | HD | 4.NP_SO-102 | 3100 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 19.8438 | 32.5 | 40 | 65 | 80 | 80 | 65 | 0.0000832732 | 32.5 | 32.5 | 0.00829731 | ø80-ø65 | 26.67 | 31.75 | 66.675 | 79.375 | TT03.03.1901 | 1901 | yes | 3048 | 3048 | no | yes | 79.375 | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13405137 | 4.NP_SO-102 | 60 | ø200 mm-ø185 mm | HD | 4.NP_SO-102 | 3100 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 19.8438 | 32.5 | 40 | 65 | 80 | 80 | 65 | 0.0000832732 | 32.5 | 32.5 | 0.00829731 | ø80-ø65 | 26.67 | 31.75 | 66.675 | 79.375 | TT03.03.1903 | 1903 | yes | 3048 | 3048 | no | yes | 79.375 | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13405143 | 4.NP_SO-102 | 60 | ø200 mm-ø185 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 19.8438 | 32.5 | 40 | 65 | 80 | 80 | 65 | 0.0000832732 | 32.5 | 32.5 | 0.00829731 | ø80-ø65 | 26.67 | 31.75 | 66.675 | 79.375 | TT03.03.1905 | 1905 | yes | 3048 | 3048 | no | yes | 79.375 | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13405161 | 4.NP_SO-102 | 60 | ø200 mm-ø185 mm | HD | 4.NP_SO-102 | 3100 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 19.8438 | 32.5 | 40 | 65 | 80 | 80 | 65 | 0.0000832732 | 32.5 | 32.5 | 0.00829731 | ø80-ø65 | 26.67 | 31.75 | 66.675 | 79.375 | TT03.03.1907 | 1907 | yes | 3048 | 3048 | no | yes | 79.375 | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13405194 | 4.NP_SO-102 | 60 | ø200 mm-ø185 mm | HD | 4.NP_SO-102 | 3052.39 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 19.8438 | 40 | 32.5 | 80 | 65 | 80 | 65 | 0.0000832537 | 40 | 40 | 0.00829731 | ø80-ø65 | 31.75 | 26.67 | 79.375 | 66.675 | TT03.03.1908 | 1908 | yes | 3048 | 3048 | yes | no | 79.375 | 33.3375 | 39.6875 | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13405197 | 4.NP_SO-102 | 60 | ø200 mm-ø185 mm | HD | 4.NP_SO-102 | 3100 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 19.8438 | 40 | 32.5 | 80 | 65 | 80 | 65 | 0.0000832537 | 40 | 40 | 0.00829731 | ø80-ø65 | 31.75 | 26.67 | 79.375 | 66.675 | TT03.03.1909 | 1909 | yes | 3048 | 3048 | yes | no | 79.375 | 33.3375 | 39.6875 | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13405200 | 4.NP_SO-102 | 60 | ø200 mm-ø185 mm | HD | 4.NP_SO-102 | 3052.39 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 19.8438 | 40 | 32.5 | 80 | 65 | 80 | 65 | 0.0000832537 | 40 | 40 | 0.00829731 | ø80-ø65 | 31.75 | 26.67 | 79.375 | 66.675 | TT03.03.1910 | 1910 | yes | 3048 | 3048 | yes | no | 79.375 | 33.3375 | 39.6875 | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13405245 | 2.NP_SO-102 | 60 | ø200 mm-ø185 mm | HD | 2.NP_SO-102 | 3289.69 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 19.8438 | 32.5 | 40 | 65 | 80 | 80 | 65 | 0.0000832732 | 32.5 | 32.5 | 0.00829731 | ø80-ø65 | 26.67 | 31.75 | 66.675 | 79.375 | TT03.03.1911 | 1911 | yes | 3048 | 3048 | no | yes | 79.375 | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13405248 | 2.NP_SO-102 | 60 | ø200 mm-ø185 mm | HD | 2.NP_SO-102 | 3289.69 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 19.8438 | 32.5 | 40 | 65 | 80 | 80 | 65 | 0.0000832732 | 32.5 | 32.5 | 0.00829731 | ø80-ø65 | 26.67 | 31.75 | 66.675 | 79.375 | TT03.03.1912 | 1912 | yes | 3048 | 3048 | no | yes | 79.375 | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13405251 | 2.NP_SO-102 | 60 | ø200 mm-ø185 mm | HD | 2.NP_SO-102 | 3289.69 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 19.8438 | 32.5 | 40 | 65 | 80 | 80 | 65 | 0.0000832732 | 32.5 | 32.5 | 0.00829731 | ø80-ø65 | 26.67 | 31.75 | 66.675 | 79.375 | TT03.03.1913 | 1913 | yes | 3048 | 3048 | no | yes | 79.375 | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7 | Izolace - Typ izolace: Tepelná
13405254 | 2.NP_SO-102 | 60 | ø200 mm-ø185 mm | HD | 2.NP_SO-102 | 3289.69 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 19.8438 | 32.5 | 40 | 65 | 80 | 80 | 65 | 0.0000832732 | 32.5 | 32.5 | 0.00829731 | ø80-ø65 | 26.67 | 31.75 | 66.675 | 79.375 | TT03.03.1914 | 1914 | yes | 3048 | 3048 | no | yes | 79.375 | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13405303 | 4.NP_SO-102 | 0 | ø80 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 19.8438 | 40 | 32.5 | 80 | 65 | 80 | 65 | 0.0000832537 | 40 | 40 | 0.00829731 | ø80-ø65 | 31.75 | 26.67 | 79.375 | 66.675 | TT03.03.1915 | 1915 | yes | 3048 | 3048 | yes | no | 79.375 | 33.3375 | 39.6875 | HT_PRIMÁR_přívodní 4
13405305 | 4.NP_SO-102 | 0 | ø80 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 19.8438 | 40 | 32.5 | 80 | 65 | 80 | 65 | 0.0000832537 | 40 | 40 | 0.00829731 | ø80-ø65 | 31.75 | 26.67 | 79.375 | 66.675 | TT03.03.1916 | 1916 | yes | 3048 | 3048 | yes | no | 79.375 | 33.3375 | 39.6875 | HT_PRIMÁR_přívodní 4
13405307 | 4.NP_SO-102 | 0 | ø80 mm-ø65 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 19.8438 | 40 | 32.5 | 80 | 65 | 80 | 65 | 0.0000832537 | 40 | 40 | 0.00829731 | ø80-ø65 | 31.75 | 26.67 | 79.375 | 66.675 | TT03.03.1917 | 1917 | yes | 3048 | 3048 | yes | no | 79.375 | 33.3375 | 39.6875 | HT_PRIMÁR_vratné 7
13405309 | 4.NP_SO-102 | 0 | ø80 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 19.8438 | 40 | 32.5 | 80 | 65 | 80 | 65 | 0.0000832537 | 40 | 40 | 0.00829731 | ø80-ø65 | 31.75 | 26.67 | 79.375 | 66.675 | TT03.03.1918 | 1918 | yes | 3048 | 3048 | yes | no | 79.375 | 33.3375 | 39.6875 | HT_PRIMÁR_vratné 7
13405311 | 4.NP_SO-102 | 0 | ø80 mm-ø65 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 19.8438 | 40 | 32.5 | 80 | 65 | 80 | 65 | 0.0000832537 | 40 | 40 | 0.00829731 | ø80-ø65 | 31.75 | 26.67 | 79.375 | 66.675 | TT03.03.1919 | 1919 | yes | 3048 | 3048 | yes | no | 79.375 | 33.3375 | 39.6875 | HT_PRIMÁR_vratné 7
13405313 | 4.NP_SO-102 | 0 | ø80 mm-ø65 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 19.8438 | 40 | 32.5 | 80 | 65 | 80 | 65 | 0.0000832537 | 40 | 40 | 0.00829731 | ø80-ø65 | 31.75 | 26.67 | 79.375 | 66.675 | TT03.03.1920 | 1920 | yes | 3048 | 3048 | yes | no | 79.375 | 33.3375 | 39.6875 | HT_PRIMÁR_přívodní 4
13407653 | 1.NP_SO-102 | 40 | ø130 mm-ø122 mm | HD | 1.NP_SO-102 | 2864.71 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 13.4938 | 21 | 25 | 42 | 50 | 50 | 42 | 0.0000260841 | 21 | 21 | 0.00361867 | ø50-ø42 | 18.07 | 21.59 | 45.175 | 53.975 | TT03.03.1950 | 1950 | yes | 3048 | 3048 | no | yes | 53.975 | 26.9875 | 22.5875 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13407656 | 1.NP_SO-102 | 40 | ø130 mm-ø100 mm | HD | 1.NP_SO-102 | 2828.02 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT03.03.1951 | 1951 | yes | 3048 | 3048 | yes | no | 53.975 | 11.1125 | 26.9875 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13408110 | -1.PP_SO-102 | 0 | ø50 mm-ø20 mm | HC | -1.PP_SO-102 | 3000 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT03.03.1957 | 1957 | yes | 3048 | 3048 | yes | no | 53.975 | 11.1125 | 26.9875 | CL_vratné vodní (15 °C) 8
13408203 | -1.PP_SO-102 | 0 | ø50 mm-ø20 mm | HC | -1.PP_SO-102 | 3000 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT03.03.1963 | 1963 | yes | 3048 | 3048 | yes | no | 53.975 | 11.1125 | 26.9875 | CL_přívodní vodní (10 °C) 4
13409550 | 2.NP_SO-102 | 0 | ø80 mm-ø65 mm | HE | 2.NP_SO-102 | 2260.31 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 19.8438 | 32.5 | 40 | 65 | 80 | 80 | 65 | 0.0000832732 | 32.5 | 32.5 | 0.00829731 | ø80-ø65 | 26.67 | 31.75 | 66.675 | 79.375 | TT03.03.1982 | 1982 | yes | 3048 | 3048 | no | yes | 79.375 | 39.6875 | 33.3375 | HT/CL_vratné vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13409889 | 2.NP_SO-102 | 0 | ø80 mm-ø65 mm | HE | 2.NP_SO-102 | 2300 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 19.8438 | 40 | 32.5 | 80 | 65 | 80 | 65 | 0.0000832537 | 40 | 40 | 0.00829731 | ø80-ø65 | 31.75 | 26.67 | 79.375 | 66.675 | TT03.03.1984 | 1984 | yes | 3048 | 3048 | yes | no | 79.375 | 33.3375 | 39.6875 | HT/CL_přívodní vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13409928 | 2.NP_SO-102 | 0 | ø40 mm-ø20 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 10.3188 | 10 | 20 | 20 | 40 | 40 | 20 | 0.00000837091 | 10 | 10 | 0.0017689 | ø40-ø20 | 8.89 | 16.51 | 22.225 | 41.275 | TT03.03.1987 | 1987 | yes | 3048 | 3048 | no | yes | 41.275 | 20.6375 | 11.1125 | HT_vratné vodní (45 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13409938 | 2.NP_SO-102 | 0 | ø40 mm-ø20 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 10.3188 | 10 | 20 | 20 | 40 | 40 | 20 | 0.00000837091 | 10 | 10 | 0.0017689 | ø40-ø20 | 8.89 | 16.51 | 22.225 | 41.275 | TT03.03.1990 | 1990 | yes | 3048 | 3048 | no | yes | 41.275 | 20.6375 | 11.1125 | HT_přívodní vodní (55 °C) 12 | Mechanické – tok - Tlaková ztráta: 0 Pa
13409953 | 2.NP_SO-102 | 0 | ø65 mm-ø20 mm | HD | 2.NP_SO-102 | 2500 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 16.6688 | 32.5 | 10 | 65 | 20 | 65 | 20 | 0.0000279826 | 32.5 | 32.5 | 0.00413069 | ø65-ø20 | 26.67 | 8.89 | 66.675 | 22.225 | TT03.03.1993 | 1993 | yes | 3048 | 3048 | yes | no | 66.675 | 11.1125 | 33.3375 | HT_vratné vodní (45 °C) 26
13409955 | 2.NP_SO-102 | 0 | ø80 mm-ø65 mm | HD | 2.NP_SO-102 | 2260.31 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 19.8438 | 32.5 | 40 | 65 | 80 | 80 | 65 | 0.0000832732 | 32.5 | 32.5 | 0.00829731 | ø80-ø65 | 26.67 | 31.75 | 66.675 | 79.375 | TT03.03.1994 | 1994 | yes | 3048 | 3048 | no | yes | 79.375 | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 26 | Mechanické – tok - Tlaková ztráta: 0 Pa
13409968 | 2.NP_SO-102 | 0 | ø65 mm-ø20 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 16.6688 | 32.5 | 10 | 65 | 20 | 65 | 20 | 0.0000279826 | 32.5 | 32.5 | 0.00413069 | ø65-ø20 | 26.67 | 8.89 | 66.675 | 22.225 | TT03.03.1996 | 1996 | yes | 3048 | 3048 | yes | no | 66.675 | 11.1125 | 33.3375 | HT_přívodní vodní (55 °C) 25
13409970 | 2.NP_SO-102 | 0 | ø80 mm-ø65 mm | HD | 2.NP_SO-102 | 2260.31 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 19.8438 | 32.5 | 40 | 65 | 80 | 80 | 65 | 0.0000832732 | 32.5 | 32.5 | 0.00829731 | ø80-ø65 | 26.67 | 31.75 | 66.675 | 79.375 | TT03.03.1997 | 1997 | yes | 3048 | 3048 | no | yes | 79.375 | 39.6875 | 33.3375 | HT_přívodní vodní (55 °C) 25 | Mechanické – tok - Tlaková ztráta: 0 Pa
13409980 | 2.NP_SO-102 | 0 | ø40 mm-ø20 mm | HD | 2.NP_SO-102 | 2476.99 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.1998 | 1998 | yes | 3048 | 3048 | yes | no | 41.275 | 11.1125 | 20.6375 | HT_přívodní vodní (55 °C) 25 | Mechanické – tok - Tlaková ztráta: 0 Pa
13416200 | -1.PP_SO-102 | 0 | ø50 mm-ø20 mm | HC | -1.PP_SO-102 | 3000 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT03.03.2013 | 2013 | yes | 3048 | 3048 | yes | no | 53.975 | 11.1125 | 26.9875 | CL_přívodní vodní (10 °C) 4
13416235 | -1.PP_SO-102 | 0 | ø50 mm-ø20 mm | HC | -1.PP_SO-102 | 3000 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 13.4938 | 25 | 10 | 50 | 20 | 50 | 20 | 0.0000162305 | 25 | 25 | 0.00272121 | ø50-ø20 | 21.59 | 8.89 | 53.975 | 22.225 | TT03.03.2017 | 2017 | yes | 3048 | 3048 | yes | no | 53.975 | 11.1125 | 26.9875 | CL_vratné vodní (15 °C) 8
13431602 | 2.NP_SO-102 | 0 | ø25 mm-ø15 mm | HD | 2.NP_SO-102 | 3026.99 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 7.14375 | 12.5 | 7.5 | 25 | 15 | 25 | 15 | 0.00000283078 | 12.5 | 12.5 | 0.000807205 | ø25-ø15 | 11.43 | 6.35 | 28.575 | 15.875 | TT03.03.2141 | 2141 | yes | 3048 | 3048 | yes | no | 28.575 | 7.9375 | 14.2875 | HT_vratné vodní (45 °C) 9
13435605 | -1.PP_SO-102 | 0 | ø32 mm-ø20 mm | HD | -1.PP_SO-102 | 3340 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8.73125 | 10 | 16 | 20 | 32 | 32 | 20 | 0.00000565444 | 10 | 10 | 0.00129853 | ø32-ø20 | 8.89 | 13.97 | 22.225 | 34.925 | TT03.03.2161 | 2161 | yes | 3048 | 3048 | no | yes | 34.925 | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13436252 | 2.NP_SO-102 | 0 | ø125 mm-ø65 mm | HD | 2.NP_SO-102 | 1000 | Fáze 2 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 4 | 32.5438 | 32.5 | 62.5 | 65 | 125 | 125 | 65 | 0.000256122 | 32.5 | 32.5 | 0.0173861 | ø125-ø65 | 26.67 | 52.07 | 66.675 | 130.175 | TT03.03.2180 | 2180 | yes | 3048 | 3048 | no | yes | 130.175 | 65.0875 | 33.3375 | HT_PRIMÁR_vratné 4; HT_vratné vodní (45 °C) 7
13437946 | 2.NP_SO-102 | 0 | ø40 mm-ø25 mm | HD | 2.NP_SO-102 | 2979.36 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 10.3188 | 12.5 | 20 | 25 | 40 | 40 | 25 | 0.00000997107 | 12.5 | 12.5 | 0.00193705 | ø40-ø25 | 11.43 | 16.51 | 28.575 | 41.275 | TT03.03.2183 | 2183 | yes | 3048 | 3048 | no | yes | 41.275 | 20.6375 | 14.2875 | HT_vratné vodní (45 °C) 9
13438120 | 2.NP_SO-102 | 0 | ø40 mm-ø25 mm | HD | 2.NP_SO-102 | 2979.36 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 10.3188 | 12.5 | 20 | 25 | 40 | 40 | 25 | 0.00000997107 | 12.5 | 12.5 | 0.00193705 | ø40-ø25 | 11.43 | 16.51 | 28.575 | 41.275 | TT03.03.2185 | 2185 | yes | 3048 | 3048 | no | yes | 41.275 | 20.6375 | 14.2875 | HT_přívodní vodní (55 °C) 12
13438259 | 2.NP_SO-102 | 0 | ø40 mm-ø15 mm | HD | 2.NP_SO-102 | 2544.29 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 10.3188 | 7.5 | 20 | 15 | 40 | 40 | 15 | 0.00000703078 | 7.5 | 7.5 | 0.00162635 | ø40-ø15 | 6.35 | 16.51 | 15.875 | 41.275 | TT03.03.2187 | 2187 | yes | 3048 | 3048 | no | yes | 41.275 | 20.6375 | 7.9375 | HT_přívodní vodní (55 °C) 12
13454072 | 4.NP_SO-102 | 60 | ø200 mm-ø185 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 19.8438 | 32.5 | 40 | 65 | 80 | 80 | 65 | 0.0000832732 | 32.5 | 32.5 | 0.00829731 | ø80-ø65 | 26.67 | 31.75 | 66.675 | 79.375 | TT03.03.2296 | 2296 |  | 3048 | 3048 | no | yes | 79.375 | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná

# IfcPipeFitting: M_Přechod, obecný:Standardní (16)
Type - Material: 0-255-128
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT03; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: Redukce; Popis sestavy: Redukce
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT03 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: H; CCI Komponenta: XMB
Grafika - Použít měřítko poznámky: no
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Šířkové odsazení: 3048 mm; Viditelnost 1: no; Výškové odsazení: 3048 mm
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Délka (mm) | Jmenovitý poloměr 1 (mm) = Odskok – šířka = Odskok – výška | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Viditelnost 2 | Viditelnost 3 | Max. vnější průměr tvarovky 12 (mm) | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm)
13309498 | -1.PP_SO-102 | ø20 mm-ø15 mm | HC | -1.PP_SO-102 | 3300 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 5.55625 | 7.5 | 10 | 15 | 20 | 20 | 15 | 0.00000158628 | 0.000554533 | ø20-ø15 | 6.35 | 8.89 | 15.875 | 22.225 | TT03.03.1329 | 1329 | no | yes | 22.225 | 11.1125 | 7.9375
13309500 | -1.PP_SO-102 | ø20 mm-ø15 mm | HC | -1.PP_SO-102 | 3300 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 5.55625 | 7.5 | 10 | 15 | 20 | 20 | 15 | 0.00000158628 | 0.000554533 | ø20-ø15 | 6.35 | 8.89 | 15.875 | 22.225 | TT03.03.1330 | 1330 | no | yes | 22.225 | 11.1125 | 7.9375
13310520 | 2.NP_SO-102 | ø89 mm-ø65 mm | HC | 2.NP_SO-102 | 2447.56 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 23.0438 | 44.5 | 32.5 | 89 | 65 | 89 | 65 | 0.000115048 | 0.0100571 | ø89-ø65 | 36.87 | 26.67 | 92.175 | 66.675 | TT03.03.1334 | 1334 | yes | no | 92.175 | 33.3375 | 46.0875
13310524 | 2.NP_SO-102 | ø89 mm-ø65 mm | HC | 2.NP_SO-102 | 2447.56 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 23.0438 | 44.5 | 32.5 | 89 | 65 | 89 | 65 | 0.000115048 | 0.0100571 | ø89-ø65 | 36.87 | 26.67 | 92.175 | 66.675 | TT03.03.1335 | 1335 | yes | no | 92.175 | 33.3375 | 46.0875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13313442 | 2.NP_SO-102 | ø89 mm-ø80 mm | HC | 2.NP_SO-102 | 2500 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 23.0438 | 44.5 | 40 | 89 | 80 | 89 | 80 | 0.0001333 | 0.0112403 | ø89-ø80 | 36.87 | 31.75 | 92.175 | 79.375 | TT03.03.1413 | 1413 | yes | no | 92.175 | 39.6875 | 46.0875
13313444 | 2.NP_SO-102 | ø89 mm-ø80 mm | HC | 2.NP_SO-102 | 2500 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 23.0438 | 44.5 | 40 | 89 | 80 | 89 | 80 | 0.0001333 | 0.0112403 | ø89-ø80 | 36.87 | 31.75 | 92.175 | 79.375 | TT03.03.1414 | 1414 | yes | no | 92.175 | 39.6875 | 46.0875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13313680 | 3.NP_SO-102 | ø32 mm-ø15 mm | HC | 3.NP_SO-102 | 3355.71 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 8.73125 | 7.5 | 16 | 15 | 32 | 32 | 15 | 0.00000461265 | 0.00116529 | ø32-ø15 | 6.35 | 13.97 | 15.875 | 34.925 | TT03.03.1417 | 1417 | no | yes | 34.925 | 17.4625 | 7.9375
13313688 | 2.NP_SO-102 | ø65 mm-ø32 mm | HC | 2.NP_SO-102 | 1209.5 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 16.6688 | 32.5 | 16 | 65 | 32 | 65 | 32 | 0.0000348451 | 0.00460467 | ø65-ø32 | 26.67 | 13.97 | 66.675 | 34.925 | TT03.03.1418 | 1418 | yes | no | 66.675 | 17.4625 | 33.3375 | Mechanické – tok - Tlaková ztráta: 0 Pa
13313690 | 2.NP_SO-102 | ø65 mm-ø32 mm | HC | 2.NP_SO-102 | 1209.5 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 16.6688 | 32.5 | 16 | 65 | 32 | 65 | 32 | 0.0000348451 | 0.00460467 | ø65-ø32 | 26.67 | 13.97 | 66.675 | 34.925 | TT03.03.1419 | 1419 | yes | no | 66.675 | 17.4625 | 33.3375 | Mechanické – tok - Tlaková ztráta: 0 Pa
13313715 | 2.NP_SO-102 | ø65 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 16.6688 | 32.5 | 12.5 | 65 | 25 | 65 | 25 | 0.0000312379 | 0.00433875 | ø65-ø25 | 26.67 | 11.43 | 66.675 | 28.575 | TT03.03.1420 | 1420 | yes | no | 66.675 | 14.2875 | 33.3375
13316332 | 2.NP_SO-102 | ø65 mm-ø25 mm | HE | 2.NP_SO-102 | 3000 | Fáze 2 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 16.6688 | 32.5 | 12.5 | 65 | 25 | 65 | 25 | 0.0000312379 | 0.00433875 | ø65-ø25 | 26.67 | 11.43 | 66.675 | 28.575 | TT03.03.1533 | 1533 | yes | no | 66.675 | 14.2875 | 33.3375 | Mechanické – tok - Tlaková ztráta: 0 Pa
13316334 | 2.NP_SO-102 | ø65 mm-ø25 mm | HE | 2.NP_SO-102 | 3000 | Fáze 2 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 16.6688 | 32.5 | 12.5 | 65 | 25 | 65 | 25 | 0.0000312379 | 0.00433875 | ø65-ø25 | 26.67 | 11.43 | 66.675 | 28.575 | TT03.03.1534 | 1534 | yes | no | 66.675 | 14.2875 | 33.3375
13322385 | -1.PP_SO-102 | ø80 mm-ø50 mm | HC | -1.PP_SO-102 | 3000 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 19.8438 | 40 | 25 | 80 | 50 | 80 | 50 | 0.0000700565 | 0.00735821 | ø80-ø50 | 31.75 | 21.59 | 79.375 | 53.975 | TT03.03.1587 | 1587 | yes | no | 79.375 | 26.9875 | 39.6875
13419349 | -1.PP_SO-102 | ø50 mm-ø15 mm | HC | -1.PP_SO-102 | 2760.31 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 13.4938 | 25 | 7.5 | 50 | 15 | 50 | 15 | 0.000014165 | 0.00255798 | ø50-ø15 | 21.59 | 6.35 | 53.975 | 15.875 | TT03.03.2055 | 2055 | yes | no | 53.975 | 7.9375 | 26.9875
13419387 | -1.PP_SO-102 | ø50 mm-ø15 mm | HC | -1.PP_SO-102 | 2760.31 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 13.4938 | 25 | 7.5 | 50 | 15 | 50 | 15 | 0.000014165 | 0.00255798 | ø50-ø15 | 21.59 | 6.35 | 53.975 | 15.875 | TT03.03.2059 | 2059 | yes | no | 53.975 | 7.9375 | 26.9875
13427231 | -1.PP_SO-102 | ø80 mm-ø50 mm | HC | -1.PP_SO-102 | 3000 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 19.8438 | 40 | 25 | 80 | 50 | 80 | 50 | 0.0000700565 | 0.00735821 | ø80-ø50 | 31.75 | 21.59 | 79.375 | 53.975 | TT03.03.2107 | 2107 | yes | no | 79.375 | 26.9875 | 39.6875

# IfcPipeFitting: M_Přechod, obecný:Standardní (7)
Type - Material: 128-255-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT03; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: Redukce; Popis sestavy: Redukce
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT03 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: H; CCI Komponenta: XMB; CCI Technický systém: HC
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Šířkové odsazení: 3048 mm; Viditelnost 1: no; Výškové odsazení: 3048 mm
Name (M_Přechod, obecný:Standardní:...) | In | Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Délka (mm) | Jmenovitý poloměr 1 (mm) = Odskok – šířka = Odskok – výška | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Viditelnost 2 | Viditelnost 3 | Max. vnější průměr tvarovky 12 (mm) | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm)
13313485 | 2.NP_SO-102 | ø80 mm-ø76 mm | 0 | 2.NP_SO-102 | 2500 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 19.8438 | 38 | 40 | 76 | 80 | 80 | 76 | 0.0000978798 | 0.00929438 | ø80-ø76 | 31.67 | 31.75 | 79.175 | 79.375 | TT03.03.1415 | 1415 | no | yes | 79.375 | 39.6875 | 39.5875
13313499 | 2.NP_SO-102 | ø80 mm-ø76 mm | 0 | 2.NP_SO-102 | 2454.06 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 19.8438 | 38 | 40 | 76 | 80 | 80 | 76 | 0.0000978798 | 0.00929438 | ø80-ø76 | 31.67 | 31.75 | 79.175 | 79.375 | TT03.03.1416 | 1416 | no | yes | 79.375 | 39.6875 | 39.5875
13322055 | 2.NP_SO-102 | ø100 mm-ø15 mm |  | 2.NP_SO-102 | 2985.71 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 13 | 26.1938 | 7.5 | 50 | 15 | 100 | 100 | 15 | 0.0000883579 | 0.00917695 | ø100-ø15 | 6.35 | 41.91 | 15.875 | 104.775 | TT03.03.1577 | 1577 | no | yes | 104.775 | 52.3875 | 7.9375
13322057 | 2.NP_SO-102 | ø100 mm-ø15 mm |  | 2.NP_SO-102 | 2585.71 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 12 | 26.1938 | 7.5 | 50 | 15 | 100 | 100 | 15 | 0.0000883579 | 0.00917695 | ø100-ø15 | 6.35 | 41.91 | 15.875 | 104.775 | TT03.03.1578 | 1578 | no | yes | 104.775 | 52.3875 | 7.9375
13390594 | 2.NP_SO-102 | ø125 mm-ø100 mm | 0 | 2.NP_SO-102 | 1209.5 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 4 | 32.5438 | 62.5 | 50 | 125 | 100 | 125 | 100 | 0.000354017 | 0.0210887 | ø125-ø100 | 52.07 | 41.91 | 130.175 | 104.775 | TT03.03.1769 | 1769 | yes | no | 130.175 | 52.3875 | 65.0875
13390629 | 2.NP_SO-102 | ø125 mm-ø100 mm | 0 | 2.NP_SO-102 | 1209.5 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 7 | 32.5438 | 62.5 | 50 | 125 | 100 | 125 | 100 | 0.000354017 | 0.0210887 | ø125-ø100 | 52.07 | 41.91 | 130.175 | 104.775 | TT03.03.1770 | 1770 | yes | no | 130.175 | 52.3875 | 65.0875
13438843 | 3.NP_SO-102 | ø32 mm-ø15 mm |  | 3.NP_SO-102 | 3355.71 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 8.73125 | 7.5 | 16 | 15 | 32 | 32 | 15 | 0.00000461265 | 0.00116529 | ø32-ø15 | 6.35 | 13.97 | 15.875 | 34.925 | TT03.03.2196 | 2196 | no | yes | 34.925 | 17.4625 | 7.9375

# IfcPipeFitting: M_Přechod, obecný:Standardní (145)
Type - Material: 255-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Reducer/Coupling/Union/Increaser
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: R; Kód sestavy: TT03; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 03; Popis: Redukce; Popis sestavy: Redukce
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Přechod, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT03 Uniformat (Uniformat)
Text - CCI Funkční systém: H; CCI Komponenta: XMB
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336402; Rodina: M_Přechod, obecný; Rodina a typ: M_Přechod, obecný: Standardní; Viditelnost 1: no; Výškové odsazení: 3048 mm
Name (M_Přechod, obecný:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Délka (mm) | Jmenovitý poloměr 1 (mm) = Odskok – výška | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Odskok – šířka | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Max. vnější průměr tvarovky 12 (mm) | Šířkové odsazení (mm) | Viditelnost 2 | Viditelnost 3 | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm) | Group
13066253 | 2.NP_SO-102 | 0 | ø80 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 19.8438 | 20 | 40 | 40 | 80 | 80 | 40 | 0.0000585088 | 20 | 0.00670892 | ø80-ø40 | 16.51 | 31.75 | 41.275 | 79.375 | TT03.03.0182 | 0182 | yes | 79.375 | 3048 | no | yes | 39.6875 | 20.6375 | HT_přívodní vodní (55 °C) 9
13066655 | 1.NP_SO-102 | 40 | ø120 mm-ø95 mm | HD | 1.NP_SO-102 | 3326.66 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10.3188 | 20 | 7.5 | 40 | 15 | 40 | 15 | 0.00000700483 | 20 | 0.00162635 | ø40-ø15 | 16.51 | 6.35 | 41.275 | 15.875 | TT03.03.0183 | 0183 | yes | 41.275 | 3048 | yes | no | 7.9375 | 20.6375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13066994 | 3.NP_SO-102 | 40 | ø120 mm-ø105 mm | HD | 3.NP_SO-102 | 3383.34 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10.3188 | 20 | 12.5 | 40 | 25 | 40 | 25 | 0.00000994592 | 20 | 0.00193705 | ø40-ø25 | 16.51 | 11.43 | 41.275 | 28.575 | TT03.03.0185 | 0185 | yes | 41.275 | 3048 | yes | no | 14.2875 | 20.6375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13069786 | -1.PP_SO-102 | 0 | ø40 mm-ø15 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10.3188 | 20 | 7.5 | 40 | 15 | 40 | 15 | 0.00000700483 | 20 | 0.00162635 | ø40-ø15 | 16.51 | 6.35 | 41.275 | 15.875 | TT03.03.0187 | 0187 | yes | 41.275 | 3048 | yes | no | 7.9375 | 20.6375 | HT_přívodní vodní (55 °C) 9
13069788 | -1.PP_SO-102 | 0 | ø40 mm-ø15 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10.3188 | 20 | 7.5 | 40 | 15 | 40 | 15 | 0.00000700483 | 20 | 0.00162635 | ø40-ø15 | 16.51 | 6.35 | 41.275 | 15.875 | TT03.03.0188 | 0188 | yes | 41.275 | 3048 | yes | no | 7.9375 | 20.6375 | HT_přívodní vodní (55 °C) 9
13070122 | 2.NP_SO-102 | 40 | ø130 mm-ø120 mm | HD | 2.NP_SO-102 | 3060.31 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 13.4938 | 25 | 20 | 50 | 40 | 50 | 40 | 0.0000241362 | 25 | 0.00346833 | ø50-ø40 | 21.59 | 16.51 | 53.975 | 41.275 | TT03.03.0192 | 0192 | yes | 53.975 | 3048 | yes | no | 20.6375 | 26.9875 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13070124 | 2.NP_SO-102 | 40 | ø130 mm-ø120 mm | HD | 2.NP_SO-102 | 3139.69 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 13.4938 | 25 | 20 | 50 | 40 | 50 | 40 | 0.0000241362 | 25 | 0.00346833 | ø50-ø40 | 21.59 | 16.51 | 53.975 | 41.275 | TT03.03.0193 | 0193 | yes | 53.975 | 3048 | yes | no | 20.6375 | 26.9875 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13070137 | 2.NP_SO-102 | 0 | ø80 mm-ø50 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 19.8438 | 40 | 25 | 80 | 50 | 80 | 50 | 0.0000700565 | 40 | 0.00735821 | ø80-ø50 | 31.75 | 21.59 | 79.375 | 53.975 | TT03.03.0195 | 0195 | yes | 79.375 | 3048 | yes | no | 26.9875 | 39.6875 | HT_přívodní vodní (55 °C) 9
13078795 | 2.NP_SO-102 | 0 | ø80 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 19.8438 | 20 | 40 | 40 | 80 | 80 | 40 | 0.0000585088 | 20 | 0.00670892 | ø80-ø40 | 16.51 | 31.75 | 41.275 | 79.375 | TT03.03.0209 | 0209 | yes | 79.375 | 3048 | no | yes | 39.6875 | 20.6375 | HT_vratné vodní (45 °C) 1
13081154 | 2.NP_SO-102 | 0 | ø80 mm-ø50 mm | HD | 2.NP_SO-102 | 3152.39 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 19.8438 | 40 | 25 | 80 | 50 | 80 | 50 | 0.0000700565 | 40 | 0.00735821 | ø80-ø50 | 31.75 | 21.59 | 79.375 | 53.975 | TT03.03.0237 | 0237 | yes | 79.375 | 3048 | yes | no | 26.9875 | 39.6875 | HT_vratné vodní (45 °C) 1
13081315 | 2.NP_SO-102 | 40 | ø130 mm-ø120 mm | HD | 2.NP_SO-102 | 3210.31 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 13.4938 | 25 | 20 | 50 | 40 | 50 | 40 | 0.0000241362 | 25 | 0.00346833 | ø50-ø40 | 21.59 | 16.51 | 53.975 | 41.275 | TT03.03.0240 | 0240 | yes | 53.975 | 3048 | yes | no | 20.6375 | 26.9875 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13088683 | -1.PP_SO-102 | 0 | ø40 mm-ø15 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10.3188 | 20 | 7.5 | 40 | 15 | 40 | 15 | 0.00000700483 | 20 | 0.00162635 | ø40-ø15 | 16.51 | 6.35 | 41.275 | 15.875 | TT03.03.0297 | 0297 | yes | 41.275 | 3048 | yes | no | 7.9375 | 20.6375 | HT_vratné vodní (45 °C) 1
13101995 | 2.NP_SO-102 | 0 | ø54 mm-ø40 mm | HD | 2.NP_SO-102 | 3291.29 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 14.2937 | 27 | 20 | 54 | 40 | 54 | 40 | 0.0000273868 | 27 | 0.00381252 | ø54-ø40 | 22.87 | 16.51 | 57.175 | 41.275 | TT03.03.0388 | 0388 | yes | 57.175 | 3048 | yes | no | 20.6375 | 28.5875 | HT_přívodní vodní (55 °C) 19
13102005 | 1.NP_SO-102 | 0 | ø40 mm-ø35 mm | HD | 1.NP_SO-102 | 3331.79 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10.3188 | 17.5 | 20 | 35 | 40 | 40 | 35 | 0.0000127544 | 17.5 | 0.00229993 | ø40-ø35 | 15.27 | 16.51 | 38.175 | 41.275 | TT03.03.0389 | 0389 | yes | 41.275 | 3048 | no | yes | 20.6375 | 19.0875 | HT_přívodní vodní (55 °C) 19
13116025 | 2.NP_SO-102 | 0 | ø42 mm-ø15 mm | HD | 2.NP_SO-102 | 2614.71 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 11.2937 | 21 | 7.5 | 42 | 15 | 42 | 15 | 0.00000887377 | 21 | 0.00185457 | ø42-ø15 | 18.07 | 6.35 | 45.175 | 15.875 | TT03.03.0520 | 0520 | yes | 45.175 | 3048 | yes | no | 7.9375 | 22.5875 | HT_přívodní vodní (55 °C) 9
13116062 | 2.NP_SO-102 | 0 | ø42 mm-ø15 mm | HD | 2.NP_SO-102 | 2614.71 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11.2937 | 21 | 7.5 | 42 | 15 | 42 | 15 | 0.00000887377 | 21 | 0.00185457 | ø42-ø15 | 18.07 | 6.35 | 45.175 | 15.875 | TT03.03.0523 | 0523 | yes | 45.175 | 3048 | yes | no | 7.9375 | 22.5875 | HT_vratné vodní (45 °C) 1
13123854 | 1.NP_SO-102 | 40 | ø120 mm-ø95 mm | HD | 1.NP_SO-102 | 3246.66 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10.3188 | 20 | 7.5 | 40 | 15 | 40 | 15 | 0.00000700483 | 20 | 0.00162635 | ø40-ø15 | 16.51 | 6.35 | 41.275 | 15.875 | TT03.03.0581 | 0581 | yes | 41.275 | 3048 | yes | no | 7.9375 | 20.6375 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13125475 | 2.NP_SO-102 | 0 | ø22 mm-ø15 mm | HD | 2.NP_SO-102 | 3025.29 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 6.29375 | 11 | 7.5 | 22 | 15 | 22 | 15 | 0.00000210707 | 11 | 0.000659252 | ø22-ø15 | 10.07 | 6.35 | 25.175 | 15.875 | TT03.03.0587 | 0587 | yes | 25.175 | 3048 | yes | no | 7.9375 | 12.5875 | HT_přívodní vodní (55 °C) 12
13147846 | 4.NP_SO-102 | 0 | ø25 mm-ø22 mm | HD | 4.NP_SO-102 | 3225.29 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.14375 | 11 | 12.5 | 22 | 25 | 25 | 22 | 0.00000404537 | 11 | 0.00100151 | ø25-ø22 | 10.07 | 11.43 | 25.175 | 28.575 | TT03.03.0803 | 0803 | yes | 28.575 | 3048 | no | yes | 14.2875 | 12.5875 | HT_přívodní vodní (55 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13206708 | -1.PP_SO-102 | 0 | ø80 mm-ø40 mm | HD | -1.PP_SO-102 | 2803.17 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 32 | 19.8438 | 40 | 20 | 80 | 40 | 80 | 40 | 0.0000585352 | 40 | 0.00670892 | ø80-ø40 | 31.75 | 16.51 | 79.375 | 41.275 | TT03.03.0950 | 0950 | yes | 79.375 | 3048 | yes | no | 20.6375 | 39.6875 | HT_přívodní vodní (65 °C) 32 | Mechanické – tok - Tlaková ztráta: 0 Pa
13207382 | -1.PP_SO-102 | 0 | ø80 mm-ø40 mm | HD | -1.PP_SO-102 | 2823.01 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 8 | 19.8438 | 20 | 40 | 40 | 80 | 80 | 40 | 0.0000585088 | 20 | 0.00670892 | ø80-ø40 | 16.51 | 31.75 | 41.275 | 79.375 | TT03.03.0954 | 0954 | yes | 79.375 | 3048 | no | yes | 39.6875 | 20.6375 | HT_vratné vodní (45 °C) 8
13208000 | -1.PP_SO-102 | 0 | ø80 mm-ø32 mm | HD | -1.PP_SO-102 | 2806.34 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 36 | 19.8438 | 40 | 16 | 80 | 32 | 80 | 32 | 0.000053403 | 40 | 0.00636724 | ø80-ø32 | 31.75 | 13.97 | 79.375 | 34.925 | TT03.03.0957 | 0957 | yes | 79.375 | 3048 | yes | no | 17.4625 | 39.6875 | HT_přívodní vodní (65 °C) 36
13208036 | -1.PP_SO-102 | 0 | ø80 mm-ø50 mm | HD | -1.PP_SO-102 | 2746.82 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 31 | 19.8438 | 40 | 25 | 80 | 50 | 80 | 50 | 0.0000700565 | 40 | 0.00735821 | ø80-ø50 | 31.75 | 21.59 | 79.375 | 53.975 | TT03.03.0960 | 0960 | yes | 79.375 | 3048 | yes | no | 26.9875 | 39.6875 | HT_přívodní vodní (65 °C) 31
13208292 | -1.PP_SO-102 | 0 | ø80 mm-ø50 mm | HD | -1.PP_SO-102 | 2796.82 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 6 | 19.8438 | 40 | 25 | 80 | 50 | 80 | 50 | 0.0000700565 | 40 | 0.00735821 | ø80-ø50 | 31.75 | 21.59 | 79.375 | 53.975 | TT03.03.0965 | 0965 | yes | 79.375 | 3048 | yes | no | 26.9875 | 39.6875 | HT_vratné vodní (45 °C) 6
13216284 | 2.NP_SO-102 | 0 | ø125 mm-ø65 mm | HD | 2.NP_SO-102 | 1000 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 1 | 32.5438 | 62.5 | 32.5 | 125 | 65 | 125 | 65 | 0.000256107 | 62.5 | 0.0173861 | ø125-ø65 | 52.07 | 26.67 | 130.175 | 66.675 | TT03.03.0982 | 0982 | yes | 130.175 | 3048 | yes | no | 33.3375 | 65.0875 | HT_přívodní vodní (55 °C) 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13216314 | 2.NP_SO-102 | 0 | ø100 mm-ø65 mm | HD | 2.NP_SO-102 | 1662 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 1 | 26.1938 | 50 | 32.5 | 100 | 65 | 100 | 65 | 0.000153591 | 50 | 0.0121569 | ø100-ø65 | 41.91 | 26.67 | 104.775 | 66.675 | TT03.03.0985 | 0985 | yes | 104.775 | 3048 | yes | no | 33.3375 | 52.3875 | HT_přívodní vodní (55 °C) 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13216512 | 2.NP_SO-102 | 0 | ø100 mm-ø65 mm | HD | 2.NP_SO-102 | 300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 26.1938 | 50 | 32.5 | 100 | 65 | 100 | 65 | 0.000153591 | 50 | 0.0121569 | ø100-ø65 | 41.91 | 26.67 | 104.775 | 66.675 | TT03.03.0986 | 0986 | yes | 104.775 | 3048 | yes | no | 33.3375 | 52.3875 | HT_vratné vodní (45 °C) 7
13219715 | 2.NP_SO-102 | 0 | ø100 mm-ø65 mm | HD | 2.NP_SO-102 | 704 | Fáze 1 | HT_přívodní vodní (45 °C) | Přívod teplé vody | HT_přívodní vodní (45 °C) 5 | 26.1938 | 50 | 32.5 | 100 | 65 | 100 | 65 | 0.000153591 | 50 | 0.0121569 | ø100-ø65 | 41.91 | 26.67 | 104.775 | 66.675 | TT03.03.1014 | 1014 | yes | 104.775 | 3048 | yes | no | 33.3375 | 52.3875 | HT_přívodní vodní (45 °C) 5
13219968 | 2.NP_SO-102 | 0 | ø125 mm-ø65 mm | HD | 2.NP_SO-102 | 1000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 5 | 32.5438 | 62.5 | 32.5 | 125 | 65 | 125 | 65 | 0.000256107 | 62.5 | 0.0173861 | ø125-ø65 | 52.07 | 26.67 | 130.175 | 66.675 | TT03.03.1018 | 1018 | yes | 130.175 | 3048 | yes | no | 33.3375 | 65.0875 | HT_vratné vodní (45 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13226339 | 2.NP_SO-102 | 0 | ø80 mm-ø40 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 19.8438 | 40 | 20 | 80 | 40 | 80 | 40 | 0.0000585352 | 40 | 0.00670892 | ø80-ø40 | 31.75 | 16.51 | 79.375 | 41.275 | TT03.03.1052 | 1052 | yes | 79.375 | 3048 | yes | no | 20.6375 | 39.6875 | HT_přívodní vodní (55 °C) 9
13226341 | 2.NP_SO-102 | 0 | ø80 mm-ø40 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 19.8438 | 40 | 20 | 80 | 40 | 80 | 40 | 0.0000585352 | 40 | 0.00670892 | ø80-ø40 | 31.75 | 16.51 | 79.375 | 41.275 | TT03.03.1053 | 1053 | yes | 79.375 | 3048 | yes | no | 20.6375 | 39.6875 | HT_vratné vodní (45 °C) 1
13311107 | -1.PP_SO-102 | 0 | ø20 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 10 | 8 | 20 | 16 | 20 | 16 | 0.00000184965 | 10 | 0.000597935 | ø20-ø16 | 8.89 | 7.67 | 22.225 | 19.175 | TT03.03.1336 | 1336 | no | 22.225 | 3048 | yes | no | 9.5875 | 11.1125 | HT_přívodní vodní (55 °C) 19
13311147 | 1.NP_SO-102 | 0 | ø35 mm-ø32 mm | HD | 1.NP_SO-102 | 3268.21 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 9.54375 | 17.5 | 16 | 35 | 32 | 35 | 32 | 0.00000998182 | 17.5 | 0.00190288 | ø35-ø32 | 15.27 | 13.97 | 38.175 | 34.925 | TT03.03.1338 | 1338 | yes | 38.175 | 3048 | yes | no | 17.4625 | 19.0875 | HT_přívodní vodní (55 °C) 19
13311344 | 2.NP_SO-102 | 0 | ø32 mm-ø20 mm | HD | 2.NP_SO-102 | 2632.54 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 8.73125 | 10 | 16 | 20 | 32 | 32 | 20 | 0.00000565444 | 9.98565 | 0.00129848 | ø32-ø20 | 8.89 | 13.97 | 22.225 | 34.925 | TT03.03.1344 | 1344 | yes | 34.925 | 3047.99 | no | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 25; HT_přívodní vodní (65 °C) 27 | Mechanické – tok - Tlaková ztráta: 0 Pa
13311483 | 1.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5.55625 | 10 | 8 | 20 | 16 | 20 | 16 | 0.00000184965 | 10 | 0.000597935 | ø20-ø16 | 8.89 | 7.67 | 22.225 | 19.175 | TT03.03.1351 | 1351 | no | 22.225 | 3048 | yes | no | 9.5875 | 11.1125 | HT_vratné vodní (45 °C) 1
13311490 | 1.NP_SO-102 | 40 | ø120 mm-ø100 mm | HD | 1.NP_SO-102 | 2900 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.1352 | 1352 | yes | 41.275 | 3048 | yes | no | 11.1125 | 20.6375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13311809 | 1.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5.55625 | 10 | 8 | 20 | 16 | 20 | 16 | 0.00000184965 | 10 | 0.000597935 | ø20-ø16 | 8.89 | 7.67 | 22.225 | 19.175 | TT03.03.1354 | 1354 | no | 22.225 | 3048 | yes | no | 9.5875 | 11.1125 | HT_vratné vodní (45 °C) 1
13311827 | 1.NP_SO-102 | 40 | ø120 mm-ø112 mm | HD | 1.NP_SO-102 | 3360 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT03.03.1355 | 1355 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13311832 | 1.NP_SO-102 | 0 | ø32 mm-ø20 mm | HD | 1.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT03.03.1356 | 1356 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | HT_přívodní vodní (55 °C) 9
13311834 | 1.NP_SO-102 | 0 | ø32 mm-ø20 mm | HD | 1.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT03.03.1357 | 1357 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | HT_přívodní vodní (55 °C) 9
13311836 | 1.NP_SO-102 | 0 | ø32 mm-ø20 mm | HD | 1.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT03.03.1358 | 1358 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | HT_vratné vodní (45 °C) 1
13311838 | 1.NP_SO-102 | 0 | ø32 mm-ø20 mm | HD | 1.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT03.03.1359 | 1359 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | HT_vratné vodní (45 °C) 1
13311840 | 1.NP_SO-102 | 40 | ø120 mm-ø112 mm | HD | 1.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT03.03.1360 | 1360 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13311854 | 1.NP_SO-102 | 0 | ø32 mm-ø15 mm | HD | 1.NP_SO-102 | 3329.84 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8.73125 | 16 | 7.5 | 32 | 15 | 32 | 15 | 0.0000046023 | 16 | 0.00116529 | ø32-ø15 | 13.97 | 6.35 | 34.925 | 15.875 | TT03.03.1361 | 1361 | yes | 34.925 | 3048 | yes | no | 7.9375 | 17.4625 | HT_přívodní vodní (55 °C) 9
13311901 | 2.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 4.79375 | 8 | 7.5 | 16 | 15 | 16 | 15 | 0.00000114458 | 8 | 0.000434165 | ø16-ø15 | 7.67 | 6.35 | 19.175 | 15.875 | TT03.03.1363 | 1363 | yes | 19.175 | 3048 | yes | no | 7.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13311903 | 2.NP_SO-102 | 0 | ø16 mm-ø15 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 4.79375 | 8 | 7.5 | 16 | 15 | 16 | 15 | 0.00000114458 | 8 | 0.000434165 | ø16-ø15 | 7.67 | 6.35 | 19.175 | 15.875 | TT03.03.1364 | 1364 | yes | 19.175 | 3048 | yes | no | 7.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13312483 | 1.NP_SO-102 | 0 | ø22 mm-ø15 mm | HD | 1.NP_SO-102 | 3931.06 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6.29375 | 11 | 7.5 | 22 | 15 | 22 | 15 | 0.00000210707 | 11 | 0.000659252 | ø22-ø15 | 10.07 | 6.35 | 25.175 | 15.875 | TT03.03.1375 | 1375 | no | 25.175 | 3048 | yes | no | 7.9375 | 12.5875 | HT_přívodní vodní (55 °C) 9
13312487 | 1.NP_SO-102 | 0 | ø22 mm-ø15 mm | HD | 1.NP_SO-102 | -41.0625 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 6.29375 | 11 | 7.5 | 22 | 15 | 22 | 15 | 0.00000210707 | 11 | 0.000659252 | ø22-ø15 | 10.07 | 6.35 | 25.175 | 15.875 | TT03.03.1376 | 1376 | no | 25.175 | 3048 | yes | no | 7.9375 | 12.5875 | HT_vratné vodní (45 °C) 32
13312489 | 1.NP_SO-102 | 0 | ø22 mm-ø15 mm | HD | 1.NP_SO-102 | 3921.06 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 6.29375 | 11 | 7.5 | 22 | 15 | 22 | 15 | 0.00000210707 | 11 | 0.000659252 | ø22-ø15 | 10.07 | 6.35 | 25.175 | 15.875 | TT03.03.1377 | 1377 | no | 25.175 | 3048 | yes | no | 7.9375 | 12.5875 | HT_vratné vodní (45 °C) 32
13312669 | 1.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 10 | 8 | 20 | 16 | 20 | 16 | 0.00000184965 | 10 | 0.000597935 | ø20-ø16 | 8.89 | 7.67 | 22.225 | 19.175 | TT03.03.1378 | 1378 | no | 22.225 | 3048 | yes | no | 9.5875 | 11.1125 | HT_přívodní vodní (55 °C) 19
13312671 | 1.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 10 | 8 | 20 | 16 | 20 | 16 | 0.00000184965 | 10 | 0.000597935 | ø20-ø16 | 8.89 | 7.67 | 22.225 | 19.175 | TT03.03.1379 | 1379 | no | 22.225 | 3048 | yes | no | 9.5875 | 11.1125 | HT_vratné vodní (45 °C) 13
13312694 | 1.NP_SO-102 | 0 | ø35 mm-ø25 mm | HD | 1.NP_SO-102 | 3300 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 9.54375 | 17.5 | 12.5 | 35 | 25 | 35 | 25 | 0.00000836867 | 17.5 | 0.00166421 | ø35-ø25 | 15.27 | 11.43 | 38.175 | 28.575 | TT03.03.1380 | 1380 | yes | 38.175 | 3048 | yes | no | 14.2875 | 19.0875 | HT_přívodní vodní (55 °C) 19
13312698 | 1.NP_SO-102 | 0 | ø40 mm-ø25 mm | HD | 1.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10.3188 | 20 | 12.5 | 40 | 25 | 40 | 25 | 0.00000994592 | 20 | 0.00193705 | ø40-ø25 | 16.51 | 11.43 | 41.275 | 28.575 | TT03.03.1382 | 1382 | yes | 41.275 | 3048 | yes | no | 14.2875 | 20.6375 | HT_vratné vodní (45 °C) 13
13312704 | 1.NP_SO-102 | 0 | ø25 mm-ø20 mm | HD | 1.NP_SO-102 | 3200 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT03.03.1384 | 1384 | yes | 28.575 | 3048 | yes | no | 11.1125 | 14.2875 | HT_přívodní vodní (55 °C) 19
13312902 | 2.NP_SO-102 | 0 | ø25 mm-ø22 mm | HD | 2.NP_SO-102 | 2750 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.14375 | 11 | 12.5 | 22 | 25 | 25 | 22 | 0.00000404537 | 11 | 0.00100151 | ø25-ø22 | 10.07 | 11.43 | 25.175 | 28.575 | TT03.03.1392 | 1392 | yes | 28.575 | 3048 | no | yes | 14.2875 | 12.5875 | HT_vratné vodní (45 °C) 1
13312906 | 2.NP_SO-102 | 0 | ø25 mm-ø22 mm | HD | 2.NP_SO-102 | 2731.06 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.14375 | 11 | 12.5 | 22 | 25 | 25 | 22 | 0.00000404537 | 11 | 0.00100151 | ø25-ø22 | 10.07 | 11.43 | 25.175 | 28.575 | TT03.03.1394 | 1394 | yes | 28.575 | 3048 | no | yes | 14.2875 | 12.5875 | HT_vratné vodní (45 °C) 1
13312910 | 2.NP_SO-102 | 0 | ø25 mm-ø22 mm | HD | 2.NP_SO-102 | 2468.94 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.14375 | 11 | 12.5 | 22 | 25 | 25 | 22 | 0.00000404537 | 11 | 0.00100151 | ø25-ø22 | 10.07 | 11.43 | 25.175 | 28.575 | TT03.03.1396 | 1396 | yes | 28.575 | 3048 | no | yes | 14.2875 | 12.5875 | HT_vratné vodní (45 °C) 1
13312914 | 2.NP_SO-102 | 0 | ø25 mm-ø22 mm | HD | 2.NP_SO-102 | 2468.94 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.14375 | 11 | 12.5 | 22 | 25 | 25 | 22 | 0.00000404537 | 11 | 0.00100151 | ø25-ø22 | 10.07 | 11.43 | 25.175 | 28.575 | TT03.03.1398 | 1398 | yes | 28.575 | 3048 | no | yes | 14.2875 | 12.5875 | HT_vratné vodní (45 °C) 1
13312920 | 2.NP_SO-102 | 0 | ø25 mm-ø22 mm | HD | 2.NP_SO-102 | 2468.94 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.14375 | 11 | 12.5 | 22 | 25 | 25 | 22 | 0.00000404537 | 11 | 0.00100151 | ø25-ø22 | 10.07 | 11.43 | 25.175 | 28.575 | TT03.03.1401 | 1401 | yes | 28.575 | 3048 | no | yes | 14.2875 | 12.5875 | HT_přívodní vodní (55 °C) 9
13312924 | 2.NP_SO-102 | 0 | ø25 mm-ø22 mm | HD | 2.NP_SO-102 | 2468.94 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.14375 | 11 | 12.5 | 22 | 25 | 25 | 22 | 0.00000404537 | 11 | 0.00100151 | ø25-ø22 | 10.07 | 11.43 | 25.175 | 28.575 | TT03.03.1403 | 1403 | yes | 28.575 | 3048 | no | yes | 14.2875 | 12.5875 | HT_přívodní vodní (55 °C) 9
13313141 | 2.NP_SO-102 | 0 | ø25 mm-ø20 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT03.03.1406 | 1406 | yes | 28.575 | 3048 | no | yes | 14.2875 | 11.1125 | HT_přívodní vodní (55 °C) 12 | Mechanické – tok - Tlaková ztráta: 0 Pa
13313143 | 2.NP_SO-102 | 0 | ø25 mm-ø22 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 7.14375 | 11 | 12.5 | 22 | 25 | 25 | 22 | 0.00000404537 | 11 | 0.00100151 | ø25-ø22 | 10.07 | 11.43 | 25.175 | 28.575 | TT03.03.1407 | 1407 | yes | 28.575 | 3048 | no | yes | 14.2875 | 12.5875 | HT_vratné vodní (45 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13313928 | 2.NP_SO-102 | 0 | ø25 mm-ø22 mm | HD | 2.NP_SO-102 | 2750 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.14375 | 11 | 12.5 | 22 | 25 | 25 | 22 | 0.00000404537 | 11 | 0.00100151 | ø25-ø22 | 10.07 | 11.43 | 25.175 | 28.575 | TT03.03.1427 | 1427 | yes | 28.575 | 3048 | no | yes | 14.2875 | 12.5875 | HT_vratné vodní (45 °C) 1
13314044 | 2.NP_SO-102 | 0 | ø125 mm-ø65 mm | HE | 2.NP_SO-102 | 1209.5 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 32.5438 | 62.5 | 32.5 | 125 | 65 | 125 | 65 | 0.000256107 | 62.5 | 0.0173861 | ø125-ø65 | 52.07 | 26.67 | 130.175 | 66.675 | TT03.03.1428 | 1428 | yes | 130.175 | 3048 | yes | no | 33.3375 | 65.0875 | HT/CL_přívodní vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13314046 | 2.NP_SO-102 | 0 | ø125 mm-ø65 mm | HE | 2.NP_SO-102 | 1209.5 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 32.5438 | 62.5 | 32.5 | 125 | 65 | 125 | 65 | 0.000256107 | 62.5 | 0.0173861 | ø125-ø65 | 52.07 | 26.67 | 130.175 | 66.675 | TT03.03.1429 | 1429 | yes | 130.175 | 3048 | yes | no | 33.3375 | 65.0875 | HT/CL_vratné vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13314220 | 2.NP_SO-102 | 40 | ø120 mm-ø100 mm | HD | 2.NP_SO-102 | 3257.78 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 21.7577 | 0.00176413 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.1430 | 1430 | yes | 41.275 | 3049.76 | yes | no | 11.1125 | 20.6375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13314295 | 2.NP_SO-102 | 0 | ø20 mm-ø15 mm | HD | 2.NP_SO-102 | 3234.97 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 5.55625 | 10 | 7.5 | 20 | 15 | 20 | 15 | 0.00000157471 | 10 | 0.000554533 | ø20-ø15 | 8.89 | 6.35 | 22.225 | 15.875 | TT03.03.1437 | 1437 | yes | 22.225 | 3048 | yes | no | 7.9375 | 11.1125 | HT_přívodní vodní (55 °C) 9
