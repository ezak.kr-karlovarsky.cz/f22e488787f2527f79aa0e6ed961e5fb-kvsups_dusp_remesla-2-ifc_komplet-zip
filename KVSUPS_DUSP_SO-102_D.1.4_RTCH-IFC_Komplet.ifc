Properties of the parts of a building model (IFC4), part 66 of 72

# IfcPipeSegment: Typy trubek:Ocel_uhlíková (1186)
Name (Typy trubek:Ocel_uhlíková:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Tloušťka izolace (mm) | Celková velikost | Relativní drsnost | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) | Řez | Délka (mm) | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
13188585 | 2.NP_SO-102 | 6640.11 | 0.00141175 | 0.884486 | 0 | ø32 mm | 0.00278552 | HD | 2.NP_SO-102 | 2221.2 | 2200 | 2200 | 2178.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 6182.05 | 0.667537 | 32 | 36 | 6640.11 | ø32 | 42.4 | 35.9 | TR02.02.1298 | 1298 | yes | HT_vratné vodní (45 °C) 23 | 0
13188985 | 2.NP_SO-102 | 72.375 | 0.00141175 | 0.00964061 | 0 | ø32 mm | 0.00278552 | HD | 2.NP_SO-102 | 2176.19 | 2176.19 | 2103.81 | 2103.81 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 6103.81 | 0.00727593 | 32 | 36 | 72.375 | ø32 | 42.4 | 35.9 | TR02.02.1299 | 1299 | yes | HT_vratné vodní (45 °C) 23
13189031 | 2.NP_SO-102 | 72.375 | 0.00141175 | 0.00964061 | 0 | ø32 mm | 0.00278552 | HD | 2.NP_SO-102 | 2176.19 | 2176.19 | 2103.81 | 2103.81 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 6103.81 | 0.00727593 | 32 | 55 | 72.375 | ø32 | 42.4 | 35.9 | TR02.02.1300 | 1300 | yes | HT_přívodní vodní (65 °C) 8
13189407 | 2.NP_SO-102 | 2825.42 | 0.00141175 | 0.376356 | 0 | ø32 mm | 0.00278552 | HD | 2.NP_SO-102 | 2221.2 | 2200 | 2200 | 2178.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 6182.05 | 0.284043 | 32 | 36 | 2825.42 | ø32 | 42.4 | 35.9 | TR02.02.1303 | 1303 | yes | HT_vratné vodní (45 °C) 23 | 0
13206680 | -1.PP_SO-102 | 7884.85 | 0.00183197 | 1.19644 | 40 | ø120 mm | 0.00239234 | HD | -1.PP_SO-102 | 2874.15 | 2850 | 2850 | 2825.85 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 32 | -1170.9 | 0.99084 | 40 | 2 | 7884.85 | ø40 | 48.3 | 41.8 | TR02.02.1308 | 1308 | yes | HT_přívodní vodní (65 °C) 32 | 0 | Izolace - Typ izolace: Tepelná
13206691 | -1.PP_SO-102 | 2138.03 | 0.00183197 | 0.324423 | 0 | ø40 mm | 0.00239234 | HD | -1.PP_SO-102 | 2874.15 | 2850 | 2850 | 2825.85 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 32 | -1170.9 | 0.268673 | 40 | 2 | 2138.03 | ø40 | 48.3 | 41.8 | TR02.02.1309 | 1309 | yes | HT_přívodní vodní (65 °C) 32 | 0
13206719 | -1.PP_SO-102 | 7534.85 | 0.00183197 | 1.14333 | 40 | ø120 mm | 0.00239234 | HD | -1.PP_SO-102 | 2874.15 | 2850 | 2850 | 2825.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 8 | -1170.9 | 0.946857 | 40 | 186 | 7534.85 | ø40 | 48.3 | 41.8 | TR02.02.1311 | 1311 | yes | HT_vratné vodní (45 °C) 8 | 0 | Izolace - Typ izolace: Tepelná
13206762 | -1.PP_SO-102 | 2268.03 | 0.00183197 | 0.344149 | 0 | ø40 mm | 0.00239234 | HD | -1.PP_SO-102 | 2874.15 | 2850 | 2850 | 2825.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 8 | -1170.9 | 0.28501 | 40 | 186 | 2268.03 | ø40 | 48.3 | 41.8 | TR02.02.1312 | 1312 | yes | HT_vratné vodní (45 °C) 8 | 0
13207391 | -1.PP_SO-102 | 8241.2 | 0.00141175 | 1.09776 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2871.2 | 2850 | 2850 | 2828.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 4 | -1167.95 | 0.828496 | 32 | 8 | 8241.2 | ø32 | 42.4 | 35.9 | TR02.02.1317 | 1317 | yes | HT_vratné vodní (45 °C) 4 | 0 | Izolace - Typ izolace: Tepelná
13207402 | -1.PP_SO-102 | 2574.38 | 0.00141175 | 0.342917 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 2871.2 | 2850 | 2850 | 2828.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 4 | -1167.95 | 0.258805 | 32 | 8 | 2574.38 | ø32 | 42.4 | 35.9 | TR02.02.1318 | 1318 | yes | HT_vratné vodní (45 °C) 4 | 0
13207981 | -1.PP_SO-102 | 8591.2 | 0.00141175 | 1.14438 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2871.2 | 2850 | 2850 | 2828.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 36 | -1167.95 | 0.863682 | 32 | 184 | 8591.2 | ø32 | 42.4 | 35.9 | TR02.02.1322 | 1322 | yes | HT_přívodní vodní (65 °C) 36 | 0 | Izolace - Typ izolace: Tepelná
13207990 | -1.PP_SO-102 | 2444.38 | 0.00141175 | 0.325601 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 2871.2 | 2850 | 2850 | 2828.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 36 | -1167.95 | 0.245736 | 32 | 184 | 2444.38 | ø32 | 42.4 | 35.9 | TR02.02.1323 | 1323 | yes | HT_přívodní vodní (65 °C) 36 | 0
13208015 | -1.PP_SO-102 | 9272.15 | 0.00285535 | 1.7565 | 40 | ø130 mm | 0.00188679 | HD | -1.PP_SO-102 | 2830.15 | 2800 | 2800 | 2769.85 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 31 | -1226.5 | 1.45647 | 50 | 94 | 9272.15 | ø50 | 60.3 | 53 | TR02.02.1324 | 1324 | yes | HT_přívodní vodní (65 °C) 31 | 0 | Izolace - Typ izolace: Tepelná
13208026 | -1.PP_SO-102 | 2725.33 | 0.00285535 | 0.516282 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-102 | 2830.15 | 2800 | 2800 | 2769.85 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 31 | -1226.5 | 0.428095 | 50 | 94 | 2725.33 | ø50 | 60.3 | 53 | TR02.02.1325 | 1325 | yes | HT_přívodní vodní (65 °C) 31 | 0
13208051 | -1.PP_SO-102 | 8922.15 | 0.00285535 | 1.69019 | 40 | ø130 mm | 0.00188679 | HD | -1.PP_SO-102 | 2880.15 | 2850 | 2850 | 2819.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 6 | -1176.5 | 1.40149 | 50 | 187 | 8922.15 | ø50 | 60.3 | 53 | TR02.02.1326 | 1326 | yes | HT_vratné vodní (45 °C) 6 | 0 | Izolace - Typ izolace: Tepelná
13208075 | -1.PP_SO-102 | 2855.33 | 0.00285535 | 0.540909 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-102 | 2880.15 | 2850 | 2850 | 2819.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 6 | -1176.5 | 0.448515 | 50 | 187 | 2855.33 | ø50 | 60.3 | 53 | TR02.02.1327 | 1327 | yes | HT_vratné vodní (45 °C) 6 | 0
13213579 | 2.NP_SO-102 | 6107.14 | 0.000356274 | 0.408665 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 3110.65 | 3100 | 3100 | 3089.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 7092 | 0.287792 | 15 | 129 | 6107.14 | ø15 | 21.3 | 16 | TR02.02.1337 | 1337 | yes | HT_vratné vodní (45 °C) 9 | 0
13213589 | 2.NP_SO-102 | 75.7125 | 0.000356274 | 0.00506637 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 3110.65 | 3100 | 3100 | 3089.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 7092 | 0.00356787 | 15 | 129 | 75.7125 | ø15 | 21.3 | 16 | TR02.02.1338 | 1338 | no | HT_vratné vodní (45 °C) 9 | 0
13214743 | -1.PP_SO-102 | 1046.03 | 0.00141175 | 0.139334 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 1821.2 | 1800 | 1800 | 1778.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -2217.95 | 0.105158 | 32 | 32 | 1046.03 | ø32 | 42.4 | 35.9 | TR02.02.1341 | 1341 | yes | HT_vratné vodní (45 °C) 23 | 0
13215155 | -1.PP_SO-102 | 3776.05 | 0.00141175 | 0.502984 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 1821.2 | 1800 | 1800 | 1778.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -2217.95 | 0.37961 | 32 | 36 | 3776.05 | ø32 | 42.4 | 35.9 | TR02.02.1342 | 1342 | yes | HT_vratné vodní (45 °C) 23 | 0
13215166 | -1.PP_SO-102 | 752.375 | 0.00141175 | 0.100219 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 2576.19 | 1823.81 | 2576.19 | 1823.81 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -2176.19 | 0.075637 | 32 | 36 | 752.375 | ø32 | 42.4 | 35.9 | TR02.02.1343 | 1343 | yes | HT_vratné vodní (45 °C) 23
13215185 | -1.PP_SO-102 | 4026.05 | 0.00141175 | 0.536285 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 1821.2 | 1800 | 1800 | 1778.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -2217.95 | 0.404743 | 32 | 55 | 4026.05 | ø32 | 42.4 | 35.9 | TR02.02.1344 | 1344 | yes | HT_přívodní vodní (65 °C) 8 | 0
13215196 | -1.PP_SO-102 | 752.375 | 0.00141175 | 0.100219 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 2576.19 | 1823.81 | 2576.19 | 1823.81 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -2176.19 | 0.075637 | 32 | 55 | 752.375 | ø32 | 42.4 | 35.9 | TR02.02.1345 | 1345 | yes | HT_přívodní vodní (65 °C) 8
13216170 | 2.NP_SO-102 | 4365.17 | 0.00183197 | 0.662367 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 3124.15 | 3100 | 3100 | 3075.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 7079.1 | 0.548544 | 40 | 2 | 4365.17 | ø40 | 48.3 | 41.8 | TR02.02.1348 | 1348 | yes | HT_vratné vodní (45 °C) 10 | 0
13216180 | 2.NP_SO-102 | 6205.94 | 0.00183197 | 0.941682 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2324.15 | 2300 | 2300 | 2275.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 6279.1 | 0.779861 | 40 | 2 | 6205.94 | ø40 | 48.3 | 41.8 | TR02.02.1349 | 1349 | yes | HT_vratné vodní (45 °C) 10 | 0
13216217 | 2.NP_SO-102 | 4665.17 | 0.00183197 | 0.707889 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 3124.15 | 3100 | 3100 | 3075.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 7079.1 | 0.586243 | 40 | 2 | 4665.17 | ø40 | 48.3 | 41.8 | TR02.02.1350 | 1350 | yes | HT_přívodní vodní (55 °C) 2 | 0
13216226 | 2.NP_SO-102 | 6156.83 | 0.00183197 | 0.93423 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2324.15 | 2300 | 2300 | 2275.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 6279.1 | 0.77369 | 40 | 2 | 6156.83 | ø40 | 48.3 | 41.8 | TR02.02.1351 | 1351 | yes | HT_přívodní vodní (55 °C) 2 | 0
13216926 | 2.NP_SO-102 | 746.025 | 0.00183197 | 0.113201 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 3073.01 | 2326.99 | 3073.01 | 2326.99 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 6326.99 | 0.0937483 | 40 | 2 | 746.025 | ø40 | 48.3 | 41.8 | TR02.02.1360 | 1360 | yes | HT_přívodní vodní (55 °C) 2
13217022 | 2.NP_SO-102 | 746.025 | 0.00183197 | 0.113201 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 3073.01 | 2326.99 | 3073.01 | 2326.99 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 6326.99 | 0.0937483 | 40 | 2 | 746.025 | ø40 | 48.3 | 41.8 | TR02.02.1363 | 1363 | yes | HT_vratné vodní (45 °C) 10
13217374 | 2.NP_SO-102 | 8700.64 | 0.00183197 | 1.32023 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2324.15 | 2300 | 2300 | 2275.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 6279.1 | 1.09336 | 40 | 33 | 8700.64 | ø40 | 48.3 | 41.8 | TR02.02.1367 | 1367 | yes | HT_přívodní vodní (55 °C) 12 | 0
13217383 | 2.NP_SO-102 | 9349.75 | 0.00183197 | 1.41872 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2324.15 | 2300 | 2300 | 2275.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 6279.1 | 1.17492 | 40 | 144 | 9349.75 | ø40 | 48.3 | 41.8 | TR02.02.1368 | 1368 | yes | HT_vratné vodní (45 °C) 9 | 0
13217413 | 2.NP_SO-102 | 3961.72 | 0.00183197 | 0.601147 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2674.15 | 2650 | 2650 | 2625.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6629.1 | 0.497844 | 40 | 45 | 3961.72 | ø40 | 48.3 | 41.8 | TR02.02.1369 | 1369 | yes | HT_vratné vodní (45 °C) 1 | 0
13217446 | 2.NP_SO-102 | 1306.03 | 0.00183197 | 0.198175 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2674.15 | 2650 | 2650 | 2625.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6629.1 | 0.16412 | 40 | 45 | 1306.03 | ø40 | 48.3 | 41.8 | TR02.02.1370 | 1370 | yes | HT_vratné vodní (45 °C) 1 | 0
13217458 | 2.NP_SO-102 | 5746.03 | 0.00183197 | 0.871896 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2674.15 | 2650 | 2650 | 2625.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6629.1 | 0.722067 | 40 | 45 | 5746.03 | ø40 | 48.3 | 41.8 | TR02.02.1371 | 1371 | yes | HT_vratné vodní (45 °C) 1 | 0
13217521 | 2.NP_SO-102 | 23.0634 | 0.00183197 | 0.00349962 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 3024.15 | 3000 | 3000 | 2975.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6979.1 | 0.00289823 | 40 | 51 | 23.0634 | ø40 | 48.3 | 41.8 | TR02.02.1372 | 1372 | yes | HT_vratné vodní (45 °C) 1 | 0
13217752 | 2.NP_SO-102 | 3798.26 | 0.00183197 | 0.576344 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2674.15 | 2650 | 2650 | 2625.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6629.1 | 0.477303 | 40 | 43 | 3798.26 | ø40 | 48.3 | 41.8 | TR02.02.1373 | 1373 | yes | HT_přívodní vodní (55 °C) 9 | 0
13217762 | 2.NP_SO-102 | 1306.03 | 0.00183197 | 0.198175 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2674.15 | 2650 | 2650 | 2625.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6629.1 | 0.16412 | 40 | 43 | 1306.03 | ø40 | 48.3 | 41.8 | TR02.02.1374 | 1374 | yes | HT_přívodní vodní (55 °C) 9 | 0
13217770 | 2.NP_SO-102 | 5659.49 | 0.00183197 | 0.858764 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2674.15 | 2650 | 2650 | 2625.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6629.1 | 0.711192 | 40 | 43 | 5659.49 | ø40 | 48.3 | 41.8 | TR02.02.1375 | 1375 | yes | HT_přívodní vodní (55 °C) 9 | 0
13218030 | 2.NP_SO-102 | 289.675 | 0.00183197 | 0.043955 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2966.66 | 2676.99 | 2966.66 | 2676.99 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6676.99 | 0.0364016 | 40 | 45 | 289.675 | ø40 | 48.3 | 41.8 | TR02.02.1376 | 1376 | yes | HT_vratné vodní (45 °C) 1
13218033 | 2.NP_SO-102 | 6002.08 | 0.00183197 | 0.910749 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 3024.15 | 3000 | 3000 | 2975.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6979.1 | 0.754244 | 40 | 534 | 6002.08 | ø40 | 48.3 | 41.8 | TR02.02.1377 | 1377 | yes | HT_vratné vodní (45 °C) 1 | 0
13218069 | 2.NP_SO-102 | 941.154 | 0.00454772 | 0.225007 | 0 | ø65 mm | 0.00145138 | HD | 2.NP_SO-102 | 2338.05 | 2300 | 2300 | 2261.95 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6265.55 | 0.192187 | 65 | 113 | 941.154 | ø65 | 76.1 | 68.9 | TR02.02.1378 | 1378 | yes | HT_vratné vodní (45 °C) 26 | 0
13218078 | 2.NP_SO-102 | 342.047 | 0.00454772 | 0.081775 | 0 | ø65 mm | 0.00145138 | HD | 2.NP_SO-102 | 2338.05 | 2300 | 2300 | 2261.95 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6265.55 | 0.0698472 | 65 | 111 | 342.047 | ø65 | 76.1 | 68.9 | TR02.02.1379 | 1379 | yes | HT_přívodní vodní (55 °C) 25 | 0
13218198 | 2.NP_SO-102 | 6402.08 | 0.00183197 | 0.971445 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 3024.15 | 3000 | 3000 | 2975.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6979.1 | 0.804509 | 40 | 370 | 6402.08 | ø40 | 48.3 | 41.8 | TR02.02.1380 | 1380 | yes | HT_přívodní vodní (55 °C) 9 | 0
13218298 | 2.NP_SO-102 | 289.675 | 0.00183197 | 0.043955 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2966.66 | 2676.99 | 2966.66 | 2676.99 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6676.99 | 0.0364016 | 40 | 43 | 289.675 | ø40 | 48.3 | 41.8 | TR02.02.1381 | 1381 | yes | HT_přívodní vodní (55 °C) 9
13218301 | 2.NP_SO-102 | 53.0634 | 0.00183197 | 0.00805179 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 3024.15 | 3000 | 3000 | 2975.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6979.1 | 0.00666815 | 40 | 80 | 53.0634 | ø40 | 48.3 | 41.8 | TR02.02.1382 | 1382 | yes | HT_přívodní vodní (55 °C) 9 | 0
13218354 | 2.NP_SO-102 | 10306.4 | 0.00183197 | 1.56389 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 3024.15 | 3000 | 3000 | 2975.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6979.1 | 1.29515 | 40 | 370 | 10306.4 | ø40 | 48.3 | 41.8 | TR02.02.1383 | 1383 | yes | HT_přívodní vodní (55 °C) 9 | 0
13219113 | 2.NP_SO-102 | 10206.4 | 0.00183197 | 1.54871 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 3024.15 | 3000 | 3000 | 2975.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6979.1 | 1.28258 | 40 | 534 | 10206.4 | ø40 | 48.3 | 41.8 | TR02.02.1391 | 1391 | yes | HT_vratné vodní (45 °C) 1 | 0
13223114 | 2.NP_SO-102 | 3080.41 | 0.00141175 | 0.410322 | 0 | ø32 mm | 0.00278552 | HD | 2.NP_SO-102 | 2221.2 | 2200 | 2200 | 2178.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 6182.05 | 0.309677 | 32 | 55 | 3080.41 | ø32 | 42.4 | 35.9 | TR02.02.1424 | 1424 | yes | HT_přívodní vodní (65 °C) 8 | 0
13223484 | 2.NP_SO-102 | 306.991 | 0.00141175 | 0.0408922 | 0 | ø32 mm | 0.00278552 | HD | 2.NP_SO-102 | 2671.2 | 2650 | 2650 | 2628.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 6632.05 | 0.0308621 | 32 | 55 | 306.991 | ø32 | 42.4 | 35.9 | TR02.02.1426 | 1426 | yes | HT_přívodní vodní (65 °C) 8 | 0
13223498 | 2.NP_SO-102 | 402.375 | 0.00141175 | 0.0535978 | 0 | ø32 mm | 0.00278552 | HD | 2.NP_SO-102 | 2626.19 | 2626.19 | 2223.81 | 2223.81 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 6223.81 | 0.0404511 | 32 | 55 | 402.375 | ø32 | 42.4 | 35.9 | TR02.02.1427 | 1427 | yes | HT_přívodní vodní (65 °C) 8
13223784 | 2.NP_SO-102 | 556.982 | 0.00141175 | 0.074192 | 0 | ø32 mm | 0.00278552 | HD | 2.NP_SO-102 | 2621.2 | 2600 | 2600 | 2578.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 6582.05 | 0.0559939 | 32 | 36 | 556.982 | ø32 | 42.4 | 35.9 | TR02.02.1429 | 1429 | yes | HT_vratné vodní (45 °C) 23 | 0
13223793 | 2.NP_SO-102 | 352.375 | 0.00141175 | 0.0469376 | 0 | ø32 mm | 0.00278552 | HD | 2.NP_SO-102 | 2576.19 | 2576.19 | 2223.81 | 2223.81 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 6223.81 | 0.0354246 | 32 | 36 | 352.375 | ø32 | 42.4 | 35.9 | TR02.02.1430 | 1430 | yes | HT_vratné vodní (45 °C) 23
13226194 | 2.NP_SO-102 | 1945.39 | 0.00183197 | 0.295192 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2324.15 | 2300 | 2300 | 2275.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6279.1 | 0.244465 | 40 | 370 | 1945.39 | ø40 | 48.3 | 41.8 | TR02.02.1432 | 1432 | yes | HT_přívodní vodní (55 °C) 9 | 0
13226217 | 2.NP_SO-102 | 2545.39 | 0.00183197 | 0.386235 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2324.15 | 2300 | 2300 | 2275.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6279.1 | 0.319863 | 40 | 534 | 2545.39 | ø40 | 48.3 | 41.8 | TR02.02.1434 | 1434 | yes | HT_vratné vodní (45 °C) 1 | 0
13226277 | 2.NP_SO-102 | 646.025 | 0.00183197 | 0.0980271 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2973.01 | 2326.99 | 2973.01 | 2326.99 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6326.99 | 0.0811819 | 40 | 370 | 646.025 | ø40 | 48.3 | 41.8 | TR02.02.1435 | 1435 | yes | HT_přívodní vodní (55 °C) 9
13226311 | 2.NP_SO-102 | 646.025 | 0.00183197 | 0.0980271 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2973.01 | 2326.99 | 2973.01 | 2326.99 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6326.99 | 0.0811819 | 40 | 534 | 646.025 | ø40 | 48.3 | 41.8 | TR02.02.1436 | 1436 | yes | HT_vratné vodní (45 °C) 1
13226857 | 2.NP_SO-102 | 915.853 | 0.00620623 | 0.255787 | 0 | ø80 mm | 0.00123762 | HE | 2.NP_SO-102 | 2344.45 | 2300 | 2300 | 2255.55 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 6259.6 | 0.230179 | 80 | 18 | 915.853 | ø80 | 88.9 | 80.8 | TR02.02.1437 | 1437 | yes | HT/CL_přívodní vodní 1 | 0
13226875 | 2.NP_SO-102 | 1141.15 | 0.00454772 | 0.272822 | 0 | ø65 mm | 0.00145138 | HE | 2.NP_SO-102 | 2338.05 | 2300 | 2300 | 2261.95 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 6265.55 | 0.233028 | 65 | 4 | 1141.15 | ø65 | 76.1 | 68.9 | TR02.02.1438 | 1438 | yes | HT/CL_vratné vodní 1 | 0
13230095 | 2.NP_SO-102 | 1014.14 | 0.00141175 | 0.135087 | 0 | ø32 mm | 0.00278552 | HC | 2.NP_SO-102 | 2921.2 | 2900 | 2900 | 2878.8 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 6882.05 | 0.101952 | 32 | 2 | 1014.14 | ø32 | 42.4 | 35.9 | TR02.02.1457 | 1457 | yes | CL_přívodní vodní (10 °C) 1 | 0
13230105 | 2.NP_SO-102 | 1650.02 | 0.00141175 | 0.219788 | 0 | ø32 mm | 0.00278552 | HC | 2.NP_SO-102 | 2876.19 | 2876.19 | 1226.17 | 1226.17 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 5226.17 | 0.165878 | 32 | 2 | 1650.02 | ø32 | 42.4 | 35.9 | TR02.02.1458 | 1458 | yes | CL_přívodní vodní (10 °C) 1
13230138 | 2.NP_SO-102 | 153.309 | 0.00141175 | 0.0204213 | 0 | ø32 mm | 0.00278552 | HC | 2.NP_SO-102 | 2921.2 | 2900 | 2900 | 2878.8 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 6882.05 | 0.0154123 | 32 | 10 | 153.309 | ø32 | 42.4 | 35.9 | TR02.02.1459 | 1459 | yes | CL_vratné vodní (15 °C) 2 | 0
13230150 | 2.NP_SO-102 | 1650.02 | 0.00141175 | 0.219788 | 0 | ø32 mm | 0.00278552 | HC | 2.NP_SO-102 | 2876.19 | 2876.19 | 1226.17 | 1226.17 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 5226.17 | 0.165878 | 32 | 10 | 1650.02 | ø32 | 42.4 | 35.9 | TR02.02.1460 | 1460 | yes | CL_vratné vodní (15 °C) 2
13230202 | 2.NP_SO-102 | 2139.15 | 0.000891835 | 0.226476 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 3016.85 | 3000 | 3000 | 2983.15 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 6986.4 | 0.168009 | 25 | 21 | 2139.15 | ø25 | 33.7 | 27.2 | TR02.02.1461 | 1461 | yes | HT_přívodní vodní (55 °C) 12 | 0
13230212 | 2.NP_SO-102 | 1568.73 | 0.000891835 | 0.166084 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 3016.85 | 3000 | 3000 | 2983.15 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 6986.4 | 0.123207 | 25 | 21 | 1568.73 | ø25 | 33.7 | 27.2 | TR02.02.1462 | 1462 | yes | HT_přívodní vodní (55 °C) 12 | 0
13230225 | 2.NP_SO-102 | 5808.05 | 0.000891835 | 0.614908 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 3016.85 | 3000 | 3000 | 2983.15 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 6986.4 | 0.456163 | 25 | 21 | 5808.05 | ø25 | 33.7 | 27.2 | TR02.02.1463 | 1463 | yes | HT_přívodní vodní (55 °C) 12 | 0
13230281 | 2.NP_SO-102 | 1518.73 | 0.000891835 | 0.16079 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 3016.85 | 3000 | 3000 | 2983.15 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 6986.4 | 0.11928 | 25 | 120 | 1518.73 | ø25 | 33.7 | 27.2 | TR02.02.1464 | 1464 | yes | HT_vratné vodní (45 °C) 9 | 0
13230291 | 2.NP_SO-102 | 5356.57 | 0.000891835 | 0.567109 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 3016.85 | 3000 | 3000 | 2983.15 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 6986.4 | 0.420704 | 25 | 120 | 5356.57 | ø25 | 33.7 | 27.2 | TR02.02.1465 | 1465 | yes | HT_vratné vodní (45 °C) 9 | 0
13230585 | 2.NP_SO-102 | 5751.76 | 0.000568237 | 0.486075 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3013.45 | 3000 | 3000 | 2986.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 6989.2 | 0.361394 | 20 | 12 | 5751.76 | ø20 | 26.9 | 21.6 | TR02.02.1466 | 1466 | yes | HT_přívodní vodní (55 °C) 12 | 0
13230608 | 2.NP_SO-102 | 5693.99 | 0.000568237 | 0.481193 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3013.45 | 3000 | 3000 | 2986.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 6989.2 | 0.357764 | 20 | 18 | 5693.99 | ø20 | 26.9 | 21.6 | TR02.02.1467 | 1467 | yes | HT_vratné vodní (45 °C) 9 | 0
13230643 | 2.NP_SO-102 | 665.075 | 0.000568237 | 0.0562047 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2982.54 | 2982.54 | 2317.46 | 2317.46 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 6317.46 | 0.0417879 | 20 | 12 | 665.075 | ø20 | 26.9 | 21.6 | TR02.02.1468 | 1468 | yes | HT_přívodní vodní (55 °C) 12
13230670 | 2.NP_SO-102 | 665.075 | 0.000568237 | 0.0562047 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2982.54 | 2982.54 | 2317.46 | 2317.46 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 6317.46 | 0.0417879 | 20 | 18 | 665.075 | ø20 | 26.9 | 21.6 | TR02.02.1469 | 1469 | yes | HT_vratné vodní (45 °C) 9
13246121 | 2.NP_SO-102 | 182.537 | 0.000568237 | 0.015426 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2213.45 | 2200 | 2200 | 2186.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6189.2 | 0.0114692 | 20 | 106 | 182.537 | ø20 | 26.9 | 21.6 | TR02.02.1499 | 1499 | yes | HT_přívodní vodní (55 °C) 25 | 0
13246130 | 2.NP_SO-102 | 6975.6 | 0.000568237 | 0.5895 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2213.45 | 2200 | 2200 | 2186.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6189.2 | 0.43829 | 20 | 106 | 6975.6 | ø20 | 26.9 | 21.6 | TR02.02.1500 | 1500 | yes | HT_přívodní vodní (55 °C) 25 | 0
13246150 | 2.NP_SO-102 | 2282.54 | 0.000568237 | 0.192895 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2463.45 | 2450 | 2450 | 2436.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6439.2 | 0.143416 | 20 | 93 | 2282.54 | ø20 | 26.9 | 21.6 | TR02.02.1501 | 1501 | yes | HT_přívodní vodní (55 °C) 25 | 0
13246168 | 2.NP_SO-102 | 3972.81 | 0.000568237 | 0.335737 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2463.45 | 2450 | 2450 | 2436.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6439.2 | 0.249619 | 20 | 9 | 3972.81 | ø20 | 26.9 | 21.6 | TR02.02.1502 | 1502 | yes | HT_přívodní vodní (55 °C) 25 | 0
13246221 | 2.NP_SO-102 | 64.275 | 0.00454772 | 0.0153666 | 0 | ø65 mm | 0.00145138 | HD | 2.NP_SO-102 | 2403.96 | 2339.69 | 2403.96 | 2339.69 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6339.69 | 0.0131252 | 65 | 111 | 64.275 | ø65 | 76.1 | 68.9 | TR02.02.1503 | 1503 | yes | HT_přívodní vodní (55 °C) 25
13246224 | 2.NP_SO-102 | 1269.83 | 0.000568237 | 0.107312 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2463.45 | 2450 | 2450 | 2436.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6439.2 | 0.0797859 | 20 | 100 | 1269.83 | ø20 | 26.9 | 21.6 | TR02.02.1504 | 1504 | yes | HT_přívodní vodní (55 °C) 25 | 0
13246268 | 2.NP_SO-102 | 5185.6 | 0.000568237 | 0.438229 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2413.45 | 2400 | 2400 | 2386.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6389.2 | 0.325821 | 20 | 111 | 5185.6 | ø20 | 26.9 | 21.6 | TR02.02.1505 | 1505 | yes | HT_vratné vodní (45 °C) 26 | 0
13246277 | 2.NP_SO-102 | 2082.54 | 0.000568237 | 0.175993 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2413.45 | 2400 | 2400 | 2386.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6389.2 | 0.13085 | 20 | 111 | 2082.54 | ø20 | 26.9 | 21.6 | TR02.02.1506 | 1506 | yes | HT_vratné vodní (45 °C) 26 | 0
13246295 | 2.NP_SO-102 | 332.537 | 0.000568237 | 0.0281024 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2213.45 | 2200 | 2200 | 2186.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6189.2 | 0.0208939 | 20 | 101 | 332.537 | ø20 | 26.9 | 21.6 | TR02.02.1507 | 1507 | yes | HT_vratné vodní (45 °C) 26 | 0
13246304 | 2.NP_SO-102 | 1315.2 | 0.000568237 | 0.111146 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2413.45 | 2400 | 2400 | 2386.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6389.2 | 0.0826363 | 20 | 101 | 1315.2 | ø20 | 26.9 | 21.6 | TR02.02.1508 | 1508 | yes | HT_vratné vodní (45 °C) 26 | 0
13246322 | 2.NP_SO-102 | 2520.73 | 0.000568237 | 0.213024 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2413.45 | 2400 | 2400 | 2386.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6389.2 | 0.158382 | 20 | 96 | 2520.73 | ø20 | 26.9 | 21.6 | TR02.02.1509 | 1509 | yes | HT_vratné vodní (45 °C) 26 | 0
13246436 | 2.NP_SO-102 | 5352.95 | 0.000568237 | 0.452372 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2513.45 | 2500 | 2500 | 2486.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6489.2 | 0.336336 | 20 | 110 | 5352.95 | ø20 | 26.9 | 21.6 | TR02.02.1510 | 1510 | yes | HT_vratné vodní (45 °C) 26 | 0
13246438 | 2.NP_SO-102 | 5628.91 | 0.000568237 | 0.475693 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2463.45 | 2450 | 2450 | 2436.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6439.2 | 0.353675 | 20 | 93 | 5628.91 | ø20 | 26.9 | 21.6 | TR02.02.1511 | 1511 | yes | HT_přívodní vodní (55 °C) 25 | 0
13246582 | 2.NP_SO-102 | 4939.83 | 0.000568237 | 0.417459 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2463.45 | 2450 | 2450 | 2436.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6439.2 | 0.310379 | 20 | 87 | 4939.83 | ø20 | 26.9 | 21.6 | TR02.02.1512 | 1512 | yes | HT_přívodní vodní (55 °C) 25 | 0
13246962 | 2.NP_SO-102 | 3622.81 | 0.000568237 | 0.306159 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2413.45 | 2400 | 2400 | 2386.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6389.2 | 0.227628 | 20 | 96 | 3622.81 | ø20 | 26.9 | 21.6 | TR02.02.1513 | 1513 | yes | HT_vratné vodní (45 °C) 26 | 0
13247000 | 2.NP_SO-102 | 114.275 | 0.00454772 | 0.0273203 | 0 | ø65 mm | 0.00145138 | HD | 2.NP_SO-102 | 2453.96 | 2339.69 | 2453.96 | 2339.69 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6339.69 | 0.0233354 | 65 | 113 | 114.275 | ø65 | 76.1 | 68.9 | TR02.02.1514 | 1514 | yes | HT_vratné vodní (45 °C) 26
13247003 | 2.NP_SO-102 | 969.831 | 0.000568237 | 0.0819593 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2513.45 | 2500 | 2500 | 2486.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6489.2 | 0.0609363 | 20 | 1 | 969.831 | ø20 | 26.9 | 21.6 | TR02.02.1515 | 1515 | yes | HT_vratné vodní (45 °C) 26 | 0
13247223 | 2.NP_SO-102 | 1753.92 | 0.000891835 | 0.185691 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 3016.85 | 3000 | 3000 | 2983.15 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 6986.4 | 0.137753 | 25 | 15 | 1753.92 | ø25 | 33.7 | 27.2 | TR02.02.1518 | 1518 | yes | HT/CL_přívodní vodní 1 | 0
13247231 | 2.NP_SO-102 | 5111.12 | 0.000891835 | 0.541123 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 2666.85 | 2650 | 2650 | 2633.15 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 6636.4 | 0.401427 | 25 | 15 | 5111.12 | ø25 | 33.7 | 27.2 | TR02.02.1519 | 1519 | yes | HT/CL_přívodní vodní 1 | 0
13247243 | 2.NP_SO-102 | 1318.73 | 0.000891835 | 0.139616 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 2666.85 | 2650 | 2650 | 2633.15 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 6636.4 | 0.103572 | 25 | 15 | 1318.73 | ø25 | 33.7 | 27.2 | TR02.02.1520 | 1520 | yes | HT/CL_přívodní vodní 1 | 0
13248314 | 2.NP_SO-102 | 308.725 | 0.000891835 | 0.0326852 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 2979.36 | 2670.64 | 2979.36 | 2670.64 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 6670.64 | 0.0242472 | 25 | 15 | 308.725 | ø25 | 33.7 | 27.2 | TR02.02.1524 | 1524 | yes | HT/CL_přívodní vodní 1
13248473 | 2.NP_SO-102 | 1318.73 | 0.000891835 | 0.139616 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 2666.85 | 2650 | 2650 | 2633.15 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 6636.4 | 0.103572 | 25 | 38 | 1318.73 | ø25 | 33.7 | 27.2 | TR02.02.1525 | 1525 | yes | HT/CL_vratné vodní 1 | 0
13248482 | 2.NP_SO-102 | 4761.12 | 0.000891835 | 0.504068 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 2666.85 | 2650 | 2650 | 2633.15 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 6636.4 | 0.373938 | 25 | 38 | 4761.12 | ø25 | 33.7 | 27.2 | TR02.02.1526 | 1526 | yes | HT/CL_vratné vodní 1 | 0
13248491 | 2.NP_SO-102 | 1403.92 | 0.000891835 | 0.148636 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 3016.85 | 3000 | 3000 | 2983.15 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 6986.4 | 0.110264 | 25 | 38 | 1403.92 | ø25 | 33.7 | 27.2 | TR02.02.1527 | 1527 | yes | HT/CL_vratné vodní 1 | 0
13248524 | 2.NP_SO-102 | 308.725 | 0.000891835 | 0.0326852 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 2979.36 | 2670.64 | 2979.36 | 2670.64 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 6670.64 | 0.0242472 | 25 | 38 | 308.725 | ø25 | 33.7 | 27.2 | TR02.02.1530 | 1530 | yes | HT/CL_vratné vodní 1
13248737 | 2.NP_SO-102 | 70.625 | 0.00454772 | 0.0168847 | 0 | ø65 mm | 0.00145138 | HE | 2.NP_SO-102 | 2410.31 | 2410.31 | 2339.69 | 2339.69 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 6339.69 | 0.0144219 | 65 | 4 | 70.625 | ø65 | 76.1 | 68.9 | TR02.02.1534 | 1534 | yes | HT/CL_vratné vodní 1
13248841 | 2.NP_SO-102 | 840.765 | 0.000891835 | 0.0890132 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6186.4 | 0.0660335 | 25 | 2 | 840.765 | ø25 | 33.7 | 27.2 | TR02.02.1535 | 1535 | yes | CL_přívodní vodní (10 °C) 4 | 0
13248848 | 2.NP_SO-102 | 422.389 | 0.000891835 | 0.044719 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6186.4 | 0.0331743 | 25 | 2 | 422.389 | ø25 | 33.7 | 27.2 | TR02.02.1536 | 1536 | yes | CL_přívodní vodní (10 °C) 4 | 0
13248858 | 2.NP_SO-102 | 9087.14 | 0.000891835 | 0.962071 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6186.4 | 0.713702 | 25 | 2 | 9087.14 | ø25 | 33.7 | 27.2 | TR02.02.1537 | 1537 | yes | CL_přívodní vodní (10 °C) 4 | 0
13248879 | 2.NP_SO-102 | 5098.55 | 0.000891835 | 0.539792 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6186.4 | 0.400439 | 25 | 10 | 5098.55 | ø25 | 33.7 | 27.2 | TR02.02.1538 | 1538 | yes | CL_přívodní vodní (10 °C) 4 | 0
13248901 | 2.NP_SO-102 | 4156.34 | 0.000891835 | 0.440039 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6186.4 | 0.326438 | 25 | 14 | 4156.34 | ø25 | 33.7 | 27.2 | TR02.02.1539 | 1539 | yes | CL_přívodní vodní (10 °C) 4 | 0
13248951 | 2.NP_SO-102 | 3535.47 | 0.000891835 | 0.374306 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6186.4 | 0.277675 | 25 | 12 | 3535.47 | ø25 | 33.7 | 27.2 | TR02.02.1540 | 1540 | yes | CL_přívodní vodní (10 °C) 4 | 0
13248959 | 2.NP_SO-102 | 2650.76 | 0.000891835 | 0.28064 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6186.4 | 0.20819 | 25 | 12 | 2650.76 | ø25 | 33.7 | 27.2 | TR02.02.1541 | 1541 | yes | CL_přívodní vodní (10 °C) 4 | 0
13248980 | 2.NP_SO-102 | 8719.38 | 0.000891835 | 0.923135 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6186.4 | 0.684818 | 25 | 13 | 8719.38 | ø25 | 33.7 | 27.2 | TR02.02.1542 | 1542 | yes | CL_přívodní vodní (10 °C) 4 | 0
13248992 | 2.NP_SO-102 | 497.589 | 0.000891835 | 0.0526805 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6186.4 | 0.0390805 | 25 | 13 | 497.589 | ø25 | 33.7 | 27.2 | TR02.02.1543 | 1543 | yes | CL_přívodní vodní (10 °C) 4 | 0
13249043 | 2.NP_SO-102 | 2312.67 | 0.000891835 | 0.244847 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6186.4 | 0.181637 | 25 | 15 | 2312.67 | ø25 | 33.7 | 27.2 | TR02.02.1544 | 1544 | yes | CL_přívodní vodní (10 °C) 4 | 0
13249349 | 2.NP_SO-102 | 4320.39 | 0.000891835 | 0.457407 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2016.85 | 2000 | 2000 | 1983.15 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 5986.4 | 0.339323 | 25 | 11 | 4320.39 | ø25 | 33.7 | 27.2 | TR02.02.1545 | 1545 | yes | CL_přívodní vodní (10 °C) 4 | 0
13249357 | 2.NP_SO-102 | 6289.06 | 0.000891835 | 0.665833 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6186.4 | 0.493942 | 25 | 14 | 6289.06 | ø25 | 33.7 | 27.2 | TR02.02.1546 | 1546 | yes | CL_přívodní vodní (10 °C) 4 | 0
13249480 | 2.NP_SO-102 | 342.389 | 0.000891835 | 0.0362493 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 6186.4 | 0.0268912 | 25 | 7 | 342.389 | ø25 | 33.7 | 27.2 | TR02.02.1547 | 1547 | yes | CL_vratné vodní (15 °C) 11 | 0
13249507 | 2.NP_SO-102 | 9487.14 | 0.000891835 | 1.00442 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 6186.4 | 0.745118 | 25 | 7 | 9487.14 | ø25 | 33.7 | 27.2 | TR02.02.1548 | 1548 | yes | CL_vratné vodní (15 °C) 11 | 0
13249534 | 2.NP_SO-102 | 4106.34 | 0.000891835 | 0.434745 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 6186.4 | 0.322511 | 25 | 3 | 4106.34 | ø25 | 33.7 | 27.2 | TR02.02.1549 | 1549 | yes | CL_vratné vodní (15 °C) 11 | 0
13249543 | 2.NP_SO-102 | 2450.76 | 0.000891835 | 0.259466 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 6186.4 | 0.192482 | 25 | 4 | 2450.76 | ø25 | 33.7 | 27.2 | TR02.02.1550 | 1550 | yes | CL_vratné vodní (15 °C) 11 | 0
13249552 | 2.NP_SO-102 | 8669.38 | 0.000891835 | 0.917841 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 6186.4 | 0.680891 | 25 | 6 | 8669.38 | ø25 | 33.7 | 27.2 | TR02.02.1551 | 1551 | yes | CL_vratné vodní (15 °C) 11 | 0
13249561 | 2.NP_SO-102 | 647.589 | 0.000891835 | 0.0685613 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 6186.4 | 0.0508615 | 25 | 6 | 647.589 | ø25 | 33.7 | 27.2 | TR02.02.1552 | 1552 | yes | CL_vratné vodní (15 °C) 11 | 0
13249731 | 2.NP_SO-102 | 6339.06 | 0.000891835 | 0.671127 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 6186.4 | 0.497869 | 25 | 3 | 6339.06 | ø25 | 33.7 | 27.2 | TR02.02.1553 | 1553 | yes | CL_vratné vodní (15 °C) 11 | 0
13249807 | 2.NP_SO-102 | 3185.47 | 0.000891835 | 0.337251 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 6186.4 | 0.250186 | 25 | 4 | 3185.47 | ø25 | 33.7 | 27.2 | TR02.02.1554 | 1554 | yes | CL_vratné vodní (15 °C) 11 | 0
13249819 | 2.NP_SO-102 | 4320.39 | 0.000891835 | 0.457407 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2016.85 | 2000 | 2000 | 1983.15 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 5986.4 | 0.339323 | 25 | 10 | 4320.39 | ø25 | 33.7 | 27.2 | TR02.02.1555 | 1555 | yes | CL_vratné vodní (15 °C) 11 | 0
13249996 | 2.NP_SO-102 | 2112.67 | 0.000891835 | 0.223672 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 6186.4 | 0.165929 | 25 | 9 | 2112.67 | ø25 | 33.7 | 27.2 | TR02.02.1556 | 1556 | yes | CL_vratné vodní (15 °C) 11 | 0
13250030 | 2.NP_SO-102 | 4698.55 | 0.000891835 | 0.497443 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 6186.4 | 0.369023 | 25 | 8 | 4698.55 | ø25 | 33.7 | 27.2 | TR02.02.1557 | 1557 | yes | CL_vratné vodní (15 °C) 11 | 0
13250085 | 2.NP_SO-102 | 1043.47 | 0.000891835 | 0.110474 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2216.85 | 2200 | 2200 | 2183.15 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 6186.4 | 0.081954 | 25 | 7 | 1043.47 | ø25 | 33.7 | 27.2 | TR02.02.1558 | 1558 | yes | CL_vratné vodní (15 °C) 11 | 0
13253835 | 3.NP_SO-102 | 66.425 | 0.000356274 | 0.00444489 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | -39.35 | -50 | -50 | -60.65 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 7942 | 0.0031302 | 15 | 7 | 66.425 | ø15 | 21.3 | 16 | TR02.02.1574 | 1574 | no | HT_přívodní vodní (55 °C) 12 | 0
13253861 | 3.NP_SO-102 | 948.572 | 0.000356274 | 0.0634746 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | -39.35 | -50 | -50 | -60.65 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 7942 | 0.0447004 | 15 | 17 | 948.572 | ø15 | 21.3 | 16 | TR02.02.1575 | 1575 | no | HT_vratné vodní (45 °C) 9 | 0
13253870 | 3.NP_SO-102 | 137.1 | 0.000356274 | 0.0091742 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | -39.35 | -50 | -50 | -60.65 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 7942 | 0.0064607 | 15 | 17 | 137.1 | ø15 | 21.3 | 16 | TR02.02.1576 | 1576 | no | HT_vratné vodní (45 °C) 9 | 0
13254102 | -1.PP_SO-102 | 1046.03 | 0.00141175 | 0.139334 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 1821.2 | 1800 | 1800 | 1778.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -2217.95 | 0.105158 | 32 | 48 | 1046.03 | ø32 | 42.4 | 35.9 | TR02.02.1577 | 1577 | yes | HT_přívodní vodní (65 °C) 8 | 0
13260922 | -1.PP_SO-102 | 553.325 | 0.00285535 | 0.104821 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 3030.15 | 3000 | 3000 | 2969.85 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1026.5 | 0.0869161 | 50 | 98 | 553.325 | ø50 | 60.3 | 53 | TR02.02.1598 | 1598 | yes | CL_vratné vodní (15 °C) 8 | 0
13260942 | -1.PP_SO-102 | 3052.84 | 0.00183197 | 0.463235 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-102 | 2624.15 | 2600 | 2600 | 2575.85 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1420.9 | 0.383632 | 40 | 72 | 3052.84 | ø40 | 48.3 | 41.8 | TR02.02.1599 | 1599 | yes | CL_vratné vodní (15 °C) 8 | 0
13260989 | -1.PP_SO-102 | 1446.03 | 0.00183197 | 0.219418 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-102 | 3224.15 | 3200 | 3200 | 3175.85 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -820.9 | 0.181713 | 40 | 72 | 1446.03 | ø40 | 48.3 | 41.8 | TR02.02.1600 | 1600 | yes | CL_vratné vodní (15 °C) 8 | 0
13261006 | -1.PP_SO-102 | 4793.01 | 0.00183197 | 0.727287 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-102 | 3224.15 | 3200 | 3200 | 3175.85 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -820.9 | 0.602308 | 40 | 72 | 4793.01 | ø40 | 48.3 | 41.8 | TR02.02.1601 | 1601 | yes | CL_vratné vodní (15 °C) 8 | 0
13261480 | -1.PP_SO-102 | 614.205 | 0.00285535 | 0.116354 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 3030.15 | 3000 | 3000 | 2969.85 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1026.5 | 0.0964791 | 50 | 119 | 614.205 | ø50 | 60.3 | 53 | TR02.02.1602 | 1602 | yes | CL_přívodní vodní (10 °C) 4 | 0
13261500 | -1.PP_SO-102 | 485.046 | 0.00183197 | 0.0736003 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-102 | 2324.15 | 2300 | 2300 | 2275.85 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1720.9 | 0.0609527 | 40 | 80 | 485.046 | ø40 | 48.3 | 41.8 | TR02.02.1603 | 1603 | yes | CL_přívodní vodní (10 °C) 4 | 0
13261508 | -1.PP_SO-102 | 1246.03 | 0.00183197 | 0.18907 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-102 | 3224.15 | 3200 | 3200 | 3175.85 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -820.9 | 0.15658 | 40 | 80 | 1246.03 | ø40 | 48.3 | 41.8 | TR02.02.1604 | 1604 | yes | CL_přívodní vodní (10 °C) 4 | 0
13261551 | -1.PP_SO-102 | 4596.86 | 0.00183197 | 0.697522 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-102 | 3224.15 | 3200 | 3200 | 3175.85 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -820.9 | 0.577658 | 40 | 80 | 4596.86 | ø40 | 48.3 | 41.8 | TR02.02.1605 | 1605 | yes | CL_přívodní vodní (10 °C) 4 | 0
13267106 | -1.PP_SO-102 | 225.712 | 0.000356274 | 0.0151038 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2760.65 | 2750 | 2750 | 2739.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | -1258 | 0.0106365 | 15 | 4 | 225.712 | ø15 | 21.3 | 16 | TR02.02.1606 | 1606 | yes | CL_přívodní vodní (10 °C) 9 | 0
13267140 | -1.PP_SO-102 | 219.362 | 0.000356274 | 0.0146788 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2760.65 | 2750 | 2750 | 2739.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | -1258 | 0.0103372 | 15 | 5 | 219.362 | ø15 | 21.3 | 16 | TR02.02.1607 | 1607 | yes | CL_přívodní vodní (10 °C) 9 | 0
13267149 | -1.PP_SO-102 | 1176.71 | 0.000356274 | 0.0787405 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2760.65 | 2750 | 2750 | 2739.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | -1258 | 0.055451 | 15 | 4 | 1176.71 | ø15 | 21.3 | 16 | TR02.02.1608 | 1608 | yes | CL_přívodní vodní (10 °C) 9 | 0
13267223 | 1.NP_SO-102 | 8415.07 | 0.000356274 | 0.563103 | 0 | ø15 mm | 0.00625 | HC | 1.NP_SO-102 | 11185.7 | 11185.7 | 2770.64 | 2770.64 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 2770.64 | 0.396551 | 15 | 7 | 8415.07 | ø15 | 21.3 | 16 | TR02.02.1609 | 1609 | yes | CL_přívodní vodní (10 °C) 9
13267267 | 3.NP_SO-102 | 6071.43 | 0.000356274 | 0.406275 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3210.65 | 3200 | 3200 | 3189.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 11192 | 0.286109 | 15 | 7 | 6071.43 | ø15 | 21.3 | 16 | TR02.02.1610 | 1610 | yes | CL_přívodní vodní (10 °C) 9 | 0
13267275 | 3.NP_SO-102 | 1085.71 | 0.000356274 | 0.0726515 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 2710.65 | 2700 | 2700 | 2689.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 10692 | 0.051163 | 15 | 7 | 1085.71 | ø15 | 21.3 | 16 | TR02.02.1611 | 1611 | yes | CL_přívodní vodní (10 °C) 9 | 0
13267487 | 3.NP_SO-102 | 371.425 | 0.000356274 | 0.0248542 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 2710.65 | 2700 | 2700 | 2689.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 10692 | 0.017503 | 15 | 7 | 371.425 | ø15 | 21.3 | 16 | TR02.02.1612 | 1612 | yes | CL_přívodní vodní (10 °C) 9 | 0
13267500 | 3.NP_SO-102 | 471.425 | 0.000356274 | 0.0315458 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3185.71 | 2714.29 | 3185.71 | 2714.29 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 10714.3 | 0.0222154 | 15 | 7 | 471.425 | ø15 | 21.3 | 16 | TR02.02.1613 | 1613 | yes | CL_přívodní vodní (10 °C) 9
13267560 | 3.NP_SO-102 | 6071.43 | 0.000356274 | 0.406275 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3210.65 | 3200 | 3200 | 3189.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 11192 | 0.286109 | 15 | 1 | 6071.43 | ø15 | 21.3 | 16 | TR02.02.1614 | 1614 | yes | CL_vratné vodní (15 °C) 9 | 0
13267569 | 3.NP_SO-102 | 885.713 | 0.000356274 | 0.0592683 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 2710.65 | 2700 | 2700 | 2689.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 10692 | 0.0417382 | 15 | 1 | 885.713 | ø15 | 21.3 | 16 | TR02.02.1615 | 1615 | yes | CL_vratné vodní (15 °C) 9 | 0
13267578 | 3.NP_SO-102 | 251.425 | 0.000356274 | 0.0168243 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 2710.65 | 2700 | 2700 | 2689.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 10692 | 0.0118481 | 15 | 1 | 251.425 | ø15 | 21.3 | 16 | TR02.02.1616 | 1616 | yes | CL_vratné vodní (15 °C) 9 | 0
13267657 | 3.NP_SO-102 | 471.425 | 0.000356274 | 0.0315458 | 0 | ø15 mm | 0.00625 | HC | 3.NP_SO-102 | 3185.71 | 2714.29 | 3185.71 | 2714.29 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 10714.3 | 0.0222154 | 15 | 1 | 471.425 | ø15 | 21.3 | 16 | TR02.02.1617 | 1617 | yes | CL_vratné vodní (15 °C) 9
13267778 | -1.PP_SO-102 | 171.425 | 0.000356274 | 0.0114711 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2810.65 | 2800 | 2800 | 2789.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | -1208 | 0.00807821 | 15 | 18 | 171.425 | ø15 | 21.3 | 16 | TR02.02.1618 | 1618 | yes | CL_vratné vodní (15 °C) 9 | 0
13268091 | -1.PP_SO-102 | 425.712 | 0.000356274 | 0.0284869 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2830.65 | 2820 | 2820 | 2809.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | -1188 | 0.0200612 | 15 | 2 | 425.712 | ø15 | 21.3 | 16 | TR02.02.1619 | 1619 | yes | CL_vratné vodní (15 °C) 9 | 0
13268100 | -1.PP_SO-102 | 419.362 | 0.000356274 | 0.028062 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2830.65 | 2820 | 2820 | 2809.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | -1188 | 0.019762 | 15 | 3 | 419.362 | ø15 | 21.3 | 16 | TR02.02.1620 | 1620 | yes | CL_vratné vodní (15 °C) 9 | 0
13268418 | 1.NP_SO-102 | 592.194 | 0.000356274 | 0.0396272 | 0 | ø15 mm | 0.00625 | HC | 1.NP_SO-102 | 2760.65 | 2750 | 2750 | 2739.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 2742 | 0.0279065 | 15 | 8 | 592.194 | ø15 | 21.3 | 16 | TR02.02.1621 | 1621 | yes | CL_přívodní vodní (10 °C) 9 | 0
13268431 | 1.NP_SO-102 | 7.21229 | 0.000356274 | 0.000482617 | 0 | ø15 mm | 0.00625 | HC | 1.NP_SO-102 | 2760.65 | 2750 | 2750 | 2739.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 2742 | 0.000339871 | 15 | 8 | 7.21229 | ø15 | 21.3 | 16 | TR02.02.1622 | 1622 | yes | CL_přívodní vodní (10 °C) 9 | 0
13268432 | 1.NP_SO-102 | 16.9266 | 0.000356274 | 0.00113266 | 0 | ø15 mm | 0.00625 | HC | 1.NP_SO-102 | 2760.65 | 2750 | 2750 | 2739.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 2742 | 0.000797648 | 15 | 8 | 16.9266 | ø15 | 21.3 | 16 | TR02.02.1623 | 1623 | yes | CL_přívodní vodní (10 °C) 9 | 0
13268436 | 1.NP_SO-102 | 3915.08 | 0.000356274 | 0.261981 | 0 | ø15 mm | 0.00625 | HC | 1.NP_SO-102 | 2729.36 | 2729.36 | -1185.71 | -1185.71 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | -1185.71 | 0.184494 | 15 | 18 | 3915.08 | ø15 | 21.3 | 16 | TR02.02.1624 | 1624 | yes | CL_přívodní vodní (10 °C) 9
13268446 | 1.NP_SO-102 | 3134.32 | 0.000356274 | 0.209736 | 0 | ø15 mm | 0.00625 | HC | 1.NP_SO-102 | 2760.65 | 2750 | 2750 | 2739.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 2742 | 0.147702 | 15 | 8 | 3134.32 | ø15 | 21.3 | 16 | TR02.02.1625 | 1625 | yes | CL_přívodní vodní (10 °C) 9 | 0
13268454 | 1.NP_SO-102 | 645.713 | 0.000356274 | 0.0432084 | 0 | ø15 mm | 0.00625 | HC | 1.NP_SO-102 | 2760.65 | 2750 | 2750 | 2739.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 2742 | 0.0304285 | 15 | 8 | 645.713 | ø15 | 21.3 | 16 | TR02.02.1626 | 1626 | yes | CL_přívodní vodní (10 °C) 9 | 0
13268498 | 1.NP_SO-102 | 2817.59 | 0.000356274 | 0.188542 | 0 | ø15 mm | 0.00625 | HC | 1.NP_SO-102 | 2760.65 | 2750 | 2750 | 2739.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 2742 | 0.132776 | 15 | 9 | 2817.59 | ø15 | 21.3 | 16 | TR02.02.1627 | 1627 | yes | CL_vratné vodní (15 °C) 9 | 0
13268516 | 1.NP_SO-102 | 445.713 | 0.000356274 | 0.0298253 | 0 | ø15 mm | 0.00625 | HC | 1.NP_SO-102 | 2760.65 | 2750 | 2750 | 2739.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 2742 | 0.0210037 | 15 | 9 | 445.713 | ø15 | 21.3 | 16 | TR02.02.1628 | 1628 | yes | CL_vratné vodní (15 °C) 9 | 0
13268565 | 1.NP_SO-102 | 631.425 | 0.000356274 | 0.0422524 | 0 | ø15 mm | 0.00625 | HC | 1.NP_SO-102 | 2760.65 | 2750 | 2750 | 2739.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 2742 | 0.0297552 | 15 | 9 | 631.425 | ø15 | 21.3 | 16 | TR02.02.1629 | 1629 | yes | CL_vratné vodní (15 °C) 9 | 0
13268613 | 1.NP_SO-102 | 157.575 | 0.000356274 | 0.0105443 | 0 | ø15 mm | 0.00625 | HC | 1.NP_SO-102 | 2760.65 | 2750 | 2750 | 2739.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 2742 | 0.00742555 | 15 | 9 | 157.575 | ø15 | 21.3 | 16 | TR02.02.1630 | 1630 | yes | CL_vratné vodní (15 °C) 9 | 0
13268620 | 1.NP_SO-102 | 3915.08 | 0.000356274 | 0.261981 | 0 | ø15 mm | 0.00625 | HC | 1.NP_SO-102 | 2729.36 | -1185.71 | 2729.36 | -1185.71 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | -1185.71 | 0.184494 | 15 | 18 | 3915.08 | ø15 | 21.3 | 16 | TR02.02.1631 | 1631 | yes | CL_vratné vodní (15 °C) 9
13268666 | 1.NP_SO-102 | 8415.07 | 0.000356274 | 0.563103 | 0 | ø15 mm | 0.00625 | HC | 1.NP_SO-102 | 11185.7 | 2770.64 | 11185.7 | 2770.64 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 2770.64 | 0.396551 | 15 | 1 | 8415.07 | ø15 | 21.3 | 16 | TR02.02.1632 | 1632 | yes | CL_vratné vodní (15 °C) 9
13269136 | -1.PP_SO-102 | 1142.68 | 0.000356274 | 0.0764638 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2830.65 | 2820 | 2820 | 2809.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | -1188 | 0.0538477 | 15 | 2 | 1142.68 | ø15 | 21.3 | 16 | TR02.02.1633 | 1633 | yes | CL_vratné vodní (15 °C) 9 | 0
13271095 | -1.PP_SO-102 | 1271.42 | 0.000356274 | 0.0850786 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2810.65 | 2800 | 2800 | 2789.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | -1208 | 0.0599145 | 15 | 18 | 1271.42 | ø15 | 21.3 | 16 | TR02.02.1634 | 1634 | yes | CL_přívodní vodní (10 °C) 9 | 0
13271140 | -1.PP_SO-102 | 1471.43 | 0.000356274 | 0.0984618 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2810.65 | 2800 | 2800 | 2789.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | -1208 | 0.0693393 | 15 | 18 | 1471.43 | ø15 | 21.3 | 16 | TR02.02.1635 | 1635 | yes | CL_vratné vodní (15 °C) 9 | 0
13271183 | -1.PP_SO-102 | 2652.18 | 0.000356274 | 0.177473 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2710.65 | 2700 | 2700 | 2689.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | -1308 | 0.124981 | 15 | 16 | 2652.18 | ø15 | 21.3 | 16 | TR02.02.1636 | 1636 | yes | CL_vratné vodní (15 °C) 9 | 0
13271191 | -1.PP_SO-102 | 2701.14 | 0.000356274 | 0.180749 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2710.65 | 2700 | 2700 | 2689.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | -1308 | 0.127288 | 15 | 16 | 2701.14 | ø15 | 21.3 | 16 | TR02.02.1637 | 1637 | yes | CL_vratné vodní (15 °C) 9 | 0
13271201 | -1.PP_SO-102 | 4771.43 | 0.000356274 | 0.319284 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2710.65 | 2700 | 2700 | 2689.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | -1308 | 0.224848 | 15 | 16 | 4771.43 | ø15 | 21.3 | 16 | TR02.02.1638 | 1638 | yes | CL_vratné vodní (15 °C) 9 | 0
13271387 | -2.PP_SO-102 | 5125.71 | 0.000356274 | 0.342992 | 0 | ø15 mm | 0.00625 | HC | -2.PP_SO-102 | 3160.65 | 3150 | 3150 | 3139.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | -4858 | 0.241544 | 15 | 16 | 5125.71 | ø15 | 21.3 | 16 | TR02.02.1639 | 1639 | yes | CL_vratné vodní (15 °C) 9 | 0
13271404 | -2.PP_SO-102 | 3521.43 | 0.000356274 | 0.235639 | 0 | ø15 mm | 0.00625 | HC | -2.PP_SO-102 | 6685.71 | 3164.29 | 6685.71 | 3164.29 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | -4835.71 | 0.165943 | 15 | 16 | 3521.43 | ø15 | 21.3 | 16 | TR02.02.1640 | 1640 | yes | CL_vratné vodní (15 °C) 9
13271522 | -2.PP_SO-102 | 5125.71 | 0.000356274 | 0.342992 | 0 | ø15 mm | 0.00625 | HC | -2.PP_SO-102 | 3160.65 | 3150 | 3150 | 3139.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | -4858 | 0.241544 | 15 | 11 | 5125.71 | ø15 | 21.3 | 16 | TR02.02.1641 | 1641 | yes | CL_přívodní vodní (10 °C) 9 | 0
13271560 | -1.PP_SO-102 | 4971.43 | 0.000356274 | 0.332667 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2710.65 | 2700 | 2700 | 2689.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | -1308 | 0.234273 | 15 | 11 | 4971.43 | ø15 | 21.3 | 16 | TR02.02.1642 | 1642 | yes | CL_přívodní vodní (10 °C) 9 | 0
13271569 | -1.PP_SO-102 | 2701.14 | 0.000356274 | 0.180749 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2710.65 | 2700 | 2700 | 2689.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | -1308 | 0.127288 | 15 | 11 | 2701.14 | ø15 | 21.3 | 16 | TR02.02.1643 | 1643 | yes | CL_přívodní vodní (10 °C) 9 | 0
