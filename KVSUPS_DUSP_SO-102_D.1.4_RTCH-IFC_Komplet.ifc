Properties of the parts of a building model (IFC4), part 41 of 72

# IfcDistributionPort (10261)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_13278381_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 21
Port_13405694_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 21
InPort_13278412_3 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 26
OutPort_13278410_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 26
InPort_13278410_1 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 5
OutPort_13278424_1 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 5
InPort_13278412_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 26
OutPort_13278413_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 26
InPort_13278413_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 26
OutPort_13405671_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 26
InPort_13278444_0 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 6
OutPort_13278446_3 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 6
InPort_13278458_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 6
OutPort_13278444_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 6
InPort_13278447_0 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 20
OutPort_13278446_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 20
InPort_13406576_2 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 20
OutPort_13278447_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 20
InPort_13278485_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 13
OutPort_13278478_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 13
Port_13278485_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 13
Port_13278486_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 13
Port_13278486_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 13
Port_13406595_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 13
Port_13278692_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13292700_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13278692_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13278744_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13347058_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13278744_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13278753_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13292663_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13278753_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13278763_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13347037_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13278763_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13278772_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13292254_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13278772_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13292696_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13278782_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13290748_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13278782_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13278814_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13290777_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13278814_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13279023_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13416344_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13279023_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13285556_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13279040_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13287648_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13279040_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13285577_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13279071_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13289417_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13279071_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13416919_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13279261_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13292589_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13279261_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13279289_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13347012_3 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13279289_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13279298_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13292155_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13279298_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13309498_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13279308_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13408106_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13279308_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13408110_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13279316_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13292626_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13279316_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13279333_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13346991_3 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13279333_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13279342_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13292188_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13279342_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13309500_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13279379_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13419355_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13279379_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13419359_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13279421_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13419393_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13279421_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13419397_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13279464_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13295628_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13279464_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13296183_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13279497_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13295688_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13279497_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13296154_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13279603_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13295808_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13279603_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13296096_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13279633_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295748_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13279633_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13296125_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
InPort_13279678_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13283036_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13409982_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13279678_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13279684_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13281671_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13279703_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13279684_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13282331_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13279697_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13279697_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13282384_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13282063_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13279703_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13279705_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13282331_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13282709_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13279705_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13279735_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13283000_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13279735_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282970_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13279741_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282484_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13279741_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13281660_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13279753_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13280013_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13279753_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282650_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13279761_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13280013_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13279761_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282817_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13279857_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13279859_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13279857_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13311346_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13279859_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13294236_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
InPort_13279937_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
OutPort_13282705_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
InPort_13279937_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
OutPort_13311344_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13280925_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13310520_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13280925_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13313442_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
InPort_13310524_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13280955_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13280955_2 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13313444_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13281007_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13281018_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13281007_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13310520_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
InPort_13281019_1 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
OutPort_13281018_1 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13281018_3 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13313715_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13281658_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13281660_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13281658_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282970_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
InPort_13281671_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13281669_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13281669_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13409980_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13282019_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282484_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282019_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282486_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
InPort_13282200_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13282063_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13282189_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13282200_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13282216_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13282189_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13282204_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13282216_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13282380_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13282204_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13282260_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13282380_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13282384_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13282260_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13282441_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282486_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282441_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13423135_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282450_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282650_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282450_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13423131_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282461_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13423131_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282461_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13423135_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
InPort_13282705_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
OutPort_13294152_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
InPort_13311344_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13282709_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13282762_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282817_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282762_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282819_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282819_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13311346_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282836_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13283042_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13282836_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13282864_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13283004_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282864_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282940_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13283037_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13409980_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13282942_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13282942_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13409982_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13282968_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13283001_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282998_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13283000_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13282998_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13283004_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13283000_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13283001_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13283034_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13283036_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13283034_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13283042_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13283036_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13283037_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13283117_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13283130_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13283117_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13283126_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13283128_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13283126_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13283130_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13283152_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13283165_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13283152_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13283161_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13283163_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13283161_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13283165_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
InPort_13283707_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
OutPort_13283715_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13283743_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 10
OutPort_13409926_2 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 10
InPort_13409926_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 10
OutPort_13283753_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 10
InPort_13283779_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
OutPort_13409930_2 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 9
InPort_13409928_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
OutPort_13283785_2 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 9
InPort_13409930_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
OutPort_13283789_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 9
InPort_13283819_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
OutPort_13409955_2 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 26
InPort_13409955_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
OutPort_13283829_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 26
InPort_13283852_1 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13409550_2 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13409550_1 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13283865_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13283891_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 31
OutPort_13408448_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 31
InPort_13283933_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13283925_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13409936_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 2
OutPort_13283961_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 2
InPort_13283971_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 2
OutPort_13409936_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 2
InPort_13409940_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
OutPort_13283997_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
InPort_13284003_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
OutPort_13409938_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
InPort_13284007_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
OutPort_13409940_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
InPort_13284049_1 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13284039_1 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13409970_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13284075_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13284085_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13409970_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13408455_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 28
OutPort_13284111_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 28
Port_13284223_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13292221_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13284223_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13292659_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13285577_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13313229_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13287648_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13427776_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13287683_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13417813_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13287683_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13417816_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
InPort_13287728_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
OutPort_13417807_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
InPort_13417810_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
OutPort_13287728_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
InPort_13417807_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
OutPort_13287872_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
InPort_13287872_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
OutPort_13287904_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
Port_13288571_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13294231_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13288571_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13294235_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13288606_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13289417_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13288606_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13294231_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13289296_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13416798_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13289296_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13416955_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13289474_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340649_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13289474_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340653_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13289497_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340683_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13289497_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340687_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13289579_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340649_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13289579_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13289591_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13289612_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340683_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13289612_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13289626_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13290352_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13422170_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13290352_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13422174_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13290382_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13350682_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13290382_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13421901_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13290426_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13419309_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13290426_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13419313_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13290466_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13419277_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13290466_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13419281_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13290650_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13449426_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13290672_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13449386_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13290742_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13419277_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13290742_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13290748_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13290771_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13419309_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13290771_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13290777_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13290794_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13290811_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13290794_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13290805_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13419355_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13290805_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13290811_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13290836_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13290851_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13290836_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13290845_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13419393_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13290845_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13290851_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13291579_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13408199_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13291579_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13408203_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13292029_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13292155_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13292029_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13292157_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13292052_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13292188_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13292052_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13292190_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13292075_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13292221_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13292075_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13292223_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13292098_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13292254_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13292098_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13292256_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13292145_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13408199_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13292145_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13292157_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13292178_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13408106_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13292178_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13292190_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13292211_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13422174_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13292211_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13292223_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13292244_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13350682_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13292244_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13292256_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13292585_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13309498_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13292585_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13347013_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13292589_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13292909_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13292622_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13309500_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13292622_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13346992_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13292626_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13292879_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13292659_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13347059_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13292663_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13292939_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13292696_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13347038_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13292700_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13292969_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13292879_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13346991_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13292909_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13347012_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13292939_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13347058_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13292969_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13347037_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13294020_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13416241_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13294020_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13416243_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13294050_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13416206_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13294050_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13416208_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13294146_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13294151_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13294146_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13294497_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
InPort_13311348_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
OutPort_13294151_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13294151_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13416936_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
InPort_13294152_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
OutPort_13311348_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13294228_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295494_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13294228_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13294235_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13294235_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13311350_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13294236_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13311350_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13294497_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13295124_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13295124_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13295783_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13295149_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295492_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295149_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295723_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295205_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13416241_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13295205_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13295663_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13295230_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13416206_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13295230_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13295603_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13295317_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13295636_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13295317_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13295640_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13295342_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13295696_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13295342_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13295700_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13295366_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295756_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295366_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295760_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295388_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13295816_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13295388_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13295820_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13295490_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295492_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295490_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295494_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295601_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13295603_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13295601_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13295636_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13295626_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13295628_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13295626_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13295640_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13295661_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13295663_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13295661_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13295696_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13295686_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13295688_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13295686_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13295700_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13295721_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295723_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295721_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295756_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295746_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295748_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295746_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295760_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13295781_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13295783_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13295781_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13295816_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13295806_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13295808_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13295806_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13295820_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13296094_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13296096_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13296094_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13296100_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13296100_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13449776_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13296123_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13296125_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13296123_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13296129_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13296129_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13449746_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13296152_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13296154_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13296152_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13296158_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13296158_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13449701_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13296181_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13296183_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13296181_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13296187_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13296187_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13449655_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13296248_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13450057_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13296248_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13450059_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13296254_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13450057_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13296254_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13450247_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13296264_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13450249_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13296264_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13296337_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13450262_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13296337_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13450100_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13296345_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13450258_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13296345_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13450262_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13296355_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13450256_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13296355_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13296382_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13450139_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13296382_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13450141_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13296388_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13450139_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13296388_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13450267_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13296398_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13450269_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13296398_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13296425_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13450180_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13296425_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13450182_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13296431_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13450180_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13296431_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13450276_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13296441_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13450278_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13296441_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
OutPort_13299090_1 | SOURCE | PIPE | HEATING
InPort_13299090_2 | SINK | PIPE | HEATING
Port_13299187_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13299389_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13299187_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13299203_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13299197_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13299203_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13299197_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13299225_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13299404_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13299225_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13299239_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13299233_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13299239_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13299233_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13299383_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13299389_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13299383_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13299389_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13299390_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13299390_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13373427_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13299398_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13299404_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13299398_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13299404_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13299405_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13299405_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13373503_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13300824_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13406455_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13300824_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13406459_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13301807_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13445691_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13301807_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13438120_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13301810_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13438118_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13301810_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13337006_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13303076_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13368731_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13303076_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13417816_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
InPort_13303627_0 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13304565_2 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13304567_2 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13303627_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13313499_2 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13303636_0 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13303636_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13304567_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13303796_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13427231_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13303796_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13427277_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13303876_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
OutPort_13427757_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
Port_13304008_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13304603_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13304008_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13304522_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13304040_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13304603_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13304040_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13304605_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13304051_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13304605_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13304267_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13322385_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13304267_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13416200_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
InPort_13304305_0 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13304307_3 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13304325_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13304305_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13304307_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13427231_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13304307_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13322383_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13304308_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13416235_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13304308_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13322383_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13304503_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13304505_3 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13304503_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13304522_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13304505_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13322385_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13304505_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13427254_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13304506_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13427254_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13304506_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13427288_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13304851_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13304853_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13304851_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13427722_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13304928_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13304942_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13304934_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13304942_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13304934_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13304965_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13304963_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13304965_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13304963_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13427683_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13305300_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13418119_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13305300_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13418122_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13305405_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13368506_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13305405_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13368509_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13309998_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13408065_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13309998_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13408110_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13310067_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13408147_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13310067_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13408203_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13310167_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13327014_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13310167_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13327016_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13310190_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13326961_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13310190_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13310309_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13310307_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13310309_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13310307_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13358243_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13310359_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13327016_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13310359_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13358278_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13314297_2 | SINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 2
OutPort_13314270_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (45 °C) 2
Port_13315105_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13362457_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13315778_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13315791_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13315778_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13430416_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13315791_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13315792_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13316013_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13316015_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13316512_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316519_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316519_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316520_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316539_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13316544_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
