Properties of the parts of a building model (IFC4), part 42 of 72

# IfcDistributionPort (10261)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_13316544_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13316545_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13316947_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316991_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316947_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13317050_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316995_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13317050_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13322055_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 13
Port_13322057_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 12
Port_13322772_3 | SOURCEANDSINK | PIPE
Port_13322772_4 | SOURCEANDSINK | PIPE
Port_13322772_5 | SOURCEANDSINK | PIPE
Port_13326836_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13326838_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13326836_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13326840_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13326924_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13326961_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13326924_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13326963_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13326933_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13326935_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13326933_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13326963_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13326974_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13326991_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13326974_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13327014_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13326985_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13326987_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13326985_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13326991_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13327807_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13327809_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13327857_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13327859_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13328121_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13328260_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13328121_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13328262_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13328151_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13328226_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13328151_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13328228_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13328216_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13328218_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13328216_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13328228_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13328250_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13328252_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13328250_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13328262_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13330063_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13416423_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13330063_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13416425_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13330123_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13413760_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13330123_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13413984_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13330395_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13416423_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13330395_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13426832_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
InPort_13331386_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13416388_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13416391_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13331386_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13416388_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13331423_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13331423_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13426962_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
Port_13333595_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13333596_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13333595_3 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13333604_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13333596_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13344579_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13333636_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
OutPort_13333628_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
InPort_13333628_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
OutPort_13434252_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
InPort_13434659_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
OutPort_13333640_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
InPort_13333640_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
OutPort_13434254_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
InPort_13334041_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 24
OutPort_13334228_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 24
Port_13334100_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13334203_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13334179_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13334201_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13334179_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13334203_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13334228_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 24
OutPort_13334220_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 24
InPort_13334220_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 24
OutPort_13334246_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 24
Port_13335078_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13352289_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
InPort_13335221_0 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13335686_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13335541_1 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13335221_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13335696_2 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13335246_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
Port_13335289_1 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13335729_2 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13335310_0 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13335719_1 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13335310_1 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13335574_1 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13335335_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13335752_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13335335_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13335609_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13335354_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13335762_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13335354_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13335764_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13335375_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13335787_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13335375_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13335649_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13335396_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13335797_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13335396_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13335799_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13335539_0 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13335541_2 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13335551_1 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13335539_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
Port_13335572_0 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13335574_2 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13335572_1 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13335584_1 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13335607_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13335609_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13335607_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13335626_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13335647_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13335649_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13335647_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13335661_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13335686_2 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13335684_0 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13335684_1 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13335696_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
Port_13335717_0 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13335719_2 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13335717_1 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13335729_1 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní vodní 1
Port_13335750_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13335752_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13335750_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13335764_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13335785_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13335787_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13335785_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13335799_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13336691_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13438409_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13336691_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13336842_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13438265_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13336842_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13336894_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13336882_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13336884_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13336882_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13336894_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13337312_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13337945_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13337364_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13338014_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13337364_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13338018_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13337943_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13337945_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13337943_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13337957_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13337953_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13348783_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13337954_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13349247_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13337954_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13349251_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13338004_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13338006_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13338004_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13338018_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13338014_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13348731_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13338015_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13349352_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13338015_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13349356_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13339232_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13339234_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13339232_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13339236_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13339247_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13339249_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13339247_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13339251_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13339969_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340366_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13339969_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340370_3 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13339986_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340109_3 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13339986_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340353_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340100_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340109_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340109_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340230_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340201_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340675_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340201_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340370_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340230_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340641_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340266_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340501_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340266_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340268_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340486_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340268_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340351_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340353_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340351_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340355_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340362_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340364_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340362_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340366_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340370_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340371_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340486_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340642_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340501_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340676_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340639_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340641_3 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340639_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340653_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340641_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340642_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 9
Port_13340673_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340675_3 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340673_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340687_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340675_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13340676_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 9
Port_13341454_3 | SOURCEANDSINK | PIPE
Port_13341454_4 | SOURCEANDSINK | PIPE
Port_13341454_5 | SOURCEANDSINK | PIPE
Port_13342071_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13342083_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13342071_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13342314_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13342500_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13342500_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13342507_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13342503_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13342505_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13342507_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13342508_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13343196_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13343241_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13343196_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13343197_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13343197_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447152_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13343219_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13343262_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13343219_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13343220_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13343220_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447051_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13343240_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13343241_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13343261_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13343262_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13344339_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13344430_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13344339_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13344435_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13344352_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13434281_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13344352_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13344435_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13344496_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13344579_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13344496_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13344584_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13344507_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13344584_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13344751_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13344752_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13346991_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13346992_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13347012_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13347013_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13347037_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13347038_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13347058_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13347059_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13347552_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13347587_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13347584_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13347594_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13347584_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13347602_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13347586_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13347587_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13347586_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13347594_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13348701_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13349274_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13348731_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13349344_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13348757_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13349309_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13348783_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13349239_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13348848_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13349001_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13348871_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13349065_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13348896_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13349096_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13348999_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13349001_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13348999_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13349282_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13349063_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13349065_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13349063_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13349317_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13349094_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13349096_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13349094_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13349352_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13349160_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13349210_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13349160_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13349174_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13349197_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13349210_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13349197_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13349216_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13349210_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13349211_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13349211_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13349247_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13349237_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13349239_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13349237_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13349251_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13349272_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13349274_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13349272_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13349286_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 11
Port_13349307_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13349309_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13349307_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13349321_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13349342_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13349344_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13349342_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13349356_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13349751_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13408079_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13349751_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13408083_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13349776_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13358243_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13349776_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13358247_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13349999_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13350084_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13349999_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13350051_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13350021_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13350094_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13350049_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13350051_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13350049_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13350061_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13350082_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13350084_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13350082_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13350094_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13352253_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13435599_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13352289_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13352316_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13352297_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13352312_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13352297_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13352316_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13352306_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13352308_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13352306_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13352312_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13357518_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13416755_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13357518_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13418910_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13358233_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13408161_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13358233_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13358247_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13358268_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13408079_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13358268_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13358282_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13362057_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13362110_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13362057_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13362175_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13362100_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13362101_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13362100_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13362110_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13362145_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13362175_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13362145_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13362462_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13362456_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13362457_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13368493_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13368495_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13368493_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13368509_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13368506_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13427560_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
InPort_13368658_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
OutPort_13427912_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
InPort_13427917_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
OutPort_13368658_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
Port_13368683_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13427872_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13368683_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13427877_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13368723_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13427872_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13368723_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13368731_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
InPort_13427912_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
OutPort_13368755_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
InPort_13368755_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
OutPort_13368763_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
InPort_13370368_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
OutPort_13408377_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13372808_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13373428_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13372808_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13372809_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13372827_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13373504_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13372827_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13372828_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
InPort_13372867_1 | SINK | PIPE | HEATING
OutPort_13372867_2 | SOURCE | PIPE | HEATING
Port_13373421_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13373427_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13373421_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13373427_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13373428_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13373495_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13373503_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13373495_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13373503_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13373504_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
InPort_13381357_1 | SINK | PIPE | HEATING
OutPort_13381357_2 | SOURCE | PIPE | HEATING
InPort_13381396_1 | SINK | PIPE | HEATING
OutPort_13381396_2 | SOURCE | PIPE | HEATING
InPort_13381397_1 | SINK | PIPE | HEATING
OutPort_13381397_2 | SOURCE | PIPE | HEATING
Port_13382988_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13393848_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13382988_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13435904_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13383061_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13435916_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13383061_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13394498_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13383467_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13435955_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13383467_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13383469_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13435968_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13383469_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13383523_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13435968_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13383523_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395509_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13383761_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13436038_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13383761_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13383763_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13436051_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13383763_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13383780_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13436099_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13383780_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13383782_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13385840_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13383782_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13383801_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13436008_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13383801_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13383803_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 6
Port_13436021_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 6
Port_13383803_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 6
Port_13383875_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13436078_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13383875_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13383877_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13436065_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13383877_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13383896_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13435998_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13383896_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13383898_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13435985_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13383898_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13384285_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13384501_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13384285_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13384549_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13384541_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13384549_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13384541_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13384737_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13384761_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13384737_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13384763_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13384761_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13384830_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13384763_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13393688_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13384830_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13384846_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13384838_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13384846_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13384838_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13385308_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13436051_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13385308_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13396940_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13385329_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13436038_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13385329_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13395867_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13385657_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13385840_3 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13385657_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13385848_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13385659_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13436099_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13385659_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13385883_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13385661_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13399289_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13385661_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13399291_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13385663_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13385946_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13385663_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13399456_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13385830_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13385946_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13385830_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13385848_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13385840_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13385841_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13385841_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13385869_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13399291_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13385869_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13385883_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13386173_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13436133_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13386173_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13386196_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13436123_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13386196_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13386282_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13436133_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13386282_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13403266_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13386697_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13436078_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13386697_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402399_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13387078_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13435985_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13387078_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13399203_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13387511_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13450664_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13387511_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13450923_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13387545_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13450643_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13387545_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13450908_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13388152_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13436008_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13388152_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13402084_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
OutPort_13389314_1 | SOURCE | PIPE | HEATING
OutPort_13389314_3 | SOURCE | PIPE | HEATING
InPort_13389314_5 | SINK | PIPE | HEATING
InPort_13389314_7 | SINK | PIPE | HEATING
InPort_13390069_0 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 7
OutPort_13391696_1 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 7
InPort_13391698_2 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 7
OutPort_13390069_1 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 7
InPort_13391658_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 4
OutPort_13390118_0 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 4
InPort_13390118_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 4
OutPort_13391660_2 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 4
InPort_13390629_1 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 7
OutPort_12903824_3 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 7
InPort_13390738_2 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 4
OutPort_13390736_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 4
InPort_13390757_1 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 7
OutPort_13390759_2 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 7
Port_13390864_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13390879_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13390864_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13390873_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13390875_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13390873_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13390879_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13390899_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13390914_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13390899_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13390908_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13390910_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13390908_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13390914_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13391132_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13391140_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13391132_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13391292_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13391279_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13391391_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13391279_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13391290_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13391292_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13391290_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13391391_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13391415_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13391430_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13391424_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13391430_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13391424_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13391508_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13391432_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13391512_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13391432_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13391506_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13391508_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13391506_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13391512_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
InPort_13391642_0 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 4
OutPort_13391652_2 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 4
InPort_13391660_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 4
OutPort_13391642_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 4
Port_13391644_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13391645_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
InPort_13391644_3 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
OutPort_13391652_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13391645_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13391806_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
InPort_13391690_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
OutPort_13391680_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
InPort_13391680_1 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 7
OutPort_13391698_1 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 7
Port_13391682_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13391683_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
InPort_13391690_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
OutPort_13391682_3 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13391683_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13391847_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13391709_2 | SOURCEANDSINK | PIPE
Port_13391782_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13391816_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13391790_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13391814_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13391790_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13391816_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
InPort_13391807_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
OutPort_13391806_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13391806_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13391814_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13391829_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13391857_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13391837_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13391855_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13391837_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13391857_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
InPort_13391848_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
OutPort_13391847_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13391847_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13391855_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13393491_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13435955_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13393491_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395539_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13393500_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395539_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13393500_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395541_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13393688_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395211_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13393697_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395205_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13393697_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395211_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13393707_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395573_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13393707_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395578_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13393735_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395227_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13393744_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395221_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13393744_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395227_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13393754_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395602_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13393754_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13405197_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13393814_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395639_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13393814_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395641_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13393840_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13393848_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13393840_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395681_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13393850_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395681_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13393850_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395683_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13393988_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13435928_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13393988_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13394006_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13393996_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13394006_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13393996_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395459_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13394008_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395459_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13394008_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395461_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13394036_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13435938_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13394036_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13394453_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13394046_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13394479_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13394046_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395428_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13394059_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395428_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13394059_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395430_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13394310_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395639_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13394310_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13394496_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13394318_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13394496_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13394318_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13394498_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13394447_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13394453_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13394447_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13394479_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395199_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395573_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395199_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395205_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395215_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395602_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395215_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395221_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395420_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395422_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395420_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395430_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395422_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13405122_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
