Properties of the parts of a building model (IFC4), part 63 of 72

# IfcPipeSegment: Typy trubek:Ocel_uhlíková (1186)
Name (Typy trubek:Ocel_uhlíková:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Tloušťka izolace (mm) | Celková velikost | Relativní drsnost | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) | Řez | Délka (mm) | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
13056667 | 3.NP_SO-102 | 532.264 | 0.000356274 | 0.0356169 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 2810.65 | 2800 | 2800 | 2789.35 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10792 | 0.0250823 | 15 | 293 | 532.264 | ø15 | 21.3 | 16 | TR02.02.0338 | 0338 | yes | HT_přívodní vodní (55 °C) 9 | 0
13056714 | 3.NP_SO-102 | 1844.38 | 0.000568237 | 0.155866 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3163.45 | 3150 | 3150 | 3136.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 11139.2 | 0.115886 | 20 | 522 | 1844.38 | ø20 | 26.9 | 21.6 | TR02.02.0339 | 0339 | yes | HT_přívodní vodní (55 °C) 9 | 0
13056731 | 3.NP_SO-102 | 165.713 | 0.000356274 | 0.0110888 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | -39.35 | -50 | -50 | -60.65 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7942 | 0.00780902 | 15 | 293 | 165.713 | ø15 | 21.3 | 16 | TR02.02.0340 | 0340 | no | HT_přívodní vodní (55 °C) 9 | 0
13056740 | 3.NP_SO-102 | 2821.43 | 0.000356274 | 0.188798 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 2785.71 | -35.7125 | 2785.71 | -35.7125 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7964.29 | 0.132957 | 15 | 293 | 2821.43 | ø15 | 21.3 | 16 | TR02.02.0341 | 0341 | yes | HT_přívodní vodní (55 °C) 9
13056899 | 3.NP_SO-102 | 10621.6 | 0.000356274 | 0.710755 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 2810.65 | 2800 | 2800 | 2789.35 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10792 | 0.500531 | 15 | 294 | 10621.6 | ø15 | 21.3 | 16 | TR02.02.0342 | 0342 | yes | HT_přívodní vodní (55 °C) 9 | 0
13056920 | 3.NP_SO-102 | 1765.52 | 0.000568237 | 0.149202 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10789.2 | 0.110931 | 20 | 522 | 1765.52 | ø20 | 26.9 | 21.6 | TR02.02.0343 | 0343 | yes | HT_přívodní vodní (55 °C) 9 | 0
13056923 | 3.NP_SO-102 | 790.075 | 0.000356274 | 0.0528686 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 2810.65 | 2800 | 2800 | 2789.35 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10792 | 0.0372314 | 15 | 294 | 790.075 | ø15 | 21.3 | 16 | TR02.02.0344 | 0344 | yes | HT_přívodní vodní (55 °C) 9 | 0
13057402 | 3.NP_SO-102 | 2816.11 | 0.000356274 | 0.188443 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 2779.36 | 2779.36 | -36.7491 | -36.7491 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7963.25 | 0.132706 | 15 | 295 | 2816.11 | ø15 | 21.3 | 16 | TR02.02.0345 | 0345 | no | HT_přívodní vodní (55 °C) 9
13064867 | 2.NP_SO-102 | 2426.19 | 0.00183197 | 0.368148 | 40 | ø120 mm | 0.00239234 | HD | 2.NP_SO-102 | 3324.15 | 3300 | 3300 | 3275.85 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 7 | 7279.1 | 0.304884 | 40 | 6 | 2426.19 | ø40 | 48.3 | 41.8 | TR02.02.0352 | 0352 | yes | HT_přívodní vodní (65 °C) 7 | 0 | Izolace - Typ izolace: Tepelná
13064903 | -1.PP_SO-102 | 1730.17 | 0.00141175 | 0.230465 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2621.2 | 2600 | 2600 | 2578.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | -1417.95 | 0.173936 | 32 | 39 | 1730.17 | ø32 | 42.4 | 35.9 | TR02.02.0353 | 0353 | yes | HT_přívodní vodní (65 °C) 6 | 0 | Izolace - Typ izolace: Tepelná
13065045 | 1.NP_SO-102 | 8631.74 | 0.00183197 | 1.30977 | 40 | ø120 mm | 0.00239234 | HD | 1.NP_SO-102 | 7265.87 | 7265.87 | -1365.87 | -1365.87 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | -1365.87 | 1.0847 | 40 | 31 | 8631.74 | ø40 | 48.3 | 41.8 | TR02.02.0354 | 0354 | yes | HT_přívodní vodní (65 °C) 6 | Izolace - Typ izolace: Tepelná
13066797 | 2.NP_SO-102 | 4025.64 | 0.00183197 | 0.610846 | 40 | ø120 mm | 0.00239234 | HD | 2.NP_SO-102 | 7316.66 | 7316.66 | 3291.02 | 3291.02 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7291.02 | 0.505877 | 40 | 271 | 4025.64 | ø40 | 48.3 | 41.8 | TR02.02.0355 | 0355 | yes | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13066973 | 3.NP_SO-102 | 3885.71 | 0.000891835 | 0.411386 | 40 | ø105 mm | 0.00367647 | HD | 3.NP_SO-102 | 7279.36 | 3393.66 | 7279.36 | 3393.66 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 11393.7 | 0.305183 | 25 | 65 | 3885.71 | ø25 | 33.7 | 27.2 | TR02.02.0356 | 0356 | yes | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13069049 | -1.PP_SO-102 | 215.2 | 0.000356274 | 0.0144003 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3210.65 | 3200 | 3200 | 3189.35 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | -808 | 0.0101411 | 15 | 554 | 215.2 | ø15 | 21.3 | 16 | TR02.02.0357 | 0357 | yes | HT_přívodní vodní (55 °C) 9 | 0
13069769 | -1.PP_SO-102 | 2630 | 0.000356274 | 0.175989 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3210.65 | 3200 | 3200 | 3189.35 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | -808 | 0.123936 | 15 | 554 | 2630 | ø15 | 21.3 | 16 | TR02.02.0358 | 0358 | yes | HT_přívodní vodní (55 °C) 9 | 0
13069783 | -1.PP_SO-102 | 2999.34 | 0.000356274 | 0.200703 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3210.65 | 3200 | 3200 | 3189.35 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | -808 | 0.14134 | 15 | 30 | 2999.34 | ø15 | 21.3 | 16 | TR02.02.0359 | 0359 | yes | HT_přívodní vodní (55 °C) 9 | 0
13069813 | 2.NP_SO-102 | 4133.32 | 0.00183197 | 0.627186 | 40 | ø120 mm | 0.00239234 | HD | 2.NP_SO-102 | 3066.66 | 3066.66 | -1066.66 | -1066.66 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 2933.34 | 0.519409 | 40 | 256 | 4133.32 | ø40 | 48.3 | 41.8 | TR02.02.0360 | 0360 | yes | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13071969 | -1.PP_SO-102 | 2788.53 | 0.00141175 | 0.371442 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 2871.2 | 2850 | 2850 | 2828.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 4 | -1167.95 | 0.280333 | 32 | 8 | 2788.53 | ø32 | 42.4 | 35.9 | TR02.02.0362 | 0362 | yes | HT_vratné vodní (45 °C) 4 | 0
13071978 | -1.PP_SO-102 | 2169.48 | 0.00285535 | 0.410982 | 0 | ø50 mm | 0.00188679 | HD | -1.PP_SO-102 | 2880.15 | 2850 | 2850 | 2819.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 6 | -1176.5 | 0.340781 | 50 | 187 | 2169.48 | ø50 | 60.3 | 53 | TR02.02.0363 | 0363 | yes | HT_vratné vodní (45 °C) 6 | 0
13071987 | -1.PP_SO-102 | 2882.18 | 0.00183197 | 0.437339 | 0 | ø40 mm | 0.00239234 | HD | -1.PP_SO-102 | 2874.15 | 2850 | 2850 | 2825.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 8 | -1170.9 | 0.362185 | 40 | 186 | 2882.18 | ø40 | 48.3 | 41.8 | TR02.02.0364 | 0364 | yes | HT_vratné vodní (45 °C) 8 | 0
13078564 | 2.NP_SO-102 | 3183.49 | 0.000568237 | 0.269033 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3113.45 | 3100 | 3100 | 3086.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 7089.2 | 0.200024 | 20 | 3 | 3183.49 | ø20 | 26.9 | 21.6 | TR02.02.0369 | 0369 | yes | HT_přívodní vodní (55 °C) 2 | 0
13078573 | 2.NP_SO-102 | 6566.23 | 0.000568237 | 0.554904 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3113.45 | 3100 | 3100 | 3086.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 7089.2 | 0.412568 | 20 | 3 | 6566.23 | ø20 | 26.9 | 21.6 | TR02.02.0370 | 0370 | yes | HT_přívodní vodní (55 °C) 2 | 0
13078583 | 2.NP_SO-102 | 531.316 | 0.000568237 | 0.0449009 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3113.45 | 3100 | 3100 | 3086.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 7089.2 | 0.0333835 | 20 | 3 | 531.316 | ø20 | 26.9 | 21.6 | TR02.02.0371 | 0371 | yes | HT_přívodní vodní (55 °C) 2 | 0
13078591 | 2.NP_SO-102 | 465.075 | 0.000568237 | 0.0393029 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3113.45 | 3100 | 3100 | 3086.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 7089.2 | 0.0292215 | 20 | 3 | 465.075 | ø20 | 26.9 | 21.6 | TR02.02.0372 | 0372 | yes | HT_přívodní vodní (55 °C) 2 | 0
13078635 | 2.NP_SO-102 | 2983.49 | 0.000568237 | 0.252131 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3113.45 | 3100 | 3100 | 3086.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 7089.2 | 0.187458 | 20 | 3 | 2983.49 | ø20 | 26.9 | 21.6 | TR02.02.0373 | 0373 | yes | HT_vratné vodní (45 °C) 10 | 0
13078657 | 2.NP_SO-102 | 6866.23 | 0.000568237 | 0.580257 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3113.45 | 3100 | 3100 | 3086.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 7089.2 | 0.431418 | 20 | 3 | 6866.23 | ø20 | 26.9 | 21.6 | TR02.02.0374 | 0374 | yes | HT_vratné vodní (45 °C) 10 | 0
13078668 | 2.NP_SO-102 | 831.316 | 0.000568237 | 0.0702535 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3113.45 | 3100 | 3100 | 3086.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 7089.2 | 0.0522331 | 20 | 3 | 831.316 | ø20 | 26.9 | 21.6 | TR02.02.0375 | 0375 | yes | HT_vratné vodní (45 °C) 10 | 0
13078679 | 2.NP_SO-102 | 615.075 | 0.000568237 | 0.0519793 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3113.45 | 3100 | 3100 | 3086.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 7089.2 | 0.0386463 | 20 | 3 | 615.075 | ø20 | 26.9 | 21.6 | TR02.02.0376 | 0376 | yes | HT_vratné vodní (45 °C) 10 | 0
13078789 | 2.NP_SO-102 | 396.025 | 0.00183197 | 0.0600924 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 3073.01 | 3073.01 | 2676.99 | 2676.99 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6676.99 | 0.049766 | 40 | 238 | 396.025 | ø40 | 48.3 | 41.8 | TR02.02.0378 | 0378 | yes | HT_vratné vodní (45 °C) 1
13078853 | 2.NP_SO-102 | 1289.89 | 0.00183197 | 0.195726 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 3124.15 | 3100 | 3100 | 3075.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7079.1 | 0.162092 | 40 | 238 | 1289.89 | ø40 | 48.3 | 41.8 | TR02.02.0379 | 0379 | yes | HT_vratné vodní (45 °C) 1 | 0
13078976 | 2.NP_SO-102 | 4106.84 | 0.00183197 | 0.623167 | 40 | ø120 mm | 0.00239234 | HD | 2.NP_SO-102 | 3053.42 | 3053.42 | -1053.42 | -1053.42 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 2946.58 | 0.51608 | 40 | 254 | 4106.84 | ø40 | 48.3 | 41.8 | TR02.02.0381 | 0381 | yes | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13079121 | 1.NP_SO-102 | 3965.07 | 0.000568237 | 0.335084 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 7082.54 | 3117.46 | 7082.54 | 3117.46 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 3117.46 | 0.249133 | 20 | 3 | 3965.07 | ø20 | 26.9 | 21.6 | TR02.02.0382 | 0382 | yes | HT_přívodní vodní (55 °C) 2
13079341 | 1.NP_SO-102 | 4065.07 | 0.000568237 | 0.343535 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 7082.54 | 3017.46 | 7082.54 | 3017.46 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 3017.46 | 0.255416 | 20 | 3 | 4065.07 | ø20 | 26.9 | 21.6 | TR02.02.0383 | 0383 | yes | HT_vratné vodní (45 °C) 10
13079538 | 1.NP_SO-102 | 2565.93 | 0.000568237 | 0.216844 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3113.45 | 3100 | 3100 | 3086.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 3089.2 | 0.161222 | 20 | 3 | 2565.93 | ø20 | 26.9 | 21.6 | TR02.02.0384 | 0384 | yes | HT_přívodní vodní (55 °C) 2 | 0
13079546 | 1.NP_SO-102 | 6925.08 | 0.000568237 | 0.58523 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3113.45 | 3100 | 3100 | 3086.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 3089.2 | 0.435115 | 20 | 3 | 6925.08 | ø20 | 26.9 | 21.6 | TR02.02.0385 | 0385 | yes | HT_přívodní vodní (55 °C) 2 | 0
13079554 | 1.NP_SO-102 | 3322.54 | 0.000568237 | 0.280784 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3113.45 | 3100 | 3100 | 3086.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 3089.2 | 0.208761 | 20 | 3 | 3322.54 | ø20 | 26.9 | 21.6 | TR02.02.0386 | 0386 | yes | HT_přívodní vodní (55 °C) 2 | 0
13079603 | 1.NP_SO-102 | 2565.93 | 0.000568237 | 0.216844 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3013.45 | 3000 | 3000 | 2986.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 2989.2 | 0.161222 | 20 | 3 | 2565.93 | ø20 | 26.9 | 21.6 | TR02.02.0387 | 0387 | yes | HT_vratné vodní (45 °C) 10 | 0
13079611 | 1.NP_SO-102 | 6545.08 | 0.000568237 | 0.553117 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3013.45 | 3000 | 3000 | 2986.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 2989.2 | 0.411239 | 20 | 3 | 6545.08 | ø20 | 26.9 | 21.6 | TR02.02.0388 | 0388 | yes | HT_vratné vodní (45 °C) 10 | 0
13079619 | 1.NP_SO-102 | 3322.54 | 0.000568237 | 0.280784 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3013.45 | 3000 | 3000 | 2986.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 2989.2 | 0.208761 | 20 | 3 | 3322.54 | ø20 | 26.9 | 21.6 | TR02.02.0389 | 0389 | yes | HT_vratné vodní (45 °C) 10 | 0
13079704 | 1.NP_SO-102 | 5067.41 | 0.000568237 | 0.428241 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 2889.2 | 0.318395 | 20 | 247 | 5067.41 | ø20 | 26.9 | 21.6 | TR02.02.0390 | 0390 | yes | HT_vratné vodní (45 °C) 1 | 0
13079713 | 1.NP_SO-102 | 6945.08 | 0.000568237 | 0.58692 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 2889.2 | 0.436372 | 20 | 247 | 6945.08 | ø20 | 26.9 | 21.6 | TR02.02.0391 | 0391 | yes | HT_vratné vodní (45 °C) 1 | 0
13079721 | 1.NP_SO-102 | 670.091 | 0.000568237 | 0.0566286 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 2889.2 | 0.0421031 | 20 | 247 | 670.091 | ø20 | 26.9 | 21.6 | TR02.02.0392 | 0392 | yes | HT_vratné vodní (45 °C) 1 | 0
13079731 | 1.NP_SO-102 | 140.762 | 0.000568237 | 0.0118957 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 2889.2 | 0.00884436 | 20 | 247 | 140.762 | ø20 | 26.9 | 21.6 | TR02.02.0393 | 0393 | yes | HT_vratné vodní (45 °C) 1 | 0
13079880 | 1.NP_SO-102 | 3570.87 | 0.000568237 | 0.30177 | 40 | ø100 mm | 0.00462963 | HD | 1.NP_SO-102 | 2814.53 | -756.344 | 2814.53 | -756.344 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -756.344 | 0.224364 | 20 | 324 | 3570.87 | ø20 | 26.9 | 21.6 | TR02.02.0394 | 0394 | yes | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13079962 | 1.NP_SO-102 | 3612.69 | 0.000568237 | 0.305304 | 40 | ø100 mm | 0.00462963 | HD | 1.NP_SO-102 | 2856.34 | 2856.34 | -756.344 | -756.344 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | -756.344 | 0.226992 | 20 | 286 | 3612.69 | ø20 | 26.9 | 21.6 | TR02.02.0395 | 0395 | yes | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13080251 | 2.NP_SO-102 | 1961.92 | 0.00285535 | 0.371662 | 40 | ø130 mm | 0.00188679 | HD | 2.NP_SO-102 | 3280.15 | 3250 | 3250 | 3219.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7223.5 | 0.308178 | 50 | 258 | 1961.92 | ø50 | 60.3 | 53 | TR02.02.0402 | 0402 | yes | HT_vratné vodní (45 °C) 1 | 0 | Izolace - Typ izolace: Tepelná
13080623 | 2.NP_SO-102 | 561.423 | 0.000568237 | 0.0474452 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3173.45 | 3160 | 3160 | 3146.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7149.2 | 0.0352753 | 20 | 296 | 561.423 | ø20 | 26.9 | 21.6 | TR02.02.0403 | 0403 | yes | HT_vratné vodní (45 °C) 1 | 0
13080625 | 3.NP_SO-102 | 3855.71 | 0.00183197 | 0.585061 | 40 | ø120 mm | 0.00239234 | HD | 3.NP_SO-102 | 7169.04 | 7169.04 | 3313.34 | 3313.34 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11313.3 | 0.484522 | 40 | 344 | 3855.71 | ø40 | 48.3 | 41.8 | TR02.02.0404 | 0404 | yes | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13081142 | 2.NP_SO-102 | 44.4313 | 0.00285535 | 0.00841697 | 40 | ø130 mm | 0.00188679 | HD | 2.NP_SO-102 | 3216.66 | 3216.66 | 3172.23 | 3172.23 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7172.23 | 0.00697924 | 50 | 258 | 44.4313 | ø50 | 60.3 | 53 | TR02.02.0405 | 0405 | yes | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13081311 | 2.NP_SO-102 | 3.48125 | 0.00183197 | 0.000528241 | 40 | ø120 mm | 0.00239234 | HD | 2.NP_SO-102 | 3196.82 | 3196.82 | 3193.34 | 3193.34 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7193.34 | 0.000437467 | 40 | 5 | 3.48125 | ø40 | 48.3 | 41.8 | TR02.02.0406 | 0406 | yes | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13081389 | 2.NP_SO-102 | 233.546 | 0.000568237 | 0.0197367 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3273.45 | 3260 | 3260 | 3246.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7249.2 | 0.0146741 | 20 | 300 | 233.546 | ø20 | 26.9 | 21.6 | TR02.02.0407 | 0407 | yes | HT_vratné vodní (45 °C) 1 | 0
13081457 | 2.NP_SO-102 | 5121.81 | 0.000568237 | 0.432838 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3273.45 | 3260 | 3260 | 3246.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7249.2 | 0.321813 | 20 | 300 | 5121.81 | ø20 | 26.9 | 21.6 | TR02.02.0408 | 0408 | yes | HT_vratné vodní (45 °C) 1 | 0
13081715 | 2.NP_SO-102 | 71.165 | 0.00183197 | 0.0107985 | 40 | ø120 mm | 0.00239234 | HD | 2.NP_SO-102 | 3224.35 | 3224.35 | 3153.18 | 3153.18 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7153.18 | 0.00894286 | 40 | 257 | 71.165 | ø40 | 48.3 | 41.8 | TR02.02.0414 | 0414 | yes | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13082049 | 2.NP_SO-102 | 2130.54 | 0.000568237 | 0.18005 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6789.2 | 0.133866 | 20 | 683 | 2130.54 | ø20 | 26.9 | 21.6 | TR02.02.0417 | 0417 | yes | HT_vratné vodní (45 °C) 1 | 0
13082522 | 2.NP_SO-102 | 606.82 | 0.000568237 | 0.0512817 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7189.2 | 0.0381277 | 20 | 555 | 606.82 | ø20 | 26.9 | 21.6 | TR02.02.0426 | 0426 | yes | HT_vratné vodní (45 °C) 1 | 0
13082542 | 2.NP_SO-102 | 4822.45 | 0.000568237 | 0.40754 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7189.2 | 0.303003 | 20 | 555 | 4822.45 | ø20 | 26.9 | 21.6 | TR02.02.0427 | 0427 | yes | HT_vratné vodní (45 °C) 1 | 0
13082560 | 2.NP_SO-102 | 315.272 | 0.000568237 | 0.0266433 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7189.2 | 0.0198091 | 20 | 555 | 315.272 | ø20 | 26.9 | 21.6 | TR02.02.0428 | 0428 | yes | HT_vratné vodní (45 °C) 1 | 0
13083027 | 2.NP_SO-102 | 4272.76 | 0.000568237 | 0.361086 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3263.45 | 3250 | 3250 | 3236.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7239.2 | 0.268466 | 20 | 281 | 4272.76 | ø20 | 26.9 | 21.6 | TR02.02.0433 | 0433 | yes | HT_vratné vodní (45 °C) 1 | 0
13083124 | 1.NP_SO-102 | 3965.08 | 0.000356274 | 0.265327 | 0 | ø15 mm | 0.00625 | HD | 1.NP_SO-102 | 3929.36 | -35.7125 | 3929.36 | -35.7125 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -35.7125 | 0.18685 | 15 | 284 | 3965.08 | ø15 | 21.3 | 16 | TR02.02.0436 | 0436 | yes | HT_vratné vodní (45 °C) 1
13083246 | 3.NP_SO-102 | 3949.9 | 0.000356274 | 0.264311 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 3929.27 | 3929.27 | -20.6312 | -20.6313 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7979.37 | 0.186135 | 15 | 701 | 3949.9 | ø15 | 21.3 | 16 | TR02.02.0437 | 0437 | yes | HT_vratné vodní (45 °C) 1
13083325 | 2.NP_SO-102 | 60.3063 | 0.000568237 | 0.00509641 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3232.54 | 3232.54 | 3172.23 | 3172.23 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7172.23 | 0.00378915 | 20 | 281 | 60.3063 | ø20 | 26.9 | 21.6 | TR02.02.0438 | 0438 | yes | HT_vratné vodní (45 °C) 1
13083580 | 2.NP_SO-102 | 652.375 | 0.000568237 | 0.0551315 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3926.19 | 3926.19 | 3273.81 | 3273.81 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7273.81 | 0.0409899 | 20 | 286 | 652.375 | ø20 | 26.9 | 21.6 | TR02.02.0444 | 0444 | yes | HT_vratné vodní (45 °C) 1
13083618 | 2.NP_SO-102 | 3249.99 | 0.000568237 | 0.274653 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3226.19 | 3226.19 | -23.8062 | -23.8062 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3976.19 | 0.204203 | 20 | 283 | 3249.99 | ø20 | 26.9 | 21.6 | TR02.02.0445 | 0445 | yes | HT_vratné vodní (45 °C) 1
13083992 | 2.NP_SO-102 | 58.725 | 0.000568237 | 0.00496278 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3242.54 | 3242.54 | 3183.81 | 3183.81 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7183.81 | 0.0036898 | 20 | 300 | 58.725 | ø20 | 26.9 | 21.6 | TR02.02.0449 | 0449 | yes | HT_vratné vodní (45 °C) 1
13084186 | 2.NP_SO-102 | 3159.9 | 0.000356274 | 0.211448 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 3130.63 | 3130.63 | -29.2687 | -29.2687 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3970.73 | 0.148907 | 15 | 674 | 3159.9 | ø15 | 21.3 | 16 | TR02.02.0450 | 0450 | no | HT_vratné vodní (45 °C) 1
13084255 | 2.NP_SO-102 | 3258.68 | 0.000356274 | 0.218058 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 3229.42 | -29.2687 | 3229.42 | -29.2687 | Fáze 1 | HT_přívodní vodní (45 °C) | Přívod teplé vody | HT_přívodní vodní (45 °C) 2 | 3970.73 | 0.153562 | 15 | 1 | 3258.68 | ø15 | 21.3 | 16 | TR02.02.0452 | 0452 | no | HT_přívodní vodní (55 °C) 9; HT_přívodní vodní (45 °C) 2
13084306 | 2.NP_SO-102 | 311.425 | 0.000568237 | 0.0263182 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3272.17 | 3258.72 | 3257.81 | 3244.36 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7247.01 | 0.0195674 | 20 | 220 | 311.425 | ø20 | 26.9 | 21.6 | TR02.02.0453 | 0453 | yes | HT_přívodní vodní (55 °C) 9 | 0.290491
13084880 | 1.NP_SO-102 | 3161.43 | 0.000356274 | 0.21155 | 40 | ø95 mm | 0.00625 | HD | 1.NP_SO-102 | 2275.71 | -885.713 | 2275.71 | -885.713 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -885.712 | 0.148979 | 15 | 838 | 3161.43 | ø15 | 21.3 | 16 | TR02.02.0454 | 0454 | yes | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13084883 | 1.NP_SO-102 | 318.437 | 0.000356274 | 0.0213085 | 40 | ø95 mm | 0.00625 | HD | 1.NP_SO-102 | 2300.65 | 2290 | 2290 | 2279.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 2282 | 0.015006 | 15 | 838 | 318.437 | ø15 | 21.3 | 16 | TR02.02.0455 | 0455 | yes | HT_vratné vodní (45 °C) 1 | 0 | Izolace - Typ izolace: Tepelná
13085064 | -1.PP_SO-102 | 2731.43 | 0.000356274 | 0.182776 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 2685.71 | 2685.71 | -45.7125 | -45.7125 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -4045.71 | 0.128715 | 15 | 838 | 2731.43 | ø15 | 21.3 | 16 | TR02.02.0456 | 0456 | yes | HT_vratné vodní (45 °C) 1
13085184 | -1.PP_SO-102 | 3139.93 | 0.000356274 | 0.210111 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3110.65 | 3100 | 3100 | 3089.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -908 | 0.147966 | 15 | 838 | 3139.93 | ø15 | 21.3 | 16 | TR02.02.0457 | 0457 | yes | HT_vratné vodní (45 °C) 1 | 0
13087042 | 1.NP_SO-102 | 2875.08 | 0.000568237 | 0.242969 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 2832.54 | 2832.54 | -42.5375 | -42.5375 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -42.5375 | 0.180646 | 20 | 434 | 2875.08 | ø20 | 26.9 | 21.6 | TR02.02.0483 | 0483 | yes | HT_vratné vodní (45 °C) 1
13087053 | 1.NP_SO-102 | 1100.21 | 0.000568237 | 0.0929777 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 2863.45 | 2850 | 2850 | 2836.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 2839.2 | 0.0691284 | 20 | 434 | 1100.21 | ø20 | 26.9 | 21.6 | TR02.02.0484 | 0484 | yes | HT_vratné vodní (45 °C) 1 | 0
13087064 | 1.NP_SO-102 | 2406.14 | 0.000568237 | 0.20334 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3084.23 | 3070.78 | 3070.78 | 3057.33 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3059.98 | 0.151182 | 20 | 434 | 2406.14 | ø20 | 26.9 | 21.6 | TR02.02.0485 | 0485 | yes | HT_vratné vodní (45 °C) 1 | 0
13087108 | 1.NP_SO-102 | 1065.08 | 0.000568237 | 0.0900083 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3269.2 | 0.0669206 | 20 | 594 | 1065.08 | ø20 | 26.9 | 21.6 | TR02.02.0486 | 0486 | yes | HT_vratné vodní (45 °C) 1 | 0
13087227 | 1.NP_SO-102 | 185.854 | 0.000568237 | 0.0157063 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3053.32 | 2867.46 | 3053.32 | 2867.46 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 2867.46 | 0.0116775 | 20 | 434 | 185.854 | ø20 | 26.9 | 21.6 | TR02.02.0488 | 0488 | yes | HT_vratné vodní (45 °C) 1
13087277 | 1.NP_SO-102 | 174.296 | 0.000568237 | 0.0147296 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3262.54 | 3088.24 | 3262.54 | 3088.24 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3088.24 | 0.0109514 | 20 | 434 | 174.296 | ø20 | 26.9 | 21.6 | TR02.02.0489 | 0489 | yes | HT_vratné vodní (45 °C) 1
13088465 | -1.PP_SO-102 | 3024.34 | 0.000356274 | 0.202376 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3210.65 | 3200 | 3200 | 3189.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -808 | 0.142519 | 15 | 323 | 3024.34 | ø15 | 21.3 | 16 | TR02.02.0495 | 0495 | yes | HT_vratné vodní (45 °C) 1 | 0
13088479 | 1.NP_SO-102 | 23.1999 | 0.00285535 | 0.00439494 | 40 | ø130 mm | 0.00188679 | HD | 1.NP_SO-102 | 2851.22 | 2828.02 | 2851.22 | 2828.02 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 2828.02 | 0.00364423 | 50 | 837 | 23.1999 | ø50 | 60.3 | 53 | TR02.02.0496 | 0496 | yes | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13088484 | -1.PP_SO-102 | 2645.99 | 0.000356274 | 0.177059 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3210.65 | 3200 | 3200 | 3189.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -808 | 0.12469 | 15 | 326 | 2645.99 | ø15 | 21.3 | 16 | TR02.02.0497 | 0497 | yes | HT_vratné vodní (45 °C) 1 | 0
13088527 | -1.PP_SO-102 | 1451.43 | 0.000356274 | 0.0971234 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3210.65 | 3200 | 3200 | 3189.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -808 | 0.0683968 | 15 | 323 | 1451.43 | ø15 | 21.3 | 16 | TR02.02.0498 | 0498 | yes | HT_vratné vodní (45 °C) 1 | 0
13088538 | -1.PP_SO-102 | 471.425 | 0.000356274 | 0.0315458 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3185.71 | 2714.29 | 3185.71 | 2714.29 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -1285.71 | 0.0222154 | 15 | 323 | 471.425 | ø15 | 21.3 | 16 | TR02.02.0499 | 0499 | yes | HT_vratné vodní (45 °C) 1
13088549 | -1.PP_SO-102 | 6626.57 | 0.000356274 | 0.443423 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 2710.65 | 2700 | 2700 | 2689.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -1308 | 0.31227 | 15 | 323 | 6626.57 | ø15 | 21.3 | 16 | TR02.02.0500 | 0500 | yes | HT_vratné vodní (45 °C) 1 | 0
13088792 | -1.PP_SO-102 | 525.712 | 0.000356274 | 0.0351785 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3210.65 | 3200 | 3200 | 3189.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -808 | 0.0247736 | 15 | 326 | 525.712 | ø15 | 21.3 | 16 | TR02.02.0501 | 0501 | yes | HT_vratné vodní (45 °C) 1 | 0
13088889 | -1.PP_SO-102 | 3121.43 | 0.000356274 | 0.208873 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3185.71 | 64.2875 | 3185.71 | 64.2875 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | -3935.71 | 0.147094 | 15 | 554 | 3121.43 | ø15 | 21.3 | 16 | TR02.02.0502 | 0502 | yes | HT_přívodní vodní (55 °C) 9
13088970 | -1.PP_SO-102 | 322.768 | 0.000356274 | 0.0215983 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3210.65 | 3200 | 3200 | 3189.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -808 | 0.0152101 | 15 | 326 | 322.768 | ø15 | 21.3 | 16 | TR02.02.0503 | 0503 | yes | HT_vratné vodní (45 °C) 1 | 0
13088998 | -1.PP_SO-102 | 3121.43 | 0.000356274 | 0.208873 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3185.71 | 64.2875 | 3185.71 | 64.2875 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -3935.71 | 0.147094 | 15 | 326 | 3121.43 | ø15 | 21.3 | 16 | TR02.02.0504 | 0504 | yes | HT_vratné vodní (45 °C) 1
13089061 | -1.PP_SO-102 | 2721.43 | 0.000356274 | 0.182107 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 2685.71 | -35.7125 | 2685.71 | -35.7125 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | -4035.71 | 0.128244 | 15 | 30 | 2721.43 | ø15 | 21.3 | 16 | TR02.02.0506 | 0506 | yes | HT_přívodní vodní (55 °C) 9
13089167 | -1.PP_SO-102 | 2721.43 | 0.000356274 | 0.182107 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 2685.71 | 2685.71 | -35.7125 | -35.7125 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -4035.71 | 0.128244 | 15 | 323 | 2721.43 | ø15 | 21.3 | 16 | TR02.02.0508 | 0508 | yes | HT_vratné vodní (45 °C) 1
13089385 | 3.NP_SO-102 | 3328.55 | 0.000568237 | 0.281292 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11269.2 | 0.209139 | 20 | 694 | 3328.55 | ø20 | 26.9 | 21.6 | TR02.02.0514 | 0514 | yes | HT_vratné vodní (45 °C) 1 | 0
13089394 | 3.NP_SO-102 | 591.681 | 0.000568237 | 0.0500022 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11269.2 | 0.0371764 | 20 | 694 | 591.681 | ø20 | 26.9 | 21.6 | TR02.02.0515 | 0515 | yes | HT_vratné vodní (45 °C) 1 | 0
13090053 | 3.NP_SO-102 | 3865.14 | 0.000568237 | 0.326639 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11269.2 | 0.242854 | 20 | 694 | 3865.14 | ø20 | 26.9 | 21.6 | TR02.02.0517 | 0517 | yes | HT_vratné vodní (45 °C) 1 | 0
13090330 | 3.NP_SO-102 | 2486.64 | 0.000568237 | 0.210143 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3163.45 | 3150 | 3150 | 3136.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11139.2 | 0.15624 | 20 | 695 | 2486.64 | ø20 | 26.9 | 21.6 | TR02.02.0518 | 0518 | yes | HT_vratné vodní (45 °C) 1 | 0
13090352 | 3.NP_SO-102 | 5601.42 | 0.000356274 | 0.374825 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 2810.65 | 2800 | 2800 | 2789.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 18 | 10792 | 0.263961 | 15 | 1 | 5601.42 | ø15 | 21.3 | 16 | TR02.02.0519 | 0519 | yes | HT_vratné vodní (45 °C) 18 | 0
13090363 | 3.NP_SO-102 | 640.075 | 0.000356274 | 0.0428312 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 2810.65 | 2800 | 2800 | 2789.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 18 | 10792 | 0.0301628 | 15 | 1 | 640.075 | ø15 | 21.3 | 16 | TR02.02.0520 | 0520 | yes | HT_vratné vodní (45 °C) 18 | 0
13090385 | 3.NP_SO-102 | 1115.08 | 0.000356274 | 0.0746163 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 3935.71 | 3935.71 | 2820.64 | 2820.64 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 18 | 10820.6 | 0.0525467 | 15 | 3 | 1115.08 | ø15 | 21.3 | 16 | TR02.02.0521 | 0521 | no | HT_vratné vodní (45 °C) 18
13090410 | 3.NP_SO-102 | 382.264 | 0.000356274 | 0.0255795 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 2810.65 | 2800 | 2800 | 2789.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10792 | 0.0180138 | 15 | 341 | 382.264 | ø15 | 21.3 | 16 | TR02.02.0522 | 0522 | yes | HT_vratné vodní (45 °C) 1 | 0
13090421 | 3.NP_SO-102 | 165.713 | 0.000356274 | 0.0110888 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | -39.35 | -50 | -50 | -60.65 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7942 | 0.00780902 | 15 | 341 | 165.713 | ø15 | 21.3 | 16 | TR02.02.0523 | 0523 | no | HT_vratné vodní (45 °C) 1 | 0
13090432 | 3.NP_SO-102 | 2821.43 | 0.000356274 | 0.188798 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 2785.71 | -35.7125 | 2785.71 | -35.7125 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7964.29 | 0.132957 | 15 | 341 | 2821.43 | ø15 | 21.3 | 16 | TR02.02.0524 | 0524 | yes | HT_vratné vodní (45 °C) 1
13090535 | 3.NP_SO-102 | 4773.52 | 0.000356274 | 0.319425 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 2810.65 | 2800 | 2800 | 2789.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10792 | 0.224947 | 15 | 340 | 4773.52 | ø15 | 21.3 | 16 | TR02.02.0525 | 0525 | yes | HT_vratné vodní (45 °C) 1 | 0
13090545 | 3.NP_SO-102 | 1755.52 | 0.000568237 | 0.148357 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10789.2 | 0.110303 | 20 | 695 | 1755.52 | ø20 | 26.9 | 21.6 | TR02.02.0526 | 0526 | yes | HT_vratné vodní (45 °C) 1 | 0
13090662 | 3.NP_SO-102 | 2830.4 | 0.000356274 | 0.189399 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 2779.36 | 2779.36 | -51.0366 | -51.0366 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 18 | 7948.96 | 0.133379 | 15 | 2 | 2830.4 | ø15 | 21.3 | 16 | TR02.02.0527 | 0527 | no | HT_vratné vodní (45 °C) 18
13090708 | 3.NP_SO-102 | 94.3618 | 0.000356274 | 0.00631431 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 2803.35 | 2729.09 | 2795.82 | 2721.56 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10723.4 | 0.0044467 | 15 | 340 | 94.3618 | ø15 | 21.3 | 16 | TR02.02.0528 | 0528 | yes | HT_vratné vodní (45 °C) 1 | 100
13090728 | 3.NP_SO-102 | 4.8116 | 0.000356274 | 0.000321972 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 2810.65 | 2800 | 2800 | 2789.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10792 | 0.000226741 | 15 | 340 | 4.8116 | ø15 | 21.3 | 16 | TR02.02.0529 | 0529 | yes | HT_vratné vodní (45 °C) 1 | 0
13090737 | 3.NP_SO-102 | 67.9906 | 0.000356274 | 0.00454965 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 2735.56 | 2724.91 | 2724.91 | 2714.26 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10716.9 | 0.00320398 | 15 | 340 | 67.9906 | ø15 | 21.3 | 16 | TR02.02.0530 | 0530 | yes | HT_vratné vodní (45 °C) 1 | 0
13090747 | 3.NP_SO-102 | 94.3618 | 0.000356274 | 0.00631431 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 2803.35 | 2795.82 | 2729.09 | 2721.56 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10723.4 | 0.0044467 | 15 | 340 | 94.3618 | ø15 | 21.3 | 16 | TR02.02.0531 | 0531 | yes | HT_vratné vodní (45 °C) 1 | 100
13091089 | 3.NP_SO-102 | 63.325 | 0.00183197 | 0.00960887 | 40 | ø120 mm | 0.00239234 | HD | 3.NP_SO-102 | 3246.66 | 3246.66 | 3183.34 | 3183.34 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11183.3 | 0.00795765 | 40 | 337 | 63.325 | ø40 | 48.3 | 41.8 | TR02.02.0532 | 0532 | yes | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13091122 | 2.NP_SO-102 | 2636.1 | 0.00183197 | 0.4 | 40 | ø120 mm | 0.00239234 | HD | 2.NP_SO-102 | 3174.15 | 3150 | 3150 | 3125.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 7129.1 | 0.331263 | 40 | 150 | 2636.1 | ø40 | 48.3 | 41.8 | TR02.02.0533 | 0533 | yes | HT_vratné vodní (45 °C) 2 | 0 | Izolace - Typ izolace: Tepelná
13091211 | 1.NP_SO-102 | 8481.74 | 0.00183197 | 1.28701 | 40 | ø120 mm | 0.00239234 | HD | 1.NP_SO-102 | 7115.87 | 7115.87 | -1365.87 | -1365.87 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -1365.87 | 1.06585 | 40 | 127 | 8481.74 | ø40 | 48.3 | 41.8 | TR02.02.0534 | 0534 | yes | HT_vratné vodní (45 °C) 2 | Izolace - Typ izolace: Tepelná
13093307 | 3.NP_SO-102 | 212.403 | 0.00141175 | 0.0282929 | 0 | ø32 mm | 0.00278552 | HD | 3.NP_SO-102 | 3301.2 | 3280 | 3280 | 3258.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11262 | 0.0213531 | 32 | 348 | 212.403 | ø32 | 42.4 | 35.9 | TR02.02.0551 | 0551 | yes | HT_vratné vodní (45 °C) 1 | 0
13093446 | 2.NP_SO-102 | 3943.48 | 0.00183197 | 0.59838 | 40 | ø120 mm | 0.00239234 | HD | 2.NP_SO-102 | 7246.66 | 7246.66 | 3303.18 | 3303.18 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7303.18 | 0.495552 | 40 | 261 | 3943.48 | ø40 | 48.3 | 41.8 | TR02.02.0552 | 0552 | yes | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13093528 | 3.NP_SO-102 | 3345.17 | 0.000356274 | 0.223845 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 3311.11 | -34.0625 | 3311.11 | -34.0625 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7965.94 | 0.157637 | 15 | 299 | 3345.17 | ø15 | 21.3 | 16 | TR02.02.0553 | 0553 | no | HT_přívodní vodní (55 °C) 9
13093531 | 3.NP_SO-102 | 300.816 | 0.00141175 | 0.0400697 | 0 | ø32 mm | 0.00278552 | HD | 3.NP_SO-102 | 3371.2 | 3350 | 3350 | 3328.8 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 11332 | 0.0302413 | 32 | 273 | 300.816 | ø32 | 42.4 | 35.9 | TR02.02.0554 | 0554 | yes | HT_přívodní vodní (55 °C) 9 | 0
13093661 | 3.NP_SO-102 | 3275.17 | 0.000356274 | 0.219161 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 3241.11 | -34.0625 | 3241.11 | -34.0625 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7965.94 | 0.154339 | 15 | 350 | 3275.17 | ø15 | 21.3 | 16 | TR02.02.0556 | 0556 | no | HT_vratné vodní (45 °C) 1
13093664 | 3.NP_SO-102 | 550.816 | 0.00141175 | 0.0733706 | 0 | ø32 mm | 0.00278552 | HD | 3.NP_SO-102 | 3301.2 | 3280 | 3280 | 3258.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11262 | 0.055374 | 32 | 346 | 550.816 | ø32 | 42.4 | 35.9 | TR02.02.0557 | 0557 | yes | HT_vratné vodní (45 °C) 1 | 0
13093812 | 3.NP_SO-102 | 5014.79 | 0.000568237 | 0.423794 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11269.2 | 0.315088 | 20 | 353 | 5014.79 | ø20 | 26.9 | 21.6 | TR02.02.0558 | 0558 | yes | HT_vratné vodní (45 °C) 1 | 0
13093825 | 3.NP_SO-102 | 2130.76 | 0.000568237 | 0.180068 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11269.2 | 0.13388 | 20 | 352 | 2130.76 | ø20 | 26.9 | 21.6 | TR02.02.0559 | 0559 | yes | HT_vratné vodní (45 °C) 1 | 0
13093860 | 3.NP_SO-102 | 16.025 | 0.00141175 | 0.00213459 | 0 | ø32 mm | 0.00278552 | HD | 3.NP_SO-102 | 3326.19 | 3310.16 | 3326.19 | 3310.16 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 11310.2 | 0.00161101 | 32 | 302 | 16.025 | ø32 | 42.4 | 35.9 | TR02.02.0560 | 0560 | yes | HT_přívodní vodní (55 °C) 9; HT_přívodní vodní (65 °C) 15
13094031 | 3.NP_SO-102 | 5317.77 | 0.000568237 | 0.449399 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 15 | 11269.2 | 0.334126 | 20 | 19 | 5317.77 | ø20 | 26.9 | 21.6 | TR02.02.0562 | 0562 | yes | HT_přívodní vodní (65 °C) 15 | 0
13094046 | 3.NP_SO-102 | 1977.78 | 0.000568237 | 0.167139 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 15 | 11269.2 | 0.124267 | 20 | 20 | 1977.78 | ø20 | 26.9 | 21.6 | TR02.02.0563 | 0563 | yes | HT_přívodní vodní (65 °C) 15 | 0
13094169 | 1.NP_SO-102 | 3365.17 | 0.000356274 | 0.225183 | 0 | ø15 mm | 0.00625 | HD | 1.NP_SO-102 | 3321.11 | -44.0625 | 3321.11 | -44.0625 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | -44.0625 | 0.15858 | 15 | 306 | 3365.17 | ø15 | 21.3 | 16 | TR02.02.0564 | 0564 | no | HT_přívodní vodní (55 °C) 9
13094172 | 1.NP_SO-102 | 310.904 | 0.00141175 | 0.0414135 | 0 | ø32 mm | 0.00278552 | HD | 1.NP_SO-102 | 3381.2 | 3360 | 3360 | 3338.8 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 3342.05 | 0.0312555 | 32 | 365 | 310.904 | ø32 | 42.4 | 35.9 | TR02.02.0565 | 0565 | yes | HT_přívodní vodní (55 °C) 9 | 0
13094595 | 1.NP_SO-102 | 932.056 | 0.000356274 | 0.0623694 | 40 | ø95 mm | 0.00625 | HD | 1.NP_SO-102 | 3236.34 | 2304.29 | 3236.34 | 2304.29 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 2304.29 | 0.0439221 | 15 | 838 | 932.056 | ø15 | 21.3 | 16 | TR02.02.0567 | 0567 | yes | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13094764 | 1.NP_SO-102 | 26.025 | 0.00141175 | 0.00346662 | 0 | ø32 mm | 0.00278552 | HD | 1.NP_SO-102 | 3336.19 | 3310.16 | 3336.19 | 3310.16 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 3310.16 | 0.00261632 | 32 | 303 | 26.025 | ø32 | 42.4 | 35.9 | TR02.02.0568 | 0568 | yes | HT_přívodní vodní (55 °C) 9
13094937 | 1.NP_SO-102 | 3703.2 | 0.000568237 | 0.312953 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 23 | 3269.2 | 0.232679 | 20 | 34 | 3703.2 | ø20 | 26.9 | 21.6 | TR02.02.0570 | 0570 | yes | HT_přívodní vodní (55 °C) 9; HT_přívodní vodní (65 °C) 23 | 0
13094951 | 1.NP_SO-102 | 2241.97 | 0.000568237 | 0.189467 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 21 | 3269.2 | 0.140867 | 20 | 16 | 2241.97 | ø20 | 26.9 | 21.6 | TR02.02.0571 | 0571 | yes | HT_přívodní vodní (55 °C) 9; HT_přívodní vodní (65 °C) 21 | 0
13095013 | 1.NP_SO-102 | 3706.19 | 0.000568237 | 0.313206 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3269.2 | 0.232867 | 20 | 594 | 3706.19 | ø20 | 26.9 | 21.6 | TR02.02.0572 | 0572 | yes | HT_vratné vodní (45 °C) 1 | 0
13095692 | 4.NP_SO-102 | 5949.82 | 0.000568237 | 0.502812 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2863.45 | 2850 | 2850 | 2836.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 5 | 14839.2 | 0.373838 | 20 | 4 | 5949.82 | ø20 | 26.9 | 21.6 | TR02.02.0579 | 0579 | yes | HT_přívodní vodní (55 °C) 5 | 0
13095999 | 4.NP_SO-102 | 21.425 | 0.000356274 | 0.00143367 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 2835.71 | 2814.29 | 2835.71 | 2814.29 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 10 | 14814.3 | 0.00100963 | 15 | 304 | 21.425 | ø15 | 21.3 | 16 | TR02.02.0580 | 0580 | yes | HT_přívodní vodní (65 °C) 10
13096289 | 4.NP_SO-102 | 315.288 | 0.000356274 | 0.0210978 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 2860.65 | 2850 | 2850 | 2839.35 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 10 | 14842 | 0.0148576 | 15 | 300 | 315.288 | ø15 | 21.3 | 16 | TR02.02.0581 | 0581 | yes | HT_přívodní vodní (65 °C) 10 | 0
13096354 | 3.NP_SO-102 | 4657.4 | 0.000568237 | 0.393592 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 11269.2 | 0.292633 | 20 | 519 | 4657.4 | ø20 | 26.9 | 21.6 | TR02.02.0582 | 0582 | yes | HT_přívodní vodní (55 °C) 9 | 0
13096407 | 4.NP_SO-102 | 5368.78 | 0.000568237 | 0.453709 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2863.45 | 2850 | 2850 | 2836.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 10 | 14839.2 | 0.33733 | 20 | 6 | 5368.78 | ø20 | 26.9 | 21.6 | TR02.02.0583 | 0583 | yes | HT_přívodní vodní (65 °C) 10 | 0
13096446 | 4.NP_SO-102 | 3503.33 | 0.00183197 | 0.531591 | 40 | ø120 mm | 0.00239234 | HD | 4.NP_SO-102 | 2816.66 | -686.663 | 2816.66 | -686.663 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 11313.3 | 0.440241 | 40 | 324 | 3503.33 | ø40 | 48.3 | 41.8 | TR02.02.0584 | 0584 | yes | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13096528 | 2.NP_SO-102 | 113.325 | 0.00183197 | 0.0171958 | 40 | ø120 mm | 0.00239234 | HD | 2.NP_SO-102 | 3246.66 | 3133.34 | 3246.66 | 3133.34 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7133.34 | 0.0142408 | 40 | 280 | 113.325 | ø40 | 48.3 | 41.8 | TR02.02.0585 | 0585 | yes | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13096726 | 3.NP_SO-102 | 403.397 | 0.000568237 | 0.0340907 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10789.2 | 0.0253462 | 20 | 522 | 403.397 | ø20 | 26.9 | 21.6 | TR02.02.0586 | 0586 | yes | HT_přívodní vodní (55 °C) 9 | 0
13096744 | 3.NP_SO-102 | 553.397 | 0.000568237 | 0.046767 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10789.2 | 0.034771 | 20 | 695 | 553.397 | ø20 | 26.9 | 21.6 | TR02.02.0587 | 0587 | yes | HT_vratné vodní (45 °C) 1 | 0
13096792 | 3.NP_SO-102 | 315.075 | 0.000568237 | 0.0266266 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3132.54 | 3132.54 | 2817.46 | 2817.46 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10817.5 | 0.0197967 | 20 | 522 | 315.075 | ø20 | 26.9 | 21.6 | TR02.02.0588 | 0588 | yes | HT_přívodní vodní (55 °C) 9
13096803 | 3.NP_SO-102 | 63.325 | 0.00183197 | 0.00960887 | 40 | ø120 mm | 0.00239234 | HD | 3.NP_SO-102 | 3246.66 | 3183.34 | 3246.66 | 3183.34 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 11183.3 | 0.00795765 | 40 | 319 | 63.325 | ø40 | 48.3 | 41.8 | TR02.02.0589 | 0589 | yes | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13096835 | 3.NP_SO-102 | 315.075 | 0.000568237 | 0.0266266 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3132.54 | 3132.54 | 2817.46 | 2817.46 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10817.5 | 0.0197967 | 20 | 695 | 315.075 | ø20 | 26.9 | 21.6 | TR02.02.0590 | 0590 | yes | HT_vratné vodní (45 °C) 1
13096846 | 3.NP_SO-102 | 589.675 | 0.00183197 | 0.0894767 | 40 | ø120 mm | 0.00239234 | HD | 3.NP_SO-102 | 3116.66 | 3116.66 | 2526.99 | 2526.99 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10527 | 0.0741007 | 40 | 831 | 589.675 | ø40 | 48.3 | 41.8 | TR02.02.0591 | 0591 | yes | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13096923 | 4.NP_SO-102 | 1501.91 | 0.000568237 | 0.126925 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2933.45 | 2920 | 2920 | 2906.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 14909.2 | 0.0943678 | 20 | 835 | 1501.91 | ø20 | 26.9 | 21.6 | TR02.02.0592 | 0592 | yes | HT_vratné vodní (45 °C) 1 | 0
13096934 | 4.NP_SO-102 | 5999.82 | 0.000568237 | 0.507037 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2933.45 | 2920 | 2920 | 2906.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 14909.2 | 0.37698 | 20 | 835 | 5999.82 | ø20 | 26.9 | 21.6 | TR02.02.0593 | 0593 | yes | HT_vratné vodní (45 °C) 1 | 0
13096967 | 4.NP_SO-102 | 561.425 | 0.000356274 | 0.0375683 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 2810.65 | 2800 | 2800 | 2789.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 14792 | 0.0264565 | 15 | 389 | 561.425 | ø15 | 21.3 | 16 | TR02.02.0594 | 0594 | yes | HT_vratné vodní (45 °C) 1 | 0
13096978 | 4.NP_SO-102 | 1515.98 | 0.000356274 | 0.101443 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 2810.65 | 2800 | 2800 | 2789.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 14792 | 0.071439 | 15 | 389 | 1515.98 | ø15 | 21.3 | 16 | TR02.02.0595 | 0595 | yes | HT_vratné vodní (45 °C) 1 | 0
13096989 | 4.NP_SO-102 | 402.901 | 0.000356274 | 0.0269605 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 2810.65 | 2800 | 2800 | 2789.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 14792 | 0.0189863 | 15 | 389 | 402.901 | ø15 | 21.3 | 16 | TR02.02.0596 | 0596 | yes | HT_vratné vodní (45 °C) 1 | 0
13097000 | 4.NP_SO-102 | 145.713 | 0.000356274 | 0.00975049 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | -39.35 | -50 | -50 | -60.65 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11942 | 0.00686654 | 15 | 389 | 145.713 | ø15 | 21.3 | 16 | TR02.02.0597 | 0597 | no | HT_vratné vodní (45 °C) 1 | 0
13097011 | 4.NP_SO-102 | 2821.43 | 0.000356274 | 0.188798 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 2785.71 | -35.7125 | 2785.71 | -35.7125 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11964.3 | 0.132957 | 15 | 389 | 2821.43 | ø15 | 21.3 | 16 | TR02.02.0598 | 0598 | yes | HT_vratné vodní (45 °C) 1
13097403 | 4.NP_SO-102 | 2488.14 | 0.000356261 | 0.166496 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 2930.65 | 2920 | 2920 | 2909.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 14912 | 0.117251 | 15 | 389 | 2488.14 | ø15 | 21.3 | 16 | TR02.02.0599 | 0599 | yes | HT_vratné vodní (45 °C) 1 | 0
13097456 | 4.NP_SO-102 | 91.425 | 0.000356274 | 0.00611779 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 2905.71 | 2905.71 | 2814.29 | 2814.29 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 14814.3 | 0.0043083 | 15 | 389 | 91.425 | ø15 | 21.3 | 16 | TR02.02.0600 | 0600 | yes | HT_vratné vodní (45 °C) 1
13099058 | 4.NP_SO-102 | 46.9312 | 0.000891835 | 0.00496869 | 0 | ø25 mm | 0.00367647 | HD | 4.NP_SO-102 | 3279.36 | 3279.36 | 3232.43 | 3232.43 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 15232.4 | 0.00368597 | 25 | 333 | 46.9312 | ø25 | 33.7 | 27.2 | TR02.02.0613 | 0613 | yes | HT_přívodní vodní (55 °C) 9
13099061 | 4.NP_SO-102 | 1996.24 | 0.000568237 | 0.1687 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 28 | 15189.2 | 0.125428 | 20 | 18 | 1996.24 | ø20 | 26.9 | 21.6 | TR02.02.0614 | 0614 | yes | HT_přívodní vodní (55 °C) 9; HT_přívodní vodní (65 °C) 28 | 0
13099296 | 4.NP_SO-102 | 4653.75 | 0.000568237 | 0.393283 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 15189.2 | 0.292404 | 20 | 797 | 4653.75 | ø20 | 26.9 | 21.6 | TR02.02.0615 | 0615 | yes | HT_vratné vodní (45 °C) 1 | 0
13099360 | 4.NP_SO-102 | 2143.69 | 0.000568237 | 0.181161 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 15189.2 | 0.134692 | 20 | 484 | 2143.69 | ø20 | 26.9 | 21.6 | TR02.02.0616 | 0616 | yes | HT_vratné vodní (45 °C) 1 | 0
13099619 | 4.NP_SO-102 | 3195.14 | 0.000356274 | 0.213806 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3165.87 | 3165.87 | -29.2688 | -29.2688 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11970.7 | 0.150567 | 15 | 798 | 3195.14 | ø15 | 21.3 | 16 | TR02.02.0619 | 0619 | yes | HT_vratné vodní (45 °C) 1
13099653 | 4.NP_SO-102 | 583.583 | 0.000891835 | 0.0617849 | 0 | ø25 mm | 0.00367647 | HD | 4.NP_SO-102 | 3216.85 | 3200 | 3200 | 3183.15 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 15186.4 | 0.0458345 | 25 | 404 | 583.583 | ø25 | 33.7 | 27.2 | TR02.02.0620 | 0620 | yes | HT_vratné vodní (45 °C) 1 | 0
13099665 | 4.NP_SO-102 | 152.18 | 0.000891835 | 0.0161115 | 0 | ø25 mm | 0.00367647 | HD | 4.NP_SO-102 | 3216.85 | 3200 | 3200 | 3183.15 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 15186.4 | 0.0119522 | 25 | 420 | 152.18 | ø25 | 33.7 | 27.2 | TR02.02.0621 | 0621 | yes | HT_vratné vodní (45 °C) 1 | 0
13099702 | 4.NP_SO-102 | 3295.14 | 0.000356274 | 0.220497 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3265.87 | 3265.87 | -29.2688 | -29.2688 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 11970.7 | 0.15528 | 15 | 549 | 3295.14 | ø15 | 21.3 | 16 | TR02.02.0622 | 0622 | yes | HT_přívodní vodní (55 °C) 9
13099750 | 4.NP_SO-102 | 313.583 | 0.000891835 | 0.0331996 | 0 | ø25 mm | 0.00367647 | HD | 4.NP_SO-102 | 3316.85 | 3300 | 3300 | 3283.15 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 15286.4 | 0.0246288 | 25 | 65 | 313.583 | ø25 | 33.7 | 27.2 | TR02.02.0623 | 0623 | yes | HT_přívodní vodní (55 °C) 9 | 0
13099937 | 2.NP_SO-102 | 2058.43 | 0.000568237 | 0.173956 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2833.45 | 2820 | 2820 | 2806.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 6809.2 | 0.129335 | 20 | 409 | 2058.43 | ø20 | 26.9 | 21.6 | TR02.02.0627 | 0627 | no | HT_vratné vodní (45 °C) 13 | 0
13100537 | 2.NP_SO-102 | 27.5375 | 0.000568237 | 0.00232716 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3113.45 | 3100 | 3100 | 3086.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7089.2 | 0.00173023 | 20 | 409 | 27.5375 | ø20 | 26.9 | 21.6 | TR02.02.0634 | 0634 | yes | HT_vratné vodní (45 °C) 13 | 0
13100546 | 2.NP_SO-102 | 300.395 | 0.000568237 | 0.025386 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3263.45 | 3250 | 3250 | 3236.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7239.2 | 0.0188744 | 20 | 392 | 300.395 | ø20 | 26.9 | 21.6 | TR02.02.0635 | 0635 | yes | HT_vratné vodní (45 °C) 13 | 0
13101122 | 2.NP_SO-102 | 3256.34 | 0.000356274 | 0.217901 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 3220.63 | -35.7125 | 3220.63 | -35.7125 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 3964.29 | 0.153452 | 15 | 22 | 3256.34 | ø15 | 21.3 | 16 | TR02.02.0640 | 0640 | no | HT_vratné vodní (45 °C) 13
13101125 | 2.NP_SO-102 | 583.373 | 0.000568237 | 0.0493001 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3263.45 | 3250 | 3250 | 3236.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7239.2 | 0.0366544 | 20 | 393 | 583.373 | ø20 | 26.9 | 21.6 | TR02.02.0641 | 0641 | yes | HT_vratné vodní (45 °C) 13 | 0
13101170 | 3.NP_SO-102 | 4089.68 | 0.00183197 | 0.620563 | 0 | ø40 mm | 0.00239234 | HD | 3.NP_SO-102 | 7173.01 | 7173.01 | 3083.34 | 3083.34 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 11083.3 | 0.513924 | 40 | 62 | 4089.68 | ø40 | 48.3 | 41.8 | TR02.02.0642 | 0642 | yes | HT_vratné vodní (45 °C) 13
13102383 | 1.NP_SO-102 | 2145.08 | 0.000568237 | 0.181278 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 3189.2 | 0.134779 | 20 | 388 | 2145.08 | ø20 | 26.9 | 21.6 | TR02.02.0647 | 0647 | yes | HT_vratné vodní (45 °C) 13 | 0
13102392 | 1.NP_SO-102 | 906.138 | 0.000568237 | 0.0765766 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 3189.2 | 0.0569343 | 20 | 388 | 906.138 | ø20 | 26.9 | 21.6 | TR02.02.0648 | 0648 | yes | HT_vratné vodní (45 °C) 13 | 0
13103204 | 1.NP_SO-102 | 291.579 | 0.000891835 | 0.0308699 | 0 | ø25 mm | 0.00367647 | HD | 1.NP_SO-102 | 3216.85 | 3200 | 3200 | 3183.15 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 3186.4 | 0.0229005 | 25 | 50 | 291.579 | ø25 | 33.7 | 27.2 | TR02.02.0658 | 0658 | yes | HT_vratné vodní (45 °C) 13 | 0
