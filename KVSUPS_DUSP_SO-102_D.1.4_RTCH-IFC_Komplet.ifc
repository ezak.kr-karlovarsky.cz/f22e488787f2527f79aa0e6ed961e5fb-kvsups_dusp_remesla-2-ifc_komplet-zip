Properties of the parts of a building model (IFC4), part 70 of 72

# IfcPipeSegment: Typy trubek:Ocel_černá (499)
Name (Typy trubek:Ocel_černá:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Celková velikost | Tloušťka izolace (mm) | Relativní drsnost | CCI Technický systém | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Sklon | Spodní výška (mm) | Fáze vytvoření | Klasifikace systému | Název systému | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) | Řez | Typ systému | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group
13219153 | 2.NP_SO-102 | 1107.93 | 0.00620623 | 0.30943 | ø80 mm | 0 | 0.00123762 | HD | 2853.96 | 1746.04 | 2853.96 | 2.NP_SO-102 |  | 1746.04 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 5746.04 | 0.278452 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1392 | 1392 | yes | HT_vratné vodní (45 °C) 39
13219274 | 2.NP_SO-102 | 40 | 0.00620623 | 0.0111715 | ø80 mm | 0 | 0.00123762 | HD | 344.45 | 300 | 300 | 2.NP_SO-102 | 0 | 255.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 4259.6 | 0.0100531 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1393 | 1393 | yes | HT_vratné vodní (45 °C) 39
13219439 | 2.NP_SO-102 | 1945.07 | 0.00454772 | 0.465018 | ø65 mm | 0 | 0.00145138 | HD | 2538.05 | 2500 | 2500 | 2.NP_SO-102 | 0 | 2461.95 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (45 °C) 5 | 6465.55 | 0.39719 | 65 | 2 | HT_přívodní vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1394 | 1394 | yes | HT_přívodní vodní (45 °C) 5
13219447 | 2.NP_SO-102 | 85.3125 | 0.00454772 | 0.0203961 | ø65 mm | 0 | 0.00145138 | HD | 1038.05 | 1000 | 1000 | 2.NP_SO-102 | 0 | 961.95 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (45 °C) 5 | 4965.55 | 0.0174211 | 65 | 2 | HT_přívodní vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1395 | 1395 | yes | HT_přívodní vodní (45 °C) 5
13219544 | 2.NP_SO-102 | 1420.63 | 0.00454772 | 0.339636 | ø65 mm | 0 | 0.00145138 | HD | 2460.31 | 2460.31 | 1039.69 | 2.NP_SO-102 |  | 1039.69 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (45 °C) 5 | 5039.69 | 0.290097 | 65 | 2 | HT_přívodní vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1396 | 1396 | yes | HT_přívodní vodní (45 °C) 5
13219709 | 2.NP_SO-102 | 25.3997 | 0.00915951 | 0.00861793 | ø100 mm | 0 | 0.001 | HD | 758 | 704 | 704 | 2.NP_SO-102 | 0 | 650 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (45 °C) 5 | 4654 | 0.00797956 | 100 | 1 | HT_přívodní vodní (45 °C) | ø100 | 108 | 100 | TR02.01.1397 | 1397 | yes | HT_přívodní vodní (45 °C) 5
13219710 | 2.NP_SO-102 | 1716.63 | 0.00454772 | 0.410402 | ø65 mm | 0 | 0.00145138 | HD | 2460.31 | 2460.31 | 743.687 | 2.NP_SO-102 |  | 743.687 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (45 °C) 5 | 4743.69 | 0.350541 | 65 | 2 | HT_přívodní vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1398 | 1398 | yes | HT_přívodní vodní (45 °C) 5
13219822 | 2.NP_SO-102 | 1709.84 | 0.00454772 | 0.408781 | ø65 mm | 0 | 0.00145138 | HD | 338.05 | 300 | 300 | 2.NP_SO-102 | 0 | 261.95 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 5 | 4265.55 | 0.349156 | 65 | 2 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1399 | 1399 | yes | HT_vratné vodní (45 °C) 5
13219950 | 2.NP_SO-102 | 243.424 | 0.00454772 | 0.0581967 | ø65 mm | 0 | 0.00145138 | HD | 338.05 | 300 | 300 | 2.NP_SO-102 | 0 | 261.95 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 5 | 4265.55 | 0.0497081 | 65 | 2 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1400 | 1400 | yes | HT_vratné vodní (45 °C) 5
13219962 | 2.NP_SO-102 | 25.3999 | 0.0138908 | 0.0106129 | ø125 mm | 0 | 0.0008 | HD | 1066.5 | 1000 | 1000 | 2.NP_SO-102 | 0 | 933.5 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 5 | 4937.5 | 0.00997453 | 125 | 1 | HT_vratné vodní (45 °C) | ø125 | 133 | 125 | TR02.01.1401 | 1401 | yes | HT_vratné vodní (45 °C) 5
13219963 | 2.NP_SO-102 | 620.625 | 0.00454772 | 0.148376 | ø65 mm | 0 | 0.00145138 | HD | 960.312 | 339.687 | 960.313 | 2.NP_SO-102 |  | 339.687 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 5 | 4339.69 | 0.126734 | 65 | 2 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1402 | 1402 | yes | HT_vratné vodní (45 °C) 5
13220548 | 2.NP_SO-102 | 6854.46 | 0.00454772 | 1.63873 | ø65 mm | 0 | 0.00145138 | HD | 2838.05 | 2800 | 2800 | 2.NP_SO-102 | 0 | 2761.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 6765.55 | 1.39971 | 65 | 67 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1403 | 1403 | yes | HT_PRIMÁR_vratné 7
13220580 | 2.NP_SO-102 | 7288.58 | 0.00454772 | 1.74252 | ø65 mm | 0 | 0.00145138 | HD | 2838.05 | 2800 | 2800 | 2.NP_SO-102 | 0 | 2761.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 6765.55 | 1.48835 | 65 | 62 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.1404 | 1404 | yes | HT_PRIMÁR_přívodní 3
13220924 | 2.NP_SO-102 | 7793.46 | 0.00454772 | 1.86322 | ø65 mm | 0 | 0.00145138 | HD | 2788.05 | 2750 | 2750 | 2.NP_SO-102 | 0 | 2711.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 6715.55 | 1.59145 | 65 | 70 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1405 | 1405 | yes | HT_PRIMÁR_vratné 3
13221661 | 2.NP_SO-102 | 1020.31 | 0.00454772 | 0.243931 | ø65 mm | 0 | 0.00145138 | HD | 338.05 | 300 | 300 | 2.NP_SO-102 | 0 | 261.95 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 13 | 4265.55 | 0.208351 | 65 | 4 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.1406 | 1406 | yes | HT_přívodní vodní (55 °C) 13
13221687 | 2.NP_SO-102 | 340.313 | 0.00454772 | 0.0813603 | ø65 mm | 0 | 0.00145138 | HD | 338.05 | 300 | 300 | 2.NP_SO-102 | 0 | 261.95 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 26 | 4265.55 | 0.069493 | 65 | 4 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.1407 | 1407 | yes | HT_přívodní vodní (55 °C) 26
13221696 | 2.NP_SO-102 | 3599.82 | 0.00454772 | 0.860629 | ø65 mm | 0 | 0.00145138 | HD | 2538.05 | 2500 | 2500 | 2.NP_SO-102 | 0 | 2461.95 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 26 | 6465.55 | 0.735097 | 65 | 2 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.1408 | 1408 | yes | HT_přívodní vodní (55 °C) 26
13221751 | 2.NP_SO-102 | 1020.31 | 0.00454772 | 0.243931 | ø65 mm | 0 | 0.00145138 | HD | 338.05 | 300 | 300 | 2.NP_SO-102 | 0 | 261.95 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 20 | 4265.55 | 0.208351 | 65 | 4 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1409 | 1409 | yes | HT_vratné vodní (45 °C) 20
13221773 | 2.NP_SO-102 | 3689.82 | 0.00454772 | 0.882145 | ø65 mm | 0 | 0.00145138 | HD | 2688.05 | 2650 | 2650 | 2.NP_SO-102 | 0 | 2611.95 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 20 | 6615.55 | 0.753475 | 65 | 2 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1410 | 1410 | yes | HT_vratné vodní (45 °C) 20
13221796 | 2.NP_SO-102 | 340.313 | 0.00454772 | 0.0813603 | ø65 mm | 0 | 0.00145138 | HD | 338.05 | 300 | 300 | 2.NP_SO-102 | 0 | 261.95 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 21 | 4265.55 | 0.069493 | 65 | 4 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1411 | 1411 | yes | HT_vratné vodní (45 °C) 21
13221805 | 2.NP_SO-102 | 4189.82 | 0.00454772 | 1.00168 | ø65 mm | 0 | 0.00145138 | HD | 2538.05 | 2500 | 2500 | 2.NP_SO-102 | 0 | 2461.95 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 21 | 6465.55 | 0.855577 | 65 | 2 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1412 | 1412 | yes | HT_vratné vodní (45 °C) 21
13222478 | 2.NP_SO-102 | 2120.63 | 0.00454772 | 0.506989 | ø65 mm | 0 | 0.00145138 | HD | 2460.31 | 2460.31 | 339.687 | 2.NP_SO-102 |  | 339.687 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 13 | 4339.69 | 0.433039 | 65 | 4 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.1413 | 1413 | yes | HT_přívodní vodní (55 °C) 13
13222511 | 2.NP_SO-102 | 2270.63 | 0.00454772 | 0.54285 | ø65 mm | 0 | 0.00145138 | HD | 2610.31 | 2610.31 | 339.687 | 2.NP_SO-102 |  | 339.687 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 20 | 4339.69 | 0.46367 | 65 | 4 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1414 | 1414 | yes | HT_vratné vodní (45 °C) 20
13222544 | 2.NP_SO-102 | 2120.63 | 0.00454772 | 0.506989 | ø65 mm | 0 | 0.00145138 | HD | 2460.31 | 2460.31 | 339.687 | 2.NP_SO-102 |  | 339.687 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 26 | 4339.69 | 0.433039 | 65 | 4 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.1415 | 1415 | yes | HT_přívodní vodní (55 °C) 26
13222577 | 2.NP_SO-102 | 2120.63 | 0.00454772 | 0.506989 | ø65 mm | 0 | 0.00145138 | HD | 2460.31 | 2460.31 | 339.687 | 2.NP_SO-102 |  | 339.687 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 21 | 4339.69 | 0.433039 | 65 | 4 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1416 | 1416 | yes | HT_vratné vodní (45 °C) 21
13222731 | 2.NP_SO-102 | 4284.9 | 0.00620623 | 1.19672 | ø200 mm | 60 | 0.00123762 | HD | 1944.45 | 1900 | 1900 | 2.NP_SO-102 | 0 | 1855.55 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 5859.6 | 1.07691 | 80 | 71 | HT_PRIMÁR_přívodní | ø80 | 88.9 | 80.8 | TR02.01.1417 | 1417 | yes | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
13222919 | 2.NP_SO-102 | 1311.92 | 0.0138908 | 0.548161 | ø125 mm | 0 | 0.0008 | HD | 2521.42 | 2521.42 | 1209.5 | 2.NP_SO-102 |  | 1209.5 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 5209.5 | 0.515189 | 125 | 1 | HT_vratné vodní (45 °C) | ø125 | 133 | 125 | TR02.01.1418 | 1418 | yes | HT_vratné vodní (45 °C) 23
13222965 | 2.NP_SO-102 | 1361.92 | 0.0138908 | 0.569053 | ø125 mm | 0 | 0.0008 | HD | 2571.42 | 2571.42 | 1209.5 | 2.NP_SO-102 |  | 1209.5 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 5209.5 | 0.534824 | 125 | 1 | HT_přívodní vodní (65 °C) | ø125 | 133 | 125 | TR02.01.1419 | 1419 | yes | HT_přívodní vodní (65 °C) 8
13222992 | 2.NP_SO-102 | 1250.81 | 0.00454772 | 0.299038 | ø65 mm | 0 | 0.00145138 | HD | 2460.31 | 2460.31 | 1209.5 | 2.NP_SO-102 |  | 1209.5 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 21 | 5209.5 | 0.25542 | 65 | 2 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1420 | 1420 | yes | HT_vratné vodní (45 °C) 21
13223023 | 2.NP_SO-102 | 1250.81 | 0.00454772 | 0.299038 | ø65 mm | 0 | 0.00145138 | HD | 2460.31 | 2460.31 | 1209.5 | 2.NP_SO-102 |  | 1209.5 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 26 | 5209.5 | 0.25542 | 65 | 2 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.1421 | 1421 | yes | HT_přívodní vodní (55 °C) 26
13223057 | 2.NP_SO-102 | 1400.81 | 0.00454772 | 0.3349 | ø65 mm | 0 | 0.00145138 | HD | 2610.31 | 2610.31 | 1209.5 | 2.NP_SO-102 |  | 1209.5 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 20 | 5209.5 | 0.286051 | 65 | 2 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1422 | 1422 | yes | HT_vratné vodní (45 °C) 20
13223091 | 2.NP_SO-102 | 1250.81 | 0.00454772 | 0.299038 | ø65 mm | 0 | 0.00145138 | HD | 2460.31 | 2460.31 | 1209.5 | 2.NP_SO-102 |  | 1209.5 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 13 | 5209.5 | 0.25542 | 65 | 1 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.1423 | 1423 | yes | HT_přívodní vodní (55 °C) 13
13223349 | 2.NP_SO-102 | 1011.03 | 0.00620623 | 0.282367 | ø80 mm | 0 | 0.00123762 | HD | 2694.45 | 2650 | 2650 | 2.NP_SO-102 | 0 | 2605.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 6609.6 | 0.254099 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.1425 | 1425 | yes | HT_přívodní vodní (65 °C) 8
13223687 | 2.NP_SO-102 | 1261.03 | 0.00620623 | 0.352189 | ø80 mm | 0 | 0.00123762 | HD | 2644.45 | 2600 | 2600 | 2.NP_SO-102 | 0 | 2555.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 6559.6 | 0.31693 | 80 | 2 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1428 | 1428 | yes | HT_vratné vodní (45 °C) 23
13226188 | 2.NP_SO-102 | 6112.38 | 0.00620623 | 1.70711 | ø80 mm | 0 | 0.00123762 | HD | 2344.45 | 2300 | 2300 | 2.NP_SO-102 | 0 | 2255.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6259.6 | 1.53621 | 80 | 356 | HT_přívodní vodní (55 °C) | ø80 | 88.9 | 80.8 | TR02.01.1431 | 1431 | yes | HT_přívodní vodní (55 °C) 9
13226211 | 2.NP_SO-102 | 6161.49 | 0.00620623 | 1.72083 | ø80 mm | 0 | 0.00123762 | HD | 2344.45 | 2300 | 2300 | 2.NP_SO-102 | 0 | 2255.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6259.6 | 1.54855 | 80 | 516 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1433 | 1433 | yes | HT_vratné vodní (45 °C) 1
13227602 | 2.NP_SO-102 | 575.185 | 0.00454772 | 0.137512 | ø65 mm | 0 | 0.00145138 | HD | 3138.05 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3061.95 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 7065.55 | 0.117455 | 65 | 10 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1439 | 1439 | yes | HT_vratné vodní (45 °C) 7
13227698 | 2.NP_SO-102 | 2720.63 | 0.00454772 | 0.650434 | ø65 mm | 0 | 0.00145138 | HD | 3060.31 | 3060.31 | 339.687 | 2.NP_SO-102 |  | 339.687 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 4339.69 | 0.555561 | 65 | 9 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1440 | 1440 | yes | HT_vratné vodní (45 °C) 7
13227842 | 2.NP_SO-102 | 94.5876 | 0.00454772 | 0.0226136 | ø65 mm | 0 | 0.00145138 | HD | 3138.05 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3061.95 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 7065.55 | 0.0193151 | 65 | 3 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1441 | 1441 | yes | HT_vratné vodní (45 °C) 7
13227855 | 2.NP_SO-102 | 2803.01 | 0.00454772 | 0.670129 | ø65 mm | 0 | 0.00145138 | HD | 3060.31 | 3060.31 | 257.306 | 2.NP_SO-102 |  | 257.306 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 4257.31 | 0.572384 | 65 | 3 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1442 | 1442 | yes | HT_vratné vodní (45 °C) 7
13227866 | 2.NP_SO-102 | 192.663 | 0.00454772 | 0.0460609 | ø65 mm | 0 | 0.00145138 | HD | 3138.05 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3061.95 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 7065.55 | 0.0393425 | 65 | 3 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1443 | 1443 | yes | HT_vratné vodní (45 °C) 7
13227877 | 2.NP_SO-102 | 2628 | 0.00454772 | 0.628289 | ø65 mm | 0 | 0.00145138 | HD | 3138.05 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3061.95 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 7065.55 | 0.536646 | 65 | 9 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1444 | 1444 | yes | HT_vratné vodní (45 °C) 7
13227930 | 2.NP_SO-102 | 722.994 | 0.00454772 | 0.17285 | ø65 mm | 0 | 0.00145138 | HD | 3138.05 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3061.95 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 7065.55 | 0.147638 | 65 | 10 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1445 | 1445 | yes | HT_vratné vodní (45 °C) 7
13227999 | 2.NP_SO-102 | 25.3999 | 0.00454772 | 0.0060725 | ø65 mm | 0 | 0.00145138 | HD | 1038.05 | 1000 | 1000 | 2.NP_SO-102 | 0 | 961.95 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 4965.55 | 0.00518676 | 65 | 10 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1446 | 1446 | yes | HT_vratné vodní (45 °C) 7
13229487 | 2.NP_SO-102 | 406.571 | 0.00915951 | 0.137946 | ø100 mm | 0 | 0.001 | HC | 1054 | 1000 | 1000 | 2.NP_SO-102 | 0 | 946 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 2 | 4950 | 0.127728 | 100 | 1 | CL_přívodní vodní (10 °C) | ø100 | 108 | 100 | TR02.01.1447 | 1447 | yes | CL_přívodní vodní (10 °C) 2
13229496 | 2.NP_SO-102 | 530.496 | 0.00915951 | 0.179993 | ø100 mm | 0 | 0.001 | HC | 1054 | 1000 | 1000 | 2.NP_SO-102 | 0 | 946 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 2 | 4950 | 0.16666 | 100 | 1 | CL_přívodní vodní (10 °C) | ø100 | 108 | 100 | TR02.01.1448 | 1448 | yes | CL_přívodní vodní (10 °C) 2
13229523 | 2.NP_SO-102 | 975.67 | 0.00915951 | 0.331037 | ø100 mm | 0 | 0.001 | HC | 1054 | 1000 | 1000 | 2.NP_SO-102 | 0 | 946 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 4950 | 0.306516 | 100 | 1 | CL_vratné vodní (15 °C) | ø100 | 108 | 100 | TR02.01.1449 | 1449 | yes | CL_vratné vodní (15 °C) 1
13229532 | 2.NP_SO-102 | 109.387 | 0.00915951 | 0.0371143 | ø100 mm | 0 | 0.001 | HC | 1054 | 1000 | 1000 | 2.NP_SO-102 | 0 | 946 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 1 | 4950 | 0.0343651 | 100 | 1 | CL_vratné vodní (15 °C) | ø100 | 108 | 100 | TR02.01.1450 | 1450 | yes | CL_vratné vodní (15 °C) 1
13229649 | 2.NP_SO-102 | 761.263 | 0.00915951 | 0.25829 | ø100 mm | 0 | 0.001 | HC | 754 | 700 | 700 | 2.NP_SO-102 | 0 | 646 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 3 | 4650 | 0.239158 | 100 | 1 | CL_přívodní vodní (10 °C) | ø100 | 108 | 100 | TR02.01.1451 | 1451 | yes | CL_přívodní vodní (10 °C) 3
13229656 | 2.NP_SO-102 | 41.2625 | 0.00915951 | 0.014 | ø100 mm | 0 | 0.001 | HC | 1054 | 1000 | 1000 | 2.NP_SO-102 | 0 | 946 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 3 | 4950 | 0.012963 | 100 | 1 | CL_přívodní vodní (10 °C) | ø100 | 108 | 100 | TR02.01.1452 | 1452 | yes | CL_přívodní vodní (10 °C) 3
13229682 | 2.NP_SO-102 | 72.5207 | 0.00915951 | 0.0246057 | ø100 mm | 0 | 0.001 | HC | 1754 | 1700 | 1700 | 2.NP_SO-102 | 0 | 1646 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 3 | 5650 | 0.0227831 | 100 | 4 | CL_vratné vodní (15 °C) | ø100 | 108 | 100 | TR02.01.1453 | 1453 | yes | CL_vratné vodní (15 °C) 3
13229691 | 2.NP_SO-102 | 301.263 | 0.00915951 | 0.102216 | ø100 mm | 0 | 0.001 | HC | 1054 | 1000 | 1000 | 2.NP_SO-102 | 0 | 946 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 3 | 4950 | 0.0946444 | 100 | 1 | CL_vratné vodní (15 °C) | ø100 | 108 | 100 | TR02.01.1454 | 1454 | yes | CL_vratné vodní (15 °C) 3
13229895 | 2.NP_SO-102 | 182.525 | 0.00915951 | 0.0619293 | ø100 mm | 0 | 0.001 | HC | 941.262 | 758.737 | 941.263 | 2.NP_SO-102 |  | 758.737 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 3 | 4758.74 | 0.0573419 | 100 | 1 | CL_přívodní vodní (10 °C) | ø100 | 108 | 100 | TR02.01.1455 | 1455 | yes | CL_přívodní vodní (10 °C) 3
13229973 | 2.NP_SO-102 | 582.525 | 0.00915951 | 0.197646 | ø100 mm | 0 | 0.001 | HC | 1641.26 | 1641.26 | 1058.74 | 2.NP_SO-102 |  | 1058.74 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 3 | 5058.74 | 0.183006 | 100 | 1 | CL_vratné vodní (15 °C) | ø100 | 108 | 100 | TR02.01.1456 | 1456 | yes | CL_vratné vodní (15 °C) 3
13242894 | 2.NP_SO-102 | 1198.28 | 0.00454772 | 0.286479 | ø65 mm | 0 | 0.00145138 | HC | 3038.05 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2961.95 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 4 | 6965.55 | 0.244693 | 65 | 3 | CL_vratné vodní (15 °C) | ø65 | 76.1 | 68.9 | TR02.01.1470 | 1470 | yes | CL_vratné vodní (15 °C) 4
13242964 | 2.NP_SO-102 | 1228.28 | 0.00454772 | 0.293651 | ø65 mm | 0 | 0.00145138 | HC | 3038.05 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2961.95 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 7 | 6965.55 | 0.250819 | 65 | 3 | CL_přívodní vodní (10 °C) | ø65 | 76.1 | 68.9 | TR02.01.1471 | 1471 | yes | CL_přívodní vodní (10 °C) 7
13243310 | 2.NP_SO-102 | 3890.58 | 0.00620623 | 1.08659 | ø200 mm | 60 | 0.00123762 | HD | 1744.45 | 1700 | 1700 | 2.NP_SO-102 | 0 | 1655.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 5659.6 | 0.97781 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1472 | 1472 | yes | HT_vratné vodní (45 °C) 39 | Izolace - Typ izolace: Tepelná
13243321 | 2.NP_SO-102 | 733.705 | 0.00620623 | 0.204915 | ø80 mm | 0 | 0.00123762 | HD | 1744.45 | 1700 | 1700 | 2.NP_SO-102 | 0 | 1655.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 5659.6 | 0.1844 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1473 | 1473 | yes | HT_vratné vodní (45 °C) 39
13243405 | 2.NP_SO-102 | 3890.58 | 0.00620623 | 1.08659 | ø200 mm | 60 | 0.00123762 | HD | 1744.45 | 1700 | 1700 | 2.NP_SO-102 | 0 | 1655.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 5659.6 | 0.97781 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.1474 | 1474 | yes | HT_přívodní vodní (65 °C) 5 | Izolace - Typ izolace: Tepelná
13243414 | 2.NP_SO-102 | 821.793 | 0.00620623 | 0.229517 | ø80 mm | 0 | 0.00123762 | HD | 1744.45 | 1700 | 1700 | 2.NP_SO-102 | 0 | 1655.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 5659.6 | 0.206539 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.1475 | 1475 | yes | HT_přívodní vodní (65 °C) 5
13243631 | 2.NP_SO-102 | 1713.01 | 0.00620623 | 0.478421 | ø80 mm | 0 | 0.00123762 | HD | 2944.45 | 2900 | 2900 | 2.NP_SO-102 | 0 | 2855.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 6859.6 | 0.430526 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1476 | 1476 | yes | HT_vratné vodní (45 °C) 39
13243639 | 2.NP_SO-102 | 1427.93 | 0.00620623 | 0.398802 | ø80 mm | 0 | 0.00123762 | HD | 2944.45 | 2900 | 2900 | 2.NP_SO-102 | 0 | 2855.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 6859.6 | 0.358877 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1477 | 1477 | yes | HT_vratné vodní (45 °C) 39
13243662 | 2.NP_SO-102 | 1703.01 | 0.00620623 | 0.475629 | ø80 mm | 0 | 0.00123762 | HD | 2944.45 | 2900 | 2900 | 2.NP_SO-102 | 0 | 2855.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 6859.6 | 0.428012 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.1478 | 1478 | yes | HT_přívodní vodní (65 °C) 5
13243670 | 2.NP_SO-102 | 1339.84 | 0.00620623 | 0.3742 | ø80 mm | 0 | 0.00123762 | HD | 2944.45 | 2900 | 2900 | 2.NP_SO-102 | 0 | 2855.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 6859.6 | 0.336738 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.1479 | 1479 | yes | HT_přívodní vodní (65 °C) 5
13243698 | 2.NP_SO-102 | 3165.79 | 0.00454772 | 0.756862 | ø65 mm | 0 | 0.00145138 | HC | 2738.05 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2661.95 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 5 | 6665.55 | 0.646466 | 65 | 1 | CL_přívodní vodní (10 °C) | ø65 | 76.1 | 68.9 | TR02.01.1480 | 1480 | yes | CL_přívodní vodní (10 °C) 5
13243707 | 2.NP_SO-102 | 2353.28 | 0.00454772 | 0.562611 | ø65 mm | 0 | 0.00145138 | HC | 2738.05 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2661.95 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 5 | 6665.55 | 0.480548 | 65 | 1 | CL_přívodní vodní (10 °C) | ø65 | 76.1 | 68.9 | TR02.01.1481 | 1481 | yes | CL_přívodní vodní (10 °C) 5
13243717 | 2.NP_SO-102 | 722.978 | 0.00454772 | 0.172846 | ø65 mm | 0 | 0.00145138 | HC | 2738.05 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2661.95 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 5 | 6665.55 | 0.147635 | 65 | 1 | CL_přívodní vodní (10 °C) | ø65 | 76.1 | 68.9 | TR02.01.1482 | 1482 | yes | CL_přívodní vodní (10 °C) 5
13243807 | 2.NP_SO-102 | 3245.79 | 0.00454772 | 0.775988 | ø65 mm | 0 | 0.00145138 | HC | 2738.05 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2661.95 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 5 | 6665.55 | 0.662802 | 65 | 1 | CL_vratné vodní (15 °C) | ø65 | 76.1 | 68.9 | TR02.01.1483 | 1483 | yes | CL_vratné vodní (15 °C) 5
13243816 | 2.NP_SO-102 | 2659.44 | 0.00454772 | 0.635806 | ø65 mm | 0 | 0.00145138 | HC | 2538.05 | 2500 | 2500 | 2.NP_SO-102 | 0 | 2461.95 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 6 | 6465.55 | 0.543067 | 65 | 1 | CL_přívodní vodní (10 °C) | ø65 | 76.1 | 68.9 | TR02.01.1484 | 1484 | yes | HT_přívodní vodní (55 °C) 13; CL_přívodní vodní (10 °C) 6
13243825 | 2.NP_SO-102 | 2745.79 | 0.00454772 | 0.656451 | ø65 mm | 0 | 0.00145138 | HC | 2588.05 | 2550 | 2550 | 2.NP_SO-102 | 0 | 2511.95 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 6 | 6515.55 | 0.5607 | 65 | 1 | CL_vratné vodní (15 °C) | ø65 | 76.1 | 68.9 | TR02.01.1485 | 1485 | yes | CL_vratné vodní (15 °C) 6
13243909 | 2.NP_SO-102 | 222.978 | 0.00454772 | 0.0533084 | ø65 mm | 0 | 0.00145138 | HC | 2738.05 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2661.95 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 5 | 6665.55 | 0.0455328 | 65 | 1 | CL_vratné vodní (15 °C) | ø65 | 76.1 | 68.9 | TR02.01.1486 | 1486 | yes | CL_vratné vodní (15 °C) 5
13243927 | 2.NP_SO-102 | 722.978 | 0.00454772 | 0.172846 | ø65 mm | 0 | 0.00145138 | HC | 2538.05 | 2500 | 2500 | 2.NP_SO-102 | 0 | 2461.95 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 6 | 6465.55 | 0.147635 | 65 | 1 | CL_přívodní vodní (10 °C) | ø65 | 76.1 | 68.9 | TR02.01.1487 | 1487 | yes | CL_přívodní vodní (10 °C) 6
13243936 | 2.NP_SO-102 | 222.978 | 0.00454772 | 0.0533084 | ø65 mm | 0 | 0.00145138 | HC | 2588.05 | 2550 | 2550 | 2.NP_SO-102 | 0 | 2511.95 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 6 | 6515.55 | 0.0455328 | 65 | 1 | CL_vratné vodní (15 °C) | ø65 | 76.1 | 68.9 | TR02.01.1488 | 1488 | yes | CL_vratné vodní (15 °C) 6
13243959 | 2.NP_SO-102 | 1823.28 | 0.00454772 | 0.435901 | ø65 mm | 0 | 0.00145138 | HC | 2738.05 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2661.95 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 5 | 6665.55 | 0.37232 | 65 | 1 | CL_vratné vodní (15 °C) | ø65 | 76.1 | 68.9 | TR02.01.1489 | 1489 | yes | CL_vratné vodní (15 °C) 5
13243968 | 2.NP_SO-102 | 2353.28 | 0.00454772 | 0.562611 | ø65 mm | 0 | 0.00145138 | HC | 2538.05 | 2500 | 2500 | 2.NP_SO-102 | 0 | 2461.95 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 6 | 6465.55 | 0.480548 | 65 | 1 | CL_přívodní vodní (10 °C) | ø65 | 76.1 | 68.9 | TR02.01.1490 | 1490 | yes | CL_přívodní vodní (10 °C) 6
13243977 | 2.NP_SO-102 | 1823.28 | 0.00454772 | 0.435901 | ø65 mm | 0 | 0.00145138 | HC | 2588.05 | 2550 | 2550 | 2.NP_SO-102 | 0 | 2511.95 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 6 | 6515.55 | 0.37232 | 65 | 1 | CL_vratné vodní (15 °C) | ø65 | 76.1 | 68.9 | TR02.01.1491 | 1491 | yes | CL_vratné vodní (15 °C) 6
13245479 | 2.NP_SO-102 | 1692.08 | 0.00915951 | 0.574108 | ø100 mm | 0 | 0.001 | HC | 2934.12 | 2934.12 | 1242.04 | 2.NP_SO-102 |  | 1242.04 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 4 | 5242.04 | 0.531581 | 100 | 2 | CL_vratné vodní (15 °C) | ø100 | 108 | 100 | TR02.01.1492 | 1492 | yes | CL_vratné vodní (15 °C) 4
13245511 | 2.NP_SO-102 | 1300.81 | 0.00454772 | 0.310992 | ø65 mm | 0 | 0.00145138 | HC | 2510.31 | 2510.31 | 1209.5 | 2.NP_SO-102 |  | 1209.5 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 6 | 5209.5 | 0.26563 | 65 | 1 | CL_vratné vodní (15 °C) | ø65 | 76.1 | 68.9 | TR02.01.1493 | 1493 | yes | CL_vratné vodní (15 °C) 6
13245543 | 2.NP_SO-102 | 1450.81 | 0.00454772 | 0.346853 | ø65 mm | 0 | 0.00145138 | HC | 2660.31 | 2660.31 | 1209.5 | 2.NP_SO-102 |  | 1209.5 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 5 | 5209.5 | 0.296261 | 65 | 1 | CL_vratné vodní (15 °C) | ø65 | 76.1 | 68.9 | TR02.01.1494 | 1494 | yes | CL_vratné vodní (15 °C) 5
13245609 | 2.NP_SO-102 | 1250.81 | 0.00454772 | 0.299038 | ø65 mm | 0 | 0.00145138 | HC | 2460.31 | 2460.31 | 1209.5 | 2.NP_SO-102 |  | 1209.5 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 6 | 5209.5 | 0.25542 | 65 | 1 | CL_přívodní vodní (10 °C) | ø65 | 76.1 | 68.9 | TR02.01.1495 | 1495 | yes | CL_přívodní vodní (10 °C) 6
13245639 | 2.NP_SO-102 | 1692.07 | 0.00915951 | 0.574108 | ø100 mm | 0 | 0.001 | HC | 2934.12 | 2934.12 | 1242.04 | 2.NP_SO-102 |  | 1242.04 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 7 | 5242.04 | 0.531581 | 100 | 2 | CL_přívodní vodní (10 °C) | ø100 | 108 | 100 | TR02.01.1496 | 1496 | yes | CL_přívodní vodní (10 °C) 7
13245768 | 2.NP_SO-102 | 1450.81 | 0.00454772 | 0.346853 | ø65 mm | 0 | 0.00145138 | HC | 2660.31 | 2660.31 | 1209.5 | 2.NP_SO-102 |  | 1209.5 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 5 | 5209.5 | 0.296261 | 65 | 1 | CL_přívodní vodní (10 °C) | ø65 | 76.1 | 68.9 | TR02.01.1497 | 1497 | yes | CL_přívodní vodní (10 °C) 5
13246021 | 2.NP_SO-102 | 3125.97 | 0.00454772 | 0.747341 | ø65 mm | 0 | 0.00145138 | HD | 2438.05 | 2400 | 2400 | 2.NP_SO-102 | 0 | 2361.95 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 1 | 6365.55 | 0.638333 | 65 | 2 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.1498 | 1498 | yes | HT_přívodní vodní (55 °C) 1
13247196 | 2.NP_SO-102 | 4432.2 | 0.00454772 | 1.05963 | ø65 mm | 0 | 0.00145138 | HE | 2338.05 | 2300 | 2300 | 2.NP_SO-102 | 0 | 2261.95 | Fáze 1 | Přívod teplé vody | HT/CL_přívodní vodní 1 | 6265.55 | 0.905071 | 65 | 51 | HT/CL_přívodní vodní | ø65 | 76.1 | 68.9 | TR02.01.1516 | 1516 | yes | HT/CL_přívodní vodní 1
13247213 | 2.NP_SO-102 | 4600.26 | 0.00454772 | 1.09981 | ø65 mm | 0 | 0.00145138 | HE | 3038.05 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2961.95 | Fáze 1 | Přívod teplé vody | HT/CL_přívodní vodní 1 | 6965.55 | 0.939389 | 65 | 51 | HT/CL_přívodní vodní | ø65 | 76.1 | 68.9 | TR02.01.1517 | 1517 | yes | HT/CL_přívodní vodní 1
13247444 | 2.NP_SO-102 | 6904.62 | 0.00454772 | 1.65072 | ø65 mm | 0 | 0.00145138 | HE | 3038.05 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2961.95 | Fáze 1 | Přívod teplé vody | HT/CL_přívodní vodní 1 | 6965.55 | 1.40995 | 65 | 51 | HT/CL_přívodní vodní | ø65 | 76.1 | 68.9 | TR02.01.1521 | 1521 | yes | HT/CL_přívodní vodní 1
13247454 | 2.NP_SO-102 | 135.395 | 0.00454772 | 0.0323695 | ø65 mm | 0 | 0.00145138 | HE | 3038.05 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2961.95 | Fáze 1 | Přívod teplé vody | HT/CL_přívodní vodní 1 | 6965.55 | 0.0276481 | 65 | 51 | HT/CL_přívodní vodní | ø65 | 76.1 | 68.9 | TR02.01.1522 | 1522 | yes | HT/CL_přívodní vodní 1
13247465 | 2.NP_SO-102 | 620.625 | 0.00454772 | 0.148376 | ø65 mm | 0 | 0.00145138 | HE | 2960.31 | 2960.31 | 2339.69 | 2.NP_SO-102 |  | 2339.69 | Fáze 1 | Přívod teplé vody | HT/CL_přívodní vodní 1 | 6339.69 | 0.126734 | 65 | 51 | HT/CL_přívodní vodní | ø65 | 76.1 | 68.9 | TR02.01.1523 | 1523 | yes | HT/CL_přívodní vodní 1
13248500 | 2.NP_SO-102 | 4600.26 | 0.00454772 | 1.09981 | ø65 mm | 0 | 0.00145138 | HE | 3038.05 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2961.95 | Fáze 1 | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 6965.55 | 0.939389 | 65 | 4 | HT/CL_vratné vodní | ø65 | 76.1 | 68.9 | TR02.01.1528 | 1528 | yes | HT/CL_vratné vodní 1
13248509 | 2.NP_SO-102 | 6904.62 | 0.00454772 | 1.65072 | ø65 mm | 0 | 0.00145138 | HE | 3038.05 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2961.95 | Fáze 1 | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 6965.55 | 1.40995 | 65 | 4 | HT/CL_vratné vodní | ø65 | 76.1 | 68.9 | TR02.01.1529 | 1529 | yes | HT/CL_vratné vodní 1
13248603 | 2.NP_SO-102 | 4582.2 | 0.00454772 | 1.09549 | ø65 mm | 0 | 0.00145138 | HE | 2488.05 | 2450 | 2450 | 2.NP_SO-102 | 0 | 2411.95 | Fáze 1 | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 6415.55 | 0.935702 | 65 | 4 | HT/CL_vratné vodní | ø65 | 76.1 | 68.9 | TR02.01.1531 | 1531 | yes | HT/CL_vratné vodní 1
13248612 | 2.NP_SO-102 | 335.395 | 0.00454772 | 0.0801846 | ø65 mm | 0 | 0.00145138 | HE | 3038.05 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2961.95 | Fáze 1 | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 6965.55 | 0.0684888 | 65 | 4 | HT/CL_vratné vodní | ø65 | 76.1 | 68.9 | TR02.01.1532 | 1532 | yes | HT/CL_vratné vodní 1
13248643 | 2.NP_SO-102 | 470.625 | 0.00454772 | 0.112515 | ø65 mm | 0 | 0.00145138 | HE | 2960.31 | 2960.31 | 2489.69 | 2.NP_SO-102 |  | 2489.69 | Fáze 1 | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 6489.69 | 0.0961033 | 65 | 4 | HT/CL_vratné vodní | ø65 | 76.1 | 68.9 | TR02.01.1533 | 1533 | yes | HT/CL_vratné vodní 1
13250099 | 2.NP_SO-102 | 1215.02 | 0.00454772 | 0.290481 | ø65 mm | 0 | 0.00145138 | HC | 2424.52 | 2424.52 | 1209.5 | 2.NP_SO-102 |  | 1209.5 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 5209.5 | 0.248111 | 65 | 1 | CL_vratné vodní (15 °C) | ø65 | 76.1 | 68.9 | TR02.01.1559 | 1559 | yes | CL_vratné vodní (15 °C) 8
13250377 | 2.NP_SO-102 | 3072.89 | 0.00454772 | 0.734652 | ø65 mm | 0 | 0.00145138 | HE | 3138.05 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3061.95 | Fáze 1 | Přívod teplé vody | HT/CL_přívodní vodní 1 | 7065.55 | 0.627495 | 65 | 20 | HT/CL_přívodní vodní | ø65 | 76.1 | 68.9 | TR02.01.1560 | 1560 | yes | HT/CL_přívodní vodní 1
13250386 | 2.NP_SO-102 | 4603.58 | 0.00454772 | 1.1006 | ø65 mm | 0 | 0.00145138 | HE | 3138.05 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3061.95 | Fáze 1 | Přívod teplé vody | HT/CL_přívodní vodní 1 | 7065.55 | 0.940068 | 65 | 20 | HT/CL_přívodní vodní | ø65 | 76.1 | 68.9 | TR02.01.1561 | 1561 | yes | HT/CL_přívodní vodní 1
13250476 | 2.NP_SO-102 | 4523.58 | 0.00454772 | 1.08148 | ø65 mm | 0 | 0.00145138 | HE | 3138.05 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3061.95 | Fáze 1 | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 7065.55 | 0.923731 | 65 | 8 | HT/CL_vratné vodní | ø65 | 76.1 | 68.9 | TR02.01.1562 | 1562 | yes | HT/CL_vratné vodní 1
13250485 | 2.NP_SO-102 | 3212.89 | 0.00454772 | 0.768122 | ø65 mm | 0 | 0.00145138 | HE | 3138.05 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3061.95 | Fáze 1 | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 7065.55 | 0.656083 | 65 | 8 | HT/CL_vratné vodní | ø65 | 76.1 | 68.9 | TR02.01.1563 | 1563 | yes | HT/CL_vratné vodní 1
13250528 | 2.NP_SO-102 | 14.275 | 0.00454772 | 0.0034128 | ø65 mm | 0 | 0.00145138 | HE | 3060.31 | 3060.31 | 3046.04 | 2.NP_SO-102 |  | 3046.04 | Fáze 1 | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 7046.04 | 0.00291501 | 65 | 8 | HT/CL_vratné vodní | ø65 | 76.1 | 68.9 | TR02.01.1564 | 1564 | yes | HT/CL_vratné vodní 1
13250531 | 2.NP_SO-102 | 4889.41 | 0.00454772 | 1.16894 | ø65 mm | 0 | 0.00145138 | HE | 3038.05 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2961.95 | Fáze 1 | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 6965.55 | 0.998435 | 65 | 4 | HT/CL_vratné vodní | ø65 | 76.1 | 68.9 | TR02.01.1565 | 1565 | yes | HT/CL_vratné vodní 1
13250560 | 2.NP_SO-102 | 14.275 | 0.00454772 | 0.0034128 | ø65 mm | 0 | 0.00145138 | HE | 3060.31 | 3060.31 | 3046.04 | 2.NP_SO-102 |  | 3046.04 | Fáze 1 | Přívod teplé vody | HT/CL_přívodní vodní 1 | 7046.04 | 0.00291501 | 65 | 20 | HT/CL_přívodní vodní | ø65 | 76.1 | 68.9 | TR02.01.1566 | 1566 | yes | HT/CL_přívodní vodní 1
13250563 | 2.NP_SO-102 | 4489.41 | 0.00454772 | 1.07331 | ø65 mm | 0 | 0.00145138 | HE | 3038.05 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2961.95 | Fáze 1 | Přívod teplé vody | HT/CL_přívodní vodní 1 | 6965.55 | 0.916754 | 65 | 51 | HT/CL_přívodní vodní | ø65 | 76.1 | 68.9 | TR02.01.1567 | 1567 | yes | HT/CL_přívodní vodní 1
13250615 | 2.NP_SO-102 | 1818.27 | 0.00454772 | 0.434703 | ø65 mm | 0 | 0.00145138 | HE | 3060.31 | 3060.31 | 1242.04 | 2.NP_SO-102 |  | 1242.04 | Fáze 1 | Přívod teplé vody | HT/CL_přívodní vodní 1 | 5242.04 | 0.371297 | 65 | 20 | HT/CL_přívodní vodní | ø65 | 76.1 | 68.9 | TR02.01.1568 | 1568 | yes | HT/CL_přívodní vodní 1
13250732 | 2.NP_SO-102 | 1818.27 | 0.00454772 | 0.434703 | ø65 mm | 0 | 0.00145138 | HE | 3060.31 | 3060.31 | 1242.04 | 2.NP_SO-102 |  | 1242.04 | Fáze 1 | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 5242.04 | 0.371297 | 65 | 8 | HT/CL_vratné vodní | ø65 | 76.1 | 68.9 | TR02.01.1569 | 1569 | yes | HT/CL_vratné vodní 1
13250941 | 2.NP_SO-102 | 308.496 | 0.00915951 | 0.10467 | ø100 mm | 0 | 0.001 | HC | 1754 | 1700 | 1700 | 2.NP_SO-102 | 0 | 1646 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 3 | 5650 | 0.0969169 | 100 | 5 | CL_vratné vodní (15 °C) | ø100 | 108 | 100 | TR02.01.1570 | 1570 | yes | CL_vratné vodní (15 °C) 3
13250950 | 2.NP_SO-102 | 918.567 | 0.00915951 | 0.311662 | ø100 mm | 0 | 0.001 | HC | 1754 | 1700 | 1700 | 2.NP_SO-102 | 0 | 1646 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 3 | 5650 | 0.288576 | 100 | 1 | CL_vratné vodní (15 °C) | ø100 | 108 | 100 | TR02.01.1571 | 1571 | yes | CL_vratné vodní (15 °C) 3
13250953 | 2.NP_SO-102 | 676.933 | 0.00915951 | 0.229678 | ø100 mm | 0 | 0.001 | HC | 1754 | 1700 | 1700 | 2.NP_SO-102 | 0 | 1646 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 3 | 5650 | 0.212665 | 100 | 5 | CL_vratné vodní (15 °C) | ø100 | 108 | 100 | TR02.01.1572 | 1572 | yes | CL_vratné vodní (15 °C) 3
13250988 | 2.NP_SO-102 | 95.6701 | 0.00915951 | 0.0324601 | ø100 mm | 0 | 0.001 | HC | 1754 | 1700 | 1700 | 2.NP_SO-102 | 0 | 1646 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 3 | 5650 | 0.0300557 | 100 | 5 | CL_vratné vodní (15 °C) | ø100 | 108 | 100 | TR02.01.1573 | 1573 | yes | CL_vratné vodní (15 °C) 3
13259804 | 2.NP_SO-102 | 1035.42 | 0.00620623 | 0.28918 | ø80 mm | 0 | 0.00123762 | HC | 2544.45 | 2500 | 2500 | 2.NP_SO-102 | 0 | 2455.55 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6459.6 | 0.26023 | 80 | 125 | CL_přívodní vodní (10 °C) | ø80 | 88.9 | 80.8 | TR02.01.1588 | 1588 | yes | CL_přívodní vodní (10 °C) 4
13259883 | 2.NP_SO-102 | 7613.23 | 0.00620623 | 2.12628 | ø80 mm | 0 | 0.00123762 | HC | 2544.45 | 2500 | 2500 | 2.NP_SO-102 | 0 | 2455.55 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6459.6 | 1.91341 | 80 | 125 | CL_přívodní vodní (10 °C) | ø80 | 88.9 | 80.8 | TR02.01.1589 | 1589 | yes | CL_přívodní vodní (10 °C) 4
13260028 | 2.NP_SO-102 | 912.477 | 0.00620623 | 0.254843 | ø80 mm | 0 | 0.00123762 | HC | 2544.45 | 2500 | 2500 | 2.NP_SO-102 | 0 | 2455.55 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 6459.6 | 0.22933 | 80 | 102 | CL_vratné vodní (15 °C) | ø80 | 88.9 | 80.8 | TR02.01.1590 | 1590 | yes | CL_vratné vodní (15 °C) 8
13260092 | 2.NP_SO-102 | 7780.03 | 0.00620623 | 2.17287 | ø80 mm | 0 | 0.00123762 | HC | 2544.45 | 2500 | 2500 | 2.NP_SO-102 | 0 | 2455.55 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 6459.6 | 1.95534 | 80 | 102 | CL_vratné vodní (15 °C) | ø80 | 88.9 | 80.8 | TR02.01.1591 | 1591 | yes | CL_vratné vodní (15 °C) 8
13260191 | 2.NP_SO-102 | 26.8018 | 0.00620623 | 0.00748541 | ø80 mm | 0 | 0.00123762 | HC | 2844.45 | 2800 | 2800 | 2.NP_SO-102 | 0 | 2755.55 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6759.6 | 0.00673603 | 80 | 125 | CL_přívodní vodní (10 °C) | ø80 | 88.9 | 80.8 | TR02.01.1592 | 1592 | yes | CL_přívodní vodní (10 °C) 4
13260343 | 2.NP_SO-102 | 1815.88 | 0.00620623 | 0.507152 | ø80 mm | 0 | 0.00123762 | HC | 2844.45 | 2800 | 2800 | 2.NP_SO-102 | 0 | 2755.55 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6759.6 | 0.456379 | 80 | 125 | CL_přívodní vodní (10 °C) | ø80 | 88.9 | 80.8 | TR02.01.1593 | 1593 | yes | CL_přívodní vodní (10 °C) 4
13260351 | 2.NP_SO-102 | 1981.05 | 0.00620623 | 0.553283 | ø80 mm | 0 | 0.00123762 | HC | 2094.45 | 2050 | 2050 | 2.NP_SO-102 | 0 | 2005.55 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6009.6 | 0.497892 | 80 | 125 | CL_přívodní vodní (10 °C) | ø80 | 88.9 | 80.8 | TR02.01.1594 | 1594 | yes | CL_přívodní vodní (10 °C) 4
13260394 | 2.NP_SO-102 | 2004.44 | 0.00620623 | 0.559814 | ø80 mm | 0 | 0.00123762 | HC | 2094.45 | 2050 | 2050 | 2.NP_SO-102 | 0 | 2005.55 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 6009.6 | 0.50377 | 80 | 102 | CL_vratné vodní (15 °C) | ø80 | 88.9 | 80.8 | TR02.01.1595 | 1595 | yes | CL_vratné vodní (15 °C) 8
13260449 | 2.NP_SO-102 | 1646.13 | 0.00620623 | 0.459744 | ø80 mm | 0 | 0.00123762 | HC | 2544.45 | 2500 | 2500 | 2.NP_SO-102 | 0 | 2455.55 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 6459.6 | 0.413718 | 80 | 102 | CL_vratné vodní (15 °C) | ø80 | 88.9 | 80.8 | TR02.01.1596 | 1596 | yes | CL_vratné vodní (15 °C) 8
13260457 | -1.PP_SO-102 | 1133.14 | 0.00620623 | 0.316471 | ø80 mm | 0 | 0.00123762 | HC | 3344.45 | 3300 | 3300 | -1.PP_SO-102 | 0 | 3255.55 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -740.4 | 0.284788 | 80 | 46 | CL_vratné vodní (15 °C) | ø80 | 88.9 | 80.8 | TR02.01.1597 | 1597 | yes | CL_vratné vodní (15 °C) 8
13273383 | 4.NP_SO-102 | 934.625 | 0.00454772 | 0.223446 | ø65 mm | 0 | 0.00145138 | HD | 4174.31 | 4174.31 | 3239.69 | 4.NP_SO-102 |  | 3239.69 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15239.7 | 0.190854 | 65 | 61 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.1646 | 1646 | yes | HT_PRIMÁR_přívodní 3
13273859 | 4.NP_SO-102 | 960.313 | 0.00454772 | 0.229587 | ø185 mm | 60 | 0.00145138 | HD | 4200 | 4200 | 3239.69 | 4.NP_SO-102 |  | 3239.69 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15239.7 | 0.196099 | 65 | 52 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.1647 | 1647 | yes | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13273861 | 4.NP_SO-102 | 960.313 | 0.00454772 | 0.229587 | ø185 mm | 60 | 0.00145138 | HD | 4200 | 4200 | 3239.69 | 4.NP_SO-102 |  | 3239.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 15239.7 | 0.196099 | 65 | 59 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1648 | 1648 | yes | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13274443 | 4.NP_SO-102 | 960.313 | 0.00454772 | 0.229587 | ø65 mm | 0 | 0.00145138 | HD | 4200 | 4200 | 3239.69 | 4.NP_SO-102 |  | 3239.69 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15239.7 | 0.196099 | 65 | 44 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.1649 | 1649 | yes | HT_PRIMÁR_přívodní 3
13274471 | 4.NP_SO-102 | 960.313 | 0.00454772 | 0.229587 | ø65 mm | 0 | 0.00145138 | HD | 4200 | 4200 | 3239.69 | 4.NP_SO-102 |  | 3239.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 15239.7 | 0.196099 | 65 | 48 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1650 | 1650 | yes | HT_PRIMÁR_vratné 3
13278378 | 2.NP_SO-102 | 114.275 | 0.00454772 | 0.0273203 | ø65 mm | 0 | 0.00145138 | HC | 2660.31 | 2660.31 | 2546.04 | 2.NP_SO-102 |  | 2546.04 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 5 | 6546.04 | 0.0233354 | 65 | 1 | CL_vratné vodní (15 °C) | ø65 | 76.1 | 68.9 | TR02.01.1652 | 1652 | yes | CL_vratné vodní (15 °C) 5
13278381 | 2.NP_SO-102 | 722.211 | 0.00454772 | 0.172663 | ø65 mm | 0 | 0.00145138 | HD | 2538.05 | 2500 | 2500 | 2.NP_SO-102 | 0 | 2461.95 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 21 | 6465.55 | 0.147478 | 65 | 4 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1653 | 1653 | yes | HT_vratné vodní (45 °C) 21
13278410 | 2.NP_SO-102 | 114.275 | 0.00454772 | 0.0273203 | ø65 mm | 0 | 0.00145138 | HC | 2660.31 | 2660.31 | 2546.04 | 2.NP_SO-102 |  | 2546.04 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 5 | 6546.04 | 0.0233354 | 65 | 1 | CL_přívodní vodní (10 °C) | ø65 | 76.1 | 68.9 | TR02.01.1654 | 1654 | yes | HT_přívodní vodní (55 °C) 26; CL_přívodní vodní (10 °C) 5
13278413 | 2.NP_SO-102 | 972.211 | 0.00454772 | 0.232432 | ø65 mm | 0 | 0.00145138 | HD | 2538.05 | 2500 | 2500 | 2.NP_SO-102 | 0 | 2461.95 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 26 | 6465.55 | 0.198529 | 65 | 4 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.1655 | 1655 | yes | HT_přívodní vodní (55 °C) 26
13278444 | 2.NP_SO-102 | 14.275 | 0.00454772 | 0.0034128 | ø65 mm | 0 | 0.00145138 | HC | 2603.96 | 2589.69 | 2603.96 | 2.NP_SO-102 |  | 2589.69 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 6 | 6589.69 | 0.00291501 | 65 | 1 | CL_vratné vodní (15 °C) | ø65 | 76.1 | 68.9 | TR02.01.1656 | 1656 | yes | CL_vratné vodní (15 °C) 6
13278447 | 2.NP_SO-102 | 602.066 | 0.00454772 | 0.143939 | ø65 mm | 0 | 0.00145138 | HD | 2688.05 | 2650 | 2650 | 2.NP_SO-102 | 0 | 2611.95 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 20 | 6615.55 | 0.122944 | 65 | 4 | HT_vratné vodní (45 °C) | ø65 | 76.1 | 68.9 | TR02.01.1657 | 1657 | yes | HT_vratné vodní (45 °C) 20
13278478 | 2.NP_SO-102 | 3099.82 | 0.00454772 | 0.741091 | ø65 mm | 0 | 0.00145138 | HD | 2538.05 | 2500 | 2500 | 2.NP_SO-102 | 0 | 2461.95 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 13 | 6465.55 | 0.632995 | 65 | 1 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.1658 | 1658 | yes | HT_přívodní vodní (55 °C) 13
13278486 | 2.NP_SO-102 | 852.066 | 0.00454772 | 0.203708 | ø65 mm | 0 | 0.00145138 | HD | 2538.05 | 2500 | 2500 | 2.NP_SO-102 | 0 | 2461.95 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 13 | 6465.55 | 0.173995 | 65 | 4 | HT_přívodní vodní (55 °C) | ø65 | 76.1 | 68.9 | TR02.01.1659 | 1659 | yes | HT_přívodní vodní (55 °C) 13
13279023 | -1.PP_SO-102 | 523.494 | 0.00620623 | 0.146205 | ø200 mm | 60 | 0.00123762 | HD | 2844.45 | 2800 | 2800 | -1.PP_SO-102 | 0 | 2755.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | -1240.4 | 0.131568 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1667 | 1667 | yes | HT_vratné vodní (45 °C) 39 | Izolace - Typ izolace: Tepelná
13281007 | 2.NP_SO-102 | 178.481 | 0.00454772 | 0.0426704 | ø65 mm | 0 | 0.00145138 | HC | 2424.52 | 2424.52 | 2246.04 | 2.NP_SO-102 |  | 2246.04 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 6246.04 | 0.0364465 | 65 | 1 | CL_přívodní vodní (10 °C) | ø65 | 76.1 | 68.9 | TR02.01.1693 | 1693 | yes | CL_přívodní vodní (10 °C) 4
13281019 | 2.NP_SO-102 | 944.463 | 0.00454772 | 0.225798 | ø65 mm | 0 | 0.00145138 | HC | 2153.96 | 2153.96 | 1209.5 | 2.NP_SO-102 |  | 1209.5 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 5209.5 | 0.192863 | 65 | 8 | CL_přívodní vodní (10 °C) | ø65 | 76.1 | 68.9 | TR02.01.1694 | 1694 | yes | CL_přívodní vodní (10 °C) 4
13283707 | 2.NP_SO-102 | 994.463 | 0.00620623 | 0.277741 | ø80 mm | 0 | 0.00123762 | HD | 2253.96 | 2253.96 | 1259.5 | 2.NP_SO-102 |  | 1259.5 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5259.5 | 0.249936 | 80 | 516 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1716 | 1716 | yes | HT_vratné vodní (45 °C) 1
13283743 | 2.NP_SO-102 | 993.669 | 0.00620623 | 0.277519 | ø80 mm | 0 | 0.00123762 | HD | 2253.17 | 2253.17 | 1259.5 | 2.NP_SO-102 |  | 1259.5 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 5259.5 | 0.249736 | 80 | 1 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1717 | 1717 | yes | HT_vratné vodní (45 °C) 10
13283779 | 2.NP_SO-102 | 993.669 | 0.00620623 | 0.277519 | ø80 mm | 0 | 0.00123762 | HD | 2253.17 | 2253.17 | 1259.5 | 2.NP_SO-102 |  | 1259.5 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 5259.5 | 0.249736 | 80 | 107 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1718 | 1718 | yes | HT_vratné vodní (45 °C) 9
13283819 | 2.NP_SO-102 | 980.969 | 0.00620623 | 0.273972 | ø80 mm | 0 | 0.00123762 | HD | 2240.47 | 2240.47 | 1259.5 | 2.NP_SO-102 |  | 1259.5 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 5259.5 | 0.246544 | 80 | 102 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1719 | 1719 | yes | HT_vratné vodní (45 °C) 26
13283852 | 2.NP_SO-102 | 980.969 | 0.00620623 | 0.273972 | ø80 mm | 0 | 0.00123762 | HE | 2240.47 | 2240.47 | 1259.5 | 2.NP_SO-102 |  | 1259.5 | Fáze 1 | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 5259.5 | 0.246544 | 80 | 1 | HT/CL_vratné vodní | ø80 | 88.9 | 80.8 | TR02.01.1720 | 1720 | yes | HT/CL_vratné vodní 1
13283891 | 2.NP_SO-102 | 300 | 0.00620623 | 0.0837863 | ø80 mm | 0 | 0.00123762 | HD | 1559.5 | 1559.5 | 1259.5 | 2.NP_SO-102 |  | 1259.5 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 31 | 5259.5 | 0.0753982 | 80 | 1 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1721 | 1721 | yes | HT_vratné vodní (45 °C) 31
13283925 | 2.NP_SO-102 | 994.463 | 0.00620623 | 0.277741 | ø80 mm | 0 | 0.00123762 | HD | 2253.96 | 2253.96 | 1259.5 | 2.NP_SO-102 |  | 1259.5 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 5259.5 | 0.249936 | 80 | 356 | HT_přívodní vodní (55 °C) | ø80 | 88.9 | 80.8 | TR02.01.1722 | 1722 | yes | HT_přívodní vodní (55 °C) 9
13283961 | 2.NP_SO-102 | 993.669 | 0.00620623 | 0.277519 | ø80 mm | 0 | 0.00123762 | HD | 2253.17 | 2253.17 | 1259.5 | 2.NP_SO-102 |  | 1259.5 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 5259.5 | 0.249736 | 80 | 1 | HT_přívodní vodní (55 °C) | ø80 | 88.9 | 80.8 | TR02.01.1723 | 1723 | yes | HT_přívodní vodní (55 °C) 2
13283997 | 2.NP_SO-102 | 993.669 | 0.00620623 | 0.277519 | ø80 mm | 0 | 0.00123762 | HD | 2253.17 | 2253.17 | 1259.5 | 2.NP_SO-102 |  | 1259.5 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 5259.5 | 0.249736 | 80 | 13 | HT_přívodní vodní (55 °C) | ø80 | 88.9 | 80.8 | TR02.01.1724 | 1724 | yes | HT_přívodní vodní (55 °C) 12
13284039 | 2.NP_SO-102 | 994.463 | 0.00620623 | 0.277741 | ø80 mm | 0 | 0.00123762 | HE | 2253.96 | 2253.96 | 1259.5 | 2.NP_SO-102 |  | 1259.5 | Fáze 1 | Přívod teplé vody | HT/CL_přívodní vodní 1 | 5259.5 | 0.249936 | 80 | 18 | HT/CL_přívodní vodní | ø80 | 88.9 | 80.8 | TR02.01.1725 | 1725 | yes | HT/CL_přívodní vodní 1
13284075 | 2.NP_SO-102 | 980.969 | 0.00620623 | 0.273972 | ø80 mm | 0 | 0.00123762 | HD | 2240.47 | 2240.47 | 1259.5 | 2.NP_SO-102 |  | 1259.5 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 5259.5 | 0.246544 | 80 | 86 | HT_přívodní vodní (55 °C) | ø80 | 88.9 | 80.8 | TR02.01.1726 | 1726 | yes | HT_přívodní vodní (55 °C) 25
13284111 | 2.NP_SO-102 | 300 | 0.00620623 | 0.0837863 | ø80 mm | 0 | 0.00123762 | HD | 1559.5 | 1559.5 | 1259.5 | 2.NP_SO-102 |  | 1259.5 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 28 | 5259.5 | 0.0753982 | 80 | 1 | HT_přívodní vodní (55 °C) | ø80 | 88.9 | 80.8 | TR02.01.1727 | 1727 | yes | HT_přívodní vodní (55 °C) 28
13300824 | 2.NP_SO-102 | 240.625 | 0.00454772 | 0.0575275 | ø65 mm | 0 | 0.00145138 | HD | 2838.05 | 2800 | 2800 | 2.NP_SO-102 | 0 | 2761.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 6765.55 | 0.0491365 | 65 | 76 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.1809 | 1809 | yes | HT_PRIMÁR_přívodní 4
13303627 | -1.PP_SO-102 | 21.8041 | 0.00620623 | 0.00608961 | ø80 mm | 0 | 0.00123762 | HC | 3344.45 | 3300 | 3300 | -1.PP_SO-102 | 0 | 3255.55 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -740.4 | 0.00547997 | 80 | 46 | CL_vratné vodní (15 °C) | ø80 | 88.9 | 80.8 | TR02.01.1813 | 1813 | yes | CL_vratné vodní (15 °C) 8
13303636 | 1.NP_SO-102 | 7088.18 | 0.00620623 | 1.97964 | ø80 mm | 0 | 0.00123762 | HC | 6434.22 | -653.963 | 6434.22 | 1.NP_SO-102 |  | -653.963 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -653.963 | 1.78145 | 80 | 46 | CL_vratné vodní (15 °C) | ø80 | 88.9 | 80.8 | TR02.01.1814 | 1814 | yes | CL_vratné vodní (15 °C) 8
13304008 | -1.PP_SO-102 | 1333.14 | 0.00620623 | 0.372329 | ø80 mm | 0 | 0.00123762 | HC | 3194.45 | 3150 | 3150 | -1.PP_SO-102 | 0 | 3105.55 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -890.4 | 0.335054 | 80 | 125 | CL_přívodní vodní (10 °C) | ø80 | 88.9 | 80.8 | TR02.01.1816 | 1816 | yes | CL_přívodní vodní (10 °C) 4
13304040 | -1.PP_SO-102 | 28.9276 | 0.00620623 | 0.00807913 | ø80 mm | 0 | 0.00123762 | HC | 3194.45 | 3150 | 3150 | -1.PP_SO-102 | 0 | 3105.55 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -890.4 | 0.00727031 | 80 | 125 | CL_přívodní vodní (10 °C) | ø80 | 88.9 | 80.8 | TR02.01.1817 | 1817 | yes | CL_přívodní vodní (10 °C) 4
13304051 | 1.NP_SO-102 | 7557.92 | 0.00620623 | 2.11083 | ø80 mm | 0 | 0.00123762 | HC | 6753.96 | -803.963 | 6753.96 | 1.NP_SO-102 |  | -803.963 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -803.963 | 1.89951 | 80 | 125 | CL_přívodní vodní (10 °C) | ø80 | 88.9 | 80.8 | TR02.01.1818 | 1818 | yes | CL_přívodní vodní (10 °C) 4
13304305 | -1.PP_SO-102 | 201.575 | 0.00620623 | 0.0562974 | ø80 mm | 0 | 0.00123762 | HC | 3253.96 | 3253.96 | 3052.39 | -1.PP_SO-102 |  | 3052.39 | Fáze 1 | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -947.612 | 0.0506613 | 80 | 46 | CL_vratné vodní (15 °C) | ø80 | 88.9 | 80.8 | TR02.01.1820 | 1820 | yes | CL_vratné vodní (15 °C) 8
13304503 | -1.PP_SO-102 | 51.575 | 0.00620623 | 0.0144043 | ø80 mm | 0 | 0.00123762 | HC | 3103.96 | 3103.96 | 3052.39 | -1.PP_SO-102 |  | 3052.39 | Fáze 1 | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -947.612 | 0.0129622 | 80 | 125 | CL_přívodní vodní (10 °C) | ø80 | 88.9 | 80.8 | TR02.01.1822 | 1822 | yes | CL_přívodní vodní (10 °C) 4
13330063 | -1.PP_SO-102 | 1744.43 | 0.00620623 | 0.487198 | ø200 mm | 60 | 0.00123762 | HD | 2194.45 | 2150 | 2150 | -1.PP_SO-102 | 0 | 2105.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | -1890.4 | 0.438423 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1852 | 1852 | yes | HT_vratné vodní (45 °C) 39 | Izolace - Typ izolace: Tepelná
13330123 | -1.PP_SO-102 | 1091.24 | 0.00620623 | 0.304771 | ø200 mm | 60 | 0.00123762 | HD | 2344.45 | 2300 | 2300 | -1.PP_SO-102 | 0 | 2255.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | -1740.4 | 0.274259 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1853 | 1853 | yes | HT_vratné vodní (45 °C) 39 | Izolace - Typ izolace: Tepelná
13330395 | -1.PP_SO-102 | 187.925 | 0.00620623 | 0.0524851 | ø80 mm | 0 | 0.00123762 | HD | 2194.45 | 2150 | 2150 | -1.PP_SO-102 | 0 | 2105.55 | Fáze 1 | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | -1890.4 | 0.0472307 | 80 | 79 | HT_vratné vodní (45 °C) | ø80 | 88.9 | 80.8 | TR02.01.1854 | 1854 | yes | HT_vratné vodní (45 °C) 39
13331386 | -1.PP_SO-102 | 1994.13 | 0.00620623 | 0.556935 | ø200 mm | 60 | 0.00123762 | HD | 2194.45 | 2150 | 2150 | -1.PP_SO-102 | 0 | 2105.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | -1890.4 | 0.501179 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.1855 | 1855 | yes | HT_přívodní vodní (65 °C) 5 | Izolace - Typ izolace: Tepelná
13331423 | -1.PP_SO-102 | 427.925 | 0.00620623 | 0.119514 | ø200 mm | 60 | 0.00123762 | HD | 2194.45 | 2150 | 2150 | -1.PP_SO-102 | 0 | 2105.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | -1890.4 | 0.107549 | 80 | 2 | HT_přívodní vodní (65 °C) | ø80 | 88.9 | 80.8 | TR02.01.1856 | 1856 | yes | HT_přívodní vodní (65 °C) 5 | Izolace - Typ izolace: Tepelná
13362101 | 2.NP_SO-102 | 12203.9 | 0.00620623 | 3.4084 | ø200 mm | 60 | 0.00123762 | HD | 3144.45 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3055.55 | Fáze 1 | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7059.6 | 3.06718 | 80 | 359 | HT_přívodní vodní (55 °C) | ø80 | 88.9 | 80.8 | TR02.01.1954 | 1954 | yes | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13382988 | 4.NP_SO-102 | 4813.5 | 0.00454772 | 1.15079 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15165.5 | 0.982935 | 65 | 44 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.1968 | 1968 | yes | HT_PRIMÁR_přívodní 3
13383061 | 4.NP_SO-102 | 71.1526 | 0.00454772 | 0.0170108 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 15165.5 | 0.0145296 | 65 | 48 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1969 | 1969 | yes | HT_PRIMÁR_vratné 3
13383467 | 4.NP_SO-102 | 960.313 | 0.00454772 | 0.229587 | ø185 mm | 60 | 0.00145138 | HD | 4200 | 4200 | 3239.69 | 4.NP_SO-102 |  | 3239.69 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 15239.7 | 0.196099 | 65 | 48 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.1970 | 1970 | yes | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13383469 | 4.NP_SO-102 | 960.313 | 0.00454772 | 0.229587 | ø185 mm | 60 | 0.00145138 | HD | 4200 | 4200 | 3239.69 | 4.NP_SO-102 |  | 3239.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 15239.7 | 0.196099 | 65 | 50 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1971 | 1971 | yes | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13383523 | 4.NP_SO-102 | 1859.63 | 0.00454772 | 0.44459 | ø65 mm | 0 | 0.00145138 | HD | 3238.05 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3161.95 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 15165.5 | 0.379742 | 65 | 50 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1972 | 1972 | yes | HT_PRIMÁR_vratné 3
13383761 | 4.NP_SO-102 | 960.313 | 0.00454772 | 0.229587 | ø185 mm | 60 | 0.00145138 | HD | 4200 | 4200 | 3239.69 | 4.NP_SO-102 |  | 3239.69 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 15239.7 | 0.196099 | 65 | 56 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.1973 | 1973 | yes | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
13383763 | 4.NP_SO-102 | 960.313 | 0.00454772 | 0.229587 | ø185 mm | 60 | 0.00145138 | HD | 4200 | 4200 | 3239.69 | 4.NP_SO-102 |  | 3239.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 15239.7 | 0.196099 | 65 | 1 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1974 | 1974 | yes | HT_PRIMÁR_vratné 5 | Izolace - Typ izolace: Tepelná
13383780 | 4.NP_SO-102 | 960.313 | 0.00454772 | 0.229587 | ø185 mm | 60 | 0.00145138 | HD | 4200 | 4200 | 3239.69 | 4.NP_SO-102 |  | 3239.69 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 15239.7 | 0.196099 | 65 | 67 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.1975 | 1975 | yes | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13383782 | 4.NP_SO-102 | 953.962 | 0.00454772 | 0.228069 | ø185 mm | 60 | 0.00145138 | HD | 4200 | 4200 | 3246.04 | 4.NP_SO-102 |  | 3246.04 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 15246 | 0.194803 | 65 | 50 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1976 | 1976 | yes | HT_PRIMÁR_vratné 7 | Izolace - Typ izolace: Tepelná
13383801 | 4.NP_SO-102 | 1210.31 | 0.00454772 | 0.289356 | ø185 mm | 60 | 0.00145138 | HD | 4200 | 4200 | 2989.69 | 4.NP_SO-102 |  | 2989.69 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14989.7 | 0.24715 | 65 | 59 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.1977 | 1977 | yes | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13383803 | 4.NP_SO-102 | 1210.31 | 0.00454772 | 0.289356 | ø185 mm | 60 | 0.00145138 | HD | 4200 | 4200 | 2989.69 | 4.NP_SO-102 |  | 2989.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 6 | 14989.7 | 0.24715 | 65 | 65 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1978 | 1978 | yes | HT_PRIMÁR_vratné 6 | Izolace - Typ izolace: Tepelná
13383875 | 4.NP_SO-102 | 1360.31 | 0.00454772 | 0.325217 | ø185 mm | 60 | 0.00145138 | HD | 4200 | 4200 | 2839.69 | 4.NP_SO-102 |  | 2839.69 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 14839.7 | 0.277781 | 65 | 81 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.1979 | 1979 | yes | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13383877 | 4.NP_SO-102 | 1360.31 | 0.00454772 | 0.325217 | ø185 mm | 60 | 0.00145138 | HD | 4200 | 4200 | 2839.69 | 4.NP_SO-102 |  | 2839.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 14839.7 | 0.277781 | 65 | 72 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1980 | 1980 | yes | HT_PRIMÁR_vratné 7 | Izolace - Typ izolace: Tepelná
13383896 | 4.NP_SO-102 | 960.313 | 0.00454772 | 0.229587 | ø185 mm | 60 | 0.00145138 | HD | 4200 | 4200 | 3239.69 | 4.NP_SO-102 |  | 3239.69 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 15239.7 | 0.196099 | 65 | 72 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.1981 | 1981 | yes | HT_PRIMÁR_přívodní 4 | Izolace - Typ izolace: Tepelná
13383898 | 4.NP_SO-102 | 960.313 | 0.00454772 | 0.229587 | ø185 mm | 60 | 0.00145138 | HD | 4200 | 4200 | 3239.69 | 4.NP_SO-102 |  | 3239.69 | Fáze 1 | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 15239.7 | 0.196099 | 65 | 59 | HT_PRIMÁR_vratné | ø65 | 76.1 | 68.9 | TR02.01.1982 | 1982 | yes | HT_PRIMÁR_vratné 7 | Izolace - Typ izolace: Tepelná
13384285 | 4.NP_SO-102 | 889.467 | 0.00454772 | 0.212649 | ø65 mm | 0 | 0.00145138 | HD | 402.05 | 364 | 364 | STŘECHA_SO-102 | 0 | 325.95 | Fáze 1 | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 16179.5 | 0.181632 | 65 | 61 | HT_PRIMÁR_přívodní | ø65 | 76.1 | 68.9 | TR02.01.1983 | 1983 | yes | HT_PRIMÁR_přívodní 3
