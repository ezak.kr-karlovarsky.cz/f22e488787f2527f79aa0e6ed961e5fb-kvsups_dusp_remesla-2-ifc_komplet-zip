Properties of the parts of a building model (IFC4), part 46 of 72

# IfcPipeFitting: M_Koleno, obecné:Standardní (1543)
Name (M_Koleno, obecné:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm) | Group
13106810 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0432 | 0432 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13107512 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0433 | 0433 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13107555 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 3200 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0434 | 0434 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13107559 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 3200 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0435 | 0435 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13107652 | 4.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 4.NP_SO-102 | 3300 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0437 | 0437 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 19
13107865 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 3300 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0439 | 0439 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 13
13107869 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0440 | 0440 | no | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13107949 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 3300 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0442 | 0442 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 19
13107972 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0443 | 0443 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13108353 | 4.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 4.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0446 | 0446 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 13
13108405 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0448 | 0448 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13108506 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0450 | 0450 | no | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13108510 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 2780 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0451 | 0451 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13108662 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 6 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0452 | 0452 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 6 | Mechanické – tok - Tlaková ztráta: 0 Pa
13109063 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 6 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0453 | 0453 | no | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 6 | Mechanické – tok - Tlaková ztráta: 0 Pa
13109125 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 3300 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0454 | 0454 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 19
13109278 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 3300 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0455 | 0455 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 13
13109528 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0456 | 0456 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13109602 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0459 | 0459 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13109987 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0461 | 0461 | no | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 13
13110080 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0462 | 0462 | no | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 13
13111962 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2900 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0463 | 0463 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13111966 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0464 | 0464 | no | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13112032 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0467 | 0467 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13112051 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0468 | 0468 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13112152 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 2.NP_SO-102 | -4660 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0469 | 0469 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 13
13112238 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 3340 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0470 | 0470 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (55 °C) 19
13112270 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 3340 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0471 | 0471 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 13
13112539 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 2550 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0473 | 0473 | no | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 13
13112543 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 2550 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0474 | 0474 | no | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 13
13112579 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 2550 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0476 | 0476 | no | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 19
13112583 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 2550 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0477 | 0477 | no | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 19
13112635 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 2550 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0479 | 0479 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 19
13112639 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 2550 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0480 | 0480 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 19
13112675 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 2550 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0482 | 0482 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 13
13112679 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 2550 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0483 | 0483 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 13
13113118 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0486 | 0486 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 9
13113263 | 2.NP_SO-102 | 0 | ø22 mm-ø22 mm | HD | 2.NP_SO-102 | 2750 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11 | 22 | 0.0000148067 | 18.9375 | 90 | ø22-ø22 | 10.07 | 25.175 | TT01.01.0487 | 0487 | yes | 18.9375 | 12.5875 | HT_vratné vodní (45 °C) 1
13113282 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HD | 2.NP_SO-102 | 2750 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0488 | 0488 | yes | 20.6375 | 14.2875 | HT_vratné vodní (45 °C) 1
13113383 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 3150 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0489 | 0489 | yes | 20.6375 | 14.2875 | HT/CL_vratné vodní 1
13113385 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 3150 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0490 | 0490 | yes | 20.6375 | 14.2875 | HT/CL_vratné vodní 1
13113573 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 2450 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0492 | 0492 | yes | 20.6375 | 14.2875 | HT/CL_přívodní vodní 1
13113577 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 2450 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0493 | 0493 | yes | 20.6375 | 14.2875 | HT/CL_přívodní vodní 1
13113680 | 2.NP_SO-102 | 0 | ø22 mm-ø22 mm | HD | 2.NP_SO-102 | 2750 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11 | 22 | 0.0000148067 | 18.9375 | 90 | ø22-ø22 | 10.07 | 25.175 | TT01.01.0494 | 0494 | yes | 18.9375 | 12.5875 | HT_vratné vodní (45 °C) 1
13113727 | 2.NP_SO-102 | 0 | ø22 mm-ø22 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11 | 22 | 0.0000148067 | 18.9375 | 90 | ø22-ø22 | 10.07 | 25.175 | TT01.01.0496 | 0496 | yes | 18.9375 | 12.5875 | HT_vratné vodní (45 °C) 1
13113731 | 2.NP_SO-102 | 0 | ø22 mm-ø22 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11 | 22 | 0.0000148067 | 18.9375 | 90 | ø22-ø22 | 10.07 | 25.175 | TT01.01.0497 | 0497 | yes | 18.9375 | 12.5875 | HT_vratné vodní (45 °C) 1
13113765 | 2.NP_SO-102 | 0 | ø22 mm-ø22 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 11 | 22 | 0.0000148067 | 18.9375 | 90 | ø22-ø22 | 10.07 | 25.175 | TT01.01.0499 | 0499 | yes | 18.9375 | 12.5875 | HT_přívodní vodní (55 °C) 9
13113769 | 2.NP_SO-102 | 0 | ø22 mm-ø22 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 11 | 22 | 0.0000148067 | 18.9375 | 90 | ø22-ø22 | 10.07 | 25.175 | TT01.01.0500 | 0500 | yes | 18.9375 | 12.5875 | HT_přívodní vodní (55 °C) 9
13113797 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 3150 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0502 | 0502 | yes | 20.6375 | 14.2875 | HT/CL_vratné vodní 1
13113799 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 3150 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0503 | 0503 | yes | 20.6375 | 14.2875 | HT/CL_vratné vodní 1
13114572 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HE | 2.NP_SO-102 | 2650 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0504 | 0504 | yes | 17.4625 | 11.1125 | HT/CL_přívodní vodní 1
13114655 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HE | 2.NP_SO-102 | 2650 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0505 | 0505 | yes | 17.4625 | 11.1125 | HT/CL_vratné vodní 1
13114838 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0506 | 0506 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13114840 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0507 | 0507 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13115297 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0512 | 0512 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13115451 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0515 | 0515 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13116013 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0518 | 0518 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13116050 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0521 | 0521 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13116919 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 3150 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0526 | 0526 | yes | 20.6375 | 14.2875 | HT/CL_vratné vodní 1
13117141 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0528 | 0528 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13117198 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0529 | 0529 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13117200 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0530 | 0530 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13117332 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0531 | 0531 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13117763 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0532 | 0532 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13117836 | 4.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 4.NP_SO-102 | 0 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0534 | 0534 | yes | 20.6375 | 14.2875 | HT/CL_vratné vodní 1
13117866 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0535 | 0535 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13118378 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0536 | 0536 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 1
13118525 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0537 | 0537 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 32
13119068 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0539 | 0539 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 32
13119350 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0541 | 0541 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 32
13119352 | 1.NP_SO-102 | 0 | ø22 mm-ø22 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 11 | 22 | 0.0000148067 | 18.9375 | 90 | ø22-ø22 | 10.07 | 25.175 | TT01.01.0542 | 0542 | no | 18.9375 | 12.5875 | HT_vratné vodní (45 °C) 32
13119431 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0543 | 0543 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 32
13119433 | 1.NP_SO-102 | 0 | ø22 mm-ø22 mm | HD | 1.NP_SO-102 | 3940 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 11 | 22 | 0.0000148067 | 18.9375 | 90 | ø22-ø22 | 10.07 | 25.175 | TT01.01.0544 | 0544 | no | 18.9375 | 12.5875 | HT_vratné vodní (45 °C) 32
13119540 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0545 | 0545 | no | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9
13119668 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0546 | 0546 | no | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9
13120027 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0548 | 0548 | no | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 32
13120029 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0549 | 0549 | no | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 32
13120330 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 3950 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 28 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0551 | 0551 | no | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 28
13120402 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 28 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0552 | 0552 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 28
13120412 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 28 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0553 | 0553 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 28
13120557 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 28 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0555 | 0555 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 28
13121087 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0556 | 0556 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 32
13121220 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0557 | 0557 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13121276 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0558 | 0558 | no | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9
13121462 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0560 | 0560 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13121690 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0562 | 0562 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 32
13121692 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -58 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0563 | 0563 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 32
13121943 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0566 | 0566 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13122166 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0569 | 0569 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13122328 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0570 | 0570 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13122340 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0572 | 0572 | no | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13122450 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0573 | 0573 | no | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13123734 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0578 | 0578 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13123816 | 1.NP_SO-102 | 40 | ø95 mm-ø95 mm | HD | 1.NP_SO-102 | 2290 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0579 | 0579 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13123820 | 1.NP_SO-102 | 40 | ø95 mm-ø95 mm | HD | 1.NP_SO-102 | 2290 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0580 | 0580 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13125751 | 2.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 2.NP_SO-102 | 2230 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0588 | 0588 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13125756 | 2.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 2.NP_SO-102 | 2230 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0589 | 0589 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (65 °C) 5 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13125818 | 2.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 2.NP_SO-102 | 2230 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0590 | 0590 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39 | Izolace - Typ izolace: Tepelná
13125823 | 2.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 2.NP_SO-102 | 2230 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0591 | 0591 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39 | Izolace - Typ izolace: Tepelná
13126128 | 2.NP_SO-102 | 40 | ø112 mm-ø112 mm | HD | 2.NP_SO-102 | 3300 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0592 | 0592 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 6 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13127754 | 2.NP_SO-102 | 40 | ø120 mm-ø120 mm | HD | 2.NP_SO-102 | 3300 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 7 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0593 | 0593 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (65 °C) 7; HT_přívodní vodní (55 °C) 11 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13128006 | 2.NP_SO-102 | 40 | ø112 mm-ø112 mm | HD | 2.NP_SO-102 | 3150 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0594 | 0594 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 2 | Izolace - Typ izolace: Tepelná
13128012 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 3150 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0596 | 0596 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 2
13128282 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.0597 | 0597 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13128306 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3250 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 89.9999 | ø65-ø65 | 26.67 | 66.675 | TT01.01.0598 | 0598 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13129429 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0599 | 0599 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13129446 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0600 | 0600 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13130022 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0603 | 0603 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13130030 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0604 | 0604 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13130032 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0605 | 0605 | no | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13130055 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 14 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0606 | 0606 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 12; HT_přívodní vodní (55 °C) 14 | Mechanické – tok - Tlaková ztráta: 0 Pa
13130063 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 11 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0607 | 0607 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 11; HT_přívodní vodní (55 °C) 14 | Mechanické – tok - Tlaková ztráta: 0 Pa
13130065 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 14 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0608 | 0608 | no | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 14 | Mechanické – tok - Tlaková ztráta: 0 Pa
13130809 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 14 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0610 | 0610 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9; HT_přívodní vodní (65 °C) 14 | Mechanické – tok - Tlaková ztráta: 0 Pa
13131118 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0612 | 0612 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13131356 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3260 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0613 | 0613 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13131360 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3260 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0614 | 0614 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13131971 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0615 | 0615 | no | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13131980 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 2900 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0616 | 0616 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13131982 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 2900 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0617 | 0617 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13132244 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 23 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0618 | 0618 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 23 | Mechanické – tok - Tlaková ztráta: 0 Pa
13132496 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0619 | 0619 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13132916 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3200 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0620 | 0620 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13132918 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3200 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0621 | 0621 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13133048 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0622 | 0622 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13133214 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3200 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0623 | 0623 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13133224 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0624 | 0624 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13133314 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0626 | 0626 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13133451 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0627 | 0627 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13133459 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0628 | 0628 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13133461 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0629 | 0629 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13133655 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0633 | 0633 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13133915 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0636 | 0636 | no | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13133957 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0637 | 0637 | no | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13134154 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0638 | 0638 | no | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13134162 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3200 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0639 | 0639 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13134164 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3200 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0640 | 0640 | no | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13134191 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0641 | 0641 | no | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13134199 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0642 | 0642 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13134201 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0643 | 0643 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13134635 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3250 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0646 | 0646 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13134643 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0647 | 0647 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13134645 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0648 | 0648 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13134680 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3250 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0649 | 0649 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13134688 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0650 | 0650 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13134690 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0651 | 0651 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13135377 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3250 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0652 | 0652 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13135379 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3250 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0653 | 0653 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13136139 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3100 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0657 | 0657 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13136317 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3100 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0662 | 0662 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13136329 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2820 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0663 | 0663 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13136486 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0665 | 0665 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13136721 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0666 | 0666 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13136731 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2820 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0667 | 0667 | no | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13136758 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0668 | 0668 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13136766 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2820 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0669 | 0669 | no | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13136768 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2820 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0670 | 0670 | no | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13136840 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0671 | 0671 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13136861 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0672 | 0672 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13137205 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0674 | 0674 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13137220 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0675 | 0675 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13137452 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0676 | 0676 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13137462 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0677 | 0677 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13137523 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0678 | 0678 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9
13137533 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0679 | 0679 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13137570 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0680 | 0680 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13137595 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0682 | 0682 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13137649 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0685 | 0685 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13137651 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0686 | 0686 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13137720 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0688 | 0688 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9
13137722 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0689 | 0689 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9
13138089 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3260 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0690 | 0690 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13138091 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3260 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0691 | 0691 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13138195 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3260 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0692 | 0692 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13138475 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0693 | 0693 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13138485 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3260 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0694 | 0694 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13138512 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0695 | 0695 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13138520 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3260 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0696 | 0696 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13138522 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3260 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0697 | 0697 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13138614 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3260 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0698 | 0698 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13138616 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3260 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0699 | 0699 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13139144 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0700 | 0700 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 26
13139238 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0701 | 0701 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13139240 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0702 | 0702 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13139542 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0705 | 0705 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13139550 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0706 | 0706 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13139554 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0707 | 0707 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13139577 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 17 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0708 | 0708 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 17 | Mechanické – tok - Tlaková ztráta: 0 Pa
13139585 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 17 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0709 | 0709 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 17 | Mechanické – tok - Tlaková ztráta: 0 Pa
13139589 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 17 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0710 | 0710 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 17 | Mechanické – tok - Tlaková ztráta: 0 Pa
13139839 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2850 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0711 | 0711 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13140218 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2800 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0713 | 0713 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13140557 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0716 | 0716 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
