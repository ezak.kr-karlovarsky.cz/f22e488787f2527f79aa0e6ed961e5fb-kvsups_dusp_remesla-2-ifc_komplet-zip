Properties of the parts of a building model (IFC4), part 31 of 72

# IfcCovering: Izolace trubky:Tepelná (382)
Name (Izolace trubky:Tepelná:...) | In | Material | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Objem (m3) | Plocha (m2) | Tloušťka izolace (mm) | Délka (mm) | Velikost potrubí | Kód prvku | Označení
13273863 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 0.035497 | 0.591616 | 60 | 960.313 | ø65 | IZ01.01.0152 | 0152 | Qto_CoveringBaseQuantities - GrossArea: 0.0301981 m2
13273864 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 0.035497 | 0.591616 | 60 | 960.313 | ø65 | IZ01.01.0153 | 0153 | Qto_CoveringBaseQuantities - GrossArea: 0.0301981 m2
13285560 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 |  |  | 60 |  | ø80-ø80 | IZ01.01.0154 | 0154
13285581 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 |  |  | 40 |  | ø32-ø32 | IZ01.01.0155 | 0155
13287265 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 0.104435 | 2.61088 | 40 | 6789.77 | ø32 | IZ01.01.0156 | 0156
13287582 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 0.0424265 | 1.06066 | 40 | 2758.33 | ø32 | IZ01.01.0157 | 0157
13287588 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 0.0361824 | 0.904561 | 40 | 2352.38 | ø32 | IZ01.01.0158 | 0158
13287601 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 0.0422154 | 1.05539 | 40 | 2744.6 | ø32 | IZ01.01.0159 | 0159
13287606 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 |  |  | 40 |  | ø32-ø32 | IZ01.01.0160 | 0160
13287607 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 0.0361824 | 0.904561 | 40 | 2352.38 | ø32 | IZ01.01.0161 | 0161
13287650 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 |  |  | 40 |  | ø32-ø32 | IZ01.01.0162 | 0162
13287685 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 0.0598409 | 1.49602 | 40 | 3890.51 | ø32 | IZ01.01.0163 | 0163
13287730 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 0.00157465 | 0.0393664 | 40 | 102.375 | ø32 | IZ01.01.0164 | 0164
13287903 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 0.061379 | 1.53448 | 40 | 3990.51 | ø32 | IZ01.01.0165 | 0165
13287906 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 |  |  | 40 |  | ø32-ø32 | IZ01.01.0166 | 0166
13287914 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 |  |  | 40 |  | ø32-ø32 | IZ01.01.0167 | 0167
13303084 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 0.101668 | 2.54171 | 40 | 6609.9 | ø32 | IZ01.01.0168 | 0168
13304860 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 0.00849621 | 0.212405 | 40 | 552.375 | ø32 | IZ01.01.0169 | 0169
13305346 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 0.00950996 | 0.237749 | 40 | 618.283 | ø32 | IZ01.01.0170 | 0170
13311492 | 1.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø40-ø20 | IZ01.01.0171 | 0171
13311829 | 1.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø40-ø32 | IZ01.01.0172 | 0172
13311842 | 1.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø40-ø32 | IZ01.01.0173 | 0173
13313201 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 |  |  | 40 |  | ø40-ø32 | IZ01.01.0174 | 0174
13313208 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 |  |  | 40 |  | ø40-ø32 | IZ01.01.0175 | 0175
13313211 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 |  |  | 40 |  | ø40-ø32 | IZ01.01.0176 | 0176
13313228 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 |  |  | 40 |  | ø40-ø32 | IZ01.01.0177 | 0177
13313231 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 |  |  | 40 |  | ø40-ø32 | IZ01.01.0178 | 0178
13314222 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø40-ø20 | IZ01.01.0179 | 0179
13314225 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø40-ø20 | IZ01.01.0180 | 0180
13314356 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 60 |  | ø80-ø20 | IZ01.01.0181 | 0181
13314946 | 3.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø40-ø20 | IZ01.01.0182 | 0182
13314949 | 3.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø40-ø20 | IZ01.01.0183 | 0183
13314967 | 3.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø40-ø20 | IZ01.01.0184 | 0184
13314970 | 3.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø40-ø20 | IZ01.01.0185 | 0185
13315300 | 3.NP_SO-102 | 255-128-128 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø40-ø32 | IZ01.01.0186 | 0186
13315303 | 3.NP_SO-102 | 0-128-255 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø40-ø32 | IZ01.01.0187 | 0187
13317575 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.0402441 | 1.0061 | 40 | 3161.43 | ø15 | IZ01.01.0188 | 0188
13317576 | 1.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.00405362 | 0.101341 | 40 | 318.437 | ø15 | IZ01.01.0189 | 0189
13317577 | 1.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø15-ø15 | IZ01.01.0190 | 0190
13317578 | 1.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø15-ø15 | IZ01.01.0191 | 0191
13330065 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 0.0429696 | 0.71616 | 60 | 1091.24 | ø80 | IZ01.01.0192 | 0192 | Qto_CoveringBaseQuantities - GrossArea: 0.034269 m2
13331388 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 0.149791 | 2.49652 | 60 | 3804.05 | ø80 | IZ01.01.0193 | 0193
13331707 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 0.0427295 | 0.712158 | 60 | 1085.15 | ø80 | IZ01.01.0194 | 0194 | Qto_CoveringBaseQuantities - GrossArea: 0.034269 m2
13333598 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 0.0018271 | 0.0456775 | 40 | 113.325 | ø40 | IZ01.01.0195 | 0195
13333606 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø40-ø40-ø40 | IZ01.01.0196 | 0196 | Qto_CoveringBaseQuantities - GrossArea: 0.0113968 m2; Width: 121.275 mm
13344354 | 3.NP_SO-102 | 0-128-255 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.00950713 | 0.237678 | 40 | 589.675 | ø40 | IZ01.01.0197 | 0197
13344417 | 3.NP_SO-102 | 0-128-255 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.00451074 | 0.112769 | 40 | 279.777 | ø40 | IZ01.01.0198 | 0198
13344434 | 3.NP_SO-102 | 0-128-255 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø40-ø40 | IZ01.01.0199 | 0199
13344439 | 3.NP_SO-102 | 0-128-255 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø40-ø40 | IZ01.01.0200 | 0200
13344509 | 2.NP_SO-102 | 255-128-128 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 0.0509423 | 1.27356 | 40 | 3159.67 | ø40 | IZ01.01.0201 | 0201
13344576 | 3.NP_SO-102 | 255-128-128 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 0.00208844 | 0.052211 | 40 | 129.534 | ø40 | IZ01.01.0202 | 0202
13344583 | 3.NP_SO-102 | 255-128-128 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø40-ø40 | IZ01.01.0203 | 0203
13344588 | 3.NP_SO-102 | 255-128-128 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø40-ø40 | IZ01.01.0204 | 0204
13362103 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 0.698795 | 11.6466 | 60 | 17746.4 | ø80 | IZ01.01.0205 | 0205 | Qto_CoveringBaseQuantities - GrossArea: 0.034269 m2
13362107 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 60 |  | ø80-ø80-ø80 | IZ01.01.0206 | 0206 | Qto_CoveringBaseQuantities - GrossArea: 0.0159337 m2; Width: 104.775 mm
13362112 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 |  |  | 40 |  | ø80-ø20 | IZ01.01.0207 | 0207
13368479 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 0.00756504 | 0.189126 | 40 | 491.836 | ø32 | IZ01.01.0208 | 0208
13368499 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 |  |  | 60 |  | ø32-ø32 | IZ01.01.0209 | 0209
13368500 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 0.00772562 | 0.12876 | 60 | 252.375 | ø32 | IZ01.01.0210 | 0210
13368508 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 |  |  | 40 |  | ø32-ø32 | IZ01.01.0211 | 0211
13368513 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 |  |  | 40 |  | ø32-ø32 | IZ01.01.0212 | 0212
13368660 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 0.166793 | 4.16983 | 40 | 10843.9 | ø32 | IZ01.01.0213 | 0213
13368685 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 0.164486 | 4.11215 | 40 | 10693.9 | ø32 | IZ01.01.0214 | 0214
13368730 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 0.00157465 | 0.0393664 | 40 | 102.375 | ø32 | IZ01.01.0215 | 0215
13368735 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 |  |  | 40 |  | ø32-ø32 | IZ01.01.0216 | 0216
13368762 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 0.00157465 | 0.0393664 | 40 | 102.375 | ø32 | IZ01.01.0217 | 0217
13368767 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 |  |  | 40 |  | ø32-ø32 | IZ01.01.0218 | 0218
13369707 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 |  |  | 60 |  | ø80-ø80 | IZ01.01.0219 | 0219
13369728 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 |  |  | 60 |  | ø80-ø80 | IZ01.01.0220 | 0220
13383471 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 0.035497 | 0.591616 | 60 | 960.313 | ø65 | IZ01.01.0221 | 0221
13383540 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 0.035497 | 0.591616 | 60 | 960.313 | ø65 | IZ01.01.0222 | 0222 | Qto_CoveringBaseQuantities - GrossArea: 0.0301981 m2
13383765 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 0.035497 | 0.591616 | 60 | 960.313 | ø65 | IZ01.01.0223 | 0223 | Qto_CoveringBaseQuantities - GrossArea: 0.0301981 m2
13383766 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 0.035497 | 0.591616 | 60 | 960.313 | ø65 | IZ01.01.0224 | 0224 | Qto_CoveringBaseQuantities - GrossArea: 0.0301981 m2
13383784 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 0.035497 | 0.591616 | 60 | 960.313 | ø65 | IZ01.01.0225 | 0225 | Qto_CoveringBaseQuantities - GrossArea: 0.0301981 m2
13383805 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 0.044738 | 0.745633 | 60 | 1210.31 | ø65 | IZ01.01.0226 | 0226
13383806 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 6 | 0.044738 | 0.745633 | 60 | 1210.31 | ø65 | IZ01.01.0227 | 0227 | Qto_CoveringBaseQuantities - GrossArea: 0.0301981 m2
13383879 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 0.0502826 | 0.838043 | 60 | 1360.31 | ø65 | IZ01.01.0228 | 0228 | Qto_CoveringBaseQuantities - GrossArea: 0.0301981 m2
13383880 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 0.0502826 | 0.838043 | 60 | 1360.31 | ø65 | IZ01.01.0229 | 0229
13383900 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 0.035497 | 0.591616 | 60 | 960.313 | ø65 | IZ01.01.0230 | 0230
13383901 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 0.035497 | 0.591616 | 60 | 960.313 | ø65 | IZ01.01.0231 | 0231
13384767 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 |  |  | 60 |  | ø65-ø65 | IZ01.01.0232 | 0232
13384768 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 0.0345475 | 0.575791 | 60 | 934.625 | ø65 | IZ01.01.0233 | 0233
13385812 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 0.000527661 | 0.00879435 | 60 | 14.275 | ø65 | IZ01.01.0234 | 0234 | Qto_CoveringBaseQuantities - GrossArea: 0.0301981 m2
13385843 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 0.0352622 | 0.587704 | 60 | 953.962 | ø65 | IZ01.01.0235 | 0235 | Qto_CoveringBaseQuantities - GrossArea: 0.0301981 m2
13385847 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 |  |  | 60 |  | ø65-ø65-ø65 | IZ01.01.0236 | 0236 | Qto_CoveringBaseQuantities - GrossArea: 0.0260178 m2; Width: 186.675 mm
13386086 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 0.0384541 | 0.640901 | 60 | 1040.31 | ø65 | IZ01.01.0237 | 0237
13386152 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 0.035497 | 0.591616 | 60 | 960.313 | ø65 | IZ01.01.0238 | 0238
13387230 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 0.00263008 | 0.0438347 | 60 | 71.1526 | ø65 | IZ01.01.0239 | 0239
13387809 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 0.00785758 | 0.13096 | 60 | 212.574 | ø65 | IZ01.01.0240 | 0240
13391423 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 0.169543 | 2.82571 | 60 | 4305.66 | ø80 | IZ01.01.0241 | 0241
13393499 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 0.00524383 | 0.0873972 | 60 | 141.863 | ø65 | IZ01.01.0242 | 0242
13393696 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 0.178559 | 2.97598 | 60 | 4830.62 | ø65 | IZ01.01.0243 | 0243
13393743 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 0.164989 | 2.74981 | 60 | 4463.5 | ø65 | IZ01.01.0244 | 0244
13395155 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 0.149543 | 2.49239 | 60 | 4045.64 | ø65 | IZ01.01.0245 | 0245
13395156 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 0.166822 | 2.78037 | 60 | 4513.1 | ø65 | IZ01.01.0246 | 0246
13395204 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 0.000762382 | 0.0127064 | 60 | 20.625 | ø65 | IZ01.01.0247 | 0247
13395209 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 |  |  | 60 |  | ø65-ø65 | IZ01.01.0248 | 0248
13395210 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 0.058282 | 0.971367 | 60 | 1576.73 | ø65 | IZ01.01.0249 | 0249
13395213 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 |  |  | 60 |  | ø65-ø65 | IZ01.01.0250 | 0250
13395220 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 0.000762382 | 0.0127064 | 60 | 20.625 | ø65 | IZ01.01.0251 | 0251
13395225 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 |  |  | 60 |  | ø65-ø65 | IZ01.01.0252 | 0252
13395226 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 0.0601302 | 1.00217 | 60 | 1626.73 | ø65 | IZ01.01.0253 | 0253
13395229 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 |  |  | 60 |  | ø65-ø65 | IZ01.01.0254 | 0254
13395498 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 0.018969 | 0.31615 | 60 | 481.731 | ø80 | IZ01.01.0255 | 0255 | Qto_CoveringBaseQuantities - GrossArea: 0.034269 m2
13395500 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 |  |  | 60 |  | ø80-ø80-ø80 | IZ01.01.0256 | 0256 | Qto_CoveringBaseQuantities - GrossArea: 0.0208895 m2; Width: 199.375 mm
13395532 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 0.018969 | 0.31615 | 60 | 481.731 | ø80 | IZ01.01.0257 | 0257 | Qto_CoveringBaseQuantities - GrossArea: 0.034269 m2
13395534 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 |  |  | 60 |  | ø65-ø65-ø65 | IZ01.01.0258 | 0258 | Qto_CoveringBaseQuantities - GrossArea: 0.0171881 m2; Width: 186.675 mm
13395564 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 0.018969 | 0.31615 | 60 | 481.731 | ø80 | IZ01.01.0259 | 0259 | Qto_CoveringBaseQuantities - GrossArea: 0.034269 m2
13395566 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 |  |  | 60 |  | ø65-ø65-ø65 | IZ01.01.0260 | 0260 | Qto_CoveringBaseQuantities - GrossArea: 0.0171881 m2; Width: 186.675 mm
13395572 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 0.000527661 | 0.00879435 | 60 | 14.275 | ø65 | IZ01.01.0261 | 0261
13395577 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 |  |  | 60 |  | ø65-ø65 | IZ01.01.0262 | 0262
13395582 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 |  |  | 60 |  | ø65-ø65 | IZ01.01.0263 | 0263
13395606 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 |  |  | 60 |  | ø65-ø65 | IZ01.01.0264 | 0264
13395610 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 0.018969 | 0.31615 | 60 | 481.731 | ø80 | IZ01.01.0265 | 0265 | Qto_CoveringBaseQuantities - GrossArea: 0.034269 m2
13395612 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 |  |  | 60 |  | ø80-ø80-ø80 | IZ01.01.0266 | 0266 | Qto_CoveringBaseQuantities - GrossArea: 0.0159337 m2; Width: 152.075 mm
13395632 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 0.0310321 | 0.517201 | 60 | 788.081 | ø80 | IZ01.01.0267 | 0267 | Qto_CoveringBaseQuantities - GrossArea: 0.034269 m2
13395634 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 |  |  | 60 |  | ø80-ø80-ø80 | IZ01.01.0268 | 0268 | Qto_CoveringBaseQuantities - GrossArea: 0.0208895 m2; Width: 199.375 mm
13395674 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 0.00687468 | 0.114578 | 60 | 174.587 | ø80 | IZ01.01.0269 | 0269 | Qto_CoveringBaseQuantities - GrossArea: 0.034269 m2
13395676 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 |  |  | 60 |  | ø65-ø65-ø65 | IZ01.01.0270 | 0270 | Qto_CoveringBaseQuantities - GrossArea: 0.0171881 m2; Width: 186.675 mm
13396379 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 0.0528801 | 0.881335 | 60 | 1430.59 | ø65 | IZ01.01.0271 | 0271
13402086 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 |  |  | 60 |  | ø65-ø65 | IZ01.01.0272 | 0272
13402087 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 0.0695078 | 1.15846 | 60 | 1880.42 | ø65 | IZ01.01.0273 | 0273
13402356 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 0.054402 | 0.9067 | 60 | 1471.76 | ø65 | IZ01.01.0274 | 0274
13402485 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 0.520285 | 8.67142 | 60 | 13213 | ø80 | IZ01.01.0275 | 0275
13402489 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 0.52118 | 8.68634 | 60 | 13235.7 | ø80 | IZ01.01.0276 | 0276
13402509 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 |  |  | 60 |  | ø80-ø80 | IZ01.01.0277 | 0277
13402548 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 0.0446325 | 0.743875 | 60 | 1133.47 | ø80 | IZ01.01.0278 | 0278
13402567 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 0.00424973 | 0.0708289 | 60 | 107.925 | ø80 | IZ01.01.0279 | 0279
13402572 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 |  |  | 60 |  | ø80-ø80 | IZ01.01.0280 | 0280
13402573 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 0.00579767 | 0.0966278 | 60 | 147.236 | ø80 | IZ01.01.0281 | 0281
13402576 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 |  |  | 60 |  | ø80-ø80 | IZ01.01.0282 | 0282
13402603 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 0.238816 | 3.98026 | 60 | 6064.89 | ø80 | IZ01.01.0283 | 0283
13402633 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 0.232953 | 3.88255 | 60 | 5916 | ø80 | IZ01.01.0284 | 0284
13402831 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 0.0393942 | 0.656571 | 60 | 1000.44 | ø80 | IZ01.01.0285 | 0285
13402838 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 0.0305345 | 0.508908 | 60 | 775.445 | ø80 | IZ01.01.0286 | 0286
13404535 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 0.298286 | 4.97144 | 60 | 7575.19 | ø80 | IZ01.01.0287 | 0287
13404560 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 |  |  | 60 |  | ø80-ø80 | IZ01.01.0288 | 0288
13404561 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 0.00821747 | 0.136958 | 60 | 208.689 | ø80 | IZ01.01.0289 | 0289
13404562 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 |  |  | 60 |  | ø80-ø80 | IZ01.01.0290 | 0290
13404563 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 0.0345883 | 0.576471 | 60 | 878.394 | ø80 | IZ01.01.0291 | 0291
13404564 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 |  |  | 60 |  | ø80-ø80 | IZ01.01.0292 | 0292
13404751 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 0.0140906 | 0.234843 | 60 | 357.841 | ø80 | IZ01.01.0293 | 0293
13404752 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 0.0480281 | 0.800468 | 60 | 1219.71 | ø80 | IZ01.01.0294 | 0294
13404853 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 |  |  | 60 |  | ø80-ø80 | IZ01.01.0295 | 0295
13405124 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 |  |  | 60 |  | ø80-ø65 | IZ01.01.0296 | 0296
13405127 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 |  |  | 60 |  | ø80-ø65 | IZ01.01.0297 | 0297
13405136 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 |  |  | 60 |  | ø80-ø65 | IZ01.01.0298 | 0298
13405139 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 |  |  | 60 |  | ø80-ø65 | IZ01.01.0299 | 0299
13405142 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 |  |  | 60 |  | ø80-ø65 | IZ01.01.0300 | 0300
13405145 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 |  |  | 60 |  | ø80-ø65 | IZ01.01.0301 | 0301
13405160 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 |  |  | 60 |  | ø80-ø65 | IZ01.01.0302 | 0302
13405163 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 |  |  | 60 |  | ø80-ø65 | IZ01.01.0303 | 0303
13405196 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 |  |  | 60 |  | ø80-ø65 | IZ01.01.0304 | 0304
13405199 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 |  |  | 60 |  | ø80-ø65 | IZ01.01.0305 | 0305
13405202 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 |  |  | 60 |  | ø80-ø65 | IZ01.01.0306 | 0306
13405247 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 |  |  | 60 |  | ø80-ø65 | IZ01.01.0307 | 0307
13405250 | 2.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 |  |  | 60 |  | ø80-ø65 | IZ01.01.0308 | 0308
13405253 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 |  |  | 60 |  | ø80-ø65 | IZ01.01.0309 | 0309
13405256 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 |  |  | 60 |  | ø80-ø65 | IZ01.01.0310 | 0310
13407137 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 0.0538057 | 0.896762 | 60 | 1455.62 | ø65 | IZ01.01.0311 | 0311
13407655 | 1.NP_SO-102 | 0-128-255 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø50-ø42 | IZ01.01.0312 | 0312
13407658 | 1.NP_SO-102 | 0-128-255 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø50-ø20 | IZ01.01.0313 | 0313
13412837 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 0.139947 | 2.33245 | 60 | 3554.05 | ø80 | IZ01.01.0314 | 0314
13414032 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 |  |  | 60 |  | ø80-ø80 | IZ01.01.0315 | 0315
13414142 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 |  |  | 60 |  | ø80-ø80 | IZ01.01.0316 | 0316
13414582 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 | 0.0168503 | 0.280838 | 60 | 427.925 | ø80 | IZ01.01.0317 | 0317
13416390 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 5 |  |  | 60 |  | ø80-ø80 | IZ01.01.0318 | 0318
13417809 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 |  |  | 40 |  | ø32-ø32 | IZ01.01.0319 | 0319
13417812 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 |  |  | 40 |  | ø32-ø32 | IZ01.01.0320 | 0320
13417815 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 |  |  | 40 |  | ø32-ø32 | IZ01.01.0321 | 0321
13417818 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 |  |  | 40 |  | ø32-ø32 | IZ01.01.0322 | 0322
13418112 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 |  |  | 60 |  | ø32-ø32 | IZ01.01.0323 | 0323
13418113 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 0.00772562 | 0.12876 | 60 | 252.375 | ø32 | IZ01.01.0324 | 0324
13418121 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 |  |  | 40 |  | ø32-ø32 | IZ01.01.0325 | 0325
13418126 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 |  |  | 40 |  | ø32-ø32 | IZ01.01.0326 | 0326
13427562 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 0.0908399 | 2.271 | 40 | 5905.89 | ø32 | IZ01.01.0327 | 0327
13427582 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 0.090901 | 2.27253 | 40 | 5909.86 | ø32 | IZ01.01.0328 | 0328
13427676 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 |  |  | 40 |  | ø32-ø32 | IZ01.01.0329 | 0329
13427677 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 0.00541996 | 0.135499 | 40 | 352.375 | ø32 | IZ01.01.0330 | 0330
13427691 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 |  |  | 40 |  | ø32-ø32 | IZ01.01.0331 | 0331
13427715 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 |  |  | 40 |  | ø32-ø32 | IZ01.01.0332 | 0332
13427716 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 0.00541996 | 0.135499 | 40 | 352.375 | ø32 | IZ01.01.0333 | 0333
13427726 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 |  |  | 40 |  | ø32-ø32 | IZ01.01.0334 | 0334
13427731 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 |  |  | 40 |  | ø32-ø32 | IZ01.01.0335 | 0335
13427759 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 0.0332991 | 0.832478 | 40 | 2164.92 | ø32 | IZ01.01.0336 | 0336
13427778 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 0.0332991 | 0.832478 | 40 | 2164.92 | ø32 | IZ01.01.0337 | 0337
13427865 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 |  |  | 40 |  | ø32-ø32 | IZ01.01.0338 | 0338
13427866 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 0.00388184 | 0.097046 | 40 | 252.375 | ø32 | IZ01.01.0339 | 0339
13427876 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 |  |  | 40 |  | ø32-ø32 | IZ01.01.0340 | 0340
13427881 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 |  |  | 40 |  | ø32-ø32 | IZ01.01.0341 | 0341
13427905 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 |  |  | 40 |  | ø32-ø32 | IZ01.01.0342 | 0342
13427906 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 0.00388184 | 0.097046 | 40 | 252.375 | ø32 | IZ01.01.0343 | 0343
13427916 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 |  |  | 40 |  | ø32-ø32 | IZ01.01.0344 | 0344
13427921 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 |  |  | 40 |  | ø32-ø32 | IZ01.01.0345 | 0345
13434284 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 0.0522322 | 1.3058 | 40 | 3239.67 | ø40 | IZ01.01.0346 | 0346
13434292 | 2.NP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 |  |  | 40 |  | ø40-ø40-ø40 | IZ01.01.0347 | 0347 | Qto_CoveringBaseQuantities - GrossArea: 0.0113968 m2; Width: 93.975 mm
13435942 | 4.NP_SO-102 | 0-128-255 | Fáze 2 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 |  |  | 60 |  | ø65-ø65 | IZ01.01.0348 | 0348
13435959 | 4.NP_SO-102 | 255-128-128 | Fáze 2 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 |  |  | 60 |  | ø65-ø65 | IZ01.01.0349 | 0349
13435972 | 4.NP_SO-102 | 0-128-255 | Fáze 2 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 |  |  | 60 |  | ø65-ø65 | IZ01.01.0350 | 0350
13435989 | 4.NP_SO-102 | 0-128-255 | Fáze 2 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 |  |  | 60 |  | ø65-ø65 | IZ01.01.0351 | 0351
13436012 | 4.NP_SO-102 | 255-128-128 | Fáze 2 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 |  |  | 60 |  | ø65-ø65 | IZ01.01.0352 | 0352
13436025 | 4.NP_SO-102 | 0-128-255 | Fáze 2 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 6 |  |  | 60 |  | ø65-ø65 | IZ01.01.0353 | 0353
13436042 | 4.NP_SO-102 | 255-128-128 | Fáze 2 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 |  |  | 60 |  | ø65-ø65 | IZ01.01.0354 | 0354
13436069 | 4.NP_SO-102 | 0-128-255 | Fáze 2 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 |  |  | 60 |  | ø65-ø65 | IZ01.01.0355 | 0355
13436082 | 4.NP_SO-102 | 255-128-128 | Fáze 2 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 |  |  | 60 |  | ø65-ø65 | IZ01.01.0356 | 0356
13436137 | 4.NP_SO-102 | 0-128-255 | Fáze 2 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 |  |  | 60 |  | ø65-ø65 | IZ01.01.0357 | 0357
13449396 | -1.PP_SO-102 | 255-128-128 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 0.0544448 | 0.907413 | 60 | 1778.56 | ø32 | IZ01.01.0358 | 0358 | Qto_CoveringBaseQuantities - GrossArea: 0.0207108 m2
13449436 | -1.PP_SO-102 | 0-128-255 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 0.0612345 | 1.02058 | 60 | 2000.36 | ø32 | IZ01.01.0359 | 0359 | Qto_CoveringBaseQuantities - GrossArea: 0.0207108 m2
13450647 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 |  |  | 60 |  | ø80-ø80 | IZ01.01.0360 | 0360
13450648 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 0.00128258 | 0.0213763 | 60 | 32.572 | ø80 | IZ01.01.0361 | 0361
13450668 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 |  |  | 60 |  | ø80-ø80 | IZ01.01.0362 | 0362
13450669 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 0.00128258 | 0.0213763 | 60 | 32.572 | ø80 | IZ01.01.0363 | 0363
13450910 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 |  |  | 60 |  | ø80-ø80 | IZ01.01.0364 | 0364
13450911 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 0.0081874 | 0.136457 | 60 | 207.925 | ø80 | IZ01.01.0365 | 0365
13450916 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 |  |  | 60 |  | ø80-ø80 | IZ01.01.0366 | 0366
13450919 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 |  |  | 60 |  | ø80-ø80 | IZ01.01.0367 | 0367
13450925 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 |  |  | 60 |  | ø80-ø80 | IZ01.01.0368 | 0368
13450926 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 0.0081874 | 0.136457 | 60 | 207.925 | ø80 | IZ01.01.0369 | 0369
13450931 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 |  |  | 60 |  | ø80-ø80 | IZ01.01.0370 | 0370
13450936 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 |  |  | 60 |  | ø80-ø80 | IZ01.01.0371 | 0371
13453348 | 4.NP_SO-102 | 0-128-255 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 0.00785758 | 0.13096 | 60 | 212.574 | ø65 | IZ01.01.0372 | 0372
13453663 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 |  |  | 60 |  | ø80-ø80 | IZ01.01.0373 | 0373
13454009 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 0.00213257 | 0.0355428 | 60 | 54.158 | ø80 | IZ01.01.0374 | 0374 | Qto_CoveringBaseQuantities - GrossArea: 0.034269 m2
13454043 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 0.0542428 | 0.904047 | 60 | 1467.45 | ø65 | IZ01.01.0375 | 0375
13454045 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 |  |  | 60 |  | ø65-ø65-ø65 | IZ01.01.0376 | 0376 | Qto_CoveringBaseQuantities - GrossArea: 0.0171881 m2; Width: 186.675 mm
13454074 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 |  |  | 60 |  | ø80-ø65 | IZ01.01.0377 | 0377
13454212 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 |  |  | 60 |  | ø65-ø65 | IZ01.01.0378 | 0378
13454213 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 0.0118516 | 0.197526 | 60 | 320.625 | ø65 | IZ01.01.0379 | 0379
13454218 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 |  |  | 60 |  | ø65-ø65 | IZ01.01.0380 | 0380
13454219 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 0.0148556 | 0.247593 | 60 | 401.894 | ø65 | IZ01.01.0381 | 0381
13454222 | 4.NP_SO-102 | 255-128-128 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 |  |  | 60 |  | ø65-ø65 | IZ01.01.0382 | 0382

# IfcDistributionPort (10261)
Description: Flow
Name | FlowDirection | PredefinedType | SystemType | Group
OutPort_12775714_1 | SOURCE | PIPE | HEATING
InPort_12775714_2 | SINK | PIPE | HEATING
InPort_12775764_1 | SINK | PIPE | HEATING
OutPort_12775764_2 | SOURCE | PIPE | HEATING
OutPort_12776152_1 | SOURCE | PIPE | HEATING
InPort_12776152_2 | SINK | PIPE | HEATING
Port_12776203_3 | SOURCEANDSINK | PIPE
Port_12776203_4 | SOURCEANDSINK | PIPE
Port_12776203_5 | SOURCEANDSINK | PIPE
InPort_12776305_1 | SINK | PIPE | HEATING
OutPort_12776305_2 | SOURCE | PIPE | HEATING
InPort_12776338_1 | SINK | PIPE | HEATING
OutPort_12776338_2 | SOURCE | PIPE | HEATING
Port_12776519_3 | SOURCEANDSINK | PIPE
Port_12776519_4 | SOURCEANDSINK | PIPE
Port_12776519_5 | SOURCEANDSINK | PIPE
OutPort_12776532_1 | SOURCE | PIPE | HEATING
InPort_12776532_2 | SINK | PIPE | HEATING
OutPort_12776545_1 | SOURCE | PIPE | HEATING
InPort_12776545_2 | SINK | PIPE | HEATING
InPort_12776642_1 | SINK | PIPE | HEATING
OutPort_12776642_2 | SOURCE | PIPE | HEATING
InPort_12776771_1 | SINK | PIPE | HEATING
OutPort_12776771_2 | SOURCE | PIPE | HEATING
Port_12776841_3 | SOURCEANDSINK | PIPE
Port_12776841_4 | SOURCEANDSINK | PIPE
Port_12776841_5 | SOURCEANDSINK | PIPE
OutPort_12776977_1 | SOURCE | PIPE | HEATING
InPort_12776977_2 | SINK | PIPE | HEATING
OutPort_12777052_1 | SOURCE | PIPE | HEATING
InPort_12777052_2 | SINK | PIPE | HEATING
OutPort_12777135_1 | SOURCE | PIPE | HEATING
InPort_12777135_2 | SINK | PIPE | HEATING
Port_12777337_3 | SOURCEANDSINK | PIPE
Port_12777337_4 | SOURCEANDSINK | PIPE
Port_12777337_5 | SOURCEANDSINK | PIPE
InPort_12777346_1 | SINK | PIPE | HEATING
OutPort_12777346_2 | SOURCE | PIPE | HEATING
InPort_12777470_1 | SINK | PIPE | HEATING
OutPort_12777470_2 | SOURCE | PIPE | HEATING
InPort_12777482_1 | SINK | PIPE | HEATING
OutPort_12777482_2 | SOURCE | PIPE | HEATING
InPort_12777494_1 | SINK | PIPE | HEATING
OutPort_12777494_2 | SOURCE | PIPE | HEATING
OutPort_12778082_1 | SOURCE | PIPE | HEATING
InPort_12778082_2 | SINK | PIPE | HEATING
Port_12778255_3 | SOURCEANDSINK | PIPE
Port_12778255_4 | SOURCEANDSINK | PIPE
Port_12778255_5 | SOURCEANDSINK | PIPE
InPort_12778448_1 | SINK | PIPE | HEATING
OutPort_12778448_2 | SOURCE | PIPE | HEATING
InPort_12778506_1 | SINK | PIPE | HEATING
OutPort_12778506_2 | SOURCE | PIPE | HEATING
InPort_12778721_1 | SINK | PIPE | HEATING
OutPort_12778721_2 | SOURCE | PIPE | HEATING
OutPort_12778776_1 | SOURCE | PIPE | HEATING
InPort_12778776_2 | SINK | PIPE | HEATING
OutPort_12778827_1 | SOURCE | PIPE | HEATING
InPort_12778827_2 | SINK | PIPE | HEATING
InPort_12778969_1 | SINK | PIPE | HEATING
OutPort_12778969_2 | SOURCE | PIPE | HEATING
InPort_12779027_1 | SINK | PIPE | HEATING
OutPort_12779027_2 | SOURCE | PIPE | HEATING
InPort_12779039_1 | SINK | PIPE | HEATING
OutPort_12779039_2 | SOURCE | PIPE | HEATING
InPort_12779049_1 | SINK | PIPE | HEATING
OutPort_12779049_2 | SOURCE | PIPE | HEATING
InPort_12779169_1 | SINK | PIPE | HEATING
OutPort_12779169_2 | SOURCE | PIPE | HEATING
InPort_12779247_1 | SINK | PIPE | HEATING
OutPort_12779247_2 | SOURCE | PIPE | HEATING
Port_12779260_3 | SOURCEANDSINK | PIPE
Port_12779260_4 | SOURCEANDSINK | PIPE
Port_12779260_5 | SOURCEANDSINK | PIPE
InPort_12779359_1 | SINK | PIPE | HEATING
OutPort_12779359_2 | SOURCE | PIPE | HEATING
InPort_12779367_1 | SINK | PIPE | HEATING
OutPort_12779367_2 | SOURCE | PIPE | HEATING
InPort_12779377_1 | SINK | PIPE | HEATING
OutPort_12779377_2 | SOURCE | PIPE | HEATING
InPort_12779824_1 | SINK | PIPE | HEATING
OutPort_12779824_2 | SOURCE | PIPE | HEATING
InPort_12779832_1 | SINK | PIPE | HEATING
OutPort_12779832_2 | SOURCE | PIPE | HEATING
InPort_12779840_1 | SINK | PIPE | HEATING
OutPort_12779840_2 | SOURCE | PIPE | HEATING
Port_12779876_3 | SOURCEANDSINK | PIPE
Port_12779876_4 | SOURCEANDSINK | PIPE
Port_12779876_5 | SOURCEANDSINK | PIPE
InPort_12780141_1 | SINK | PIPE | HEATING
OutPort_12780141_2 | SOURCE | PIPE | HEATING
OutPort_12780760_1 | SOURCE | PIPE | HEATING
InPort_12780760_2 | SINK | PIPE | HEATING
OutPort_12780769_1 | SOURCE | PIPE | HEATING
InPort_12780769_2 | SINK | PIPE | HEATING
OutPort_12780778_1 | SOURCE | PIPE | HEATING
InPort_12780778_2 | SINK | PIPE | HEATING
OutPort_12780835_1 | SOURCE | PIPE | HEATING
InPort_12780835_2 | SINK | PIPE | HEATING
OutPort_12780892_1 | SOURCE | PIPE | HEATING
InPort_12780892_2 | SINK | PIPE | HEATING
OutPort_12780975_1 | SOURCE | PIPE | HEATING
InPort_12780975_2 | SINK | PIPE | HEATING
OutPort_12780989_1 | SOURCE | PIPE | HEATING
InPort_12780989_2 | SINK | PIPE | HEATING
OutPort_12781052_1 | SOURCE | PIPE | HEATING
InPort_12781052_2 | SINK | PIPE | HEATING
Port_12805506_3 | SOURCEANDSINK | PIPE
Port_12805506_4 | SOURCEANDSINK | PIPE
Port_12805506_5 | SOURCEANDSINK | PIPE
Port_12805615_3 | SOURCEANDSINK | PIPE
Port_12805615_4 | SOURCEANDSINK | PIPE
Port_12805615_5 | SOURCEANDSINK | PIPE
Port_12806367_3 | SOURCEANDSINK | PIPE
Port_12806367_4 | SOURCEANDSINK | PIPE
Port_12806367_5 | SOURCEANDSINK | PIPE
OutPort_12806450_1 | SOURCE | PIPE | HEATING
InPort_12806450_2 | SINK | PIPE | HEATING
OutPort_12806558_1 | SOURCE | PIPE | HEATING
InPort_12806558_2 | SINK | PIPE | HEATING
OutPort_12821721_1 | SOURCE | PIPE | HEATING
InPort_12821721_2 | SINK | PIPE | HEATING
OutPort_12821829_1 | SOURCE | PIPE | HEATING
InPort_12821829_2 | SINK | PIPE | HEATING
InPort_13284111_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 28
OutPort_12856536_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 28
InPort_13284039_0 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_12856536_2 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13284075_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_12856536_3 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13283997_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
OutPort_12856536_4 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
InPort_13283961_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 2
OutPort_12856536_5 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 2
InPort_13283925_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_12856536_6 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_12856536_7 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
OutPort_13216278_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
InPort_12857599_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 31
OutPort_13283891_0 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 31
InPort_12857599_2 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13283852_0 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_12857599_3 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
OutPort_13283819_0 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 26
InPort_12857599_4 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
OutPort_13283779_0 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 9
InPort_12857599_5 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 10
OutPort_13283743_0 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 10
InPort_12857599_6 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
OutPort_13283707_0 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13436252_2 | SINK | PIPE | HEATING | HT_PRIMÁR_vratné 4
OutPort_12857599_7 | SOURCE | PIPE | HEATING | HT_PRIMÁR_vratné 4
InPort_13223091_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 13
OutPort_12860398_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 13
InPort_12860398_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 26
OutPort_13223023_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 26
InPort_12860398_3 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
OutPort_13222965_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
InPort_12860398_7 | SINK | PIPE | HEATING | HT_PRIMÁR_vratné 1
InPort_13223057_0 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 20
OutPort_12860437_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 20
InPort_12860437_2 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 21
OutPort_13222992_0 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 21
InPort_12860437_3 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
OutPort_13222919_0 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 23
InPort_12860437_7 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 5
OutPort_13219962_0 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 5
Port_12863301_1 | SOURCEANDSINK | PIPE | HEATING
Port_12863324_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 4
Port_12890949_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 15
InPort_12903388_2 | SINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 3
InPort_13216308_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
OutPort_12903388_3 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
Port_12903388_4 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 5
Port_13219709_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 5
Port_12903388_5 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 4
Port_12903388_6 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
Port_12903388_7 | SOURCEANDSINK | PIPE | HEATING
Port_12903660_2 | SOURCEANDSINK | PIPE
InPort_13245768_0 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 5
OutPort_12903824_1 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 5
InPort_12903824_2 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 6
OutPort_13245609_0 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 6
InPort_12903824_3 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 7
OutPort_13390629_1 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 7
InPort_12903824_7 | SINK | PIPE | HEATING
InPort_13245543_0 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 5
OutPort_12903825_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 5
InPort_12903825_2 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 6
OutPort_13245511_0 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 6
InPort_12903825_3 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 4
OutPort_13390594_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 4
InPort_12903825_7 | SINK | PIPE | HEATING
InPort_12903865_2 | SINK | PIPE
Port_12903865_3 | SOURCEANDSINK | PIPE
Port_12903865_4 | SOURCEANDSINK | PIPE
Port_12903865_5 | SOURCEANDSINK | PIPE
OutPort_12906882_1 | SOURCE | PIPE | HEATING
OutPort_12906882_3 | SOURCE | PIPE | HEATING
InPort_12906882_5 | SINK | PIPE | HEATING
InPort_12906882_7 | SINK | PIPE | HEATING
OutPort_12906972_1 | SOURCE | PIPE | HEATING
OutPort_12906972_3 | SOURCE | PIPE | HEATING
InPort_12906972_5 | SINK | PIPE | HEATING
InPort_12906972_7 | SINK | PIPE | HEATING
InPort_12976914_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13369705_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13414140_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_12976914_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13413388_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_12976925_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_12976925_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13414099_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13052511_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_12977026_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_12977026_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13416308_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_12977266_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13052511_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13125751_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_12977266_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
Port_12977731_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13404672_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_12977731_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13189272_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
InPort_12977772_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13125751_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13125756_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_12977772_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
Port_12978744_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_12978746_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_12978744_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_12978750_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_12978746_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13216960_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_12978750_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13362101_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_12978827_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13216959_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_12978827_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13066253_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_12978875_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_12978877_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_12978875_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_12978881_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_12978877_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13066253_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_12978881_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_12978885_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_12978885_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13069810_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_12978897_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13069810_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_12978897_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13069812_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_12979010_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13070117_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_12979010_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13070137_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_12979050_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13314681_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_12979050_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13136139_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_12979250_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_12979432_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_12979250_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13160630_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_12979432_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13207981_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
InPort_12980713_1 | SINK | PIPE | HEATING
OutPort_12980713_2 | SOURCE | PIPE | HEATING
InPort_12981799_1 | SINK | PIPE | HEATING
OutPort_12981799_2 | SOURCE | PIPE | HEATING
OutPort_12983075_1 | SOURCE | PIPE | HEATING
InPort_12983075_2 | SINK | PIPE | HEATING
Port_12985708_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13159568_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_12985708_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_12985831_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
InPort_12985754_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
OutPort_12985797_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
InPort_13160798_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
OutPort_12985754_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
InPort_12985797_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
OutPort_13206680_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
Port_12985831_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13208015_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_12989258_3 | SOURCEANDSINK | PIPE
Port_12989258_4 | SOURCEANDSINK | PIPE
Port_12989258_5 | SOURCEANDSINK | PIPE
Port_12989266_3 | SOURCEANDSINK | PIPE
Port_12989266_4 | SOURCEANDSINK | PIPE
Port_12989266_5 | SOURCEANDSINK | PIPE
InPort_12989728_1 | SINK | PIPE | HEATING
OutPort_12989728_2 | SOURCE | PIPE | HEATING
InPort_12989812_1 | SINK | PIPE | HEATING
OutPort_12989812_2 | SOURCE | PIPE | HEATING
InPort_12989892_1 | SINK | PIPE | HEATING
OutPort_12989892_2 | SOURCE | PIPE | HEATING
OutPort_12989979_1 | SOURCE | PIPE | HEATING
InPort_12989979_2 | SINK | PIPE | HEATING
InPort_12990043_1 | SINK | PIPE | HEATING
OutPort_12990043_2 | SOURCE | PIPE | HEATING
InPort_12990089_1 | SINK | PIPE | HEATING
OutPort_12990089_2 | SOURCE | PIPE | HEATING
InPort_12990200_1 | SINK | PIPE | HEATING
OutPort_12990200_2 | SOURCE | PIPE | HEATING
Port_12990216_3 | SOURCEANDSINK | PIPE
Port_12990216_4 | SOURCEANDSINK | PIPE
Port_12990216_5 | SOURCEANDSINK | PIPE
Port_12990472_3 | SOURCEANDSINK | PIPE
Port_12990472_4 | SOURCEANDSINK | PIPE
