Properties of the parts of a building model (IFC4), part 49 of 72

# IfcPipeFitting: M_Koleno, obecné:Standardní (1543)
Name (M_Koleno, obecné:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm) | Group
13278388 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 2700 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1187 | 1187 | yes | 39.6875 | 33.3375 | CL_vratné vodní (15 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13278390 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 2700 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1188 | 1188 | yes | 39.6875 | 33.3375 | CL_vratné vodní (15 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13278422 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 2700 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1190 | 1190 | yes | 39.6875 | 33.3375 | CL_přívodní vodní (10 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13278424 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 2700 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 5 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1191 | 1191 | yes | 39.6875 | 33.3375 | CL_přívodní vodní (10 °C) 5 | Mechanické – tok - Tlaková ztráta: 0 Pa
13278456 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 2550 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 6 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1193 | 1193 | yes | 39.6875 | 33.3375 | CL_vratné vodní (15 °C) 6 | Mechanické – tok - Tlaková ztráta: 0 Pa
13278458 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 2550 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 6 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1194 | 1194 | yes | 39.6875 | 33.3375 | CL_vratné vodní (15 °C) 6 | Mechanické – tok - Tlaková ztráta: 0 Pa
13278483 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 2500 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 6 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1195 | 1195 | yes | 39.6875 | 33.3375 | CL_přívodní vodní (10 °C) 6 | Mechanické – tok - Tlaková ztráta: 0 Pa
13278560 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1197 | 1197 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 25
13279703 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1198 | 1198 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 25 | Mechanické – tok - Tlaková ztráta: 0 Pa
13279859 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1199 | 1199 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 26
13280013 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2550 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1200 | 1200 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13280925 | 2.NP_SO-102 | 0 | ø89 mm-ø89 mm | HC | 2.NP_SO-102 | 2500 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.01.1201 | 1201 | yes | 52.4375 | 46.0875 | CL_přívodní vodní (10 °C) 4
13280955 | 2.NP_SO-102 | 0 | ø89 mm-ø89 mm | HC | 2.NP_SO-102 | 2500 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 44.5 | 89 | 0.000549623 | 52.4375 | 90 | ø89-ø89 | 36.87 | 92.175 | TT01.01.1202 | 1202 | yes | 52.4375 | 46.0875 | CL_vratné vodní (15 °C) 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13281016 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1203 | 1203 | yes | 20.6375 | 14.2875 | CL_přívodní vodní (10 °C) 4
13281660 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1205 | 1205 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13281671 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1206 | 1206 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 25 | Mechanické – tok - Tlaková ztráta: 0 Pa
13282200 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 10 | 20 | 0.00000354698 | 4.67906 | 30 | ø20-ø20 | 2.38207 | 22.225 | TT01.01.1207 | 1207 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 25 | Mechanické – tok - Tlaková ztráta: 0 Pa
13282216 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2250 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 10 | 20 | 0.00000354698 | 4.67906 | 30 | ø20-ø20 | 2.38207 | 22.225 | TT01.01.1208 | 1208 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 25 | Mechanické – tok - Tlaková ztráta: 0 Pa
13282331 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1209 | 1209 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 25 | Mechanické – tok - Tlaková ztráta: 0 Pa
13282380 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2250 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 10 | 20 | 0.00000354698 | 4.67906 | 30 | ø20-ø20 | 2.38207 | 22.225 | TT01.01.1210 | 1210 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 25 | Mechanické – tok - Tlaková ztráta: 0 Pa
13282384 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 10 | 20 | 0.00000354698 | 4.67906 | 30 | ø20-ø20 | 2.38207 | 22.225 | TT01.01.1211 | 1211 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 25 | Mechanické – tok - Tlaková ztráta: 0 Pa
13282484 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1212 | 1212 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13282486 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.00000354698 | 4.67906 | 30 | ø20-ø20 | 2.38207 | 22.225 | TT01.01.1213 | 1213 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13282650 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2550 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.00000354698 | 4.67906 | 30 | ø20-ø20 | 2.38207 | 22.225 | TT01.01.1214 | 1214 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13282705 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 2750 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1215 | 1215 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 27 | Mechanické – tok - Tlaková ztráta: 0 Pa
13282709 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1216 | 1216 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 25 | Mechanické – tok - Tlaková ztráta: 0 Pa
13282817 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2550 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1217 | 1217 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13282819 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2550 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1218 | 1218 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13282940 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1219 | 1219 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 25
13282942 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1220 | 1220 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 25 | Mechanické – tok - Tlaková ztráta: 0 Pa
13282968 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2500 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1221 | 1221 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13282970 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2500 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1222 | 1222 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13283004 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 1000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1224 | 1224 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13283042 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 1000 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1226 | 1226 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 25
13283128 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1227 | 1227 | yes | 20.6375 | 14.2875 | CL_vratné vodní (15 °C) 11
13283130 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 1000 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1228 | 1228 | yes | 20.6375 | 14.2875 | CL_vratné vodní (15 °C) 11
13283163 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1229 | 1229 | yes | 20.6375 | 14.2875 | CL_přívodní vodní (10 °C) 4
13283165 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 1000 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1230 | 1230 | yes | 20.6375 | 14.2875 | CL_přívodní vodní (10 °C) 4
13283715 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1231 | 1231 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13283749 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1232 | 1232 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13283753 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1233 | 1233 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13283785 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1234 | 1234 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13283789 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1235 | 1235 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13283825 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1236 | 1236 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 26 | Mechanické – tok - Tlaková ztráta: 0 Pa
13283829 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1237 | 1237 | yes | 39.6875 | 33.3375 | HT_vratné vodní (45 °C) 26 | Mechanické – tok - Tlaková ztráta: 0 Pa
13283860 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 2300 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1238 | 1238 | yes | 39.6875 | 33.3375 | HT/CL_vratné vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13283865 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 2300 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1239 | 1239 | yes | 39.6875 | 33.3375 | HT/CL_vratné vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13283933 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1240 | 1240 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (55 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13283967 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1241 | 1241 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13283971 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1242 | 1242 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13284003 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1243 | 1243 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 12 | Mechanické – tok - Tlaková ztráta: 0 Pa
13284007 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1244 | 1244 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 12 | Mechanické – tok - Tlaková ztráta: 0 Pa
13284049 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HE | 2.NP_SO-102 | 2300 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1245 | 1245 | yes | 46.0375 | 39.6875 | HT/CL_přívodní vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13284081 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1246 | 1246 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (55 °C) 25 | Mechanické – tok - Tlaková ztráta: 0 Pa
13284085 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1247 | 1247 | yes | 39.6875 | 33.3375 | HT_přívodní vodní (55 °C) 25 | Mechanické – tok - Tlaková ztráta: 0 Pa
13285556 | -1.PP_SO-102 | 60 | ø200 mm-ø200 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 39 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1248 | 1248 | yes | 46.0375 | 39.6875 | HT_vratné vodní (45 °C) 39 | Izolace - Typ izolace: Tepelná
13285577 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1249 | 1249 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 2 | Izolace - Typ izolace: Tepelná
13287602 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1250 | 1250 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 6 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13287648 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1251 | 1251 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 2 | Izolace - Typ izolace: Tepelná
13287904 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1252 | 1252 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 6 | Izolace - Typ izolace: Tepelná; Mechanické – tok - Tlaková ztráta: 0 Pa
13287910 | -1.PP_SO-102 | 40 | ø112 mm-ø112 mm | HD | -1.PP_SO-102 | 2450 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1253 | 1253 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 2 | Izolace - Typ izolace: Tepelná
13289417 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2750 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1254 | 1254 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13289589 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2800 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1255 | 1255 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 9
13289591 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2800 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1256 | 1256 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 9
13289622 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2800 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1257 | 1257 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 9
13289626 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2800 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1258 | 1258 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 9
13290650 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1259 | 1259 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13290672 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1260 | 1260 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13290748 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1261 | 1261 | no | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13290777 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1262 | 1262 | no | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13290811 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2800 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1263 | 1263 | no | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 4
13290851 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2800 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1264 | 1264 | no | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 8
13292155 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 3300 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1265 | 1265 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 4
13292157 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 3300 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1266 | 1266 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 4
13292188 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 3300 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1267 | 1267 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 8
13292190 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 3300 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1268 | 1268 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 8
13292221 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 3300 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1269 | 1269 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13292223 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 3300 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1270 | 1270 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13292254 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 3300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1271 | 1271 | no | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13292256 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 3300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1272 | 1272 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13292585 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 3300 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1273 | 1273 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 4
13292589 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2550 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1274 | 1274 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 4
13292622 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 3300 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1275 | 1275 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 8
13292626 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2550 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1276 | 1276 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 8
13292659 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 3300 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1277 | 1277 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13292663 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2550 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1278 | 1278 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13292696 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 3300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1279 | 1279 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13292700 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2550 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1280 | 1280 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13294231 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1282 | 1282 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13294497 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2750 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1284 | 1284 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13295492 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2750 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1285 | 1285 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13295494 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2650 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1286 | 1286 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13295603 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2750 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1287 | 1287 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 4
13295628 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2750 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1288 | 1288 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 4
13295636 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2350 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1289 | 1289 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 4
13295640 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2350 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1290 | 1290 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 4
13295663 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2750 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1291 | 1291 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 8
13295688 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2750 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1292 | 1292 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 8
13295696 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2350 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1293 | 1293 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 8
13295700 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2350 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1294 | 1294 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 8
13295723 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2750 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1295 | 1295 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13295748 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2750 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1296 | 1296 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13295756 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2400 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1297 | 1297 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13295760 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2400 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1298 | 1298 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13295783 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2750 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1299 | 1299 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13295808 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2750 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1300 | 1300 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13295816 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2400 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1301 | 1301 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13295820 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2400 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1302 | 1302 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13296096 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2750 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1303 | 1303 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13296100 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2450 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1304 | 1304 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 27
13296125 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2750 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1305 | 1305 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13296129 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2450 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1306 | 1306 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 26
13296154 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2750 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1307 | 1307 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 8
13296158 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2450 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1308 | 1308 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 8
13296183 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2750 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1309 | 1309 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 4
13296187 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HC | -1.PP_SO-102 | 2450 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1310 | 1310 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 4
13299203 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.1311 | 1311 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13299239 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.1312 | 1312 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13300774 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2750 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1315 | 1315 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13300778 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2750 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.1316 | 1316 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3
13303876 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 2600 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1317 | 1317 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 6 | Mechanické – tok - Tlaková ztráta: 0 Pa
13304325 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HC | -1.PP_SO-102 | 3300 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1319 | 1319 | yes | 46.0375 | 39.6875 | CL_vratné vodní (15 °C) 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13304522 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HC | -1.PP_SO-102 | 3150 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1321 | 1321 | yes | 46.0375 | 39.6875 | CL_přívodní vodní (10 °C) 4
13304565 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HC | -1.PP_SO-102 | 3300 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1322 | 1322 | yes | 46.0375 | 39.6875 | CL_vratné vodní (15 °C) 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13304567 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HC | -1.PP_SO-102 | 3300 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1323 | 1323 | yes | 46.0375 | 39.6875 | CL_vratné vodní (15 °C) 8 | Mechanické – tok - Tlaková ztráta: 0 Pa
13304603 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HC | -1.PP_SO-102 | 3150 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1324 | 1324 | yes | 46.0375 | 39.6875 | CL_přívodní vodní (10 °C) 4
13304605 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm | HC | -1.PP_SO-102 | 3150 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.1325 | 1325 | yes | 46.0375 | 39.6875 | CL_přívodní vodní (10 °C) 4
13304853 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 3300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1326 | 1326 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13304942 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 3300 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1327 | 1327 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13304965 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 3300 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.1328 | 1328 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13310309 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-102 | 2800 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1331 | 1331 | yes | 26.9875 | 20.6375 | CL_přívodní vodní (10 °C) 4
13314270 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (45 °C) | Přívod teplé vody | HT_přívodní vodní (45 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.1434 | 1434 | no | 15.9375 | 9.5875 | HT_přívodní vodní (45 °C) 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13314521 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3250 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1443 | 1443 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13314523 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3250 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1444 | 1444 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13314709 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2820 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1452 | 1452 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13314713 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2820 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1453 | 1453 | no | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13315787 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2800 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1515 | 1515 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13315871 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2850 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1517 | 1517 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13315873 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2850 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1518 | 1518 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13316013 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1523 | 1523 | no | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 13
13316430 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HD | 2.NP_SO-102 | 2750 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1537 | 1537 | yes | 20.6375 | 14.2875 | HT_přívodní vodní (55 °C) 9
13316434 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HD | 2.NP_SO-102 | 2750 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1538 | 1538 | yes | 20.6375 | 14.2875 | HT_přívodní vodní (55 °C) 9
13316517 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.1539 | 1539 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13316542 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 34 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.1541 | 1541 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 34
13316567 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 35 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1543 | 1543 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 35; HT_přívodní vodní (55 °C) 21 | Mechanické – tok - Tlaková ztráta: 0 Pa
13316571 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 33 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1544 | 1544 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 33; HT_přívodní vodní (55 °C) 22
13316991 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1558 | 1558 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13316995 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.1559 | 1559 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13316999 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.1560 | 1560 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13323027 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1590 | 1590 | no | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13323033 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1592 | 1592 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13323035 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1593 | 1593 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13323076 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1594 | 1594 | no | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13323080 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1595 | 1595 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13323082 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1596 | 1596 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13326838 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 8 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1597 | 1597 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 8
13326840 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 8 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1598 | 1598 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 8
13326935 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-102 | 3200 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1599 | 1599 | yes | 26.9875 | 20.6375 | CL_přívodní vodní (10 °C) 4
13326961 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-102 | 2800 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1600 | 1600 | yes | 26.9875 | 20.6375 | CL_přívodní vodní (10 °C) 4
13326963 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-102 | 2800 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1601 | 1601 | yes | 26.9875 | 20.6375 | CL_přívodní vodní (10 °C) 4
13326987 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-102 | 3200 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1602 | 1602 | yes | 26.9875 | 20.6375 | CL_vratné vodní (15 °C) 8
13326991 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-102 | 2800 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1603 | 1603 | yes | 26.9875 | 20.6375 | CL_vratné vodní (15 °C) 8
13327014 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-102 | 2800 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1604 | 1604 | yes | 26.9875 | 20.6375 | CL_vratné vodní (15 °C) 8
13327016 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HC | -1.PP_SO-102 | 2800 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1605 | 1605 | yes | 26.9875 | 20.6375 | CL_vratné vodní (15 °C) 8
13327807 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1606 | 1606 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9
13327857 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1609 | 1609 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13328218 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-102 | 2850 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1611 | 1611 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13328228 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1613 | 1613 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 1
13328252 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1614 | 1614 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13328262 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.1616 | 1616 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13333636 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 12 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1619 | 1619 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 12 | Mechanické – tok - Tlaková ztráta: 0 Pa
13334201 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 3270 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1620 | 1620 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13334203 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 3270 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1621 | 1621 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13334228 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 3270 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 24 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1622 | 1622 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 24 | Mechanické – tok - Tlaková ztráta: 0 Pa
13334246 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 3270 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 24 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1623 | 1623 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 24 | Mechanické – tok - Tlaková ztráta: 0 Pa
13334248 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 3270 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 24 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1624 | 1624 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 24 | Mechanické – tok - Tlaková ztráta: 0 Pa
13335078 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2900 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.1625 | 1625 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13335541 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 2750 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1626 | 1626 | yes | 20.6375 | 14.2875 | HT/CL_vratné vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13335549 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 2650 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1627 | 1627 | yes | 20.6375 | 14.2875 | HT/CL_vratné vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13335551 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 2650 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1628 | 1628 | yes | 20.6375 | 14.2875 | HT/CL_vratné vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13335574 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 2750 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1629 | 1629 | yes | 20.6375 | 14.2875 | HT/CL_přívodní vodní 1
13335582 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 2650 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1630 | 1630 | yes | 20.6375 | 14.2875 | HT/CL_přívodní vodní 1
13335584 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 2650 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1631 | 1631 | yes | 20.6375 | 14.2875 | HT/CL_přívodní vodní 1
13335609 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2750 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1632 | 1632 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 1
13335626 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1634 | 1634 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 1
13335649 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2750 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1635 | 1635 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 9
13335661 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.1637 | 1637 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 9
13335686 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 2750 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.1638 | 1638 | yes | 20.6375 | 14.2875 | HT/CL_vratné vodní 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
