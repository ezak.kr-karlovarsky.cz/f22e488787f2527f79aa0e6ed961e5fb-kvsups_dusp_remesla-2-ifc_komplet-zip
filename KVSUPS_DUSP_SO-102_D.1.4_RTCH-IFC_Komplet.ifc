Properties of the parts of a building model (IFC4), part 67 of 72

# IfcPipeSegment: Typy trubek:Ocel_uhlíková (1186)
Name (Typy trubek:Ocel_uhlíková:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Tloušťka izolace (mm) | Celková velikost | Relativní drsnost | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) | Řez | Délka (mm) | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
13271578 | -1.PP_SO-102 | 2652.18 | 0.000356274 | 0.177473 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2710.65 | 2700 | 2700 | 2689.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | -1308 | 0.124981 | 15 | 11 | 2652.18 | ø15 | 21.3 | 16 | TR02.02.1644 | 1644 | yes | CL_přívodní vodní (10 °C) 9 | 0
13271627 | -2.PP_SO-102 | 3521.43 | 0.000356274 | 0.235639 | 0 | ø15 mm | 0.00625 | HC | -2.PP_SO-102 | 6685.71 | 3164.29 | 6685.71 | 3164.29 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | -4835.71 | 0.165943 | 15 | 11 | 3521.43 | ø15 | 21.3 | 16 | TR02.02.1645 | 1645 | yes | CL_přívodní vodní (10 °C) 9
13277688 | 2.NP_SO-102 | 2720.73 | 0.000568237 | 0.229925 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2463.45 | 2450 | 2450 | 2436.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6439.2 | 0.170948 | 20 | 9 | 2720.73 | ø20 | 26.9 | 21.6 | TR02.02.1651 | 1651 | yes | HT_přívodní vodní (55 °C) 25 | 0
13278692 | -1.PP_SO-102 | 4734.52 | 0.000568237 | 0.400109 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2563.45 | 2550 | 2550 | 2536.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1460.8 | 0.297479 | 20 | 116 | 4734.52 | ø20 | 26.9 | 21.6 | TR02.02.1660 | 1660 | yes | HT_vratné vodní (45 °C) 26 | 0
13278744 | -1.PP_SO-102 | 451.187 | 0.000568237 | 0.0381293 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3113.45 | 3100 | 3100 | 3086.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -910.8 | 0.0283489 | 20 | 3 | 451.187 | ø20 | 26.9 | 21.6 | TR02.02.1661 | 1661 | yes | HT_přívodní vodní (65 °C) 27 | 0
13278753 | -1.PP_SO-102 | 4573.63 | 0.000568237 | 0.386512 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2563.45 | 2550 | 2550 | 2536.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1460.8 | 0.287369 | 20 | 7 | 4573.63 | ø20 | 26.9 | 21.6 | TR02.02.1662 | 1662 | yes | HT_přívodní vodní (65 °C) 27 | 0
13278763 | -1.PP_SO-102 | 601.187 | 0.000568237 | 0.0508057 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3113.45 | 3100 | 3100 | 3086.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -910.8 | 0.0377737 | 20 | 3 | 601.187 | ø20 | 26.9 | 21.6 | TR02.02.1663 | 1663 | yes | HT_vratné vodní (45 °C) 26 | 0
13278772 | -1.PP_SO-102 | 12759.9 | 0.000568237 | 1.07832 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3313.45 | 3300 | 3300 | 3286.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -710.8 | 0.801727 | 20 | 139 | 12759.9 | ø20 | 26.9 | 21.6 | TR02.02.1664 | 1664 | yes | HT_vratné vodní (45 °C) 26 | 0
13278782 | -1.PP_SO-102 | 7219.97 | 0.000568237 | 0.610151 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1210.8 | 0.453644 | 20 | 19 | 7219.97 | ø20 | 26.9 | 21.6 | TR02.02.1665 | 1665 | no | HT_přívodní vodní (65 °C) 27 | 0
13278814 | -1.PP_SO-102 | 7219.97 | 0.000568237 | 0.610151 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1210.8 | 0.453644 | 20 | 114 | 7219.97 | ø20 | 26.9 | 21.6 | TR02.02.1666 | 1666 | no | HT_vratné vodní (45 °C) 26 | 0
13279040 | -1.PP_SO-102 | 1593.9 | 0.00141175 | 0.212313 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2621.2 | 2600 | 2600 | 2578.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -1417.95 | 0.160236 | 32 | 146 | 1593.9 | ø32 | 42.4 | 35.9 | TR02.02.1668 | 1668 | yes | HT_vratné vodní (45 °C) 2 | 0 | Izolace - Typ izolace: Tepelná
13279071 | -1.PP_SO-102 | 1394.52 | 0.000568237 | 0.117849 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2763.45 | 2750 | 2750 | 2736.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1260.8 | 0.0876201 | 20 | 140 | 1394.52 | ø20 | 26.9 | 21.6 | TR02.02.1669 | 1669 | yes | HT_vratné vodní (45 °C) 26 | 0
13279261 | -1.PP_SO-102 | 4996.05 | 0.000356274 | 0.334315 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2560.65 | 2550 | 2550 | 2539.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1458 | 0.235433 | 15 | 24 | 4996.05 | ø15 | 21.3 | 16 | TR02.02.1670 | 1670 | yes | CL_přívodní vodní (10 °C) 4 | 0
13279289 | -1.PP_SO-102 | 129.362 | 0.000356274 | 0.00865641 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 3110.65 | 3100 | 3100 | 3089.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -908 | 0.00609606 | 15 | 5 | 129.362 | ø15 | 21.3 | 16 | TR02.02.1671 | 1671 | yes | CL_přívodní vodní (10 °C) 4 | 0
13279298 | -1.PP_SO-102 | 12138.8 | 0.000568237 | 1.02583 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 3313.45 | 3300 | 3300 | 3286.55 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -710.8 | 0.762701 | 20 | 111 | 12138.8 | ø20 | 26.9 | 21.6 | TR02.02.1672 | 1672 | yes | CL_přívodní vodní (10 °C) 4 | 0
13279308 | -1.PP_SO-102 | 2723.17 | 0.000568237 | 0.230132 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 3013.45 | 3000 | 3000 | 2986.55 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1010.8 | 0.171102 | 20 | 90 | 2723.17 | ø20 | 26.9 | 21.6 | TR02.02.1673 | 1673 | yes | CL_vratné vodní (15 °C) 8 | 0
13279316 | -1.PP_SO-102 | 5202.15 | 0.000356274 | 0.348107 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2560.65 | 2550 | 2550 | 2539.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1458 | 0.245146 | 15 | 15 | 5202.15 | ø15 | 21.3 | 16 | TR02.02.1674 | 1674 | yes | CL_vratné vodní (15 °C) 8 | 0
13279333 | -1.PP_SO-102 | 279.362 | 0.000356274 | 0.0186938 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 3110.65 | 3100 | 3100 | 3089.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -908 | 0.0131646 | 15 | 5 | 279.362 | ø15 | 21.3 | 16 | TR02.02.1675 | 1675 | yes | CL_vratné vodní (15 °C) 8 | 0
13279342 | -1.PP_SO-102 | 12046.3 | 0.000568237 | 1.01802 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 3313.45 | 3300 | 3300 | 3286.55 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -710.8 | 0.756894 | 20 | 90 | 12046.3 | ø20 | 26.9 | 21.6 | TR02.02.1676 | 1676 | yes | CL_vratné vodní (15 °C) 8 | 0
13279379 | -1.PP_SO-102 | 9315.04 | 0.000356274 | 0.623324 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2610.65 | 2600 | 2600 | 2589.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1408 | 0.438961 | 15 | 108 | 9315.04 | ø15 | 21.3 | 16 | TR02.02.1677 | 1677 | no | CL_přívodní vodní (10 °C) 4 | 0
13279421 | -1.PP_SO-102 | 9164.52 | 0.000356274 | 0.613252 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2610.65 | 2600 | 2600 | 2589.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1408 | 0.431868 | 15 | 87 | 9164.52 | ø15 | 21.3 | 16 | TR02.02.1678 | 1678 | no | CL_vratné vodní (15 °C) 8 | 0
13279464 | -1.PP_SO-102 | 8325.08 | 0.000568237 | 0.703542 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2763.45 | 2750 | 2750 | 2736.55 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1260.8 | 0.52308 | 20 | 131 | 8325.08 | ø20 | 26.9 | 21.6 | TR02.02.1679 | 1679 | yes | CL_přívodní vodní (10 °C) 4 | 0
13279497 | -1.PP_SO-102 | 8325.08 | 0.000568237 | 0.703542 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2763.45 | 2750 | 2750 | 2736.55 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1260.8 | 0.52308 | 20 | 105 | 8325.08 | ø20 | 26.9 | 21.6 | TR02.02.1680 | 1680 | yes | CL_vratné vodní (15 °C) 8 | 0
13279603 | -1.PP_SO-102 | 8325.08 | 0.000568237 | 0.703542 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2763.45 | 2750 | 2750 | 2736.55 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1260.8 | 0.52308 | 20 | 41 | 8325.08 | ø20 | 26.9 | 21.6 | TR02.02.1681 | 1681 | yes | HT_přívodní vodní (65 °C) 27 | 0
13279633 | -1.PP_SO-102 | 8325.08 | 0.000568237 | 0.703542 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2763.45 | 2750 | 2750 | 2736.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1260.8 | 0.52308 | 20 | 142 | 8325.08 | ø20 | 26.9 | 21.6 | TR02.02.1682 | 1682 | yes | HT_vratné vodní (45 °C) 26 | 0
13279678 | 2.NP_SO-102 | 1380.64 | 0.000568237 | 0.116677 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2463.45 | 2450 | 2450 | 2436.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6439.2 | 0.0867485 | 20 | 112 | 1380.64 | ø20 | 26.9 | 21.6 | TR02.02.1683 | 1683 | yes | HT_přívodní vodní (55 °C) 25 | 0
13279684 | 2.NP_SO-102 | 4859.38 | 0.000568237 | 0.41066 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2663.45 | 2650 | 2650 | 2636.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6639.2 | 0.305324 | 20 | 103 | 4859.38 | ø20 | 26.9 | 21.6 | TR02.02.1684 | 1684 | yes | HT_přívodní vodní (55 °C) 25 | 0
13279697 | 2.NP_SO-102 | 2563.61 | 0.000568237 | 0.216648 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2663.45 | 2650 | 2650 | 2636.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6639.2 | 0.161076 | 20 | 103 | 2563.61 | ø20 | 26.9 | 21.6 | TR02.02.1685 | 1685 | yes | HT_přívodní vodní (55 °C) 25 | 0
13279705 | 2.NP_SO-102 | 862.785 | 0.000568237 | 0.072913 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2663.45 | 2650 | 2650 | 2636.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6639.2 | 0.0542104 | 20 | 103 | 862.785 | ø20 | 26.9 | 21.6 | TR02.02.1686 | 1686 | yes | HT_přívodní vodní (55 °C) 25 | 0
13279735 | 2.NP_SO-102 | 1450.49 | 0.000568237 | 0.122579 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2513.45 | 2500 | 2500 | 2486.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6489.2 | 0.0911369 | 20 | 106 | 1450.49 | ø20 | 26.9 | 21.6 | TR02.02.1687 | 1687 | yes | HT_vratné vodní (45 °C) 26 | 0
13279741 | 2.NP_SO-102 | 4809.38 | 0.000568237 | 0.406435 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2663.45 | 2650 | 2650 | 2636.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6639.2 | 0.302182 | 20 | 106 | 4809.38 | ø20 | 26.9 | 21.6 | TR02.02.1688 | 1688 | yes | HT_vratné vodní (45 °C) 26 | 0
13279753 | 2.NP_SO-102 | 2886.81 | 0.000568237 | 0.243961 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2563.45 | 2550 | 2550 | 2536.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6539.2 | 0.181384 | 20 | 106 | 2886.81 | ø20 | 26.9 | 21.6 | TR02.02.1689 | 1689 | yes | HT_vratné vodní (45 °C) 26 | 0
13279761 | 2.NP_SO-102 | 876.722 | 0.000568237 | 0.0740908 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2563.45 | 2550 | 2550 | 2536.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6539.2 | 0.0550861 | 20 | 106 | 876.722 | ø20 | 26.9 | 21.6 | TR02.02.1690 | 1690 | yes | HT_vratné vodní (45 °C) 26 | 0
13279857 | 1.NP_SO-102 | 7849.99 | 0.00141175 | 1.04565 | 0 | ø32 mm | 0.00278552 | HD | 1.NP_SO-102 | 6523.81 | 6523.81 | -1326.19 | -1326.19 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1326.19 | 0.789167 | 32 | 122 | 7849.99 | ø32 | 42.4 | 35.9 | TR02.02.1691 | 1691 | yes | HT_vratné vodní (45 °C) 26
13279937 | 1.NP_SO-102 | 7849.99 | 0.00141175 | 1.04565 | 0 | ø32 mm | 0.00278552 | HD | 1.NP_SO-102 | 6623.81 | 6623.81 | -1226.19 | -1226.19 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1226.19 | 0.789167 | 32 | 22 | 7849.99 | ø32 | 42.4 | 35.9 | TR02.02.1692 | 1692 | yes | HT_přívodní vodní (65 °C) 27 | 350718
13281658 | 2.NP_SO-102 | 115.075 | 0.000568237 | 0.00972486 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2632.54 | 2517.46 | 2632.54 | 2517.46 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6517.46 | 0.00723038 | 20 | 106 | 115.075 | ø20 | 26.9 | 21.6 | TR02.02.1695 | 1695 | yes | HT_vratné vodní (45 °C) 26
13281669 | 2.NP_SO-102 | 145.231 | 0.000568237 | 0.0122733 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2632.54 | 2487.31 | 2632.54 | 2487.31 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6487.31 | 0.00912515 | 20 | 103 | 145.231 | ø20 | 26.9 | 21.6 | TR02.02.1696 | 1696 | yes | HT_přívodní vodní (55 °C) 25
13282019 | 2.NP_SO-102 | 4657.86 | 0.000568237 | 0.39363 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2663.45 | 2650 | 2650 | 2636.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6639.2 | 0.292662 | 20 | 106 | 4657.86 | ø20 | 26.9 | 21.6 | TR02.02.1697 | 1697 | yes | HT_vratné vodní (45 °C) 26 | 0
13282063 | 2.NP_SO-102 | 4857.86 | 0.000568237 | 0.410532 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2663.45 | 2650 | 2650 | 2636.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6639.2 | 0.305228 | 20 | 103 | 4857.86 | ø20 | 26.9 | 21.6 | TR02.02.1698 | 1698 | yes | HT_přívodní vodní (55 °C) 25 | 0
13282189 | 2.NP_SO-102 | 790.642 | 0.000568237 | 0.0668162 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2659.31 | 2252.34 | 2647.66 | 2240.69 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6242.99 | 0.0496775 | 20 | 103 | 790.642 | ø20 | 26.9 | 21.6 | TR02.02.1699 | 1699 | yes | HT_přívodní vodní (55 °C) 25 | 57.735
13282204 | 2.NP_SO-102 | 5082.45 | 0.000568237 | 0.429512 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2263.45 | 2250 | 2250 | 2236.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6239.2 | 0.31934 | 20 | 103 | 5082.45 | ø20 | 26.9 | 21.6 | TR02.02.1700 | 1700 | yes | HT_přívodní vodní (55 °C) 25 | 0
13282260 | 2.NP_SO-102 | 790.642 | 0.000568237 | 0.0668162 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2659.31 | 2647.66 | 2252.34 | 2240.69 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6242.99 | 0.0496775 | 20 | 103 | 790.642 | ø20 | 26.9 | 21.6 | TR02.02.1701 | 1701 | yes | HT_přívodní vodní (55 °C) 25 | 57.735
13282441 | 2.NP_SO-102 | 790.642 | 0.000568237 | 0.0668162 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2659.31 | 2252.34 | 2647.66 | 2240.69 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6242.99 | 0.0496775 | 20 | 106 | 790.642 | ø20 | 26.9 | 21.6 | TR02.02.1702 | 1702 | yes | HT_vratné vodní (45 °C) 26 | 57.735
13282450 | 2.NP_SO-102 | 590.642 | 0.000568237 | 0.0499145 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2559.31 | 2252.34 | 2547.66 | 2240.69 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6242.99 | 0.0371111 | 20 | 106 | 590.642 | ø20 | 26.9 | 21.6 | TR02.02.1703 | 1703 | yes | HT_vratné vodní (45 °C) 26 | 57.735
13282461 | 2.NP_SO-102 | 5082.45 | 0.000568237 | 0.429512 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2263.45 | 2250 | 2250 | 2236.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6239.2 | 0.31934 | 20 | 106 | 5082.45 | ø20 | 26.9 | 21.6 | TR02.02.1704 | 1704 | yes | HT_vratné vodní (45 °C) 26 | 0
13282762 | 2.NP_SO-102 | 115.075 | 0.000568237 | 0.00972486 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2563.45 | 2550 | 2550 | 2536.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6539.2 | 0.00723038 | 20 | 106 | 115.075 | ø20 | 26.9 | 21.6 | TR02.02.1705 | 1705 | yes | HT_vratné vodní (45 °C) 26 | 0
13282836 | 2.NP_SO-102 | 1532.54 | 0.000568237 | 0.129513 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 1013.45 | 1000 | 1000 | 986.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 4989.2 | 0.0962922 | 20 | 102 | 1532.54 | ø20 | 26.9 | 21.6 | TR02.02.1706 | 1706 | yes | HT_přívodní vodní (55 °C) 25 | 0
13282864 | 2.NP_SO-102 | 1682.54 | 0.000568237 | 0.142189 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 1013.45 | 1000 | 1000 | 986.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 4989.2 | 0.105717 | 20 | 105 | 1682.54 | ø20 | 26.9 | 21.6 | TR02.02.1707 | 1707 | yes | HT_vratné vodní (45 °C) 26 | 0
13282998 | 2.NP_SO-102 | 1458.72 | 0.000568237 | 0.123275 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2476.19 | 1017.46 | 2476.19 | 1017.46 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 5017.46 | 0.0916544 | 20 | 105 | 1458.72 | ø20 | 26.9 | 21.6 | TR02.02.1708 | 1708 | yes | HT_vratné vodní (45 °C) 26
13283001 | 2.NP_SO-102 | 4506.34 | 0.000568237 | 0.380826 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2513.45 | 2500 | 2500 | 2486.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 6489.2 | 0.283142 | 20 | 1 | 4506.34 | ø20 | 26.9 | 21.6 | TR02.02.1709 | 1709 | yes | HT_vratné vodní (45 °C) 26 | 0
13283034 | 2.NP_SO-102 | 1408.72 | 0.000568237 | 0.11905 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2426.19 | 1017.46 | 2426.19 | 1017.46 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 5017.46 | 0.0885128 | 20 | 102 | 1408.72 | ø20 | 26.9 | 21.6 | TR02.02.1710 | 1710 | yes | HT_přívodní vodní (55 °C) 25
13283037 | 2.NP_SO-102 | 4556.34 | 0.000568237 | 0.385051 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2463.45 | 2450 | 2450 | 2436.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 6439.2 | 0.286283 | 20 | 100 | 4556.34 | ø20 | 26.9 | 21.6 | TR02.02.1711 | 1711 | yes | HT_přívodní vodní (55 °C) 25 | 0
13283117 | 2.NP_SO-102 | 1679.36 | 0.000891835 | 0.177797 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 1016.85 | 1000 | 1000 | 983.15 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 4986.4 | 0.131897 | 25 | 3 | 1679.36 | ø25 | 33.7 | 27.2 | TR02.02.1712 | 1712 | yes | CL_vratné vodní (15 °C) 11 | 0
13283126 | 2.NP_SO-102 | 1158.72 | 0.000891835 | 0.122676 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2179.36 | 1020.64 | 2179.36 | 1020.64 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 5020.64 | 0.091006 | 25 | 3 | 1158.72 | ø25 | 33.7 | 27.2 | TR02.02.1713 | 1713 | yes | CL_vratné vodní (15 °C) 11
13283152 | 2.NP_SO-102 | 1529.36 | 0.000891835 | 0.161916 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 1016.85 | 1000 | 1000 | 983.15 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 4986.4 | 0.120116 | 25 | 14 | 1529.36 | ø25 | 33.7 | 27.2 | TR02.02.1714 | 1714 | yes | CL_přívodní vodní (10 °C) 4 | 0
13283161 | 2.NP_SO-102 | 1158.72 | 0.000891835 | 0.122676 | 0 | ø25 mm | 0.00367647 | HC | 2.NP_SO-102 | 2179.36 | 1020.64 | 2179.36 | 1020.64 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 5020.64 | 0.091006 | 25 | 14 | 1158.72 | ø25 | 33.7 | 27.2 | TR02.02.1715 | 1715 | yes | CL_přívodní vodní (10 °C) 4
13284223 | -1.PP_SO-102 | 12820.8 | 0.000568237 | 1.08347 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3313.45 | 3300 | 3300 | 3286.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -710.8 | 0.805553 | 20 | 37 | 12820.8 | ø20 | 26.9 | 21.6 | TR02.02.1728 | 1728 | yes | HT_přívodní vodní (65 °C) 27 | 0
13287683 | -1.PP_SO-102 | 2758.33 | 0.00141175 | 0.367419 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2471.2 | 2450 | 2450 | 2428.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -1567.95 | 0.277298 | 32 | 146 | 2758.33 | ø32 | 42.4 | 35.9 | TR02.02.1729 | 1729 | yes | HT_vratné vodní (45 °C) 2 | 0 | Izolace - Typ izolace: Tepelná
13287728 | -1.PP_SO-102 | 2744.6 | 0.00141175 | 0.365591 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2471.2 | 2450 | 2450 | 2428.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | -1567.95 | 0.275918 | 32 | 39 | 2744.6 | ø32 | 42.4 | 35.9 | TR02.02.1730 | 1730 | yes | HT_přívodní vodní (65 °C) 6 | 0 | Izolace - Typ izolace: Tepelná
13287872 | -1.PP_SO-102 | 3990.51 | 0.00141175 | 0.53155 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2471.2 | 2450 | 2450 | 2428.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 6 | -1567.95 | 0.40117 | 32 | 39 | 3990.51 | ø32 | 42.4 | 35.9 | TR02.02.1731 | 1731 | yes | HT_přívodní vodní (65 °C) 6 | 0 | Izolace - Typ izolace: Tepelná
13288571 | -1.PP_SO-102 | 141.877 | 0.000568237 | 0.0119899 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2663.45 | 2650 | 2650 | 2636.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1360.8 | 0.00891439 | 20 | 140 | 141.877 | ø20 | 26.9 | 21.6 | TR02.02.1732 | 1732 | yes | HT_vratné vodní (45 °C) 26 | 0
13288606 | -1.PP_SO-102 | 65.075 | 0.000568237 | 0.00549941 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2732.54 | 2667.46 | 2732.54 | 2667.46 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1332.54 | 0.00408878 | 20 | 140 | 65.075 | ø20 | 26.9 | 21.6 | TR02.02.1733 | 1733 | yes | HT_vratné vodní (45 °C) 26
13289296 | -1.PP_SO-102 | 7200.69 | 0.000568237 | 0.608522 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3013.45 | 3000 | 3000 | 2986.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1010.8 | 0.452433 | 20 | 39 | 7200.69 | ø20 | 26.9 | 21.6 | TR02.02.1734 | 1734 | yes | HT_přívodní vodní (65 °C) 27 | 0
13289474 | -1.PP_SO-102 | 2532.06 | 0.000356274 | 0.169435 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 3210.65 | 3200 | 3200 | 3189.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | -808 | 0.119321 | 15 | 18 | 2532.06 | ø15 | 21.3 | 16 | TR02.02.1735 | 1735 | yes | CL_vratné vodní (15 °C) 9 | 0
13289497 | -1.PP_SO-102 | 2732.06 | 0.000356274 | 0.182818 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 3210.65 | 3200 | 3200 | 3189.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | -808 | 0.128745 | 15 | 18 | 2732.06 | ø15 | 21.3 | 16 | TR02.02.1736 | 1736 | yes | CL_přívodní vodní (10 °C) 9 | 0
13289579 | -1.PP_SO-102 | 371.425 | 0.000356274 | 0.0248542 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 3185.71 | 2814.29 | 3185.71 | 2814.29 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | -1185.71 | 0.017503 | 15 | 18 | 371.425 | ø15 | 21.3 | 16 | TR02.02.1737 | 1737 | yes | CL_vratné vodní (15 °C) 9
13289612 | -1.PP_SO-102 | 371.425 | 0.000356274 | 0.0248542 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 3185.71 | 2814.29 | 3185.71 | 2814.29 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | -1185.71 | 0.017503 | 15 | 18 | 371.425 | ø15 | 21.3 | 16 | TR02.02.1738 | 1738 | yes | CL_přívodní vodní (10 °C) 9
13290352 | -1.PP_SO-102 | 8911.84 | 0.000568237 | 0.753129 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3013.45 | 3000 | 3000 | 2986.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1010.8 | 0.559947 | 20 | 37 | 8911.84 | ø20 | 26.9 | 21.6 | TR02.02.1739 | 1739 | yes | HT_přívodní vodní (65 °C) 27 | 0
13290382 | -1.PP_SO-102 | 8911.84 | 0.000568237 | 0.753129 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3013.45 | 3000 | 3000 | 2986.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1010.8 | 0.559947 | 20 | 139 | 8911.84 | ø20 | 26.9 | 21.6 | TR02.02.1740 | 1740 | yes | HT_vratné vodní (45 °C) 26 | 0
13290426 | -1.PP_SO-102 | 8911.63 | 0.000568237 | 0.753112 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2613.45 | 2600 | 2600 | 2586.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1410.8 | 0.559934 | 20 | 114 | 8911.63 | ø20 | 26.9 | 21.6 | TR02.02.1741 | 1741 | no | HT_vratné vodní (45 °C) 26 | 0
13290466 | -1.PP_SO-102 | 9011.63 | 0.000568237 | 0.761562 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2613.45 | 2600 | 2600 | 2586.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1410.8 | 0.566217 | 20 | 19 | 9011.63 | ø20 | 26.9 | 21.6 | TR02.02.1742 | 1742 | no | HT_přívodní vodní (65 °C) 27 | 0
13290742 | -1.PP_SO-102 | 165.075 | 0.000568237 | 0.0139503 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2782.54 | 2782.54 | 2617.46 | 2617.46 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1382.54 | 0.010372 | 20 | 19 | 165.075 | ø20 | 26.9 | 21.6 | TR02.02.1743 | 1743 | no | HT_přívodní vodní (65 °C) 27
13290771 | -1.PP_SO-102 | 165.075 | 0.000568237 | 0.0139503 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2782.54 | 2782.54 | 2617.46 | 2617.46 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1382.54 | 0.010372 | 20 | 114 | 165.075 | ø20 | 26.9 | 21.6 | TR02.02.1744 | 1744 | no | HT_vratné vodní (45 °C) 26
13290794 | -1.PP_SO-102 | 7223.14 | 0.000356274 | 0.483343 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2810.65 | 2800 | 2800 | 2789.35 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1208 | 0.340382 | 15 | 108 | 7223.14 | ø15 | 21.3 | 16 | TR02.02.1745 | 1745 | no | CL_přívodní vodní (10 °C) 4 | 0
13290805 | -1.PP_SO-102 | 171.425 | 0.000356274 | 0.0114711 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2785.71 | 2785.71 | 2614.29 | 2614.29 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1385.71 | 0.00807821 | 15 | 108 | 171.425 | ø15 | 21.3 | 16 | TR02.02.1746 | 1746 | no | CL_přívodní vodní (10 °C) 4
13290836 | -1.PP_SO-102 | 7223.14 | 0.000356274 | 0.483343 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2810.65 | 2800 | 2800 | 2789.35 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1208 | 0.340382 | 15 | 87 | 7223.14 | ø15 | 21.3 | 16 | TR02.02.1747 | 1747 | no | CL_vratné vodní (15 °C) 8 | 0
13290845 | -1.PP_SO-102 | 171.425 | 0.000356274 | 0.0114711 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 2785.71 | 2785.71 | 2614.29 | 2614.29 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1385.71 | 0.00807821 | 15 | 87 | 171.425 | ø15 | 21.3 | 16 | TR02.02.1748 | 1748 | no | CL_vratné vodní (15 °C) 8
13291579 | -1.PP_SO-102 | 2453.17 | 0.000568237 | 0.207314 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 3013.45 | 3000 | 3000 | 2986.55 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1010.8 | 0.154137 | 20 | 111 | 2453.17 | ø20 | 26.9 | 21.6 | TR02.02.1749 | 1749 | yes | CL_přívodní vodní (10 °C) 4 | 0
13292029 | -1.PP_SO-102 | 5499.66 | 0.000568237 | 0.46477 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 3313.45 | 3300 | 3300 | 3286.55 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -710.8 | 0.345554 | 20 | 111 | 5499.66 | ø20 | 26.9 | 21.6 | TR02.02.1750 | 1750 | yes | CL_přívodní vodní (10 °C) 4 | 0
13292052 | -1.PP_SO-102 | 5649.66 | 0.000568237 | 0.477447 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 3313.45 | 3300 | 3300 | 3286.55 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -710.8 | 0.354979 | 20 | 90 | 5649.66 | ø20 | 26.9 | 21.6 | TR02.02.1751 | 1751 | yes | CL_vratné vodní (15 °C) 8 | 0
13292075 | -1.PP_SO-102 | 5824.66 | 0.000568237 | 0.492236 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3313.45 | 3300 | 3300 | 3286.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -710.8 | 0.365974 | 20 | 37 | 5824.66 | ø20 | 26.9 | 21.6 | TR02.02.1752 | 1752 | yes | HT_přívodní vodní (65 °C) 27 | 0
13292098 | -1.PP_SO-102 | 5974.66 | 0.000568237 | 0.504912 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3313.45 | 3300 | 3300 | 3286.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -710.8 | 0.375399 | 20 | 139 | 5974.66 | ø20 | 26.9 | 21.6 | TR02.02.1753 | 1753 | yes | HT_vratné vodní (45 °C) 26 | 0
13292145 | -1.PP_SO-102 | 265.075 | 0.000568237 | 0.0224012 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 3282.54 | 3282.54 | 3017.46 | 3017.46 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -982.538 | 0.0166552 | 20 | 111 | 265.075 | ø20 | 26.9 | 21.6 | TR02.02.1754 | 1754 | yes | CL_přívodní vodní (10 °C) 4
13292178 | -1.PP_SO-102 | 265.075 | 0.000568237 | 0.0224012 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 3282.54 | 3282.54 | 3017.46 | 3017.46 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -982.538 | 0.0166552 | 20 | 90 | 265.075 | ø20 | 26.9 | 21.6 | TR02.02.1755 | 1755 | yes | CL_vratné vodní (15 °C) 8
13292211 | -1.PP_SO-102 | 265.075 | 0.000568237 | 0.0224012 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3282.54 | 3282.54 | 3017.46 | 3017.46 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -982.537 | 0.0166552 | 20 | 37 | 265.075 | ø20 | 26.9 | 21.6 | TR02.02.1756 | 1756 | yes | HT_přívodní vodní (65 °C) 27
13292244 | -1.PP_SO-102 | 265.075 | 0.000568237 | 0.0224012 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3282.54 | 3282.54 | 3017.46 | 3017.46 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -982.538 | 0.0166552 | 20 | 139 | 265.075 | ø20 | 26.9 | 21.6 | TR02.02.1757 | 1757 | yes | HT_vratné vodní (45 °C) 26
13292879 | -1.PP_SO-102 | 515.075 | 0.000356274 | 0.0344667 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 3079.36 | 2564.29 | 3079.36 | 2564.29 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1435.71 | 0.0242723 | 15 | 15 | 515.075 | ø15 | 21.3 | 16 | TR02.02.1758 | 1758 | yes | CL_vratné vodní (15 °C) 8
13292909 | -1.PP_SO-102 | 515.075 | 0.000356274 | 0.0344667 | 0 | ø15 mm | 0.00625 | HC | -1.PP_SO-102 | 3079.36 | 2564.29 | 3079.36 | 2564.29 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1435.71 | 0.0242723 | 15 | 24 | 515.075 | ø15 | 21.3 | 16 | TR02.02.1759 | 1759 | yes | CL_přívodní vodní (10 °C) 4
13292939 | -1.PP_SO-102 | 508.725 | 0.000568237 | 0.0429918 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3076.19 | 2567.46 | 3076.19 | 2567.46 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1432.54 | 0.0319641 | 20 | 7 | 508.725 | ø20 | 26.9 | 21.6 | TR02.02.1760 | 1760 | yes | HT_přívodní vodní (65 °C) 27
13292969 | -1.PP_SO-102 | 508.725 | 0.000568237 | 0.0429918 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3076.19 | 2567.46 | 3076.19 | 2567.46 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1432.54 | 0.0319641 | 20 | 116 | 508.725 | ø20 | 26.9 | 21.6 | TR02.02.1761 | 1761 | yes | HT_vratné vodní (45 °C) 26
13294020 | -1.PP_SO-102 | 553.215 | 0.000568237 | 0.0467516 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2763.45 | 2750 | 2750 | 2736.55 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1260.8 | 0.0347595 | 20 | 105 | 553.215 | ø20 | 26.9 | 21.6 | TR02.02.1762 | 1762 | yes | CL_vratné vodní (15 °C) 8 | 0
13294050 | -1.PP_SO-102 | 699.968 | 0.000568237 | 0.0591535 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2763.45 | 2750 | 2750 | 2736.55 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1260.8 | 0.0439803 | 20 | 131 | 699.968 | ø20 | 26.9 | 21.6 | TR02.02.1763 | 1763 | yes | CL_přívodní vodní (10 °C) 4 | 0
13294146 | -1.PP_SO-102 | 61.2625 | 0.000568237 | 0.00517722 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2763.45 | 2750 | 2750 | 2736.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1260.8 | 0.00384924 | 20 | 41 | 61.2625 | ø20 | 26.9 | 21.6 | TR02.02.1764 | 1764 | yes | HT_přívodní vodní (65 °C) 27 | 0
13294152 | -1.PP_SO-102 | 523.644 | 0.00141175 | 0.0697512 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 2771.2 | 2750 | 2750 | 2728.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1267.95 | 0.0526424 | 32 | 22 | 523.644 | ø32 | 42.4 | 35.9 | TR02.02.1765 | 1765 | yes | HT_přívodní vodní (65 °C) 27 | 0
13294228 | -1.PP_SO-102 | 345.199 | 0.000568237 | 0.0291724 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2663.45 | 2650 | 2650 | 2636.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1360.8 | 0.0216895 | 20 | 142 | 345.199 | ø20 | 26.9 | 21.6 | TR02.02.1766 | 1766 | yes | HT_vratné vodní (45 °C) 26 | 0
13294236 | -1.PP_SO-102 | 603.644 | 0.00141175 | 0.0804075 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 2671.2 | 2650 | 2650 | 2628.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1367.95 | 0.0606849 | 32 | 122 | 603.644 | ø32 | 42.4 | 35.9 | TR02.02.1767 | 1767 | yes | HT_vratné vodní (45 °C) 26 | 0
13295124 | -1.PP_SO-102 | 18366.5 | 0.000568237 | 1.55213 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2763.45 | 2750 | 2750 | 2736.55 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1260.8 | 1.154 | 20 | 41 | 18366.5 | ø20 | 26.9 | 21.6 | TR02.02.1768 | 1768 | yes | HT_přívodní vodní (65 °C) 27 | 0
13295149 | -1.PP_SO-102 | 18368.8 | 0.000568237 | 1.55232 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2763.45 | 2750 | 2750 | 2736.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1260.8 | 1.15414 | 20 | 142 | 18368.8 | ø20 | 26.9 | 21.6 | TR02.02.1769 | 1769 | yes | HT_vratné vodní (45 °C) 26 | 0
13295205 | -1.PP_SO-102 | 20804.5 | 0.000568237 | 1.75817 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2763.45 | 2750 | 2750 | 2736.55 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1260.8 | 1.30719 | 20 | 105 | 20804.5 | ø20 | 26.9 | 21.6 | TR02.02.1770 | 1770 | yes | CL_vratné vodní (15 °C) 8 | 0
13295230 | -1.PP_SO-102 | 21004.5 | 0.000568237 | 1.77507 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2763.45 | 2750 | 2750 | 2736.55 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1260.8 | 1.31975 | 20 | 131 | 21004.5 | ø20 | 26.9 | 21.6 | TR02.02.1771 | 1771 | yes | CL_přívodní vodní (10 °C) 4 | 0
13295317 | -1.PP_SO-102 | 6262.09 | 0.000568237 | 0.529202 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2363.45 | 2350 | 2350 | 2336.55 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1660.8 | 0.393459 | 20 | 131 | 6262.09 | ø20 | 26.9 | 21.6 | TR02.02.1772 | 1772 | yes | CL_přívodní vodní (10 °C) 4 | 0
13295342 | -1.PP_SO-102 | 6262.09 | 0.000568237 | 0.529202 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2363.45 | 2350 | 2350 | 2336.55 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1660.8 | 0.393459 | 20 | 105 | 6262.09 | ø20 | 26.9 | 21.6 | TR02.02.1773 | 1773 | yes | CL_vratné vodní (15 °C) 8 | 0
13295366 | -1.PP_SO-102 | 6265.26 | 0.000568237 | 0.52947 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2413.45 | 2400 | 2400 | 2386.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1610.8 | 0.393658 | 20 | 142 | 6265.26 | ø20 | 26.9 | 21.6 | TR02.02.1774 | 1774 | yes | HT_vratné vodní (45 °C) 26 | 0
13295388 | -1.PP_SO-102 | 6265.26 | 0.000568237 | 0.52947 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2413.45 | 2400 | 2400 | 2386.55 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1610.8 | 0.393658 | 20 | 41 | 6265.26 | ø20 | 26.9 | 21.6 | TR02.02.1775 | 1775 | yes | HT_přívodní vodní (65 °C) 27 | 0
13295490 | -1.PP_SO-102 | 65.075 | 0.000568237 | 0.00549941 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2732.54 | 2667.46 | 2732.54 | 2667.46 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1332.54 | 0.00408878 | 20 | 142 | 65.075 | ø20 | 26.9 | 21.6 | TR02.02.1776 | 1776 | yes | HT_vratné vodní (45 °C) 26
13295601 | -1.PP_SO-102 | 365.075 | 0.000568237 | 0.0308521 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2732.54 | 2367.46 | 2732.54 | 2367.46 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1632.54 | 0.0229383 | 20 | 131 | 365.075 | ø20 | 26.9 | 21.6 | TR02.02.1777 | 1777 | yes | CL_přívodní vodní (10 °C) 4
13295626 | -1.PP_SO-102 | 365.075 | 0.000568237 | 0.0308521 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2732.54 | 2367.46 | 2732.54 | 2367.46 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1632.54 | 0.0229383 | 20 | 131 | 365.075 | ø20 | 26.9 | 21.6 | TR02.02.1778 | 1778 | yes | CL_přívodní vodní (10 °C) 4
13295661 | -1.PP_SO-102 | 365.075 | 0.000568237 | 0.0308521 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2732.54 | 2367.46 | 2732.54 | 2367.46 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1632.54 | 0.0229383 | 20 | 105 | 365.075 | ø20 | 26.9 | 21.6 | TR02.02.1779 | 1779 | yes | CL_vratné vodní (15 °C) 8
13295686 | -1.PP_SO-102 | 365.075 | 0.000568237 | 0.0308521 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2732.54 | 2367.46 | 2732.54 | 2367.46 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1632.54 | 0.0229383 | 20 | 105 | 365.075 | ø20 | 26.9 | 21.6 | TR02.02.1780 | 1780 | yes | CL_vratné vodní (15 °C) 8
13295721 | -1.PP_SO-102 | 315.075 | 0.000568237 | 0.0266266 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2732.54 | 2417.46 | 2732.54 | 2417.46 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1582.54 | 0.0197967 | 20 | 142 | 315.075 | ø20 | 26.9 | 21.6 | TR02.02.1781 | 1781 | yes | HT_vratné vodní (45 °C) 26
13295746 | -1.PP_SO-102 | 315.075 | 0.000568237 | 0.0266266 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2732.54 | 2417.46 | 2732.54 | 2417.46 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1582.54 | 0.0197967 | 20 | 142 | 315.075 | ø20 | 26.9 | 21.6 | TR02.02.1782 | 1782 | yes | HT_vratné vodní (45 °C) 26
13295781 | -1.PP_SO-102 | 315.075 | 0.000568237 | 0.0266266 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2732.54 | 2417.46 | 2732.54 | 2417.46 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1582.54 | 0.0197967 | 20 | 41 | 315.075 | ø20 | 26.9 | 21.6 | TR02.02.1783 | 1783 | yes | HT_přívodní vodní (65 °C) 27
13295806 | -1.PP_SO-102 | 315.075 | 0.000568237 | 0.0266266 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2732.54 | 2417.46 | 2732.54 | 2417.46 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1582.54 | 0.0197967 | 20 | 41 | 315.075 | ø20 | 26.9 | 21.6 | TR02.02.1784 | 1784 | yes | HT_přívodní vodní (65 °C) 27
13296094 | -1.PP_SO-102 | 265.075 | 0.000568237 | 0.0224012 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2732.54 | 2467.46 | 2732.54 | 2467.46 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1532.54 | 0.0166552 | 20 | 41 | 265.075 | ø20 | 26.9 | 21.6 | TR02.02.1785 | 1785 | yes | HT_přívodní vodní (65 °C) 27
13296123 | -1.PP_SO-102 | 265.075 | 0.000568237 | 0.0224012 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2732.54 | 2467.46 | 2732.54 | 2467.46 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1532.54 | 0.0166552 | 20 | 142 | 265.075 | ø20 | 26.9 | 21.6 | TR02.02.1786 | 1786 | yes | HT_vratné vodní (45 °C) 26
13296152 | -1.PP_SO-102 | 265.075 | 0.000568237 | 0.0224012 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2732.54 | 2467.46 | 2732.54 | 2467.46 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1532.54 | 0.0166552 | 20 | 105 | 265.075 | ø20 | 26.9 | 21.6 | TR02.02.1787 | 1787 | yes | CL_vratné vodní (15 °C) 8
13296181 | -1.PP_SO-102 | 265.075 | 0.000568237 | 0.0224012 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2732.54 | 2467.46 | 2732.54 | 2467.46 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1532.54 | 0.0166552 | 20 | 131 | 265.075 | ø20 | 26.9 | 21.6 | TR02.02.1788 | 1788 | yes | CL_přívodní vodní (10 °C) 4
13296248 | -1.PP_SO-102 | 4327.55 | 0.000568237 | 0.365716 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2693.45 | 2680 | 2680 | 2666.55 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1330.8 | 0.271908 | 20 | 131 | 4327.55 | ø20 | 26.9 | 21.6 | TR02.02.1789 | 1789 | yes | CL_přívodní vodní (10 °C) 4 | 0
13296254 | -1.PP_SO-102 | 3265.08 | 0.000568237 | 0.275928 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2693.45 | 2680 | 2680 | 2666.55 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1330.8 | 0.205151 | 20 | 131 | 3265.08 | ø20 | 26.9 | 21.6 | TR02.02.1790 | 1790 | yes | CL_přívodní vodní (10 °C) 4 | 0
13296264 | -1.PP_SO-102 | 1200.06 | 0.000568237 | 0.101416 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2513.45 | 2500 | 2500 | 2486.55 | Fáze 2 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1510.8 | 0.0754021 | 20 | 131 | 1200.06 | ø20 | 26.9 | 21.6 | TR02.02.1791 | 1791 | yes | CL_přívodní vodní (10 °C) 4 | 0
13296337 | -1.PP_SO-102 | 4177.55 | 0.000568237 | 0.35304 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2693.45 | 2680 | 2680 | 2666.55 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1330.8 | 0.262483 | 20 | 105 | 4177.55 | ø20 | 26.9 | 21.6 | TR02.02.1792 | 1792 | yes | CL_vratné vodní (15 °C) 8 | 0
13296345 | -1.PP_SO-102 | 3265.08 | 0.000568237 | 0.275928 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2693.45 | 2680 | 2680 | 2666.55 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1330.8 | 0.205151 | 20 | 105 | 3265.08 | ø20 | 26.9 | 21.6 | TR02.02.1793 | 1793 | yes | CL_vratné vodní (15 °C) 8 | 0
13296355 | -1.PP_SO-102 | 1350.06 | 0.000568237 | 0.114092 | 0 | ø20 mm | 0.00462963 | HC | -1.PP_SO-102 | 2513.45 | 2500 | 2500 | 2486.55 | Fáze 2 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1510.8 | 0.0848269 | 20 | 105 | 1350.06 | ø20 | 26.9 | 21.6 | TR02.02.1794 | 1794 | yes | CL_vratné vodní (15 °C) 8 | 0
13296382 | -1.PP_SO-102 | 4027.55 | 0.000568237 | 0.340364 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2693.45 | 2680 | 2680 | 2666.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1330.8 | 0.253059 | 20 | 142 | 4027.55 | ø20 | 26.9 | 21.6 | TR02.02.1795 | 1795 | yes | HT_vratné vodní (45 °C) 26 | 0
13296388 | -1.PP_SO-102 | 3322.9 | 0.000568237 | 0.280815 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2693.45 | 2680 | 2680 | 2666.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1330.8 | 0.208784 | 20 | 142 | 3322.9 | ø20 | 26.9 | 21.6 | TR02.02.1796 | 1796 | yes | HT_vratné vodní (45 °C) 26 | 0
13296398 | -1.PP_SO-102 | 1500.06 | 0.000568237 | 0.126768 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2513.45 | 2500 | 2500 | 2486.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | -1510.8 | 0.0942516 | 20 | 142 | 1500.06 | ø20 | 26.9 | 21.6 | TR02.02.1797 | 1797 | yes | HT_vratné vodní (45 °C) 26 | 0
13296425 | -1.PP_SO-102 | 3877.55 | 0.000568237 | 0.327687 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2693.45 | 2680 | 2680 | 2666.55 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1330.8 | 0.243634 | 20 | 41 | 3877.55 | ø20 | 26.9 | 21.6 | TR02.02.1798 | 1798 | yes | HT_přívodní vodní (65 °C) 27 | 0
13296431 | -1.PP_SO-102 | 3322.9 | 0.000568237 | 0.280815 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2693.45 | 2680 | 2680 | 2666.55 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1330.8 | 0.208784 | 20 | 41 | 3322.9 | ø20 | 26.9 | 21.6 | TR02.02.1799 | 1799 | yes | HT_přívodní vodní (65 °C) 27 | 0
13296441 | -1.PP_SO-102 | 1650.06 | 0.000568237 | 0.139445 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2513.45 | 2500 | 2500 | 2486.55 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | -1510.8 | 0.103676 | 20 | 41 | 1650.06 | ø20 | 26.9 | 21.6 | TR02.02.1800 | 1800 | yes | HT_přívodní vodní (65 °C) 27 | 0
13301807 | 2.NP_SO-102 | 335.706 | 0.00183197 | 0.0509397 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2969.04 | 2969.04 | 2633.34 | 2633.34 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 6633.34 | 0.0421861 | 40 | 35 | 335.706 | ø40 | 48.3 | 41.8 | TR02.02.1810 | 1810 | yes | HT_přívodní vodní (55 °C) 12
13301810 | 2.NP_SO-102 | 524.674 | 0.000891835 | 0.0555481 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 3016.85 | 3000 | 3000 | 2983.15 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 6986.4 | 0.0412078 | 25 | 30 | 524.674 | ø25 | 33.7 | 27.2 | TR02.02.1811 | 1811 | yes | HT_přívodní vodní (55 °C) 12 | 0
13303076 | -1.PP_SO-102 | 10693.9 | 0.00141175 | 1.42447 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2471.2 | 2450 | 2450 | 2428.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 2 | -1567.95 | 1.07507 | 32 | 146 | 10693.9 | ø32 | 42.4 | 35.9 | TR02.02.1812 | 1812 | yes | HT_vratné vodní (45 °C) 2 | 0 | Izolace - Typ izolace: Tepelná
13303796 | -1.PP_SO-102 | 6306.41 | 0.00285535 | 1.19467 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 3030.15 | 3000 | 3000 | 2969.85 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1026.5 | 0.990608 | 50 | 98 | 6306.41 | ø50 | 60.3 | 53 | TR02.02.1815 | 1815 | yes | CL_vratné vodní (15 °C) 8 | 0
13304267 | -1.PP_SO-102 | 387.769 | 0.00285535 | 0.0734582 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 3030.15 | 3000 | 3000 | 2969.85 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1026.5 | 0.0609106 | 50 | 68 | 387.769 | ø50 | 60.3 | 53 | TR02.02.1819 | 1819 | yes | CL_přívodní vodní (10 °C) 4 | 0
13304308 | -1.PP_SO-102 | 586.086 | 0.00285535 | 0.111027 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 3030.15 | 3000 | 3000 | 2969.85 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1026.5 | 0.0920621 | 50 | 47 | 586.086 | ø50 | 60.3 | 53 | TR02.02.1821 | 1821 | yes | CL_vratné vodní (15 °C) 8 | 0
13304506 | -1.PP_SO-102 | 6658.99 | 0.00285535 | 1.26147 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 3030.15 | 3000 | 3000 | 2969.85 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1026.5 | 1.04599 | 50 | 119 | 6658.99 | ø50 | 60.3 | 53 | TR02.02.1823 | 1823 | yes | CL_přívodní vodní (10 °C) 4 | 0
13304851 | -1.PP_SO-102 | 552.375 | 0.00141175 | 0.0735783 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 3276.19 | 2723.81 | 3276.19 | 2723.81 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -1276.19 | 0.0555308 | 32 | 36 | 552.375 | ø32 | 42.4 | 35.9 | TR02.02.1824 | 1824 | yes | HT_vratné vodní (45 °C) 23 | Izolace - Typ izolace: Tepelná
13304928 | -1.PP_SO-102 | 977.587 | 0.00141175 | 0.130218 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 3321.2 | 3300 | 3300 | 3278.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -717.95 | 0.0982778 | 32 | 55 | 977.587 | ø32 | 42.4 | 35.9 | TR02.02.1825 | 1825 | yes | HT_přívodní vodní (65 °C) 8 | 0
13304934 | -1.PP_SO-102 | 98.4035 | 0.00141175 | 0.0131077 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 3321.2 | 3300 | 3300 | 3278.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -717.95 | 0.0098926 | 32 | 55 | 98.4035 | ø32 | 42.4 | 35.9 | TR02.02.1826 | 1826 | yes | HT_přívodní vodní (65 °C) 8 | 0
13304963 | -1.PP_SO-102 | 552.375 | 0.00141175 | 0.0735783 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 3276.19 | 2723.81 | 3276.19 | 2723.81 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -1276.19 | 0.0555308 | 32 | 55 | 552.375 | ø32 | 42.4 | 35.9 | TR02.02.1827 | 1827 | yes | HT_přívodní vodní (65 °C) 8
13305300 | -1.PP_SO-102 | 618.283 | 0.00141175 | 0.0823575 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2321.2 | 2300 | 2300 | 2278.8 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | -1717.95 | 0.0621566 | 32 | 55 | 618.283 | ø32 | 42.4 | 35.9 | TR02.02.1828 | 1828 | yes | HT_přívodní vodní (65 °C) 8 | 0 | Izolace - Typ izolace: Tepelná
13305405 | -1.PP_SO-102 | 491.836 | 0.00141175 | 0.0655142 | 40 | ø112 mm | 0.00278552 | HD | -1.PP_SO-102 | 2321.2 | 2300 | 2300 | 2278.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | -1717.95 | 0.0494447 | 32 | 36 | 491.836 | ø32 | 42.4 | 35.9 | TR02.02.1829 | 1829 | yes | HT_vratné vodní (45 °C) 23 | 0 | Izolace - Typ izolace: Tepelná
13309998 | -1.PP_SO-102 | 3.03106 | 0.00285535 | 0.000574197 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 3030.15 | 3000 | 3000 | 2969.85 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1026.5 | 0.000476117 | 50 | 91 | 3.03106 | ø50 | 60.3 | 53 | TR02.02.1830 | 1830 | yes | CL_vratné vodní (15 °C) 8 | 0
13310067 | -1.PP_SO-102 | 23.0311 | 0.00285535 | 0.00436296 | 0 | ø50 mm | 0.00188679 | HC | -1.PP_SO-102 | 3030.15 | 3000 | 3000 | 2969.85 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1026.5 | 0.00361771 | 50 | 113 | 23.0311 | ø50 | 60.3 | 53 | TR02.02.1831 | 1831 | yes | CL_přívodní vodní (10 °C) 4 | 0
13310167 | -1.PP_SO-102 | 1731.77 | 0.00183197 | 0.262777 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-102 | 2824.15 | 2800 | 2800 | 2775.85 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1220.9 | 0.217621 | 40 | 72 | 1731.77 | ø40 | 48.3 | 41.8 | TR02.02.1832 | 1832 | yes | CL_vratné vodní (15 °C) 8 | 0
13310190 | -1.PP_SO-102 | 1931.77 | 0.00183197 | 0.293125 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-102 | 2824.15 | 2800 | 2800 | 2775.85 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1220.9 | 0.242754 | 40 | 80 | 1931.77 | ø40 | 48.3 | 41.8 | TR02.02.1833 | 1833 | yes | CL_přívodní vodní (10 °C) 4 | 0
13310307 | -1.PP_SO-102 | 146.025 | 0.00183197 | 0.0221577 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-102 | 2773.01 | 2626.99 | 2773.01 | 2626.99 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1373.01 | 0.01835 | 40 | 80 | 146.025 | ø40 | 48.3 | 41.8 | TR02.02.1834 | 1834 | yes | CL_přívodní vodní (10 °C) 4
13310359 | -1.PP_SO-102 | 146.025 | 0.00183197 | 0.0221577 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-102 | 2773.01 | 2626.99 | 2773.01 | 2626.99 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1373.01 | 0.01835 | 40 | 72 | 146.025 | ø40 | 48.3 | 41.8 | TR02.02.1835 | 1835 | yes | CL_vratné vodní (15 °C) 8
13315778 | 3.NP_SO-102 | 1131.27 | 0.000568237 | 0.0956022 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10789.2 | 0.0710797 | 20 | 432 | 1131.27 | ø20 | 26.9 | 21.6 | TR02.02.1836 | 1836 | yes | HT_přívodní vodní (55 °C) 19 | 0
13315792 | 3.NP_SO-102 | 9335.77 | 0.000568237 | 0.788956 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10789.2 | 0.586584 | 20 | 431 | 9335.77 | ø20 | 26.9 | 21.6 | TR02.02.1837 | 1837 | yes | HT_přívodní vodní (55 °C) 19 | 0
13316947 | 4.NP_SO-102 | 2821.04 | 0.000568237 | 0.238403 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2782.54 | -38.5063 | 2782.54 | -38.5063 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11961.5 | 0.177251 | 20 | 484 | 2821.04 | ø20 | 26.9 | 21.6 | TR02.02.1842 | 1842 | yes | HT_vratné vodní (45 °C) 1
13326836 | -1.PP_SO-102 | 296.025 | 0.00183197 | 0.0449185 | 0 | ø40 mm | 0.00239234 | HD | -1.PP_SO-102 | 3173.01 | 3173.01 | 2876.99 | 2876.99 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 8 | -1123.01 | 0.0371996 | 40 | 186 | 296.025 | ø40 | 48.3 | 41.8 | TR02.02.1843 | 1843 | yes | HT_vratné vodní (45 °C) 8
13326924 | -1.PP_SO-102 | 1750.4 | 0.00183197 | 0.265604 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-102 | 2824.15 | 2800 | 2800 | 2775.85 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1220.9 | 0.219962 | 40 | 80 | 1750.4 | ø40 | 48.3 | 41.8 | TR02.02.1844 | 1844 | yes | CL_přívodní vodní (10 °C) 4 | 0
13326933 | -1.PP_SO-102 | 346.025 | 0.00183197 | 0.0525055 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-102 | 3173.01 | 2826.99 | 3173.01 | 2826.99 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | -1173.01 | 0.0434828 | 40 | 80 | 346.025 | ø40 | 48.3 | 41.8 | TR02.02.1845 | 1845 | yes | CL_přívodní vodní (10 °C) 4
13326974 | -1.PP_SO-102 | 1500.4 | 0.00183197 | 0.22767 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-102 | 2824.15 | 2800 | 2800 | 2775.85 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1220.9 | 0.188546 | 40 | 72 | 1500.4 | ø40 | 48.3 | 41.8 | TR02.02.1846 | 1846 | yes | CL_vratné vodní (15 °C) 8 | 0
13326985 | -1.PP_SO-102 | 346.025 | 0.00183197 | 0.0525055 | 0 | ø40 mm | 0.00239234 | HC | -1.PP_SO-102 | 3173.01 | 2826.99 | 3173.01 | 2826.99 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | -1173.01 | 0.0434828 | 40 | 72 | 346.025 | ø40 | 48.3 | 41.8 | TR02.02.1847 | 1847 | yes | CL_vratné vodní (15 °C) 8
13328121 | 2.NP_SO-102 | 1325.71 | 0.000356274 | 0.0887113 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 3010.65 | 3000 | 3000 | 2989.35 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6992 | 0.0624727 | 15 | 558 | 1325.71 | ø15 | 21.3 | 16 | TR02.02.1848 | 1848 | yes | HT_přívodní vodní (55 °C) 9 | 0
13328151 | 2.NP_SO-102 | 1505.71 | 0.000356274 | 0.100756 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 3010.65 | 3000 | 3000 | 2989.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6992 | 0.070955 | 15 | 822 | 1505.71 | ø15 | 21.3 | 16 | TR02.02.1849 | 1849 | yes | HT_vratné vodní (45 °C) 1 | 0
13328216 | 2.NP_SO-102 | 121.425 | 0.000356274 | 0.00812527 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 2985.71 | 2985.71 | 2864.29 | 2864.29 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6864.29 | 0.00572202 | 15 | 822 | 121.425 | ø15 | 21.3 | 16 | TR02.02.1850 | 1850 | yes | HT_vratné vodní (45 °C) 1
13328250 | 2.NP_SO-102 | 121.425 | 0.000356274 | 0.00812527 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 2985.71 | 2985.71 | 2864.29 | 2864.29 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6864.29 | 0.00572202 | 15 | 558 | 121.425 | ø15 | 21.3 | 16 | TR02.02.1851 | 1851 | yes | HT_přívodní vodní (55 °C) 9
13333596 | 3.NP_SO-102 | 3159.67 | 0.00183197 | 0.479446 | 40 | ø120 mm | 0.00239234 | HD | 3.NP_SO-102 | 2473.01 | -686.662 | 2473.01 | -686.662 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7313.34 | 0.397056 | 40 | 571 | 3159.67 | ø40 | 48.3 | 41.8 | TR02.02.1857 | 1857 | yes | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13333628 | 2.NP_SO-102 | 481.466 | 0.000568237 | 0.0406881 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 12 | 7269.2 | 0.0302514 | 20 | 9 | 481.466 | ø20 | 26.9 | 21.6 | TR02.02.1858 | 1858 | yes | HT_přívodní vodní (65 °C) 12 | 0
13333640 | 2.NP_SO-102 | 4609.78 | 0.000568237 | 0.389567 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 12 | 7269.2 | 0.289641 | 20 | 9 | 4609.78 | ø20 | 26.9 | 21.6 | TR02.02.1859 | 1859 | yes | HT_přívodní vodní (65 °C) 12 | 0
13334041 | 4.NP_SO-102 | 325.737 | 0.000568237 | 0.0275276 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3283.45 | 3270 | 3270 | 3256.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 24 | 15259.2 | 0.0204666 | 20 | 6 | 325.737 | ø20 | 26.9 | 21.6 | TR02.02.1860 | 1860 | yes | HT_přívodní vodní (65 °C) 18; HT_přívodní vodní (55 °C) 24 | 0
13334100 | 4.NP_SO-102 | 325.737 | 0.000568237 | 0.0275276 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3283.45 | 3270 | 3270 | 3256.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 15259.2 | 0.0204666 | 20 | 797 | 325.737 | ø20 | 26.9 | 21.6 | TR02.02.1861 | 1861 | yes | HT_vratné vodní (45 °C) 1 | 0
13334179 | 4.NP_SO-102 | 1010.6 | 0.000568237 | 0.0854047 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3283.45 | 3270 | 3270 | 3256.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 15259.2 | 0.0634979 | 20 | 797 | 1010.6 | ø20 | 26.9 | 21.6 | TR02.02.1862 | 1862 | yes | HT_vratné vodní (45 °C) 1 | 0
13334220 | 4.NP_SO-102 | 1010.6 | 0.000568237 | 0.0854047 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3283.45 | 3270 | 3270 | 3256.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 24 | 15259.2 | 0.0634979 | 20 | 6 | 1010.6 | ø20 | 26.9 | 21.6 | TR02.02.1863 | 1863 | yes | HT_přívodní vodní (55 °C) 24 | 0
13335221 | 2.NP_SO-102 | 487.605 | 0.000891835 | 0.0516235 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 2766.85 | 2750 | 2750 | 2733.15 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 6736.4 | 0.0382964 | 25 | 38 | 487.605 | ø25 | 33.7 | 27.2 | TR02.02.1864 | 1864 | yes | HT/CL_vratné vodní 1 | 0
