Properties of the parts of a building model (IFC4), part 55 of 72

# IfcPipeFitting: M_Přechod, obecný:Standardní (145)
Name (M_Přechod, obecný:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Délka (mm) | Jmenovitý poloměr 1 (mm) = Odskok – výška | Jmenovitý poloměr 2 (mm) | Jmenovitý průměr 1 (mm) = DN tvarovky 1 (sdílený) (mm) | Jmenovitý průměr 2 (mm) = DN tvarovky 2 (sdílený) (mm) | Maximální velikost (mm) | Minimální velikost (mm) | Objem (m3) | Odskok – šířka | Plocha (m2) | Velikost | Velikost značky 1 (mm) | Velikost značky 2 (mm) | Vnější průměr tvarovky 1 (mm) | Vnější průměr tvarovky 2 (mm) | Kód prvku | Označení | Páteřní trasa | Max. vnější průměr tvarovky 12 (mm) | Šířkové odsazení (mm) | Viditelnost 2 | Viditelnost 3 | Vnější poloměr tvarovky 2 (mm) | Vnější proloměr tvarovky 1 (mm) | Group
13314566 | 2.NP_SO-102 | 0 | ø54 mm-ø20 mm | HD | 2.NP_SO-102 | 3250 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 14.2937 | 27 | 10 | 54 | 20 | 54 | 20 | 0.0000187842 | 23.228 | 0.00309408 | ø54-ø20 | 22.87 | 8.89 | 57.175 | 22.225 | TT03.03.1445 | 1445 | yes | 57.175 | 3044.23 | yes | no | 11.1125 | 28.5875 | HT_přívodní vodní (55 °C) 19
13314570 | 2.NP_SO-102 | 0 | ø20 mm-ø15 mm | HD | 2.NP_SO-102 | 3226.19 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 10 | 7.5 | 20 | 15 | 20 | 15 | 0.00000157471 | 10 | 0.000554533 | ø20-ø15 | 8.89 | 6.35 | 22.225 | 15.875 | TT03.03.1446 | 1446 | yes | 22.225 | 3048 | yes | no | 7.9375 | 11.1125 | HT_vratné vodní (45 °C) 13
13314576 | 2.NP_SO-102 | 0 | ø40 mm-ø20 mm | HD | 2.NP_SO-102 | 3250 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.1447 | 1447 | yes | 41.275 | 3048 | yes | no | 11.1125 | 20.6375 | HT_vratné vodní (45 °C) 13
13314625 | 2.NP_SO-102 | 0 | ø20 mm-ø15 mm | HD | 2.NP_SO-102 | 3226.19 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 10 | 7.5 | 20 | 15 | 20 | 15 | 0.00000157471 | 10 | 0.000554533 | ø20-ø15 | 8.89 | 6.35 | 22.225 | 15.875 | TT03.03.1448 | 1448 | yes | 22.225 | 3048 | yes | no | 7.9375 | 11.1125 | HT_přívodní vodní (55 °C) 19
13314681 | 2.NP_SO-102 | 0 | ø65 mm-ø20 mm | HD | 2.NP_SO-102 | 3100 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 16.6688 | 32.5 | 10 | 65 | 20 | 65 | 20 | 0.0000279826 | 32.5 | 0.00413069 | ø65-ø20 | 26.67 | 8.89 | 66.675 | 22.225 | TT03.03.1450 | 1450 | yes | 66.675 | 3048 | yes | no | 11.1125 | 33.3375 | HT_přívodní vodní (55 °C) 19
13314683 | 2.NP_SO-102 | 0 | ø65 mm-ø20 mm | HD | 2.NP_SO-102 | 3100 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 16.6688 | 32.5 | 10 | 65 | 20 | 65 | 20 | 0.0000279826 | 32.5 | 0.00413069 | ø65-ø20 | 26.67 | 8.89 | 66.675 | 22.225 | TT03.03.1451 | 1451 | yes | 66.675 | 3048 | yes | no | 11.1125 | 33.3375 | HT_vratné vodní (45 °C) 13
13314944 | 3.NP_SO-102 | 40 | ø120 mm-ø100 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.1456 | 1456 | yes | 41.275 | 3048 | yes | no | 11.1125 | 20.6375 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13314961 | 3.NP_SO-102 | 0 | ø20 mm-ø15 mm | HD | 3.NP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 5.55625 | 7.5 | 10 | 15 | 20 | 20 | 15 | 0.00000158628 | 7.5 | 0.000554533 | ø20-ø15 | 6.35 | 8.89 | 15.875 | 22.225 | TT03.03.1458 | 1458 | yes | 22.225 | 3048 | no | yes | 11.1125 | 7.9375 | HT_přívodní vodní (55 °C) 9
13314963 | 3.NP_SO-102 | 0 | ø20 mm-ø15 mm | HD | 3.NP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5.55625 | 7.5 | 10 | 15 | 20 | 20 | 15 | 0.00000158628 | 7.5 | 0.000554533 | ø20-ø15 | 6.35 | 8.89 | 15.875 | 22.225 | TT03.03.1459 | 1459 | yes | 22.225 | 3048 | no | yes | 11.1125 | 7.9375 | HT_vratné vodní (45 °C) 1
13314965 | 3.NP_SO-102 | 40 | ø120 mm-ø100 mm | HD | 3.NP_SO-102 | 3150 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.1460 | 1460 | yes | 41.275 | 3048 | yes | no | 11.1125 | 20.6375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13314968 | 3.NP_SO-102 | 40 | ø120 mm-ø100 mm | HD | 3.NP_SO-102 | 3150 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.1461 | 1461 | yes | 41.275 | 3048 | yes | no | 11.1125 | 20.6375 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13315105 | 2.NP_SO-102 | 0 | ø20 mm-ø15 mm | HD | 2.NP_SO-102 | -29.3625 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 5.55625 | 7.5 | 10 | 15 | 20 | 20 | 15 | 0.00000158628 | 7.5 | 0.000554533 | ø20-ø15 | 6.35 | 8.89 | 15.875 | 22.225 | TT03.03.1463 | 1463 | yes | 22.225 | 3048 | no | yes | 11.1125 | 7.9375 | HT_přívodní vodní (55 °C) 9
13315107 | 2.NP_SO-102 | 0 | ø20 mm-ø15 mm | HD | 2.NP_SO-102 | -29.3625 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5.55625 | 7.5 | 10 | 15 | 20 | 20 | 15 | 0.00000158628 | 7.5 | 0.000554533 | ø20-ø15 | 6.35 | 8.89 | 15.875 | 22.225 | TT03.03.1464 | 1464 | yes | 22.225 | 3048 | no | yes | 11.1125 | 7.9375 | HT_vratné vodní (45 °C) 1
13315135 | 3.NP_SO-102 | 0 | ø20 mm-ø15 mm | HD | 3.NP_SO-102 | -26.1875 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 5.55625 | 10 | 7.5 | 20 | 15 | 20 | 15 | 0.00000157471 | 10 | 0.000554533 | ø20-ø15 | 8.89 | 6.35 | 22.225 | 15.875 | TT03.03.1466 | 1466 | yes | 22.225 | 3048 | yes | no | 7.9375 | 11.1125 | HT_přívodní vodní (55 °C) 9
13315141 | 3.NP_SO-102 | 0 | ø20 mm-ø15 mm | HD | 3.NP_SO-102 | -26.1875 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5.55625 | 10 | 7.5 | 20 | 15 | 20 | 15 | 0.00000157471 | 10 | 0.000554533 | ø20-ø15 | 8.89 | 6.35 | 22.225 | 15.875 | TT03.03.1467 | 1467 | yes | 22.225 | 3048 | yes | no | 7.9375 | 11.1125 | HT_vratné vodní (45 °C) 1
13315298 | 3.NP_SO-102 | 40 | ø120 mm-ø112 mm | HD | 3.NP_SO-102 | 3350 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT03.03.1473 | 1473 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13315301 | 3.NP_SO-102 | 40 | ø120 mm-ø112 mm | HD | 3.NP_SO-102 | 3280 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT03.03.1474 | 1474 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13315304 | 3.NP_SO-102 | 0 | ø32 mm-ø15 mm | HD | 3.NP_SO-102 | 3319.84 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8.73125 | 16 | 7.5 | 32 | 15 | 32 | 15 | 0.0000046023 | 16 | 0.00116529 | ø32-ø15 | 13.97 | 6.35 | 34.925 | 15.875 | TT03.03.1475 | 1475 | yes | 34.925 | 3048 | yes | no | 7.9375 | 17.4625 | HT_přívodní vodní (55 °C) 9
13315306 | 3.NP_SO-102 | 0 | ø32 mm-ø15 mm | HD | 3.NP_SO-102 | 3249.84 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8.73125 | 16 | 7.5 | 32 | 15 | 32 | 15 | 0.0000046023 | 16 | 0.00116529 | ø32-ø15 | 13.97 | 6.35 | 34.925 | 15.875 | TT03.03.1476 | 1476 | yes | 34.925 | 3048 | yes | no | 7.9375 | 17.4625 | HT_vratné vodní (45 °C) 1
13315308 | 3.NP_SO-102 | 0 | ø32 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT03.03.1477 | 1477 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | HT_vratné vodní (45 °C) 1
13315310 | 3.NP_SO-102 | 0 | ø32 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT03.03.1478 | 1478 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | HT_vratné vodní (45 °C) 1
13315312 | 3.NP_SO-102 | 0 | ø32 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 15 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT03.03.1479 | 1479 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | HT_přívodní vodní (65 °C) 15 | Mechanické – tok - Tlaková ztráta: 0 Pa
13315314 | 3.NP_SO-102 | 0 | ø32 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 15 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT03.03.1480 | 1480 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | HT_přívodní vodní (65 °C) 15 | Mechanické – tok - Tlaková ztráta: 0 Pa
13315422 | 2.NP_SO-102 | 0 | ø25 mm-ø16 mm | HD | 2.NP_SO-102 | 3934.06 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.14375 | 8 | 12.5 | 16 | 25 | 25 | 16 | 0.0000032169 | 8 | 0.00085321 | ø25-ø16 | 7.67 | 11.43 | 19.175 | 28.575 | TT03.03.1481 | 1481 | no | 28.575 | 3048 | no | yes | 14.2875 | 9.5875 | HT_přívodní vodní (55 °C) 9
13315424 | 3.NP_SO-102 | 0 | ø25 mm-ø16 mm | HD | 3.NP_SO-102 | -75.9375 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7.14375 | 8 | 12.5 | 16 | 25 | 25 | 16 | 0.0000032169 | 8 | 0.00085321 | ø25-ø16 | 7.67 | 11.43 | 19.175 | 28.575 | TT03.03.1482 | 1482 | no | 28.575 | 3048 | no | yes | 14.2875 | 9.5875 | HT_vratné vodní (45 °C) 1
13316118 | 3.NP_SO-102 | 0 | ø40 mm-ø32 mm | HD | 3.NP_SO-102 | 3150 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT03.03.1525 | 1525 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | HT_přívodní vodní (55 °C) 19
13316122 | 3.NP_SO-102 | 0 | ø40 mm-ø32 mm | HD | 3.NP_SO-102 | 3050 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10.3188 | 20 | 16 | 40 | 32 | 40 | 32 | 0.0000117432 | 20 | 0.00217103 | ø40-ø32 | 16.51 | 13.97 | 41.275 | 34.925 | TT03.03.1527 | 1527 | yes | 41.275 | 3048 | yes | no | 17.4625 | 20.6375 | HT_vratné vodní (45 °C) 13
13316124 | 3.NP_SO-102 | 0 | ø32 mm-ø20 mm | HD | 3.NP_SO-102 | 3050 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT03.03.1528 | 1528 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | HT_vratné vodní (45 °C) 13
13316126 | 3.NP_SO-102 | 0 | ø32 mm-ø20 mm | HD | 3.NP_SO-102 | 3050 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT03.03.1529 | 1529 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | HT_vratné vodní (45 °C) 13
13316130 | 3.NP_SO-102 | 0 | ø32 mm-ø20 mm | HD | 3.NP_SO-102 | 3050 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT03.03.1531 | 1531 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | HT_přívodní vodní (55 °C) 19
13316132 | 3.NP_SO-102 | 0 | ø32 mm-ø20 mm | HD | 3.NP_SO-102 | 3050 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT03.03.1532 | 1532 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | HT_přívodní vodní (55 °C) 19
13316366 | 2.NP_SO-102 | 0 | ø25 mm-ø20 mm | HE | 2.NP_SO-102 | 2650 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 7.14375 | 12.5 | 10 | 25 | 20 | 25 | 20 | 0.00000362261 | 12.5 | 0.000934648 | ø25-ø20 | 11.43 | 8.89 | 28.575 | 22.225 | TT03.03.1535 | 1535 | yes | 28.575 | 3048 | yes | no | 11.1125 | 14.2875 | HT/CL_přívodní vodní 1
13316659 | 4.NP_SO-102 | 0 | ø40 mm-ø20 mm | HD | 4.NP_SO-102 | 2850 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 10 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.1545 | 1545 | yes | 41.275 | 3048 | yes | no | 11.1125 | 20.6375 | HT_přívodní vodní (65 °C) 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13316672 | 4.NP_SO-102 | 0 | ø40 mm-ø15 mm | HD | 4.NP_SO-102 | 2850 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 10 | 10.3188 | 20 | 7.5 | 40 | 15 | 40 | 15 | 0.00000700483 | 20 | 0.00162635 | ø40-ø15 | 16.51 | 6.35 | 41.275 | 15.875 | TT03.03.1548 | 1548 | yes | 41.275 | 3048 | yes | no | 7.9375 | 20.6375 | HT_přívodní vodní (65 °C) 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13316674 | 4.NP_SO-102 | 0 | ø40 mm-ø15 mm | HD | 4.NP_SO-102 | 2920 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10.3188 | 20 | 7.5 | 40 | 15 | 40 | 15 | 0.00000700483 | 20 | 0.00162635 | ø40-ø15 | 16.51 | 6.35 | 41.275 | 15.875 | TT03.03.1549 | 1549 | yes | 41.275 | 3048 | yes | no | 7.9375 | 20.6375 | HT_vratné vodní (45 °C) 1
13316820 | 4.NP_SO-102 | 0 | ø22 mm-ø20 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6.29375 | 11 | 10 | 22 | 20 | 22 | 20 | 0.00000276911 | 11 | 0.000785339 | ø22-ø20 | 10.07 | 8.89 | 25.175 | 22.225 | TT03.03.1550 | 1550 | yes | 25.175 | 3048 | yes | no | 11.1125 | 12.5875 | HT_přívodní vodní (55 °C) 9
13317385 | 4.NP_SO-102 | 0 | ø40 mm-ø15 mm | HD | 4.NP_SO-102 | 3266.66 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10.3188 | 20 | 7.5 | 40 | 15 | 40 | 15 | 0.00000700483 | 20 | 0.00162635 | ø40-ø15 | 16.51 | 6.35 | 41.275 | 15.875 | TT03.03.1567 | 1567 | yes | 41.275 | 3048 | yes | no | 7.9375 | 20.6375 | HT_přívodní vodní (55 °C) 19
13317387 | 4.NP_SO-102 | 0 | ø40 mm-ø20 mm | HD | 4.NP_SO-102 | 3200 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.1568 | 1568 | yes | 41.275 | 3048 | yes | no | 11.1125 | 20.6375 | HT_přívodní vodní (55 °C) 19
13317395 | 4.NP_SO-102 | 0 | ø40 mm-ø15 mm | HD | 4.NP_SO-102 | 3166.66 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10.3188 | 20 | 7.5 | 40 | 15 | 40 | 15 | 0.00000700483 | 20 | 0.00162635 | ø40-ø15 | 16.51 | 6.35 | 41.275 | 15.875 | TT03.03.1572 | 1572 | yes | 41.275 | 3048 | yes | no | 7.9375 | 20.6375 | HT_vratné vodní (45 °C) 13
13317492 | 4.NP_SO-102 | 0 | ø20 mm-ø15 mm | HD | 4.NP_SO-102 | -32.5375 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 10 | 7.5 | 20 | 15 | 20 | 15 | 0.00000157471 | 10 | 0.000554533 | ø20-ø15 | 8.89 | 6.35 | 22.225 | 15.875 | TT03.03.1573 | 1573 | no | 22.225 | 3048 | yes | no | 7.9375 | 11.1125 | HT_vratné vodní (45 °C) 13
13317496 | 4.NP_SO-102 | 0 | ø20 mm-ø15 mm | HD | 4.NP_SO-102 | 3223.81 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 5.55625 | 10 | 7.5 | 20 | 15 | 20 | 15 | 0.00000157471 | 10 | 0.000554533 | ø20-ø15 | 8.89 | 6.35 | 22.225 | 15.875 | TT03.03.1575 | 1575 | yes | 22.225 | 3048 | yes | no | 7.9375 | 11.1125 | HT_přívodní vodní (55 °C) 19
13317498 | 4.NP_SO-102 | 0 | ø20 mm-ø15 mm | HD | 4.NP_SO-102 | 3223.81 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 5.55625 | 10 | 7.5 | 20 | 15 | 20 | 15 | 0.00000157471 | 10 | 0.000554533 | ø20-ø15 | 8.89 | 6.35 | 22.225 | 15.875 | TT03.03.1576 | 1576 | yes | 22.225 | 3048 | yes | no | 7.9375 | 11.1125 | HT_vratné vodní (45 °C) 13
13322221 | 3.NP_SO-102 | 0 | ø25 mm-ø20 mm | HD | 3.NP_SO-102 | 2882.54 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 20 | 7.14375 | 10 | 12.5 | 20 | 25 | 25 | 20 | 0.00000360829 | 10 | 0.000934648 | ø25-ø20 | 8.89 | 11.43 | 22.225 | 28.575 | TT03.03.1579 | 1579 | yes | 28.575 | 3048 | no | yes | 14.2875 | 11.1125 | HT_přívodní vodní (55 °C) 20 | Mechanické – tok - Tlaková ztráta: 0 Pa
13322223 | 3.NP_SO-102 | 0 | ø25 mm-ø16 mm | HD | 3.NP_SO-102 | -34.0625 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 20 | 7.14375 | 8 | 12.5 | 16 | 25 | 25 | 16 | 0.0000032169 | 8 | 0.00085321 | ø25-ø16 | 7.67 | 11.43 | 19.175 | 28.575 | TT03.03.1580 | 1580 | no | 28.575 | 3048 | no | yes | 14.2875 | 9.5875 | HT_přívodní vodní (55 °C) 20 | Mechanické – tok - Tlaková ztráta: 0 Pa
13322383 | -1.PP_SO-102 | 0 | ø80 mm-ø50 mm | HC | -1.PP_SO-102 | 3000 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 19.8438 | 40 | 25 | 80 | 50 | 80 | 50 | 0.0000700565 | 40 | 0.00735821 | ø80-ø50 | 31.75 | 21.59 | 79.375 | 53.975 | TT03.03.1586 | 1586 | yes | 79.375 | 3048 | yes | no | 26.9875 | 39.6875 | CL_vratné vodní (15 °C) 8
13322420 | 2.NP_SO-102 | 0 | ø65 mm-ø54 mm | HD | 2.NP_SO-102 | 3208.71 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 16.6688 | 27 | 32.5 | 54 | 65 | 65 | 54 | 0.0000502401 | 27 | 0.00577773 | ø65-ø54 | 22.87 | 26.67 | 57.175 | 66.675 | TT03.03.1588 | 1588 | yes | 66.675 | 3048 | no | yes | 33.3375 | 28.5875 | HT_přívodní vodní (55 °C) 19
13327811 | 1.NP_SO-102 | 0 | ø20 mm-ø16 mm | HD | 1.NP_SO-102 | -22.1562 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 5.55625 | 10 | 8 | 20 | 16 | 20 | 16 | 0.00000184965 | 10 | 0.000597935 | ø20-ø16 | 8.89 | 7.67 | 22.225 | 19.175 | TT03.03.1608 | 1608 | yes | 22.225 | 3048 | yes | no | 9.5875 | 11.1125 | HT_přívodní vodní (55 °C) 9
13328226 | 2.NP_SO-102 | 0 | ø40 mm-ø15 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10.3188 | 20 | 7.5 | 40 | 15 | 40 | 15 | 0.00000700483 | 20 | 0.00162635 | ø40-ø15 | 16.51 | 6.35 | 41.275 | 15.875 | TT03.03.1612 | 1612 | yes | 41.275 | 3048 | yes | no | 7.9375 | 20.6375 | HT_vratné vodní (45 °C) 1
13328260 | 2.NP_SO-102 | 0 | ø40 mm-ø15 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10.3188 | 20 | 7.5 | 40 | 15 | 40 | 15 | 0.00000700483 | 20 | 0.00162635 | ø40-ø15 | 16.51 | 6.35 | 41.275 | 15.875 | TT03.03.1615 | 1615 | yes | 41.275 | 3048 | yes | no | 7.9375 | 20.6375 | HT_přívodní vodní (55 °C) 9
13333604 | 2.NP_SO-102 | 0 | ø40 mm-ø20 mm | HD | 2.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 12 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.1618 | 1618 | yes | 41.275 | 3048 | yes | no | 11.1125 | 20.6375 | HT_přívodní vodní (55 °C) 9; HT_přívodní vodní (65 °C) 12 | Mechanické – tok - Tlaková ztráta: 0 Pa
13337006 | 2.NP_SO-102 | 0 | ø25 mm-ø22 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 7.14375 | 12.5 | 11 | 25 | 22 | 25 | 22 | 0.00000404178 | 12.5 | 0.00100151 | ø25-ø22 | 11.43 | 10.07 | 28.575 | 25.175 | TT03.03.1650 | 1650 | no | 28.575 | 3048 | yes | no | 12.5875 | 14.2875 | HT_přívodní vodní (55 °C) 12
13347552 | 4.NP_SO-102 | 0 | ø40 mm-ø20 mm | HD | 4.NP_SO-102 | 2920 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.1696 | 1696 | yes | 41.275 | 3048 | yes | no | 11.1125 | 20.6375 | HT_vratné vodní (45 °C) 1
13347594 | 4.NP_SO-102 | 0 | ø20 mm-ø15 mm | HD | 4.NP_SO-102 | 2896.19 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 5.55625 | 10 | 7.5 | 20 | 15 | 20 | 15 | 0.00000157471 | 10 | 0.000554533 | ø20-ø15 | 8.89 | 6.35 | 22.225 | 15.875 | TT03.03.1699 | 1699 | yes | 22.225 | 3048 | yes | no | 7.9375 | 11.1125 | HT_vratné vodní (45 °C) 1
13352079 | -1.PP_SO-102 | 0 | ø32 mm-ø20 mm | HD | -1.PP_SO-102 | 3340 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT03.03.1726 | 1726 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | HT_přívodní vodní (55 °C) 19
13390738 | 2.NP_SO-102 | 0 | ø100 mm-ø65 mm | HC | 2.NP_SO-102 | 2934.12 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 4 | 26.1938 | 50 | 32.5 | 100 | 65 | 100 | 65 | 0.000153591 | 50 | 0.0121569 | ø100-ø65 | 41.91 | 26.67 | 104.775 | 66.675 | TT03.03.1772 | 1772 | yes | 104.775 | 3048 | yes | no | 33.3375 | 52.3875 | CL_vratné vodní (15 °C) 4 | Mechanické – tok - Tlaková ztráta: 0 Pa
13390759 | 2.NP_SO-102 | 0 | ø100 mm-ø65 mm | HC | 2.NP_SO-102 | 2934.12 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 7 | 26.1938 | 50 | 32.5 | 100 | 65 | 100 | 65 | 0.000153591 | 50 | 0.0121569 | ø100-ø65 | 41.91 | 26.67 | 104.775 | 66.675 | TT03.03.1774 | 1774 | yes | 104.775 | 3048 | yes | no | 33.3375 | 52.3875 | CL_přívodní vodní (10 °C) 7 | Mechanické – tok - Tlaková ztráta: 0 Pa
13391814 | 2.NP_SO-102 | 0 | ø80 mm-ø32 mm | HD | 2.NP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 19.8438 | 40 | 16 | 80 | 32 | 80 | 32 | 0.000053403 | 40 | 0.00636724 | ø80-ø32 | 31.75 | 13.97 | 79.375 | 34.925 | TT03.03.1794 | 1794 | yes | 79.375 | 3048 | yes | no | 17.4625 | 39.6875 | HT_vratné vodní (45 °C) 23
13391855 | 2.NP_SO-102 | 0 | ø80 mm-ø32 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 19.8438 | 40 | 16 | 80 | 32 | 80 | 32 | 0.000053403 | 40 | 0.00636724 | ø80-ø32 | 31.75 | 13.97 | 79.375 | 34.925 | TT03.03.1797 | 1797 | yes | 79.375 | 3048 | yes | no | 17.4625 | 39.6875 | HT_přívodní vodní (65 °C) 8
13405134 | 4.NP_SO-102 | 60 | ø200 mm-ø185 mm | HD | 4.NP_SO-102 | 3100 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 19.8438 | 32.5 | 40 | 65 | 80 | 80 | 65 | 0.0000832732 | 32.5 | 0.00829731 | ø80-ø65 | 26.67 | 31.75 | 66.675 | 79.375 | TT03.03.1902 | 1902 | yes | 79.375 | 3048 | no | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13405140 | 4.NP_SO-102 | 60 | ø200 mm-ø185 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 19.8438 | 32.5 | 40 | 65 | 80 | 80 | 65 | 0.0000832732 | 32.5 | 0.00829731 | ø80-ø65 | 26.67 | 31.75 | 66.675 | 79.375 | TT03.03.1904 | 1904 | yes | 79.375 | 3048 | no | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13405158 | 4.NP_SO-102 | 60 | ø200 mm-ø185 mm | HD | 4.NP_SO-102 | 3100 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 19.8438 | 32.5 | 40 | 65 | 80 | 80 | 65 | 0.0000832732 | 32.5 | 0.00829731 | ø80-ø65 | 26.67 | 31.75 | 66.675 | 79.375 | TT03.03.1906 | 1906 | yes | 79.375 | 3048 | no | yes | 39.6875 | 33.3375 | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13405315 | 4.NP_SO-102 | 0 | ø80 mm-ø65 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 19.8438 | 40 | 32.5 | 80 | 65 | 80 | 65 | 0.0000832537 | 40 | 0.00829731 | ø80-ø65 | 31.75 | 26.67 | 79.375 | 66.675 | TT03.03.1921 | 1921 | yes | 79.375 | 3048 | yes | no | 33.3375 | 39.6875 | HT_PRIMÁR_přívodní 4
13408073 | -1.PP_SO-102 | 0 | ø50 mm-ø40 mm | HC | -1.PP_SO-102 | 2960.31 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 13.4938 | 25 | 20 | 50 | 40 | 50 | 40 | 0.0000241362 | 25 | 0.00346833 | ø50-ø40 | 21.59 | 16.51 | 53.975 | 41.275 | TT03.03.1953 | 1953 | yes | 53.975 | 3048 | yes | no | 20.6375 | 26.9875 | CL_vratné vodní (15 °C) 8
13408155 | -1.PP_SO-102 | 0 | ø50 mm-ø40 mm | HC | -1.PP_SO-102 | 2960.31 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 13.4938 | 25 | 20 | 50 | 40 | 50 | 40 | 0.0000241362 | 25 | 0.00346833 | ø50-ø40 | 21.59 | 16.51 | 53.975 | 41.275 | TT03.03.1959 | 1959 | yes | 53.975 | 3048 | yes | no | 20.6375 | 26.9875 | CL_přívodní vodní (10 °C) 4
13409926 | 2.NP_SO-102 | 0 | ø80 mm-ø40 mm | HD | 2.NP_SO-102 | 2273.01 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 19.8438 | 20 | 40 | 40 | 80 | 80 | 40 | 0.0000585088 | 20 | 0.00670892 | ø80-ø40 | 16.51 | 31.75 | 41.275 | 79.375 | TT03.03.1986 | 1986 | yes | 79.375 | 3048 | no | yes | 39.6875 | 20.6375 | HT_vratné vodní (45 °C) 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13409930 | 2.NP_SO-102 | 0 | ø80 mm-ø40 mm | HD | 2.NP_SO-102 | 2273.01 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 19.8438 | 20 | 40 | 40 | 80 | 80 | 40 | 0.0000585088 | 20 | 0.00670892 | ø80-ø40 | 16.51 | 31.75 | 41.275 | 79.375 | TT03.03.1988 | 1988 | yes | 79.375 | 3048 | no | yes | 39.6875 | 20.6375 | HT_vratné vodní (45 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13409936 | 2.NP_SO-102 | 0 | ø80 mm-ø40 mm | HD | 2.NP_SO-102 | 2273.01 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 19.8438 | 20 | 40 | 40 | 80 | 80 | 40 | 0.0000585088 | 20 | 0.00670892 | ø80-ø40 | 16.51 | 31.75 | 41.275 | 79.375 | TT03.03.1989 | 1989 | yes | 79.375 | 3048 | no | yes | 39.6875 | 20.6375 | HT_přívodní vodní (55 °C) 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13409940 | 2.NP_SO-102 | 0 | ø80 mm-ø40 mm | HD | 2.NP_SO-102 | 2273.01 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 19.8438 | 20 | 40 | 40 | 80 | 80 | 40 | 0.0000585088 | 20 | 0.00670892 | ø80-ø40 | 16.51 | 31.75 | 41.275 | 79.375 | TT03.03.1991 | 1991 | yes | 79.375 | 3048 | no | yes | 39.6875 | 20.6375 | HT_přívodní vodní (55 °C) 12 | Mechanické – tok - Tlaková ztráta: 0 Pa
13409951 | 2.NP_SO-102 | 0 | ø65 mm-ø20 mm | HD | 2.NP_SO-102 | 2500 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 16.6688 | 32.5 | 10 | 65 | 20 | 65 | 20 | 0.0000279826 | 32.5 | 0.00413069 | ø65-ø20 | 26.67 | 8.89 | 66.675 | 22.225 | TT03.03.1992 | 1992 | yes | 66.675 | 3048 | yes | no | 11.1125 | 33.3375 | HT_vratné vodní (45 °C) 26
13409966 | 2.NP_SO-102 | 0 | ø65 mm-ø20 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 16.6688 | 32.5 | 10 | 65 | 20 | 65 | 20 | 0.0000279826 | 32.5 | 0.00413069 | ø65-ø20 | 26.67 | 8.89 | 66.675 | 22.225 | TT03.03.1995 | 1995 | yes | 66.675 | 3048 | yes | no | 11.1125 | 33.3375 | HT_přívodní vodní (55 °C) 25
13409982 | 2.NP_SO-102 | 0 | ø40 mm-ø20 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.1999 | 1999 | yes | 41.275 | 3048 | yes | no | 11.1125 | 20.6375 | HT_přívodní vodní (55 °C) 25 | Mechanické – tok - Tlaková ztráta: 0 Pa
13409984 | 2.NP_SO-102 | 0 | ø40 mm-ø20 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 2 | 10.3188 | 10 | 20 | 20 | 40 | 40 | 20 | 0.00000837091 | 10 | 0.0017689 | ø40-ø20 | 8.89 | 16.51 | 22.225 | 41.275 | TT03.03.2000 | 2000 | yes | 41.275 | 3048 | no | yes | 20.6375 | 11.1125 | HT_přívodní vodní (55 °C) 2 | Mechanické – tok - Tlaková ztráta: 0 Pa
13409986 | 2.NP_SO-102 | 0 | ø40 mm-ø20 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 10 | 10.3188 | 10 | 20 | 20 | 40 | 40 | 20 | 0.00000837091 | 10 | 0.0017689 | ø40-ø20 | 8.89 | 16.51 | 22.225 | 41.275 | TT03.03.2001 | 2001 | yes | 41.275 | 3048 | no | yes | 20.6375 | 11.1125 | HT_vratné vodní (45 °C) 10 | Mechanické – tok - Tlaková ztráta: 0 Pa
13427254 | -1.PP_SO-102 | 0 | ø80 mm-ø50 mm | HC | -1.PP_SO-102 | 3000 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 19.8438 | 40 | 25 | 80 | 50 | 80 | 50 | 0.0000700565 | 40 | 0.00735821 | ø80-ø50 | 31.75 | 21.59 | 79.375 | 53.975 | TT03.03.2108 | 2108 | yes | 79.375 | 3048 | yes | no | 26.9875 | 39.6875 | CL_přívodní vodní (10 °C) 4
13434290 | 2.NP_SO-102 | 0 | ø40 mm-ø20 mm | HD | 2.NP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10.3188 | 20 | 10 | 40 | 20 | 40 | 20 | 0.00000836645 | 20 | 0.0017689 | ø40-ø20 | 16.51 | 8.89 | 41.275 | 22.225 | TT03.03.2152 | 2152 | yes | 41.275 | 3048 | yes | no | 11.1125 | 20.6375 | HT_vratné vodní (45 °C) 1
13438263 | 2.NP_SO-102 | 0 | ø40 mm-ø15 mm | HD | 2.NP_SO-102 | 2554.61 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 10.3188 | 20 | 7.5 | 40 | 15 | 40 | 15 | 0.00000700483 | 20 | 0.00162635 | ø40-ø15 | 16.51 | 6.35 | 41.275 | 15.875 | TT03.03.2189 | 2189 | yes | 41.275 | 3048 | yes | no | 7.9375 | 20.6375 | HT_vratné vodní (45 °C) 9
13440006 | 2.NP_SO-102 | 0 | ø32 mm-ø20 mm | HC | 2.NP_SO-102 | -1073.81 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT03.03.2204 | 2204 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | CL_vratné vodní (15 °C) 2
13440209 | 2.NP_SO-102 | 0 | ø32 mm-ø20 mm | HC | 2.NP_SO-102 | -1073.81 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 8.73125 | 16 | 10 | 32 | 20 | 32 | 20 | 0.00000566227 | 16 | 0.00129853 | ø32-ø20 | 13.97 | 8.89 | 34.925 | 22.225 | TT03.03.2208 | 2208 | yes | 34.925 | 3048 | yes | no | 11.1125 | 17.4625 | CL_přívodní vodní (10 °C) 1

# IfcPipeFitting: M_Spoj T, obecný:Standardní (7)
Type - Material: 0-128-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT02; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 02; Popis: T kus; Popis sestavy: Odbočka
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT02 Uniformat (Uniformat)
Text - CCI Funkční systém: H; CCI Komponenta: XMB; CCI Technický systém: HD
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní
Name (M_Spoj T, obecný:Standardní:...) | In | Celková velikost | Tloušťka izolace (mm) | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) = Úhel 1 (deg) | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) = Štítek, od středu ke konci (mm) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Vnější poloměr tvarovky (mm)
13078975 | 2.NP_SO-102 | ø122 mm-ø122 mm-ø122 mm | 40 | 2.NP_SO-102 | 3100 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 21 | 42 | 0.000138944 | 35.2875 | ø42-ø42-ø42 | 18.07 | 45.175 | TT02.02.0210 | 0210 | yes | 22.5875 | Izolace - Typ izolace: Tepelná
13079879 | 1.NP_SO-102 | ø122 mm-ø122 mm-ø122 mm | 40 | 1.NP_SO-102 | 2900 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 21 | 42 | 0.000138944 | 35.2875 | ø42-ø42-ø42 | 18.07 | 45.175 | TT02.02.0225 | 0225 | yes | 22.5875 | Izolace - Typ izolace: Tepelná
13113713 | 2.NP_SO-102 | ø42 mm-ø42 mm-ø42 mm | 0 | 2.NP_SO-102 | 2650 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 21 | 42 | 0.000138944 | 35.2875 | ø42-ø42-ø42 | 18.07 | 45.175 | TT02.02.0495 | 0495 | yes | 22.5875
13113751 | 2.NP_SO-102 | ø42 mm-ø42 mm-ø42 mm | 0 | 2.NP_SO-102 | 2650 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 21 | 42 | 0.000138944 | 35.2875 | ø42-ø42-ø42 | 18.07 | 45.175 | TT02.02.0498 | 0498 | yes | 22.5875
13116017 | 2.NP_SO-102 | ø42 mm-ø42 mm-ø42 mm | 0 | 2.NP_SO-102 | 2650 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 21 | 42 | 0.000138944 | 35.2875 | ø42-ø42-ø42 | 18.07 | 45.175 | TT02.02.0519 | 0519 | yes | 22.5875
13116054 | 2.NP_SO-102 | ø42 mm-ø42 mm-ø42 mm | 0 | 2.NP_SO-102 | 2650 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 21 | 42 | 0.000138944 | 35.2875 | ø42-ø42-ø42 | 18.07 | 45.175 | TT02.02.0522 | 0522 | yes | 22.5875
13117767 | 3.NP_SO-102 | ø16 mm-ø16 mm-ø16 mm | 0 | 3.NP_SO-102 | -52.1685 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 89.8758 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0533 | 0533 | no | 9.5875

# IfcPipeFitting: M_Spoj T, obecný:Standardní, M_Spoj T, obecný:Standardní:13250949
In: 2.NP_SO-102
Type - Material: 128-255-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT02; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 02; Popis: T kus; Popis sestavy: Odbočka
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT02 Uniformat (Uniformat); Group: CL_vratné vodní (15 °C) 3
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø100 mm-ø100 mm-ø100 mm
Text - CCI Funkční systém: H; CCI Komponenta: XMB; CCI Technický systém: HC
Vazby - Podlaží: 2.NP_SO-102; Výška od podlaží: 1700 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: CL_vratné vodní (15 °C); Klasifikace systému: Zpětné vedení teplé vody; Název systému: CL_vratné vodní (15 °C) 3
Grafika - Použít měřítko poznámky: no
Kóty - Úhel: 90 deg; Jmenovitý poloměr: 50 mm; Jmenovitý průměr: 100 mm; Maximální velikost: 100 mm; Minimální velikost: 100 mm; Objem: 0.00130008 m3; Od středu ke konci: 65.0875 mm; Velikost: ø100-ø100-ø100; Velikost značky: 41.91 mm; Vnější průměr tvarovky: 104.775 mm
Identifikační data - Kód prvku: TT02.02.1140; Označení: 1140
Jiné - Páteřní trasa: yes; Typ: Standardní; Úhel tvarovky 1 (sdílený): 90 deg; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní; Úhel 1: 90 deg; Štítek, od středu ke konci: 65.0875 mm; Vnější poloměr tvarovky: 52.3875 mm

# IfcPipeFitting: M_Spoj T, obecný:Standardní (358)
Type - Material: 255-128-128
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Koeficient K z tabulky; Tabulka koeficientů K: Tee
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: O; Kód sestavy: TT02; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 02; Popis: T kus; Popis sestavy: Odbočka
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Spoj T, obecný; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT02 Uniformat (Uniformat)
Text - CCI Funkční systém: H; CCI Komponenta: XMB
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3336370; Rodina: M_Spoj T, obecný; Rodina a typ: M_Spoj T, obecný: Standardní
Name (M_Spoj T, obecný:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Úhel (deg) | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) = Štítek, od středu ke konci (mm) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Úhel tvarovky 1 (sdílený) (deg) = Úhel 1 (deg) | Vnější poloměr tvarovky (mm) | Group
13020596 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 11 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0008 | 0008 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 11
13020776 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 11 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0011 | 0011 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 11
13020891 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0013 | 0013 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9
13021030 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 14 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0015 | 0015 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 14
13023376 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0018 | 0018 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 13
13023389 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.0019 | 0019 | yes | 90 | 11.1125 | HT_přívodní vodní (55 °C) 9
13023583 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.0022 | 0022 | yes | 90 | 7.9375 | HT_přívodní vodní (55 °C) 9
13024114 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 22 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0024 | 0024 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 22
13025208 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 15 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0028 | 0028 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 15; HT_přívodní vodní (55 °C) 20
13025295 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 15 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0029 | 0029 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 15
13025977 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 20 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0036 | 0036 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 20
13026181 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 20 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0039 | 0039 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 20
13026250 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 20 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0040 | 0040 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9; HT_přívodní vodní (65 °C) 20
13026530 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 21 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0041 | 0041 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 21
13026601 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 21 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0043 | 0043 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 21
13026972 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0050 | 0050 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 1
13030743 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0059 | 0059 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9
13031856 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0066 | 0066 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9
13032530 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0069 | 0069 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9
13033191 | 1.NP_SO-102 | 40 | ø120 mm-ø120 mm-ø120 mm | HD | 1.NP_SO-102 | 3360 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0073 | 0073 | yes | 90 | 20.6375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13033892 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 25 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0076 | 0076 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 25
13035668 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 34 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0078 | 0078 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 34
13036430 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0080 | 0080 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13036840 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0082 | 0082 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13037814 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0086 | 0086 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13037826 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0087 | 0087 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13038464 | 4.NP_SO-102 | 0 | ø40 mm-ø40 mm-ø40 mm | HD | 4.NP_SO-102 | 3300 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0089 | 0089 | yes | 90 | 20.6375 | HT_přívodní vodní (55 °C) 19
13038665 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0091 | 0091 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13039167 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 3300 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.0093 | 0093 | yes | 90 | 7.9375 | HT_přívodní vodní (55 °C) 19
13039304 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0098 | 0098 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13039788 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0100 | 0100 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 9
13040581 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0102 | 0102 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13040700 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0104 | 0104 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13040788 | 3.NP_SO-102 | 0 | ø40 mm-ø40 mm-ø40 mm | HD | 3.NP_SO-102 | 3150 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0106 | 0106 | yes | 90 | 20.6375 | HT_přívodní vodní (55 °C) 19
13041171 | 3.NP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | 3.NP_SO-102 | 3150 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.0107 | 0107 | yes | 90 | 17.4625 | HT_přívodní vodní (55 °C) 19
13041711 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0109 | 0109 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13042965 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 14 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0114 | 0114 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 14
13043044 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0117 | 0117 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13043091 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0120 | 0120 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13043750 | 2.NP_SO-102 | 0 | ø54 mm-ø54 mm-ø54 mm | HD | 2.NP_SO-102 | 3250 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 27 | 54 | 0.000255701 | 41.2875 | ø54-ø54-ø54 | 22.87 | 57.175 | TT02.02.0121 | 0121 | yes | 90 | 28.5875 | HT_přívodní vodní (55 °C) 19
13043829 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3250 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.0122 | 0122 | yes | 90 | 11.1125 | HT_přívodní vodní (55 °C) 19
13043950 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0124 | 0124 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13044624 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0126 | 0126 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13045404 | 1.NP_SO-102 | 0 | ø35 mm-ø35 mm-ø35 mm | HD | 1.NP_SO-102 | 3300 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 17.5 | 35 | 0.0000906028 | 31.7875 | ø35-ø35-ø35 | 15.27 | 38.175 | TT02.02.0130 | 0130 | yes | 90 | 19.0875 | HT_přívodní vodní (55 °C) 19
13045423 | 1.NP_SO-102 | 0 | ø25 mm-ø25 mm-ø25 mm | HD | 1.NP_SO-102 | 3300 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT02.02.0131 | 0131 | yes | 90 | 14.2875 | HT_přívodní vodní (55 °C) 19
13045576 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0133 | 0133 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13046031 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0137 | 0137 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13046052 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0138 | 0138 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13046091 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0140 | 0140 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13046163 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0142 | 0142 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13046177 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0144 | 0144 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13046468 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0148 | 0148 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9
13046516 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0150 | 0150 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9
13048026 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0156 | 0156 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9
13048100 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0158 | 0158 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9
13056919 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HD | 3.NP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.0175 | 0175 | yes | 90 | 7.9375 | HT_přívodní vodní (55 °C) 9
13057401 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HD | 3.NP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.0178 | 0178 | no | 90 | 7.9375 | HT_přívodní vodní (55 °C) 9
13066972 | 3.NP_SO-102 | 40 | ø120 mm-ø120 mm-ø120 mm | HD | 3.NP_SO-102 | 3350 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0184 | 0184 | yes | 90 | 20.6375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13069782 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm-ø40 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0186 | 0186 | yes | 90 | 20.6375 | HT_přívodní vodní (55 °C) 9
13069812 | 2.NP_SO-102 | 40 | ø120 mm-ø120 mm-ø120 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0190 | 0190 | yes | 90 | 20.6375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13070117 | 2.NP_SO-102 | 40 | ø130 mm-ø130 mm-ø130 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT02.02.0191 | 0191 | yes | 90 | 26.9875 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13070129 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.0194 | 0194 | yes | 90 | 39.6875 | HT_přívodní vodní (55 °C) 9
13079961 | 1.NP_SO-102 | 40 | ø120 mm-ø120 mm-ø120 mm | HD | 1.NP_SO-102 | 2900 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0228 | 0228 | yes | 90 | 20.6375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13080218 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0235 | 0235 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13081144 | 2.NP_SO-102 | 60 | ø200 mm-ø200 mm-ø200 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.0236 | 0236 | yes | 90 | 39.6875 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13081310 | 2.NP_SO-102 | 40 | ø130 mm-ø130 mm-ø130 mm | HD | 2.NP_SO-102 | 3250 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT02.02.0239 | 0239 | yes | 90 | 26.9875 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13081714 | 2.NP_SO-102 | 40 | ø120 mm-ø120 mm-ø120 mm | HD | 2.NP_SO-102 | 3257.68 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 89.8336 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0242 | 0242 | yes | 89.8336 | 20.6375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13081769 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0244 | 0244 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13081834 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0245 | 0245 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13082262 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0247 | 0247 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13082796 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0249 | 0249 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
