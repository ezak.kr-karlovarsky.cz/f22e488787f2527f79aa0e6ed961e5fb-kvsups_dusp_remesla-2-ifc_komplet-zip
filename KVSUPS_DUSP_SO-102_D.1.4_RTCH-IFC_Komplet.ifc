Properties of the parts of a building model (IFC4), part 38 of 72

# IfcDistributionPort (10261)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_13315664_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13141440_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13315666_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13141442_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13315752_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13141442_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13315668_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13141475_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13141477_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13141475_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315754_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13141485_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315670_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13141485_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315672_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13141487_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315754_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13141487_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315674_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13141901_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13142192_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13141925_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142334_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13141993_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
OutPort_13141983_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
InPort_13141983_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
OutPort_13142004_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
InPort_13142004_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
OutPort_13141996_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
InPort_13141996_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
OutPort_13142012_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
InPort_13142012_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
OutPort_13142006_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
InPort_13142006_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
OutPort_13142238_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
Port_13142041_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142124_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142041_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142145_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142050_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142145_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142050_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142147_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142059_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142147_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142059_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142365_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13142154_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
OutPort_13142246_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
InPort_13142250_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
OutPort_13142154_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
Port_13142192_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
Port_13142193_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 22
InPort_13142238_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
OutPort_13142236_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
InPort_13142236_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
OutPort_13315287_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
InPort_13315287_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
OutPort_13142250_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 18
Port_13142270_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142373_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142270_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142377_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142334_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142335_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142363_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142365_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142363_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13315289_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142377_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13315289_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13142873_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
OutPort_13143323_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
InPort_13143325_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
OutPort_13142873_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
InPort_13143323_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
OutPort_13142882_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
InPort_13142882_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
OutPort_13142902_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
InPort_13142902_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
OutPort_13142892_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
InPort_13142892_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
OutPort_13142910_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
InPort_13142910_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
OutPort_13142904_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
InPort_13142904_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
OutPort_13143688_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
Port_13142992_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143356_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142992_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143358_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143001_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143356_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143001_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143080_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143010_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143080_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143010_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143082_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143019_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143082_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143019_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143831_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13143315_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
OutPort_13143313_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
InPort_13143313_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
OutPort_13143325_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
Port_13143346_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143348_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143346_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143358_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143436_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13144156_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13143472_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13144189_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143474_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13144183_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13143564_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
OutPort_13143696_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
InPort_13143700_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
OutPort_13143564_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
InPort_13322221_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
OutPort_13143686_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
InPort_13143686_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
OutPort_13322223_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
InPort_13143688_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
OutPort_13322221_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
InPort_13322223_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
OutPort_13143700_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 20
Port_13143721_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143839_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143721_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143841_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143829_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143831_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143829_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13322225_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143841_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13322225_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13144156_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13144163_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13144163_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13144164_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13144183_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13144188_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13144188_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13144189_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13144305_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13144306_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13144316_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13144656_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13144324_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13144656_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13144324_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13144658_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13144359_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144500_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144411_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13144419_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13144411_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13144648_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13144456_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144504_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144456_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144685_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144500_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144501_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144517_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144772_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144517_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144695_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144646_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13317280_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13144646_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13144658_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13144648_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13317280_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13144683_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13317282_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144683_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144695_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144685_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13317282_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144968_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13317498_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144968_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144986_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144970_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144971_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144970_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13317498_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144971_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13317391_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13145060_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13145061_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13145086_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13145494_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13145118_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13145471_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13145118_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13145473_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13145134_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13145140_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13145134_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13322273_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13145189_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13145556_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13145189_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13145558_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13145331_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13145498_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13145331_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13322277_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13145461_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13317284_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13145461_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13145473_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13145463_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13322273_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13145463_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13317284_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13145494_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13145495_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13145546_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13317286_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13145546_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13145558_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13145548_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13322277_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13145548_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13317286_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
InPort_13146777_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 33
OutPort_13147088_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 33
InPort_13147088_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 33
OutPort_13316571_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 33
InPort_13316567_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 35
OutPort_13147096_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 35
InPort_13147096_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 22
OutPort_13316571_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 22
Port_13147121_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13147410_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13147121_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13147740_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13147400_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13147740_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13147400_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316667_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13147445_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 21
OutPort_13316665_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 21
InPort_13147445_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 21
OutPort_13316567_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 21
Port_13147646_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13147681_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13147681_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13147688_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13147688_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13147689_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
InPort_13316665_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
OutPort_13147688_3 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13147689_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13316542_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 34
Port_13147721_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13147737_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13147737_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13147744_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13147744_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13147745_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13147744_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316667_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13147745_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316517_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13147945_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 28
OutPort_13147943_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 28
InPort_13147943_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
OutPort_13147949_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
InPort_13147949_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
OutPort_13148000_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
Port_13147996_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148389_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13148000_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
OutPort_13148014_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
InPort_13148014_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
OutPort_13148008_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
InPort_13148008_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
OutPort_13148024_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
InPort_13148024_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
OutPort_13148016_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
InPort_13148016_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
OutPort_13148032_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
InPort_13148032_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
OutPort_13148026_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
InPort_13148026_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
OutPort_13148093_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
InPort_13148097_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
OutPort_13148034_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
InPort_13148034_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
OutPort_13148830_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
InPort_13148093_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
OutPort_13148091_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
InPort_13148091_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
OutPort_13317048_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
InPort_13317048_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
OutPort_13148097_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 23
Port_13148179_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148239_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148179_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148469_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148188_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148239_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148188_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148241_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148197_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148241_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148197_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148338_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148254_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148338_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148254_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316991_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148265_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316995_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148265_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316999_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148389_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148390_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148467_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148469_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148467_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148481_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148724_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 2
Port_13148827_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 2
Port_13148790_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 2
Port_13148818_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 2
Port_13148818_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 2
Port_13148826_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 2
Port_13148826_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 2
Port_13148827_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 2
InPort_13334246_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 24
OutPort_13149026_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 24
InPort_13149026_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 24
OutPort_13334248_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 24
InPort_13149034_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 18
OutPort_13334041_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 18
Port_13149065_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13149066_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13149065_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13149284_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
InPort_13149076_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 24
OutPort_13149256_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 24
InPort_13149258_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 24
OutPort_13149076_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 24
Port_13149133_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13334201_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149133_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149366_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13334248_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 24
OutPort_13149246_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 24
InPort_13149246_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 24
OutPort_13316824_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 24
InPort_13316824_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 24
OutPort_13149258_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 24
Port_13149283_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13149284_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 25
Port_13149301_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149374_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149301_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149376_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149333_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149334_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149333_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149400_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149364_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149366_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149364_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316826_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149374_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149394_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149376_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316826_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149394_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149399_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149399_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149400_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13316820_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13149447_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13149447_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 18
OutPort_13149766_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 18
Port_13149543_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149576_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149543_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149702_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149576_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13334100_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149700_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149702_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149700_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149714_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13149754_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 18
OutPort_13149756_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 18
InPort_13149766_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 18
OutPort_13149754_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 18
Port_13149864_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 10
Port_13149897_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 10
Port_13149896_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 10
Port_13149897_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 10
Port_13149981_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13347586_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149981_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13347554_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13150037_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13150179_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13150037_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13150181_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13150046_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13150181_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13150051_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13150179_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13150051_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13150079_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 18
Port_13150111_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 18
Port_13150079_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 18
Port_13150202_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 18
Port_13150090_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 18
Port_13150111_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 18
Port_13150090_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 18
Port_13159555_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13159568_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13159555_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13159705_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13159703_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13159705_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13159703_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13159709_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13159709_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13159713_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13159713_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13159736_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13159728_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13159736_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13159728_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13160111_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13160590_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13160111_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13160691_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13160120_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13160630_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13160120_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13160657_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13160129_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13160760_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13160129_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13160762_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
InPort_13160138_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
OutPort_13160798_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
InPort_13160823_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
OutPort_13160138_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
Port_13160147_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13160892_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13160147_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13326838_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13160216_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13160911_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13160216_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13160225_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13160695_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13160225_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13160911_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13160234_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13161979_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13160234_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13160243_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13160955_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13160243_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
InPort_13160252_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
OutPort_13160970_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
OutPort_13160252_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
Port_13160261_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13326840_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13160261_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13160270_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13160661_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13160270_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13161979_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13160279_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13160951_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13160279_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13160955_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
InPort_13160288_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
OutPort_13160827_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
InPort_13160970_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
OutPort_13160288_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
Port_13160655_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13160657_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13160655_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13160661_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13160689_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13160691_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13160689_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13160695_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13160750_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13160951_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13160750_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13160762_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
InPort_13160821_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
OutPort_13160823_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
InPort_13160827_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
OutPort_13160821_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
InPort_13368763_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
OutPort_13163451_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
InPort_13163451_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
OutPort_13417810_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
InPort_13287904_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
OutPort_13163463_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
InPort_13163463_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
OutPort_13287602_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
Port_13163541_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13417813_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13163541_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13287910_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
InPort_13287602_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
OutPort_13163785_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
InPort_13163785_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
Port_13163999_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13287910_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13163999_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
InPort_13169771_1 | SINK | DUCT
OutPort_13169771_2 | SOURCE | DUCT
InPort_13169771_3 | SINK | PIPE
OutPort_13169771_4 | SOURCE | PIPE
InPort_13169872_1 | SINK | DUCT
OutPort_13169872_2 | SOURCE | DUCT
InPort_13169872_3 | SINK | PIPE
OutPort_13169872_4 | SOURCE | PIPE
InPort_13169880_1 | SINK | DUCT
OutPort_13169880_2 | SOURCE | DUCT
InPort_13169880_3 | SINK | PIPE
OutPort_13169880_4 | SOURCE | PIPE
InPort_13169888_1 | SINK | DUCT
OutPort_13169888_2 | SOURCE | DUCT
InPort_13169888_3 | SINK | PIPE
OutPort_13169888_4 | SOURCE | PIPE
Port_13171872_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13313680_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13171872_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13171876_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13171876_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172185_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13171947_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13178049_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13171947_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172089_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172724_3 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172089_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172187_3 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172100_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13178103_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172100_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172180_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172187_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172180_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13178103_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172185_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13173136_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172187_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172188_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172188_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13178049_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172202_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172492_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172202_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13438841_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172211_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172703_3 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172211_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172494_3 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172238_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13178030_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172238_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172247_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13178101_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172247_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172489_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172494_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172489_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13178101_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172492_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13173157_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172494_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172495_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172495_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13178030_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172563_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13178374_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172563_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172565_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13178380_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172565_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172567_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172724_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172567_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13178380_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172571_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13178376_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172571_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172573_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13178378_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172573_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172575_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172703_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172575_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13178378_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172602_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172602_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172961_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172604_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13173041_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172604_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172606_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172682_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172606_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13173041_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172610_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172610_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172925_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172612_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172997_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172612_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172614_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172661_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172614_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172997_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172657_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172661_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172657_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172925_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172659_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13173159_3 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172659_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172661_4 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172661_3 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172701_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172678_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172682_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172678_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172961_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172680_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13173138_3 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172680_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172682_4 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172682_3 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172722_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172699_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172703_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172699_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13178376_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172701_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172703_4 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13172720_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172724_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172720_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13178374_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172722_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13172724_4 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13173073_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13178864_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13173073_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13173075_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13178860_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13173075_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13173079_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13178862_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13173079_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13173081_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13178858_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13173081_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13173083_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13178858_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13173083_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13173159_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13173087_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13173138_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13173087_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13178864_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13173134_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13178860_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13173134_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13173138_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13173136_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13173138_4 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13173155_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13173159_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13173155_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13178862_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13173157_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13173159_4 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
InPort_13173260_1 | SINK | DUCT
OutPort_13173260_2 | SOURCE | DUCT
InPort_13173260_3 | SINK | PIPE
OutPort_13173260_4 | SOURCE | PIPE
Port_13174072_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13439985_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174072_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174237_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174304_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174237_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174251_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174245_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174251_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174245_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174261_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174253_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174261_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174253_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174287_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174308_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174287_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174296_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174304_3 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174296_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174308_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174304_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174305_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174305_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174926_3 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174393_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13431261_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174393_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13440006_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174492_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13439983_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174492_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174510_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174693_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174510_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13175045_3 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174537_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174728_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174537_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174742_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174546_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174742_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174546_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174693_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174555_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174666_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174555_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174693_3 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174564_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174666_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174564_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174573_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174728_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174573_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13174921_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13440205_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174921_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13440207_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174926_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13440178_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174926_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174927_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13174927_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13439985_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13175040_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13439983_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13175040_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13175045_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13175045_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13440100_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13175046_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13440004_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13175046_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13440158_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13180508_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395629_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13180508_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13405122_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13180573_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13180575_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13180573_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13180585_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13180585_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13395496_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13180608_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13180610_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13180608_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13180620_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
