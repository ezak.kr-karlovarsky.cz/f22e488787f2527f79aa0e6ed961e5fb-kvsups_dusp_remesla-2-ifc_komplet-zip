Properties of the parts of a building model (IFC4), part 58 of 72

# IfcPipeSegment: Typy trubek:Kompozit PE-Xa_RAUTITAN flex (676)
Name (Typy trubek:Kompozit PE-Xa_RAUTITAN flex:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Relativní drsnost | Sklon | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Typ systému | Drsnost (mm) | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group
13026947 | 1.NP_SO-102 | 124.062 | 0.000201032 | 0.00623606 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 1 | -55.8 | RAU–PE–Xa | 16 | 357 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0102 | 0102 | no | HT_přívodní vodní (65 °C) 1
13026966 | 1.NP_SO-102 | 117.712 | 0.000201032 | 0.00591688 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 1 | -55.8 | RAU–PE–Xa | 16 | 365 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0103 | 0103 | no | HT_přívodní vodní (65 °C) 1
13026973 | 1.NP_SO-102 | 1267.79 | 0.000201032 | 0.0637261 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 1 | -55.8 | RAU–PE–Xa | 16 | 358 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0104 | 0104 | no | HT_přívodní vodní (65 °C) 1
13027118 | 1.NP_SO-102 | 7095.04 | 0.000201032 | 0.356635 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 21 | -55.8 | RAU–PE–Xa | 16 | 47 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0105 | 0105 | no | HT_přívodní vodní (65 °C) 21
13028457 | -1.PP_SO-102 | 5626.33 | 0.000201032 | 0.28281 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -4055.8 | RAU–PE–Xa | 16 | 388 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0114 | 0114 | no | HT_přívodní vodní (55 °C) 9
13028611 | -1.PP_SO-102 | 437.336 | 0.000201032 | 0.0219829 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -4055.8 | RAU–PE–Xa | 16 | 398 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0115 | 0115 | no | HT_přívodní vodní (55 °C) 9
13028663 | -1.PP_SO-102 | 464.062 | 0.000201032 | 0.0233263 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -4055.8 | RAU–PE–Xa | 16 | 388 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0116 | 0116 | no | HT_přívodní vodní (55 °C) 9
13028698 | -1.PP_SO-102 | 537.712 | 0.000201032 | 0.0270284 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -4055.8 | RAU–PE–Xa | 16 | 402 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0117 | 0117 | no | HT_přívodní vodní (55 °C) 9
13030549 | -1.PP_SO-102 | 746.008 | 0.000314112 | 0.0468731 | ø20 mm | 0.000694444 | 0 | -1.PP_SO-102 | -40 | -50 | -50 | -60 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -4057.2 | RAU–PE–Xa | 20 | 381 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0123 | 0123 | no | HT_přívodní vodní (55 °C) 9
13030607 | -1.PP_SO-102 | 964.47 | 0.000314112 | 0.0605994 | ø20 mm | 0.000694444 | 0 | -1.PP_SO-102 | -40 | -50 | -50 | -60 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -4057.2 | RAU–PE–Xa | 20 | 381 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0124 | 0124 | no | HT_přívodní vodní (55 °C) 9
13030616 | -1.PP_SO-102 | 5576.88 | 0.000314112 | 0.350406 | ø20 mm | 0.000694444 | 0 | -1.PP_SO-102 | -40 | -50 | -50 | -60 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -4057.2 | RAU–PE–Xa | 20 | 381 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0125 | 0125 | no | HT_přívodní vodní (55 °C) 9
13030646 | 1.NP_SO-102 | 373.35 | 0.000201032 | 0.0187666 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -55.8 | RAU–PE–Xa | 16 | 412 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0126 | 0126 | no | HT_přívodní vodní (55 °C) 9
13030653 | 1.NP_SO-102 | 3161.1 | 0.000201032 | 0.158894 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -55.8 | RAU–PE–Xa | 16 | 412 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0127 | 0127 | no | HT_přívodní vodní (55 °C) 9
13030714 | 1.NP_SO-102 | 843.425 | 0.000201032 | 0.0423952 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -55.8 | RAU–PE–Xa | 16 | 552 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0128 | 0128 | no | HT_přívodní vodní (55 °C) 9
13030744 | 1.NP_SO-102 | 1699.37 | 0.000201032 | 0.0854195 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -55.8 | RAU–PE–Xa | 16 | 412 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0129 | 0129 | no | HT_přívodní vodní (55 °C) 9
13030748 | -1.PP_SO-102 | 213.836 | 0.000201032 | 0.0107486 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -4055.8 | RAU–PE–Xa | 16 | 552 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0130 | 0130 | no | HT_přívodní vodní (55 °C) 9
13030878 | -1.PP_SO-102 | 169.063 | 0.000201032 | 0.00849801 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -4055.8 | RAU–PE–Xa | 16 | 552 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0132 | 0132 | no | HT_přívodní vodní (55 °C) 9
13031581 | 1.NP_SO-102 | 332.631 | 0.000201032 | 0.0167199 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -55.8 | RAU–PE–Xa | 16 | 428 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0133 | 0133 | no | HT_přívodní vodní (55 °C) 9
13031590 | 1.NP_SO-102 | 4047.47 | 0.000201032 | 0.203448 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -55.8 | RAU–PE–Xa | 16 | 428 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0134 | 0134 | no | HT_přívodní vodní (55 °C) 9
13031608 | 1.NP_SO-102 | 315.86 | 0.000201032 | 0.0158768 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -55.8 | RAU–PE–Xa | 16 | 63 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0135 | 0135 | no | HT_přívodní vodní (55 °C) 9
13031672 | 1.NP_SO-102 | 353.123 | 0.000201032 | 0.0177499 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -55.8 | RAU–PE–Xa | 16 | 63 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0136 | 0136 | no | HT_přívodní vodní (55 °C) 9
13031857 | 1.NP_SO-102 | 7942.83 | 0.000201032 | 0.39925 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -55.8 | RAU–PE–Xa | 16 | 417 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0138 | 0138 | no | HT_přívodní vodní (55 °C) 9
13031931 | 2.NP_SO-102 | 554.391 | 0.000201032 | 0.0278667 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 47 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0139 | 0139 | no | HT_přívodní vodní (55 °C) 9
13031947 | 2.NP_SO-102 | 4521.78 | 0.000201032 | 0.227289 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 46 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0140 | 0140 | no | HT_přívodní vodní (55 °C) 9
13032340 | 2.NP_SO-102 | 370.143 | 0.000201032 | 0.0186054 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 46 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0141 | 0141 | no | HT_přívodní vodní (55 °C) 9
13032531 | 2.NP_SO-102 | 691.981 | 0.000201032 | 0.0347828 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 47 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0142 | 0142 | no | HT_přívodní vodní (55 °C) 9
13032550 | 2.NP_SO-102 | 363.793 | 0.000201032 | 0.0182862 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 21 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0143 | 0143 | no | HT_přívodní vodní (55 °C) 9
13033557 | 4.NP_SO-102 | 361.775 | 0.000201032 | 0.0181848 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 25 | 11944.2 | RAU–PE–Xa | 16 | 21 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0151 | 0151 | no | HT_přívodní vodní (65 °C) 25
13033807 | 4.NP_SO-102 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 25 | 11944.2 | RAU–PE–Xa | 16 | 31 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0152 | 0152 | no | HT_přívodní vodní (65 °C) 25
13033824 | 4.NP_SO-102 | 6002.49 | 0.000201032 | 0.301718 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 25 | 11944.2 | RAU–PE–Xa | 16 | 27 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0153 | 0153 | no | HT_přívodní vodní (65 °C) 25
13033846 | 4.NP_SO-102 | 484.062 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 25 | 11944.2 | RAU–PE–Xa | 16 | 27 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0154 | 0154 | no | HT_přívodní vodní (65 °C) 25
13033884 | 4.NP_SO-102 | 477.713 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 25 | 11944.2 | RAU–PE–Xa | 16 | 30 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0155 | 0155 | no | HT_přívodní vodní (65 °C) 25
13033916 | 4.NP_SO-102 | 6404.71 | 0.000201032 | 0.321936 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 25 | 11944.2 | RAU–PE–Xa | 16 | 25 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0156 | 0156 | no | HT_přívodní vodní (65 °C) 25
13034174 | 4.NP_SO-102 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 25 | 11944.2 | RAU–PE–Xa | 16 | 34 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0157 | 0157 | no | HT_přívodní vodní (65 °C) 25
13034183 | 4.NP_SO-102 | 6945.86 | 0.000201032 | 0.349137 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 25 | 11944.2 | RAU–PE–Xa | 16 | 34 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0158 | 0158 | no | HT_přívodní vodní (65 °C) 25
13034684 | 4.NP_SO-102 | 365.662 | 0.000201032 | 0.0183802 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 2 | 11944.2 | RAU–PE–Xa | 16 | 24 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0160 | 0160 | no | HT_přívodní vodní (65 °C) 2
13035461 | 4.NP_SO-102 | 359.312 | 0.000201032 | 0.018061 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 2 | 11944.2 | RAU–PE–Xa | 16 | 30 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0161 | 0161 | no | HT_přívodní vodní (65 °C) 2
13035498 | 4.NP_SO-102 | 14648.4 | 0.000201032 | 0.736307 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 2 | 11944.2 | RAU–PE–Xa | 16 | 29 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0162 | 0162 | no | HT_přívodní vodní (65 °C) 2
13035507 | 4.NP_SO-102 | 669.985 | 0.000201032 | 0.0336771 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 34 | 11944.2 | RAU–PE–Xa | 16 | 11 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0163 | 0163 | no | HT_přívodní vodní (65 °C) 34
13035533 | 4.NP_SO-102 | 484.062 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 34 | 11944.2 | RAU–PE–Xa | 16 | 8 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0164 | 0164 | no | HT_přívodní vodní (65 °C) 34
13035550 | 4.NP_SO-102 | 479.677 | 0.000201032 | 0.0241112 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 34 | 11944.2 | RAU–PE–Xa | 16 | 7 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0165 | 0165 | no | HT_přívodní vodní (65 °C) 34
13035576 | 4.NP_SO-102 | 477.713 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 34 | 11944.2 | RAU–PE–Xa | 16 | 3 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0166 | 0166 | no | HT_přívodní vodní (65 °C) 34
13035832 | 4.NP_SO-102 | 5473.9 | 0.000201032 | 0.275148 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 34 | 11944.2 | RAU–PE–Xa | 16 | 7 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0167 | 0167 | no | HT_přívodní vodní (65 °C) 34
13035855 | 4.NP_SO-102 | 7438.85 | 0.000201032 | 0.373918 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 34 | 11944.2 | RAU–PE–Xa | 16 | 9 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0168 | 0168 | no | HT_přívodní vodní (65 °C) 34
13035920 | 4.NP_SO-102 | 6401.37 | 0.000201032 | 0.321768 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 495 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0169 | 0169 | no | HT_přívodní vodní (55 °C) 19
13036050 | 4.NP_SO-102 | 434.063 | 0.000201032 | 0.0218184 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 452 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0170 | 0170 | no | HT_přívodní vodní (55 °C) 19
13036422 | 4.NP_SO-102 | 427.713 | 0.000201032 | 0.0214992 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 467 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0171 | 0171 | no | HT_přívodní vodní (55 °C) 19
13036452 | 4.NP_SO-102 | 6992.84 | 0.000201032 | 0.351498 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 468 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0172 | 0172 | no | HT_přívodní vodní (55 °C) 19
13036761 | 4.NP_SO-102 | 708.717 | 0.000201032 | 0.035624 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 461 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0173 | 0173 | no | HT_přívodní vodní (55 °C) 19
13036767 | 4.NP_SO-102 | 434.062 | 0.000201032 | 0.0218184 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 461 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0174 | 0174 | no | HT_přívodní vodní (55 °C) 19
13036823 | 4.NP_SO-102 | 284.063 | 0.000201032 | 0.0142785 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 464 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0175 | 0175 | no | HT_přívodní vodní (55 °C) 19
13036830 | 4.NP_SO-102 | 1402.12 | 0.000201032 | 0.0704783 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 464 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0176 | 0176 | no | HT_přívodní vodní (55 °C) 19
13036841 | 4.NP_SO-102 | 8820.15 | 0.000201032 | 0.443349 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 459 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0177 | 0177 | no | HT_přívodní vodní (55 °C) 19
13037688 | 4.NP_SO-102 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 505 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0178 | 0178 | no | HT_přívodní vodní (55 °C) 19
13037697 | 4.NP_SO-102 | 4056.75 | 0.000201032 | 0.203914 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 500 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0179 | 0179 | no | HT_přívodní vodní (55 °C) 19
13037736 | 4.NP_SO-102 | 484.062 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 500 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0180 | 0180 | no | HT_přívodní vodní (55 °C) 19
13037806 | 4.NP_SO-102 | 477.713 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 504 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0181 | 0181 | no | HT_přívodní vodní (55 °C) 19
13037818 | 4.NP_SO-102 | 477.713 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 503 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0182 | 0182 | no | HT_přívodní vodní (55 °C) 19
13037827 | 4.NP_SO-102 | 5434.4 | 0.000201032 | 0.273163 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 498 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0183 | 0183 | no | HT_přívodní vodní (55 °C) 19
13037850 | 4.NP_SO-102 | 6632.08 | 0.000201032 | 0.333365 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 496 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0184 | 0184 | no | HT_přívodní vodní (55 °C) 19
13038593 | 4.NP_SO-102 | 7216.43 | 0.000201032 | 0.362738 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 78 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0189 | 0189 | no | HT_přívodní vodní (55 °C) 19
13038657 | 4.NP_SO-102 | 537.712 | 0.000201032 | 0.0270284 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 516 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0190 | 0190 | no | HT_přívodní vodní (55 °C) 19
13038666 | 4.NP_SO-102 | 147.936 | 0.000201032 | 0.00743608 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 11944.2 | RAU–PE–Xa | 16 | 515 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0191 | 0191 | no | HT_přívodní vodní (55 °C) 19
13039224 | 3.NP_SO-102 | 478.506 | 0.000314112 | 0.0300654 | ø20 mm | 0.000694444 | 0 | 3.NP_SO-102 | -40 | -50 | -50 | -60 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 7942.8 | RAU–PE–Xa | 20 | 400 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0198 | 0198 | no | HT_přívodní vodní (55 °C) 19
13039269 | 3.NP_SO-102 | 7678.54 | 0.000314112 | 0.482457 | ø20 mm | 0.000694444 | 0 | 3.NP_SO-102 | -40 | -50 | -50 | -60 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 7942.8 | RAU–PE–Xa | 20 | 406 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0199 | 0199 | no | HT_přívodní vodní (55 °C) 19
13039279 | 3.NP_SO-102 | 478.506 | 0.000314112 | 0.0300654 | ø20 mm | 0.000694444 | 0 | 3.NP_SO-102 | -40 | -50 | -50 | -60 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 7942.8 | RAU–PE–Xa | 20 | 110 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0200 | 0200 | no | HT_přívodní vodní (55 °C) 19
13039296 | 3.NP_SO-102 | 472.156 | 0.000314112 | 0.0296665 | ø20 mm | 0.000694444 | 0 | 3.NP_SO-102 | -40 | -50 | -50 | -60 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 7942.8 | RAU–PE–Xa | 20 | 111 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0201 | 0201 | no | HT_přívodní vodní (55 °C) 19
13039702 | 3.NP_SO-102 | 127.712 | 0.000201032 | 0.00641953 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 9 | 7944.2 | RAU–PE–Xa | 16 | 125 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0202 | 0202 | no | HT_přívodní vodní (65 °C) 9
13039723 | 3.NP_SO-102 | 134.063 | 0.000201032 | 0.00673872 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 4 | 7944.2 | RAU–PE–Xa | 16 | 127 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0203 | 0203 | no | HT_přívodní vodní (65 °C) 4
13039956 | 3.NP_SO-102 | 7780.23 | 0.000201032 | 0.391077 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 7944.2 | RAU–PE–Xa | 16 | 340 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0205 | 0205 | no | HT_přívodní vodní (55 °C) 19
13040024 | 3.NP_SO-102 | 5599.16 | 0.000201032 | 0.281445 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 7944.2 | RAU–PE–Xa | 16 | 531 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0208 | 0208 | no | HT_přívodní vodní (55 °C) 19
13040573 | 3.NP_SO-102 | 277.712 | 0.000201032 | 0.0139594 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 7944.2 | RAU–PE–Xa | 16 | 119 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0209 | 0209 | no | HT_přívodní vodní (55 °C) 19
13040693 | 3.NP_SO-102 | 1935.51 | 0.000201032 | 0.0972895 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 7944.2 | RAU–PE–Xa | 16 | 117 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0210 | 0210 | no | HT_přívodní vodní (55 °C) 19
13040701 | 3.NP_SO-102 | 1102.5 | 0.000201032 | 0.0554178 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 7944.2 | RAU–PE–Xa | 16 | 120 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0211 | 0211 | no | HT_přívodní vodní (55 °C) 19
13040709 | 3.NP_SO-102 | 5096.9 | 0.000201032 | 0.256198 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 7944.2 | RAU–PE–Xa | 16 | 118 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0212 | 0212 | no | HT_přívodní vodní (55 °C) 19
13040717 | 3.NP_SO-102 | 944.063 | 0.000201032 | 0.0474538 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 7944.2 | RAU–PE–Xa | 16 | 118 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0213 | 0213 | no | HT_přívodní vodní (55 °C) 19
13040735 | 3.NP_SO-102 | 7300.46 | 0.000314112 | 0.458701 | ø20 mm | 0.000694444 | 0 | 3.NP_SO-102 | -40 | -50 | -50 | -60 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 7942.8 | RAU–PE–Xa | 20 | 410 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø20 | 14.4 | TR13.03.0214 | 0214 | no | HT_přívodní vodní (55 °C) 19
13041625 | 3.NP_SO-102 | 6758.35 | 0.000201032 | 0.339712 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 7944.2 | RAU–PE–Xa | 16 | 280 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0219 | 0219 | no | HT_přívodní vodní (55 °C) 19
13041703 | 3.NP_SO-102 | 1047.68 | 0.000201032 | 0.0526621 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 7944.2 | RAU–PE–Xa | 16 | 444 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0220 | 0220 | no | HT_přívodní vodní (55 °C) 19
13041712 | 3.NP_SO-102 | 150.97 | 0.000201032 | 0.00758858 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 7944.2 | RAU–PE–Xa | 16 | 443 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0221 | 0221 | no | HT_přívodní vodní (55 °C) 19
13042920 | 2.NP_SO-102 | 377.713 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 14 | 3944.2 | RAU–PE–Xa | 16 | 9 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0229 | 0229 | no | HT_přívodní vodní (65 °C) 14
13042966 | 2.NP_SO-102 | 3815.43 | 0.000201032 | 0.191784 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 14 | 3944.2 | RAU–PE–Xa | 16 | 8 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0230 | 0230 | no | HT_přívodní vodní (65 °C) 14
13043000 | 2.NP_SO-102 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 3944.2 | RAU–PE–Xa | 16 | 177 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0231 | 0231 | no | HT_přívodní vodní (55 °C) 19
13043009 | 2.NP_SO-102 | 7725.1 | 0.000201032 | 0.388306 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 3944.2 | RAU–PE–Xa | 16 | 179 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0232 | 0232 | no | HT_přívodní vodní (55 °C) 19
13043019 | 2.NP_SO-102 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 3944.2 | RAU–PE–Xa | 16 | 179 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0233 | 0233 | no | HT_přívodní vodní (55 °C) 19
13043036 | 2.NP_SO-102 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 3944.2 | RAU–PE–Xa | 16 | 180 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0234 | 0234 | no | HT_přívodní vodní (55 °C) 19
13043049 | 2.NP_SO-102 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 3944.2 | RAU–PE–Xa | 16 | 170 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0235 | 0235 | no | HT_přívodní vodní (55 °C) 19
13043058 | 2.NP_SO-102 | 8700.56 | 0.000201032 | 0.437338 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 3944.2 | RAU–PE–Xa | 16 | 172 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0236 | 0236 | no | HT_přívodní vodní (55 °C) 19
13043066 | 2.NP_SO-102 | 484.062 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 3944.2 | RAU–PE–Xa | 16 | 172 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0237 | 0237 | no | HT_přívodní vodní (55 °C) 19
13043083 | 2.NP_SO-102 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 3944.2 | RAU–PE–Xa | 16 | 173 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0238 | 0238 | no | HT_přívodní vodní (55 °C) 19
13043907 | 2.NP_SO-102 | 846.204 | 0.000201032 | 0.0425348 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 3944.2 | RAU–PE–Xa | 16 | 165 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0244 | 0244 | no | HT_přívodní vodní (55 °C) 19
13043942 | 2.NP_SO-102 | 6660 | 0.000201032 | 0.334768 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 3944.2 | RAU–PE–Xa | 16 | 164 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0245 | 0245 | no | HT_přívodní vodní (55 °C) 19
13043951 | 2.NP_SO-102 | 136.734 | 0.000201032 | 0.00687298 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 3944.2 | RAU–PE–Xa | 16 | 162 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0246 | 0246 | no | HT_přívodní vodní (55 °C) 19
13044055 | 2.NP_SO-102 | 6573.41 | 0.000201032 | 0.330416 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 3944.2 | RAU–PE–Xa | 16 | 337 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0248 | 0248 | no | HT_přívodní vodní (55 °C) 19
13044151 | 2.NP_SO-102 | 5784.21 | 0.000201032 | 0.290746 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 3944.2 | RAU–PE–Xa | 16 | 171 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0249 | 0249 | no | HT_přívodní vodní (55 °C) 19
13044580 | 1.NP_SO-102 | 484.063 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 1 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0251 | 0251 | no | HT_přívodní vodní (55 °C) 19
13044589 | 1.NP_SO-102 | 4084.06 | 0.000201032 | 0.205287 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 533 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0252 | 0252 | no | HT_přívodní vodní (55 °C) 19
13044597 | 1.NP_SO-102 | 484.062 | 0.000201032 | 0.0243316 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 533 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0253 | 0253 | no | HT_přívodní vodní (55 °C) 19
13044616 | 1.NP_SO-102 | 477.712 | 0.000201032 | 0.0240124 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 3 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0254 | 0254 | no | HT_přívodní vodní (55 °C) 19
13044625 | 1.NP_SO-102 | 6816.52 | 0.000201032 | 0.342636 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 1 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0255 | 0255 | no | HT_přívodní vodní (55 °C) 19
13044662 | 2.NP_SO-102 | 7229.88 | 0.000201032 | 0.363413 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | 3944.2 | RAU–PE–Xa | 16 | 158 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0256 | 0256 | no | HT_přívodní vodní (55 °C) 19
13044888 | 1.NP_SO-102 | 6888.08 | 0.000201032 | 0.346233 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 359 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0259 | 0259 | no | HT_přívodní vodní (55 °C) 19
13044917 | 1.NP_SO-102 | 124.063 | 0.000201032 | 0.00623606 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 273 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0260 | 0260 | no | HT_přívodní vodní (55 °C) 19
13044934 | 1.NP_SO-102 | 137.713 | 0.000201032 | 0.00692219 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 160 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0261 | 0261 | no | HT_přívodní vodní (55 °C) 19
13044951 | 1.NP_SO-102 | 137.713 | 0.000201032 | 0.00692219 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 161 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0262 | 0262 | no | HT_přívodní vodní (55 °C) 19
13044991 | 1.NP_SO-102 | 7814.49 | 0.000201032 | 0.392799 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 271 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0263 | 0263 | no | HT_přívodní vodní (55 °C) 19
13045320 | 1.NP_SO-102 | 167.712 | 0.000201032 | 0.00843015 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 327 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0264 | 0264 | no | HT_přívodní vodní (55 °C) 19
13045536 | 1.NP_SO-102 | 400.413 | 0.000201032 | 0.020127 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 188 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0269 | 0269 | no | HT_přívodní vodní (55 °C) 19
13045572 | 1.NP_SO-102 | 5900 | 0.000201032 | 0.296566 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 262 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0270 | 0270 | no | HT_přívodní vodní (55 °C) 19
13045577 | 1.NP_SO-102 | 139.922 | 0.000201032 | 0.00703322 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -55.8 | RAU–PE–Xa | 16 | 186 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0271 | 0271 | no | HT_přívodní vodní (55 °C) 19
13045981 | -1.PP_SO-102 | 5813.94 | 0.000201032 | 0.29224 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4055.8 | RAU–PE–Xa | 16 | 197 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0273 | 0273 | no | HT_přívodní vodní (55 °C) 19
13046006 | -1.PP_SO-102 | 985.712 | 0.000201032 | 0.0495473 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4055.8 | RAU–PE–Xa | 16 | 197 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0275 | 0275 | no | HT_přívodní vodní (55 °C) 19
13046023 | -1.PP_SO-102 | 979.362 | 0.000201032 | 0.0492281 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4055.8 | RAU–PE–Xa | 16 | 198 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0276 | 0276 | no | HT_přívodní vodní (55 °C) 19
13046032 | -1.PP_SO-102 | 8673.9 | 0.000201032 | 0.435998 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4055.8 | RAU–PE–Xa | 16 | 196 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0277 | 0277 | no | HT_přívodní vodní (55 °C) 19
13046035 | -1.PP_SO-102 | 354.216 | 0.000201032 | 0.0178049 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4055.8 | RAU–PE–Xa | 16 | 200 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0278 | 0278 | no | HT_přívodní vodní (55 °C) 19
13046044 | -1.PP_SO-102 | 5824.84 | 0.000201032 | 0.292789 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4055.8 | RAU–PE–Xa | 16 | 200 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0279 | 0279 | no | HT_přívodní vodní (55 °C) 19
13046053 | -1.PP_SO-102 | 520.783 | 0.000201032 | 0.0261774 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4055.8 | RAU–PE–Xa | 16 | 316 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0280 | 0280 | no | HT_přívodní vodní (55 °C) 19
13046067 | -1.PP_SO-102 | 425.201 | 0.000201032 | 0.0213729 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4055.8 | RAU–PE–Xa | 16 | 306 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0281 | 0281 | no | HT_přívodní vodní (55 °C) 19
13046083 | -1.PP_SO-102 | 1141.03 | 0.000201032 | 0.0573542 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4055.8 | RAU–PE–Xa | 16 | 311 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0282 | 0282 | no | HT_přívodní vodní (55 °C) 19
13046095 | -1.PP_SO-102 | 2457.71 | 0.000201032 | 0.123538 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4055.8 | RAU–PE–Xa | 16 | 310 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0283 | 0283 | no | HT_přívodní vodní (55 °C) 19
13046129 | -1.PP_SO-102 | 413.915 | 0.000201032 | 0.0208056 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4065.8 | RAU–PE–Xa | 16 | 350 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0284 | 0284 | no | HT_přívodní vodní (55 °C) 19
13046146 | -1.PP_SO-102 | 284.063 | 0.000201032 | 0.0142785 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4065.8 | RAU–PE–Xa | 16 | 203 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0285 | 0285 | no | HT_přívodní vodní (55 °C) 19
13046155 | -1.PP_SO-102 | 3819.75 | 0.000201032 | 0.192001 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4065.8 | RAU–PE–Xa | 16 | 203 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0286 | 0286 | no | HT_přívodní vodní (55 °C) 19
13046164 | -1.PP_SO-102 | 4562.55 | 0.000201032 | 0.229339 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4065.8 | RAU–PE–Xa | 16 | 201 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0287 | 0287 | no | HT_přívodní vodní (55 °C) 19
13046169 | -1.PP_SO-102 | 277.712 | 0.000201032 | 0.0139594 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4065.8 | RAU–PE–Xa | 16 | 204 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0288 | 0288 | no | HT_přívodní vodní (55 °C) 19
13046178 | -1.PP_SO-102 | 217.933 | 0.000201032 | 0.0109545 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 2 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 19 | -4065.8 | RAU–PE–Xa | 16 | 202 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0289 | 0289 | no | HT_přívodní vodní (55 °C) 19
13046326 | -1.PP_SO-102 | 384.063 | 0.000201032 | 0.0193051 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -4055.8 | RAU–PE–Xa | 16 | 395 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0294 | 0294 | no | HT_přívodní vodní (55 °C) 9
13046337 | -1.PP_SO-102 | 5626.33 | 0.000201032 | 0.28281 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -4055.8 | RAU–PE–Xa | 16 | 389 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0295 | 0295 | no | HT_přívodní vodní (55 °C) 9
13046584 | -1.PP_SO-102 | 6936.13 | 0.000201032 | 0.348648 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -4055.8 | RAU–PE–Xa | 16 | 389 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0296 | 0296 | no | HT_přívodní vodní (55 °C) 9
13047116 | 1.NP_SO-102 | 3258.35 | 0.000201032 | 0.163783 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -55.8 | RAU–PE–Xa | 16 | 23 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0297 | 0297 | no | HT_přívodní vodní (55 °C) 9
13047123 | 1.NP_SO-102 | 2341.07 | 0.000201032 | 0.117675 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -55.8 | RAU–PE–Xa | 16 | 23 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0298 | 0298 | no | HT_přívodní vodní (55 °C) 9
13047423 | 3.NP_SO-102 | 4359.89 | 0.000201032 | 0.219152 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 7944.2 | RAU–PE–Xa | 16 | 535 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0300 | 0300 | no | HT_přívodní vodní (55 °C) 9
13047895 | 3.NP_SO-102 | 5071.25 | 0.000201032 | 0.254909 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 7944.2 | RAU–PE–Xa | 16 | 532 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0302 | 0302 | no | HT_přívodní vodní (55 °C) 9
13047904 | 3.NP_SO-102 | 3999.09 | 0.000201032 | 0.201016 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 7944.2 | RAU–PE–Xa | 16 | 532 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0303 | 0303 | no | HT_přívodní vodní (55 °C) 9
13047928 | 3.NP_SO-102 | 1773.28 | 0.000201032 | 0.0891347 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 7944.2 | RAU–PE–Xa | 16 | 532 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0304 | 0304 | no | HT_přívodní vodní (55 °C) 9
13048020 | 3.NP_SO-102 | 15347.3 | 0.000201032 | 0.771437 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 7944.2 | RAU–PE–Xa | 16 | 535 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0305 | 0305 | no | HT_přívodní vodní (55 °C) 9
13048027 | 3.NP_SO-102 | 3441.2 | 0.000201032 | 0.172974 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 7944.2 | RAU–PE–Xa | 16 | 32 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0306 | 0306 | no | HT_přívodní vodní (55 °C) 9
13048089 | 4.NP_SO-102 | 5260.02 | 0.000201032 | 0.264397 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 11944.2 | RAU–PE–Xa | 16 | 34 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0307 | 0307 | no | HT_přívodní vodní (55 °C) 9
13048101 | 3.NP_SO-102 | 977.888 | 0.000201032 | 0.049154 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 7944.2 | RAU–PE–Xa | 16 | 540 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0309 | 0309 | no | HT_přívodní vodní (55 °C) 9
13048165 | 4.NP_SO-102 | 925.125 | 0.000201032 | 0.0465019 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 11944.2 | RAU–PE–Xa | 16 | 34 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0310 | 0310 | no | HT_přívodní vodní (55 °C) 9
13080088 | -1.PP_SO-102 | 234.062 | 0.000201032 | 0.0117653 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -4065.8 | RAU–PE–Xa | 16 | 496 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0396 | 0396 | no | HT_vratné vodní (45 °C) 1
13080099 | -1.PP_SO-102 | 5681.19 | 0.000201032 | 0.285568 | ø16 mm | 0.000862069 | 0 | -1.PP_SO-102 | -52 | -60 | -60 | -68 | Fáze 1 | HT_vratné vodní (45 °C) | 0.01 | Zpětné vedení teplé vody | RAU–PE–Xa | HT_vratné vodní (45 °C) 1 | -4065.8 | RAU–PE–Xa | 16 | 541 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0397 | 0397 | no | HT_vratné vodní (45 °C) 1
