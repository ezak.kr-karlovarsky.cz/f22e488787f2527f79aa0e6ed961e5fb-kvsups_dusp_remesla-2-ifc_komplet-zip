Properties of the parts of a building model (IFC4), part 39 of 72

# IfcDistributionPort (10261)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_13180620_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13395530_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13181903_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13311935_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13182012_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 29
OutPort_13181922_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 29
InPort_13181922_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 29
OutPort_13182014_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 29
InPort_13181944_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 23
OutPort_13311941_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 23
Port_13182227_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13183053_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13182227_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13182319_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13182312_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13182319_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13182319_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13182320_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13182434_3 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13182332_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13182332_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
OutPort_13183088_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13182405_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13182434_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13182434_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13182435_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13183088_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
OutPort_13182810_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
InPort_13182810_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
OutPort_13183593_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13182846_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13183053_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13182846_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13183543_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13182951_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13183598_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
InPort_13183593_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
OutPort_13183093_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
InPort_13183093_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
OutPort_13183597_3 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13183442_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13183543_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13183442_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13183547_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13183492_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13183548_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13183540_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13183547_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13183540_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13183668_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13183547_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13183548_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13183590_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13183597_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13183590_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13342083_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13183597_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13183598_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 1
Port_13183660_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13183668_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13183660_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13185738_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13405251_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13186833_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13368495_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13186833_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13449416_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13187118_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13427722_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13187118_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13427727_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13187184_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13304853_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13187184_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13187743_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13187295_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13427683_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13187295_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13427687_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13187424_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13418108_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13187424_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13449376_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13187710_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13187712_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13187710_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13188460_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13187712_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13304928_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13187741_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13187743_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13187741_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13188851_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13187812_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13188683_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13187812_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13188460_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13187946_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13188849_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13187946_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13188851_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13188258_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13188683_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13188258_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13189033_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13188268_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13189035_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13188268_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13189390_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13188517_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13188849_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13188517_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13188987_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13188585_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13188989_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13188585_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13189415_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13188985_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13188987_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13188985_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13188989_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13189031_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13189033_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13189031_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13189035_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13189256_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13189258_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13189256_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13189272_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13189258_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13222731_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13189311_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13189313_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13189311_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13189327_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13189313_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13391415_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13189327_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13404527_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13189390_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13223114_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13189407_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13189415_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13189407_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13223795_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13189717_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13405254_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13189717_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13446102_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
InPort_13199416_1 | SINK | DUCT
OutPort_13199416_2 | SOURCE | DUCT
InPort_13199416_3 | SINK | PIPE
OutPort_13199416_4 | SOURCE | PIPE
InPort_13199417_1 | SINK | DUCT
OutPort_13199417_2 | SOURCE | DUCT
InPort_13199417_3 | SINK | PIPE
OutPort_13199417_4 | SOURCE | PIPE
InPort_13199418_1 | SINK | DUCT
OutPort_13199418_2 | SOURCE | DUCT
InPort_13199418_3 | SINK | PIPE
OutPort_13199418_4 | SOURCE | PIPE
InPort_13199420_1 | SINK | DUCT
OutPort_13199420_2 | SOURCE | DUCT
InPort_13199420_3 | SINK | PIPE
OutPort_13199420_4 | SOURCE | PIPE
InPort_13313688_1 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
OutPort_13200217_1 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
InPort_13200217_2 | SINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
OutPort_13281019_0 | SOURCE | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
InPort_13200217_3 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13314044_1 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13200217_7 | SINK | PIPE | HEATING
InPort_13313690_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
OutPort_13200218_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 2
InPort_13200218_2 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13250099_0 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13200218_3 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13314046_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13200218_7 | SINK | PIPE | HEATING
Port_13202937_0 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní chladivový 1
Port_13202937_1 | SOURCEANDSINK | PIPE | HEATING | HT/CL_přívodní chladivový 1
Port_13202955_0 | SOURCEANDSINK | PIPE | HEATING | HT/CL_vratné chladivový 1
Port_13202955_1 | SOURCEANDSINK | PIPE | HEATING | HT/CL_vratné chladivový 1
InPort_13208205_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13204069_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13204069_2 | SOURCE | PIPE | HEATING
OutPort_13204069_3 | SOURCE | PIPE | HEATING
InPort_13206704_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
OutPort_13204069_4 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
InPort_13204069_7 | SINK | PIPE | HEATING
OutPort_13206068_1 | SOURCE | PIPE | HEATING
OutPort_13206068_2 | SOURCE | PIPE | HEATING
OutPort_13206068_3 | SOURCE | PIPE | HEATING
OutPort_13206068_4 | SOURCE | PIPE | HEATING
InPort_13206068_7 | SINK | PIPE | HEATING
Port_13206450_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (75 °C) 1
Port_13208751_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (75 °C) 1
Port_13206450_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (75 °C) 1
Port_13206524_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (65 °C) 1
Port_13208971_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (65 °C) 1
Port_13206524_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (65 °C) 1
InPort_13206680_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
OutPort_13206710_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
InPort_13206691_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
OutPort_13206706_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
InPort_13206710_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
OutPort_13206691_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
InPort_13206708_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
OutPort_13206704_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
InPort_13206706_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
OutPort_13206708_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 32
Port_13206719_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13206770_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13206762_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13206770_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13206762_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13207380_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13206815_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13207382_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13206815_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13206883_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13208344_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13206883_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13206894_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13206894_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13208292_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13206905_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13206905_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13208259_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13207380_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13207382_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 8
Port_13207391_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13207408_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13207402_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13207408_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13207402_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13208342_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13207928_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13207928_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13208000_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13207939_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13207939_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13208036_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13207950_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 40
Port_13207950_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 40
Port_13207981_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13208002_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13207990_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13207998_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13207990_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13208002_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13207998_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13208000_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 36
Port_13208015_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13208038_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13208026_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13208034_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13208026_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13208038_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13208034_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13208036_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 31
Port_13208051_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13208288_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13208075_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13208288_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13208075_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13208290_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13208114_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13369729_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13208114_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13208259_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
InPort_13369708_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13208162_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13208162_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13208392_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13208392_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13208205_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
Port_13208290_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13208292_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 6
Port_13208342_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13208344_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 4
Port_13208461_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (75 °C) 1
Port_13208476_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (75 °C) 1
Port_13208461_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (75 °C) 1
Port_13208470_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (75 °C) 1
Port_13208751_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (75 °C) 1
Port_13208470_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (75 °C) 1
Port_13208476_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (75 °C) 1
Port_13208491_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (65 °C) 1
Port_13208506_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (65 °C) 1
Port_13208491_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (65 °C) 1
Port_13208500_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (65 °C) 1
Port_13208502_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (65 °C) 1
Port_13208500_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (65 °C) 1
Port_13208506_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (65 °C) 1
Port_13208502_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (65 °C) 1
Port_13208972_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (65 °C) 1
Port_13208854_1 | SOURCEANDSINK | PIPE | HEATING
Port_13208963_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (65 °C) 1
Port_13208971_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (65 °C) 1
Port_13208963_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (65 °C) 1
Port_13208971_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (65 °C) 1
Port_13208972_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (65 °C) 1
InPort_13210386_1 | SINK | DUCT
OutPort_13210386_2 | SOURCE | DUCT
InPort_13210386_3 | SINK | PIPE
OutPort_13210386_4 | SOURCE | PIPE
InPort_13210450_1 | SINK | DUCT
OutPort_13210450_2 | SOURCE | DUCT
InPort_13210450_3 | SINK | PIPE
OutPort_13210450_4 | SOURCE | PIPE
Port_13213579_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13213595_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13213579_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13336884_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13213589_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13213595_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13213589_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13214388_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13313812_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13214388_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13313852_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13214388_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13313854_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13214389_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13313852_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13214417_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13313856_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13214417_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13313814_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13214417_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13313858_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13214418_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13313814_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13214598_1 | SOURCE | PIPE | DOMESTICHOTWATER
InPort_13214598_2 | SINK | PIPE | HEATING
InPort_13214598_3 | SINK | PIPE | DOMESTICHOTWATER
OutPort_13214598_4 | SOURCE | PIPE | HEATING
InPort_13214598_5 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_13214600_1 | SOURCE | PIPE | DOMESTICHOTWATER
InPort_13214600_2 | SINK | PIPE | HEATING
InPort_13214600_3 | SINK | PIPE | DOMESTICHOTWATER
OutPort_13214600_4 | SOURCE | PIPE | HEATING
InPort_13214600_5 | SINK | PIPE | DOMESTICCOLDWATER
OutPort_13214601_1 | SOURCE | PIPE | DOMESTICHOTWATER
InPort_13214601_2 | SINK | PIPE | HEATING
InPort_13214601_3 | SINK | PIPE | DOMESTICHOTWATER
OutPort_13214601_4 | SOURCE | PIPE | HEATING
InPort_13214601_5 | SINK | PIPE | DOMESTICCOLDWATER
Port_13214743_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409165_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13214743_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409184_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13215155_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13215172_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13215155_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13215176_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13215166_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13290650_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13215166_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13215172_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13215176_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13409352_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13215185_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13215202_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13215185_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13215206_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13215196_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13290672_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13215196_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13215202_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13215206_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13409324_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13215986_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13217196_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13215986_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13226214_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13216023_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13216959_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13216023_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13226191_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13216170_0 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 10
OutPort_13409986_2 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 10
InPort_13217024_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 10
OutPort_13216170_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 10
InPort_13216180_0 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 10
OutPort_13283749_2 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 10
InPort_13283753_2 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 10
OutPort_13216180_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 10
InPort_13409984_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 2
OutPort_13216217_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 2
InPort_13216217_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 2
OutPort_13216928_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 2
InPort_13283967_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 2
OutPort_13216226_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 2
InPort_13216226_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 2
OutPort_13283971_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 2
InPort_13216286_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
OutPort_13216261_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
InPort_13216261_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
OutPort_13246705_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
InPort_13216278_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
OutPort_13216284_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
InPort_13216282_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
OutPort_13216279_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
InPort_13216279_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
OutPort_13216286_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
InPort_13216284_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
OutPort_13216282_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
InPort_13216314_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
OutPort_13216308_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
InPort_13216309_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
OutPort_13216312_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
InPort_13246707_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
OutPort_13216309_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
InPort_13216312_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
OutPort_13216314_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 1
InPort_13216367_0 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
OutPort_13436248_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 7
InPort_13227971_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
OutPort_13216367_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13216503_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13216512_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13216503_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13216606_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13216512_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13216514_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13216606_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13216514_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227700_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
InPort_13216928_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 2
OutPort_13216926_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 2
InPort_13216926_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 2
OutPort_13283967_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 2
Port_13216959_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13216960_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13216976_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13226191_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13216976_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13226193_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13217022_0 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 10
OutPort_13217024_2 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 10
InPort_13283749_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 10
OutPort_13217022_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 10
Port_13217054_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13217196_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13217196_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13217197_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13217213_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13226214_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13217213_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13226216_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13409938_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
OutPort_13217374_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
InPort_13217374_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
OutPort_13284007_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
InPort_13217383_0 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
OutPort_13409928_2 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 9
InPort_13283789_2 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
OutPort_13217383_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13217413_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13217648_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13217413_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13217456_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13217446_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13217456_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13217446_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13218040_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13217458_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13218040_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13217458_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13218042_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13217521_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13218032_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13217521_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13328226_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13217701_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13217752_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13217752_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13217768_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13217762_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13217768_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13217762_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13218308_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13217770_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13218308_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13217770_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13218310_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13218030_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13218032_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13218030_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13218042_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13218032_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13218033_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13218033_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13222685_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13218069_0 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
OutPort_13283825_2 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 26
InPort_13283829_2 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
OutPort_13218069_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 26
InPort_13284081_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13218078_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
InPort_13218078_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
OutPort_13284085_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 25
Port_13218198_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13218300_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13218198_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13218446_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13218298_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13218300_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13218298_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13218310_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13218300_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13218301_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13218301_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13328260_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13218354_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13218446_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13218354_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13226279_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13218558_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13437003_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13218558_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13218711_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13218579_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13218579_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13218723_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13437003_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13218707_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13218707_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13218711_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13218723_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13243662_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13243678_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13218772_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13218772_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13243422_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13243405_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13218782_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
Port_13218954_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13219205_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13218954_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13219284_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13219098_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13219205_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13219098_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13222652_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13219111_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13222652_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13219111_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13222656_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13219113_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13222685_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13219113_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13226313_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13219153_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13243649_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13219153_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13243334_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13219163_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13243310_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13219274_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13219284_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13219274_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13219439_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 5
Port_13219721_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 5
Port_13219439_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 5
Port_13219725_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 5
Port_13219447_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 5
Port_13219546_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 5
Port_13219447_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 5
Port_13219544_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 5
Port_13219546_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 5
Port_13219544_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 5
Port_13219721_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 5
Port_13219709_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 5
Port_13219715_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 5
Port_13219710_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 5
Port_13219713_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 5
Port_13219710_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 5
Port_13219725_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 5
Port_13219713_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 5
Port_13219715_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (45 °C) 5
InPort_13219822_0 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 5
InPort_13220013_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 5
OutPort_13219822_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 5
InPort_13220009_2 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 5
OutPort_13219950_0 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 5
InPort_13219950_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 5
OutPort_13220013_2 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 5
InPort_13219962_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 5
OutPort_13219968_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 5
InPort_13219966_2 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 5
OutPort_13219963_0 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 5
InPort_13219963_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 5
OutPort_13220009_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 5
InPort_13219968_2 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 5
OutPort_13219966_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 5
Port_13220548_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13406655_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13220548_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13406657_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13220580_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13406471_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13220580_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13220596_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13220596_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13406736_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 3
Port_13220924_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13300778_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13220924_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13220942_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13220942_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13406800_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13221661_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 13
Port_13222480_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 13
Port_13221661_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 13
InPort_13222546_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 26
OutPort_13221687_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 26
InPort_13221687_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 26
InPort_13221696_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 26
OutPort_13278412_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 26
InPort_13223031_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 26
OutPort_13221696_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 26
InPort_13221751_0 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 20
OutPort_13222513_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 20
OutPort_13221751_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 20
InPort_13278446_2 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 20
OutPort_13221773_0 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 20
InPort_13221773_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 20
OutPort_13223065_2 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 20
Port_13221796_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 21
Port_13222579_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 21
Port_13221796_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 21
InPort_13221805_0 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 21
OutPort_13278380_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 21
InPort_13223000_2 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 21
OutPort_13221805_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 21
Port_13222478_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 13
Port_13222480_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 13
Port_13222478_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 13
Port_13406595_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 13
InPort_13222513_2 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 20
OutPort_13222511_0 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 20
InPort_13222511_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 20
OutPort_13406576_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 20
InPort_13222544_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 26
OutPort_13222546_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 26
InPort_13405671_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 26
OutPort_13222544_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 26
Port_13222577_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 21
Port_13222579_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 21
Port_13222577_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 21
Port_13405694_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 21
Port_13222656_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13243631_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13222731_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13391140_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
InPort_13222919_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
OutPort_13222923_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 23
InPort_13222923_2 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
OutPort_13222921_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 23
InPort_13222921_2 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
OutPort_13391807_0 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 23
InPort_13222965_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
OutPort_13222969_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
InPort_13222969_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
OutPort_13222967_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
InPort_13222967_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
OutPort_13391848_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
InPort_13222992_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 21
OutPort_13223000_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 21
InPort_13223023_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 26
OutPort_13223031_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 26
InPort_13223065_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 20
OutPort_13223057_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 20
InPort_13223099_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 13
OutPort_13223091_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 13
InPort_13278478_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 13
OutPort_13223099_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 13
Port_13223114_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13223500_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13223349_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13391682_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13223349_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13390910_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13223484_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13223504_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13223484_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13223508_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13223498_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13223500_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13223498_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13223504_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13223508_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13391829_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13223687_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13391644_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13223687_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13390875_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13223784_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13223799_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13223784_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13223814_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13223793_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13223795_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13223793_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13223799_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13223814_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13391782_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
InPort_13226193_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13226188_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13226188_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13283933_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13226193_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13226339_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13226194_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13226339_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13226194_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13226289_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13226211_0 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
OutPort_13226216_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13283715_2 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
OutPort_13226211_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13226216_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13226341_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13226217_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13226341_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13226217_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13226323_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13226277_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13226279_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13226277_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13226289_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13226311_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13226313_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13226311_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13226323_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13409889_1 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13226857_0 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13226857_1 | SINK | PIPE | HEATING | HT/CL_přívodní vodní 1
OutPort_13284049_2 | SOURCE | PIPE | HEATING | HT/CL_přívodní vodní 1
InPort_13226875_0 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13283860_2 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13283865_2 | SINK | PIPE | HEATING | HT/CL_vratné vodní 1
OutPort_13226875_1 | SOURCE | PIPE | HEATING | HT/CL_vratné vodní 1
InPort_13227876_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
OutPort_13227602_0 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 7
InPort_13227602_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
OutPort_13227969_2 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227698_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227700_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227698_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227704_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227704_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227877_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227842_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227862_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227842_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227880_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227855_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227860_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227855_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227862_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227858_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227858_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227860_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227866_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227876_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227866_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227880_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227876_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13227877_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
InPort_13227969_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
OutPort_13227930_0 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 7
InPort_13227930_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
OutPort_13227971_2 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 7
InPort_13436248_2 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
OutPort_13227999_0 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 7
InPort_13227999_1 | SINK | PIPE | HEATING | HT_vratné vodní (45 °C) 7
OutPort_13436252_1 | SOURCE | PIPE | HEATING | HT_vratné vodní (45 °C) 7
Port_13229487_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 2
Port_13245892_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 2
Port_13229487_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 2
Port_13229496_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 2
Port_13245892_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 2
Port_13229496_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 2
Port_13229523_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 1
Port_13245868_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 1
Port_13229523_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 1
Port_13229532_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 1
Port_13245868_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 1
Port_13229532_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 1
Port_13229649_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 3
Port_13229899_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 3
Port_13229649_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 3
Port_13229656_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 3
Port_13229897_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 3
Port_13229656_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 3
Port_13229682_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13250949_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13229682_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13229691_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13229975_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13229691_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
Port_13229895_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 3
Port_13229897_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 3
Port_13229895_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 3
Port_13229899_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 3
Port_13229973_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 3
