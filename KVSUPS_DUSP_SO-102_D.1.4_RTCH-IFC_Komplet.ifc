Properties of the parts of a building model (IFC4), part 47 of 72

# IfcPipeFitting: M_Koleno, obecné:Standardní (1543)
Name (M_Koleno, obecné:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm) | Group
13140747 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2800 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0717 | 0717 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13140755 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0718 | 0718 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13140757 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0719 | 0719 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13140784 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0720 | 0720 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13140794 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2850 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0721 | 0721 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13140951 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2800 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0722 | 0722 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13141070 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2800 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0724 | 0724 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13141074 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2800 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0725 | 0725 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13141432 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2800 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0727 | 0727 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13141440 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0728 | 0728 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13141442 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0729 | 0729 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13141477 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2800 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0730 | 0730 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13141485 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0731 | 0731 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13141487 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0732 | 0732 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13141993 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 15 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0733 | 0733 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 15
13142004 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 18 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0734 | 0734 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 18 | Mechanické – tok - Tlaková ztráta: 0 Pa
13142012 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 18 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0735 | 0735 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 18 | Mechanické – tok - Tlaková ztráta: 0 Pa
13142124 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0736 | 0736 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13142145 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0737 | 0737 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13142147 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0738 | 0738 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13142238 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 18 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0740 | 0740 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 18 | Mechanické – tok - Tlaková ztráta: 0 Pa
13142246 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 18 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0741 | 0741 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 18 | Mechanické – tok - Tlaková ztráta: 0 Pa
13142250 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 18 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0742 | 0742 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 18 | Mechanické – tok - Tlaková ztráta: 0 Pa
13142365 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0744 | 0744 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13142373 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0745 | 0745 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13142377 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0746 | 0746 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13142902 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2900 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 20 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0747 | 0747 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 20 | Mechanické – tok - Tlaková ztráta: 0 Pa
13142910 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2900 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 20 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0748 | 0748 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 20 | Mechanické – tok - Tlaková ztráta: 0 Pa
13143080 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2900 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0749 | 0749 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13143082 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2900 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0750 | 0750 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13143315 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 15 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0751 | 0751 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 15 | Mechanické – tok - Tlaková ztráta: 0 Pa
13143323 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2900 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 20 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0752 | 0752 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 20 | Mechanické – tok - Tlaková ztráta: 0 Pa
13143325 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2900 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 20 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0753 | 0753 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 20 | Mechanické – tok - Tlaková ztráta: 0 Pa
13143348 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0754 | 0754 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13143356 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2900 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0755 | 0755 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13143358 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2900 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0756 | 0756 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13143436 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 15 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0757 | 0757 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 15
13143472 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0758 | 0758 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13143474 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0759 | 0759 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13143688 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2900 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 20 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0760 | 0760 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 20 | Mechanické – tok - Tlaková ztráta: 0 Pa
13143696 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 20 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0761 | 0761 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 20 | Mechanické – tok - Tlaková ztráta: 0 Pa
13143700 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 20 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0762 | 0762 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 20 | Mechanické – tok - Tlaková ztráta: 0 Pa
13143831 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2900 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0763 | 0763 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13143839 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0764 | 0764 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13143841 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0765 | 0765 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13144419 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0769 | 0769 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13144504 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0771 | 0771 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13144648 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0772 | 0772 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13144656 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2900 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0773 | 0773 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13144658 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2900 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0774 | 0774 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13144685 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0775 | 0775 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13144695 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2900 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0776 | 0776 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13144768 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2900 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0777 | 0777 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13144772 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2900 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0778 | 0778 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13144986 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 3300 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0780 | 0780 | yes | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 13
13145140 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0782 | 0782 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13145272 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2900 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0783 | 0783 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13145463 | 4.NP_SO-102 | 0 | ø22 mm-ø22 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 11 | 22 | 0.0000148067 | 18.9375 | 90 | ø22-ø22 | 10.07 | 25.175 | TT01.01.0784 | 0784 | no | 18.9375 | 12.5875 | HT_přívodní vodní (55 °C) 19
13145471 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2900 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0785 | 0785 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13145473 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2900 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0786 | 0786 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 19
13145498 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0788 | 0788 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 13
13145548 | 4.NP_SO-102 | 0 | ø22 mm-ø22 mm | HD | 4.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 11 | 22 | 0.0000148067 | 18.9375 | 90 | ø22-ø22 | 10.07 | 25.175 | TT01.01.0789 | 0789 | no | 18.9375 | 12.5875 | HT_vratné vodní (45 °C) 13
13145556 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2900 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0790 | 0790 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13145558 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2900 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0791 | 0791 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 13
13146741 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2920 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0792 | 0792 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13146775 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 5 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0793 | 0793 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 10; HT_přívodní vodní (55 °C) 5
13146777 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 33 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0794 | 0794 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 5; HT_přívodní vodní (65 °C) 33 | Mechanické – tok - Tlaková ztráta: 0 Pa
13146857 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 34 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0795 | 0795 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 34
13146874 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0796 | 0796 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13147410 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2920 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0797 | 0797 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13147646 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 34 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0798 | 0798 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 34
13147721 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0800 | 0800 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13147740 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2920 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0801 | 0801 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13147945 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 28 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0804 | 0804 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 28
13147949 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 23 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0805 | 0805 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 23 | Mechanické – tok - Tlaková ztráta: 0 Pa
13148014 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 23 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0806 | 0806 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 23 | Mechanické – tok - Tlaková ztráta: 0 Pa
13148024 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 23 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0807 | 0807 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 23 | Mechanické – tok - Tlaková ztráta: 0 Pa
13148032 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 23 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0808 | 0808 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 23 | Mechanické – tok - Tlaková ztráta: 0 Pa
13148093 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 23 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0809 | 0809 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 23 | Mechanické – tok - Tlaková ztráta: 0 Pa
13148097 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 23 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0810 | 0810 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 23 | Mechanické – tok - Tlaková ztráta: 0 Pa
13148239 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0811 | 0811 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13148241 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0812 | 0812 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13148338 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0813 | 0813 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13148469 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0815 | 0815 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13148481 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0816 | 0816 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13148790 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0818 | 0818 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 2
13148830 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0820 | 0820 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 2; HT_přívodní vodní (55 °C) 23 | Mechanické – tok - Tlaková ztráta: 0 Pa
13149034 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 3270 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 18 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0821 | 0821 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 18 | Mechanické – tok - Tlaková ztráta: 0 Pa
13149256 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 25 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0823 | 0823 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 25; HT_přívodní vodní (55 °C) 24 | Mechanické – tok - Tlaková ztráta: 0 Pa
13149258 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 24 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0824 | 0824 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 24 | Mechanické – tok - Tlaková ztráta: 0 Pa
13149281 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 25 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0825 | 0825 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 25
13149366 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 3270 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0828 | 0828 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13149374 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0829 | 0829 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13149376 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0830 | 0830 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13149397 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0831 | 0831 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13149576 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 3270 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0833 | 0833 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13149702 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 3270 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0834 | 0834 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13149714 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0835 | 0835 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13149756 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 3270 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 18 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0836 | 0836 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 18 | Mechanické – tok - Tlaková ztráta: 0 Pa
13149766 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 18 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0837 | 0837 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 18 | Mechanické – tok - Tlaková ztráta: 0 Pa
13149864 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 10 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0838 | 0838 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (65 °C) 10
13149894 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 6 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0839 | 0839 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 6 | Mechanické – tok - Tlaková ztráta: 0 Pa
13150111 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 18 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0841 | 0841 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 18
13150179 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0842 | 0842 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13150181 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 3.NP_SO-102 | 3950 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0843 | 0843 | no | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13150202 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 18 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0844 | 0844 | no | 14.2875 | 7.9375 | HT_vratné vodní (45 °C) 18
13159568 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 31 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0845 | 0845 | yes | 33.3375 | 26.9875 | HT_přívodní vodní (65 °C) 31
13159705 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 31 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0846 | 0846 | yes | 33.3375 | 26.9875 | HT_přívodní vodní (65 °C) 31
13159709 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 31 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0847 | 0847 | yes | 33.3375 | 26.9875 | HT_přívodní vodní (65 °C) 31
13159736 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 31 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0848 | 0848 | yes | 33.3375 | 26.9875 | HT_přívodní vodní (65 °C) 31
13160590 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 6 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0849 | 0849 | yes | 33.3375 | 26.9875 | HT_vratné vodní (45 °C) 6
13160630 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 36 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0850 | 0850 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 36
13160657 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 36 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0851 | 0851 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 36
13160661 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 36 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0852 | 0852 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 36
13160691 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 6 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0853 | 0853 | yes | 33.3375 | 26.9875 | HT_vratné vodní (45 °C) 6
13160695 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 6 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0854 | 0854 | yes | 33.3375 | 26.9875 | HT_vratné vodní (45 °C) 6
13160760 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 4 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0855 | 0855 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 4
13160762 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 4 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0856 | 0856 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 4
13160798 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 32 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0857 | 0857 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (65 °C) 32 | Mechanické – tok - Tlaková ztráta: 0 Pa
13160823 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 32 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0858 | 0858 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (65 °C) 32 | Mechanické – tok - Tlaková ztráta: 0 Pa
13160827 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 32 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0859 | 0859 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (65 °C) 32 | Mechanické – tok - Tlaková ztráta: 0 Pa
13160892 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 8 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0860 | 0860 | yes | 26.9875 | 20.6375 | HT_vratné vodní (45 °C) 8
13160911 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 6 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0861 | 0861 | yes | 33.3375 | 26.9875 | HT_vratné vodní (45 °C) 6
13160951 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 4 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0862 | 0862 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 4
13160955 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 4 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0863 | 0863 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 4
13160970 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 32 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0864 | 0864 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (65 °C) 32 | Mechanické – tok - Tlaková ztráta: 0 Pa
13161979 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 36 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0865 | 0865 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 36
13171872 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0866 | 0866 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 1
13172185 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0867 | 0867 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 1
13172492 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0869 | 0869 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 2
13172925 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0875 | 0875 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 2
13172961 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0876 | 0876 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 1
13172997 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0877 | 0877 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 2
13173041 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0878 | 0878 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 1
13174251 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HC | 1.NP_SO-102 | 2900 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0881 | 0881 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 1
13174261 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HC | 1.NP_SO-102 | 2900 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0882 | 0882 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 1
13174308 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HC | 1.NP_SO-102 | 2900 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0884 | 0884 | yes | 17.4625 | 11.1125 | CL_přívodní vodní (10 °C) 1
13174666 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HC | 1.NP_SO-102 | 2900 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0885 | 0885 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 2
13174728 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HC | 1.NP_SO-102 | 2900 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0887 | 0887 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 2
13174742 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HC | 1.NP_SO-102 | 2900 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0888 | 0888 | yes | 17.4625 | 11.1125 | CL_vratné vodní (15 °C) 2
13178030 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0891 | 0891 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 2
13178049 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0892 | 0892 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 1
13178101 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0893 | 0893 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 2
13178103 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0894 | 0894 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 1
13178374 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0895 | 0895 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 1
13178376 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0896 | 0896 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 2
13178378 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0897 | 0897 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 2
13178380 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0898 | 0898 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 1
13178858 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0899 | 0899 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 2
13178860 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0900 | 0900 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 1
13178862 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0901 | 0901 | yes | 14.2875 | 7.9375 | CL_vratné vodní (15 °C) 2
13178864 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0902 | 0902 | yes | 14.2875 | 7.9375 | CL_přívodní vodní (10 °C) 1
13180455 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 2700 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0903 | 0903 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13180575 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 2700 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0904 | 0904 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13180585 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0905 | 0905 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13180610 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 2700 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0906 | 0906 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13180620 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 3100 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0907 | 0907 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13181886 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0908 | 0908 | yes | 17.4625 | 11.1125 | HT_vratné vodní (45 °C) 1
13181903 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0909 | 0909 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13181907 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0910 | 0910 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13181919 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 29 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0911 | 0911 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 29; HT_přívodní vodní (55 °C) 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
13181944 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 23 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0912 | 0912 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 23; HT_přívodní vodní (55 °C) 16 | Mechanické – tok - Tlaková ztráta: 0 Pa
13181948 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 23 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0913 | 0913 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 23; HT_přívodní vodní (55 °C) 16
13182008 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0914 | 0914 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13182010 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0915 | 0915 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13182012 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 29 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0916 | 0916 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 29 | Mechanické – tok - Tlaková ztráta: 0 Pa
13182014 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 29 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0917 | 0917 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 29 | Mechanické – tok - Tlaková ztráta: 0 Pa
13182951 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0920 | 0920 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 1
13183053 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0921 | 0921 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13183088 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0922 | 0922 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13183492 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0923 | 0923 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13183543 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | 3940 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0924 | 0924 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13183593 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | 3950 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0926 | 0926 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 1 | Mechanické – tok - Tlaková ztráta: 0 Pa
13183668 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0928 | 0928 | no | 15.9375 | 9.5875 | HT_vratné vodní (45 °C) 1
13185620 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 2700 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0929 | 0929 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13185738 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3250 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 32.5 | 65 | 0.000217659 | 39.6875 | 90 | ø65-ø65 | 26.67 | 66.675 | TT01.01.0930 | 0930 | yes | 39.6875 | 33.3375 | HT_PRIMÁR_vratné 7
13185740 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 2700 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0931 | 0931 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 7 | Izolace - Typ izolace: Tepelná
13187712 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 3300 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0932 | 0932 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13187743 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 3300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0933 | 0933 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13188460 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 2.NP_SO-102 | 2080 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0934 | 0934 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13188683 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 2.NP_SO-102 | 2080 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0935 | 0935 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13188849 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 2.NP_SO-102 | 2080 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0936 | 0936 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13188851 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 2.NP_SO-102 | 2080 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0937 | 0937 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13188987 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 2.NP_SO-102 | 2080 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0938 | 0938 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13188989 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 2.NP_SO-102 | 2200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0939 | 0939 | yes | 23.8125 | 17.4625 | HT_vratné vodní (45 °C) 23
13189033 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 2.NP_SO-102 | 2080 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0940 | 0940 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13189035 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm | HD | 2.NP_SO-102 | 2200 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0941 | 0941 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 8
13189258 | 2.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 2.NP_SO-102 | 1900 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0942 | 0942 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
13189272 | 2.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 2.NP_SO-102 | 2230 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0943 | 0943 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná
13189313 | 2.NP_SO-102 | 60 | ø200 mm-ø200 mm | HD | 2.NP_SO-102 | 1900 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0944 | 0944 | yes | 46.0375 | 39.6875 | HT_PRIMÁR_vratné 5 | Izolace - Typ izolace: Tepelná
