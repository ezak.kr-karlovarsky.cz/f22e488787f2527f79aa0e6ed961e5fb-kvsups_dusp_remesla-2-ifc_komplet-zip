Properties of the parts of a building model (IFC4), part 56 of 72

# IfcPipeFitting: M_Spoj T, obecný:Standardní (358)
Name (M_Spoj T, obecný:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Úhel (deg) | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) = Štítek, od středu ke konci (mm) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Úhel tvarovky 1 (sdílený) (deg) = Úhel 1 (deg) | Vnější poloměr tvarovky (mm) | Group
13082890 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0250 | 0250 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13083245 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.0253 | 0253 | yes | 90 | 7.9375 | HT_vratné vodní (45 °C) 1
13083327 | 2.NP_SO-102 | 60 | ø200 mm-ø200 mm-ø200 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.0255 | 0255 | yes | 90 | 39.6875 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13083579 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.0260 | 0260 | yes | 90 | 11.1125 | HT_vratné vodní (45 °C) 1
13083617 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3250 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.0262 | 0262 | yes | 90 | 11.1125 | HT_vratné vodní (45 °C) 1
13084173 | 2.NP_SO-102 | 40 | ø120 mm-ø120 mm-ø120 mm | HD | 2.NP_SO-102 | 3160 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0267 | 0267 | yes | 90 | 20.6375 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13084185 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3160 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.0268 | 0268 | yes | 90 | 11.1125 | HT_vratné vodní (45 °C) 1
13084305 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3258.78 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90.1664 | 10 | 20 | 0.0000240537 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.0269 | 0269 | yes | 89.8336 | 11.1125 | HT_přívodní vodní (55 °C) 9
13085286 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0272 | 0272 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13085870 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0274 | 0274 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13085883 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0275 | 0275 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13085964 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0278 | 0278 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13086316 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0281 | 0281 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13086354 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0282 | 0282 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13086816 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 21 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0284 | 0284 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 21
13086857 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0285 | 0285 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13087921 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0294 | 0294 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13088483 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm-ø40 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0296 | 0296 | yes | 90 | 20.6375 | HT_vratné vodní (45 °C) 1
13089313 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 22 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0308 | 0308 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 22
13089603 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0310 | 0310 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13090544 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HD | 3.NP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.0312 | 0312 | yes | 90 | 7.9375 | HT_vratné vodní (45 °C) 1
13090661 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HD | 3.NP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 18 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.0316 | 0316 | no | 90 | 7.9375 | HT_vratné vodní (45 °C) 18
13091088 | 3.NP_SO-102 | 40 | ø120 mm-ø120 mm-ø120 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0322 | 0322 | yes | 90 | 20.6375 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13092672 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0324 | 0324 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13092676 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0325 | 0325 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13093029 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0327 | 0327 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13093048 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0328 | 0328 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13093445 | 3.NP_SO-102 | 40 | ø120 mm-ø120 mm-ø120 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0329 | 0329 | yes | 90 | 20.6375 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13093530 | 3.NP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | 3.NP_SO-102 | 3350 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.0330 | 0330 | yes | 90 | 17.4625 | HT_přívodní vodní (55 °C) 9
13093663 | 3.NP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.0331 | 0331 | yes | 90 | 17.4625 | HT_vratné vodní (45 °C) 1
13093824 | 3.NP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.0333 | 0333 | yes | 90 | 17.4625 | HT_vratné vodní (45 °C) 1
13094045 | 3.NP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 15 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.0335 | 0335 | yes | 90 | 17.4625 | HT_přívodní vodní (65 °C) 15
13094171 | 1.NP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | 1.NP_SO-102 | 3360 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.0337 | 0337 | yes | 90 | 17.4625 | HT_přívodní vodní (55 °C) 9
13094950 | 1.NP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | 1.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.0341 | 0341 | yes | 90 | 17.4625 | HT_přívodní vodní (55 °C) 9
13095394 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0342 | 0342 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13096406 | 4.NP_SO-102 | 0 | ø40 mm-ø40 mm-ø40 mm | HD | 4.NP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 10 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0346 | 0346 | yes | 90 | 20.6375 | HT_přívodní vodní (55 °C) 9; HT_přívodní vodní (65 °C) 10
13096445 | 3.NP_SO-102 | 40 | ø120 mm-ø120 mm-ø120 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0348 | 0348 | yes | 90 | 20.6375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13096802 | 3.NP_SO-102 | 40 | ø120 mm-ø120 mm-ø120 mm | HD | 3.NP_SO-102 | 3150 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0352 | 0352 | yes | 90 | 20.6375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13096845 | 3.NP_SO-102 | 40 | ø120 mm-ø120 mm-ø120 mm | HD | 3.NP_SO-102 | 3150 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0355 | 0355 | yes | 90 | 20.6375 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13097412 | 4.NP_SO-102 | 0 | ø40 mm-ø40 mm-ø40 mm | HD | 4.NP_SO-102 | 2920 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0360 | 0360 | yes | 90 | 20.6375 | HT_vratné vodní (45 °C) 1
13098416 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0365 | 0365 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13098481 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0366 | 0366 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13099060 | 4.NP_SO-102 | 0 | ø22 mm-ø22 mm-ø22 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 11 | 22 | 0.0000324424 | 25.2875 | ø22-ø22-ø22 | 10.07 | 25.175 | TT02.02.0368 | 0368 | yes | 90 | 12.5875 | HT_přívodní vodní (55 °C) 9
13099359 | 4.NP_SO-102 | 0 | ø25 mm-ø25 mm-ø25 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT02.02.0371 | 0371 | yes | 90 | 14.2875 | HT_vratné vodní (45 °C) 1
13099664 | 4.NP_SO-102 | 0 | ø25 mm-ø25 mm-ø25 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT02.02.0375 | 0375 | yes | 90 | 14.2875 | HT_vratné vodní (45 °C) 1
13099749 | 4.NP_SO-102 | 0 | ø25 mm-ø25 mm-ø25 mm | HD | 4.NP_SO-102 | 3300 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT02.02.0378 | 0378 | yes | 90 | 14.2875 | HT_přívodní vodní (55 °C) 9
13100034 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0381 | 0381 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13100433 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0383 | 0383 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13101108 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 29 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0385 | 0385 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 29
13101124 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3250 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.0386 | 0386 | yes | 90 | 11.1125 | HT_vratné vodní (45 °C) 13
13102575 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0391 | 0391 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13103322 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0395 | 0395 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13103339 | 1.NP_SO-102 | 0 | ø40 mm-ø40 mm-ø40 mm | HD | 1.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0396 | 0396 | yes | 90 | 20.6375 | HT_vratné vodní (45 °C) 13
13103349 | 1.NP_SO-102 | 0 | ø25 mm-ø25 mm-ø25 mm | HD | 1.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT02.02.0397 | 0397 | yes | 90 | 14.2875 | HT_vratné vodní (45 °C) 13
13103485 | 1.NP_SO-102 | 0 | ø25 mm-ø25 mm-ø25 mm | HD | 1.NP_SO-102 | 3200 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT02.02.0399 | 0399 | yes | 90 | 14.2875 | HT_přívodní vodní (55 °C) 19
13103595 | 1.NP_SO-102 | 0 | ø25 mm-ø25 mm-ø25 mm | HD | 1.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT02.02.0400 | 0400 | yes | 90 | 14.2875 | HT_vratné vodní (45 °C) 13
13104646 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0405 | 0405 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13104661 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0406 | 0406 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13104977 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0411 | 0411 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13105065 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0412 | 0412 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13105275 | 3.NP_SO-102 | 0 | ø40 mm-ø40 mm-ø40 mm | HD | 3.NP_SO-102 | 3050 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0415 | 0415 | yes | 90 | 20.6375 | HT_vratné vodní (45 °C) 13
13105285 | 3.NP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | 3.NP_SO-102 | 3050 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.0416 | 0416 | yes | 90 | 17.4625 | HT_vratné vodní (45 °C) 13
13105503 | 3.NP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | 3.NP_SO-102 | 3050 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.0417 | 0417 | yes | 90 | 17.4625 | HT_vratné vodní (45 °C) 13
13105665 | 3.NP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | 3.NP_SO-102 | 3050 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.0421 | 0421 | yes | 90 | 17.4625 | HT_přívodní vodní (55 °C) 19
13105930 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0422 | 0422 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13106239 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0424 | 0424 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13106351 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0425 | 0425 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13106471 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0427 | 0427 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13106660 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0429 | 0429 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13106776 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0431 | 0431 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13107636 | 4.NP_SO-102 | 0 | ø40 mm-ø40 mm-ø40 mm | HD | 4.NP_SO-102 | 3200 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0436 | 0436 | yes | 90 | 20.6375 | HT_přívodní vodní (55 °C) 19
13107838 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 3300 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.0438 | 0438 | yes | 90 | 7.9375 | HT_vratné vodní (45 °C) 13
13107933 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 3200 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.0441 | 0441 | yes | 90 | 11.1125 | HT_přívodní vodní (55 °C) 19
13108193 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0444 | 0444 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13108357 | 4.NP_SO-102 | 0 | ø40 mm-ø40 mm-ø40 mm | HD | 4.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0447 | 0447 | yes | 90 | 20.6375 | HT_vratné vodní (45 °C) 13
13108409 | 4.NP_SO-102 | 0 | ø40 mm-ø40 mm-ø40 mm | HD | 4.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0449 | 0449 | yes | 90 | 20.6375 | HT_vratné vodní (45 °C) 13
13109530 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0457 | 0457 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13109583 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0458 | 0458 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13109958 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0460 | 0460 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13111987 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0465 | 0465 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13112008 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0466 | 0466 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13112525 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 3340 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.0472 | 0472 | yes | 90 | 17.4625 | HT_vratné vodní (45 °C) 13
13112565 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 3340 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.0475 | 0475 | yes | 90 | 17.4625 | HT_přívodní vodní (55 °C) 19
13112621 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 3340 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.0478 | 0478 | yes | 90 | 17.4625 | HT_přívodní vodní (55 °C) 19
13112661 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 3340 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.0481 | 0481 | yes | 90 | 17.4625 | HT_vratné vodní (45 °C) 13
13112862 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0484 | 0484 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13112998 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0485 | 0485 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13113565 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 2650 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT02.02.0491 | 0491 | yes | 90 | 14.2875 | HT/CL_přívodní vodní 1
13113789 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm-ø25 mm | HE | 2.NP_SO-102 | 2650 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT02.02.0501 | 0501 | yes | 90 | 14.2875 | HT/CL_vratné vodní 1
13114855 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0508 | 0508 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13114997 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0509 | 0509 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13115033 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0510 | 0510 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13115048 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0511 | 0511 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13115318 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0513 | 0513 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9
13115405 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0514 | 0514 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9
13115513 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0516 | 0516 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13115676 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0517 | 0517 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9
13116098 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0524 | 0524 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9
13116119 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0525 | 0525 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9
13117120 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0527 | 0527 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13118676 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0538 | 0538 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 32
13119070 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0540 | 0540 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 32
13119855 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | -1.PP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.0547 | 0547 | no | 90 | 11.1125 | HT_vratné vodní (45 °C) 32
13120324 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 28 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0550 | 0550 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 28
13120475 | 1.NP_SO-102 | 0 | ø22 mm-ø22 mm-ø22 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 90 | 11 | 22 | 0.0000324424 | 25.2875 | ø22-ø22-ø22 | 10.07 | 25.175 | TT02.02.0554 | 0554 | no | 90 | 12.5875 | HT_vratné vodní (45 °C) 32
13121770 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0564 | 0564 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 32
13121795 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0565 | 0565 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9
13121962 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0567 | 0567 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9
13122110 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0568 | 0568 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13122336 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0571 | 0571 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9
13122454 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0574 | 0574 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13123636 | 1.NP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | 1.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.0575 | 0575 | yes | 90 | 17.4625 | HT_vratné vodní (45 °C) 1
13123646 | 1.NP_SO-102 | 40 | ø120 mm-ø120 mm-ø120 mm | HD | 1.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0576 | 0576 | yes | 90 | 20.6375 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13123704 | 1.NP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | 1.NP_SO-102 | 3280 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.0577 | 0577 | yes | 90 | 17.4625 | HT_vratné vodní (45 °C) 1
13124454 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0582 | 0582 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13124489 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0583 | 0583 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13124535 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 21 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0584 | 0584 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 21
13124587 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 21 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0585 | 0585 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 21
13125071 | 2.NP_SO-102 | 0 | ø22 mm-ø22 mm-ø22 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 90 | 11 | 22 | 0.0000324424 | 25.2875 | ø22-ø22-ø22 | 10.07 | 25.175 | TT02.02.0586 | 0586 | yes | 90 | 12.5875 | HT_přívodní vodní (55 °C) 12
13129522 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0601 | 0601 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13129554 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0602 | 0602 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9
13130761 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 14 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0609 | 0609 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 14
13131114 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0611 | 0611 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13133301 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0625 | 0625 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13133507 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0630 | 0630 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13133595 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0631 | 0631 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13133651 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0632 | 0632 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13133810 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0634 | 0634 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13133857 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0635 | 0635 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13134354 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0644 | 0644 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13134375 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0645 | 0645 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13135549 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 3250 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0654 | 0654 | yes | 90 | 20.6375 | HT_vratné vodní (45 °C) 13
13135940 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3100 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT02.02.0655 | 0655 | yes | 90 | 33.3375 | HT_přívodní vodní (55 °C) 19
13136029 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3100 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT02.02.0656 | 0656 | yes | 90 | 33.3375 | HT_přívodní vodní (55 °C) 19
13136217 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3100 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT02.02.0658 | 0658 | yes | 90 | 33.3375 | HT_vratné vodní (45 °C) 13
13136234 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3100 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT02.02.0661 | 0661 | yes | 90 | 33.3375 | HT_vratné vodní (45 °C) 13
13136409 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0664 | 0664 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13136863 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0673 | 0673 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13137572 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0681 | 0681 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9
13137597 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0683 | 0683 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13137633 | 2.NP_SO-102 | 60 | ø200 mm-ø200 mm-ø200 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.0684 | 0684 | yes | 90 | 39.6875 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13137706 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.0687 | 0687 | yes | 90 | 39.6875 | HT_přívodní vodní (55 °C) 9
13139329 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0703 | 0703 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 17; HT_přívodní vodní (65 °C) 13
13139515 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0704 | 0704 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13139905 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2850 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.0712 | 0712 | yes | 90 | 11.1125 | HT_vratné vodní (45 °C) 13
13140316 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0714 | 0714 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13140547 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0715 | 0715 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13140997 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0723 | 0723 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13141206 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0726 | 0726 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13142192 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 22 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0739 | 0739 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 18; HT_přívodní vodní (65 °C) 22
13142334 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0743 | 0743 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13144163 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 15 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0766 | 0766 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 15
13144188 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0767 | 0767 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13144305 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0768 | 0768 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13144500 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0770 | 0770 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13144970 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 3200 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.0779 | 0779 | yes | 90 | 11.1125 | HT_vratné vodní (45 °C) 13
13145060 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0781 | 0781 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13145494 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0787 | 0787 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13147688 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 34 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0799 | 0799 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 34
13147744 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0802 | 0802 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13148389 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0814 | 0814 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13148724 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0817 | 0817 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 2
13148826 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 2 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0819 | 0819 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 2
13149065 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 25 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0822 | 0822 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 25
13149283 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 25 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0826 | 0826 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 25
13149333 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0827 | 0827 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13149399 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0832 | 0832 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13149896 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 10 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.0840 | 0840 | yes | 90 | 7.9375 | HT_přívodní vodní (65 °C) 10
13172187 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.0868 | 0868 | yes | 90 | 7.9375 | CL_přívodní vodní (10 °C) 1
13172494 | 3.NP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HC | 3.NP_SO-102 | 3370 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.0870 | 0870 | yes | 90 | 7.9375 | CL_vratné vodní (15 °C) 2
13174304 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HC | 1.NP_SO-102 | 2900 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.0883 | 0883 | yes | 90 | 11.1125 | CL_přívodní vodní (10 °C) 1
13174693 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HC | 1.NP_SO-102 | 2900 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.0886 | 0886 | yes | 90 | 11.1125 | CL_vratné vodní (15 °C) 2
13174926 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HC | 1.NP_SO-102 | 2900 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.0889 | 0889 | yes | 90 | 11.1125 | CL_přívodní vodní (10 °C) 1
13175045 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HC | 1.NP_SO-102 | 2900 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.0890 | 0890 | yes | 90 | 11.1125 | CL_vratné vodní (15 °C) 2
13182319 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0918 | 0918 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13182434 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0919 | 0919 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9
13183547 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0925 | 0925 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13183597 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.0927 | 0927 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 1
13208971 | -1.PP_SO-102 | 0 | ø65 mm-ø65 mm-ø65 mm | HD | -1.PP_SO-102 | 300 | Fáze 1 | HT_vratné vodní (65 °C) | Zpětné vedení teplé vody | HT_vratné vodní (65 °C) 1 | 90 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT02.02.0973 | 0973 | yes | 90 | 33.3375 | HT_vratné vodní (65 °C) 1
13214388 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.0975 | 0975 | no | 90 | 7.9375 | HT_vratné vodní (45 °C) 1
13214417 | 2.NP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.0976 | 0976 | no | 90 | 7.9375 | HT_přívodní vodní (55 °C) 9
13216959 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.0989 | 0989 | yes | 90 | 39.6875 | HT_přívodní vodní (55 °C) 9
13217196 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.0991 | 0991 | yes | 90 | 39.6875 | HT_vratné vodní (45 °C) 1
13218032 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.0999 | 0999 | yes | 90 | 20.6375 | HT_vratné vodní (45 °C) 1
13218300 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.1002 | 1002 | yes | 90 | 20.6375 | HT_přívodní vodní (55 °C) 9
13226193 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.1045 | 1045 | yes | 90 | 39.6875 | HT_přívodní vodní (55 °C) 9
13226216 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2300 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.1047 | 1047 | yes | 90 | 39.6875 | HT_vratné vodní (45 °C) 1
13227876 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 7 | 90 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT02.02.1059 | 1059 | yes | 90 | 33.3375 | HT_vratné vodní (45 °C) 7
13246223 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 90 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT02.02.1093 | 1093 | yes | 90 | 33.3375 | HT_přívodní vodní (55 °C) 25
13246581 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.1095 | 1095 | yes | 90 | 11.1125 | HT_přívodní vodní (55 °C) 25
13247002 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2500 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 90 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT02.02.1101 | 1101 | yes | 90 | 33.3375 | HT_vratné vodní (45 °C) 26
13248988 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT02.02.1119 | 1119 | yes | 90 | 14.2875 | CL_přívodní vodní (10 °C) 4
