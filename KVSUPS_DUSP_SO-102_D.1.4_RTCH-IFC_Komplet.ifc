Properties of the parts of a building model (IFC4), part 35 of 72

# IfcDistributionPort (10261)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_13091565_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13125823_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13092527_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092603_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092527_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092549_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092676_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092549_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092560_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092672_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092560_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092571_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092761_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092571_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092582_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142334_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092582_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142373_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092603_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092673_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092672_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092677_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092672_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092673_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092676_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142335_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092676_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092677_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092761_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13141925_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092840_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093048_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092840_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143839_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092873_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13440851_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092873_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092884_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093029_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092884_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092897_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143474_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092897_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092908_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13092908_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143472_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093009_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093029_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093009_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093048_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093029_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093030_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093030_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13440851_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093043_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093048_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093043_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13144188_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093307_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093663_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093307_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093824_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093445_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093446_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093445_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13315301_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093528_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13315304_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13093528_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13094089_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13093530_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13093531_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13093530_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13315304_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13093531_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13315298_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13093548_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093673_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093548_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093661_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13315306_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093661_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093673_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093663_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093664_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093663_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13315306_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093664_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13315301_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093812_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13315308_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093812_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13142124_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093824_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13315308_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093824_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13315310_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093825_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13315310_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13093825_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13143348_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13093860_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13094041_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13094045_3 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
OutPort_13093860_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13093863_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13094089_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13093863_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13094031_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
OutPort_13315312_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
InPort_13141993_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
OutPort_13094031_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
InPort_13315312_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
OutPort_13094045_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
InPort_13094045_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
OutPort_13315314_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
InPort_13315314_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
OutPort_13094046_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
InPort_13094046_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
OutPort_13143315_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 15
Port_13094169_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13311854_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13094169_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13094807_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13094171_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13094172_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13094171_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13311854_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13094172_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13311827_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13094360_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13123734_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13094360_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13094595_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13123854_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13094595_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13123820_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13094951_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
OutPort_13094716_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 21
InPort_13094764_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13094946_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13094950_3 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13094764_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13094767_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13094807_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13094767_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13311832_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13094937_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13094937_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 23
OutPort_13132244_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 23
InPort_13311832_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13094950_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13311834_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13094950_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13311834_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13094951_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13095013_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13311836_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13095013_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13132496_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13095210_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13146874_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13095210_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13095232_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13095394_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13095232_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13095243_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13095450_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13095243_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13095276_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13147721_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13095276_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13095394_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316520_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13095394_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13095474_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13095450_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316512_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13095474_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13146874_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13095600_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316517_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13095600_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316519_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13095692_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 5
OutPort_13146775_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 5
InPort_13095692_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 5
OutPort_13146777_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 5
Port_13095999_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 10
Port_13149864_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 10
Port_13095999_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 10
Port_13096011_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 10
InPort_13096289_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 10
OutPort_13149896_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 10
InPort_13316672_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 10
OutPort_13096289_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 10
InPort_13096443_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13096354_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13096354_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13314947_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13096406_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 10
OutPort_13316672_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 10
InPort_13316659_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 10
OutPort_13096406_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 10
InPort_13096446_0 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13096406_3 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13096407_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 10
OutPort_13316659_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 10
InPort_13096407_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 10
OutPort_13146775_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 10
InPort_13096446_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13096445_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13096445_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13096803_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13314947_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13096445_3 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13096528_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13333595_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13096726_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13096734_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13096726_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13096794_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13096744_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13096752_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13096744_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13096837_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13096792_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13096794_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13096792_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13096814_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13096802_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13344507_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13096803_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13096802_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13096802_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13314965_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13096835_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13096837_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13096835_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13096857_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13096845_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13096846_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13096845_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13314968_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13096846_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13344430_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13096923_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13146741_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13096923_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13147410_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13096934_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13347554_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13096934_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13146741_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13096967_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097508_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13096967_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097511_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13096978_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097508_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13096978_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097338_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13096989_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097338_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13096989_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097381_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097000_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097385_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097000_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097011_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097381_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097011_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097385_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097403_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316674_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097403_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097618_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097412_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316674_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097412_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13347552_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097456_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097511_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097456_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097618_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097657_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13098552_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097657_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097668_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13098481_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097668_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097679_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13098481_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097679_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13098552_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097690_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 22
Port_13097690_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 22
Port_13097712_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149397_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097712_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149399_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097758_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148389_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13097758_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316999_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13098035_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 2
OutPort_13148826_3 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 2
InPort_13148830_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 2
OutPort_13098035_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 2
Port_13098081_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13098416_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13098081_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13098162_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13098162_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13098351_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13098351_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148390_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13098389_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13098416_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13098389_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13098416_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13147996_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13098481_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149334_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13098614_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149333_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13098614_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13098678_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13098678_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149397_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13147846_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13099058_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13099058_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13099078_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13316820_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13099060_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13316908_1 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13099060_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13099060_3 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13147846_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13316908_2 | SINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
OutPort_13099061_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
InPort_13147945_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 28
OutPort_13099061_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 28
Port_13099074_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13099750_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13099296_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316822_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099296_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13149714_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099359_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316822_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099359_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316910_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099359_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099665_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099360_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316910_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099360_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13148481_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099385_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099653_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099385_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099387_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099399_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099399_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099662_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099449_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13099747_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13099449_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13099619_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316844_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099619_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099672_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099653_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099664_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099662_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13316844_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099664_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099665_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099664_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099672_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13099702_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13316846_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13099702_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13099757_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13099747_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13316846_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13099749_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13099750_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13099749_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13099757_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13099869_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13099869_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13136840_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13099880_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100034_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13099880_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13099891_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13099992_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13099891_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13099937_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13136329_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13099937_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13136766_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13099992_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100035_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100034_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13136864_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100034_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100035_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100298_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100372_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100298_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100309_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100433_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100309_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100486_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100320_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100433_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100320_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100331_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100486_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100331_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100342_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13134354_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100342_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13134688_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100372_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13134355_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100433_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13134280_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100537_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13314683_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100537_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13136317_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100546_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13101124_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100546_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13135379_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100862_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13422976_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13100862_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13101014_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 29
Port_13101108_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 29
Port_13101014_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 29
Port_13101025_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 29
Port_13101108_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 29
Port_13101025_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 29
Port_13101108_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 29
Port_13101109_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 29
Port_13101109_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 29
Port_13101122_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13314570_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13101122_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13101134_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13101124_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13101125_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13101124_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13314570_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13101125_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13314576_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13101134_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13101170_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105275_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13101170_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13108353_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102299_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13255812_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102299_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102312_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102575_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102312_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102609_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102334_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102575_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102334_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102345_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102345_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102609_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102383_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102438_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102383_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13133048_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102392_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13133048_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102392_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13133459_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102438_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103350_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102527_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13133301_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102527_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447848_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102575_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102767_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102767_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13133301_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102772_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13133595_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102772_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13133451_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102781_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13255727_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102781_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13133314_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102878_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103061_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102878_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102889_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13343219_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102889_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102900_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13343261_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102900_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102911_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13133857_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102911_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13312671_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102944_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13102944_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103168_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103061_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13133858_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103168_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13133719_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103204_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103595_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103204_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103349_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103278_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103322_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103278_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103289_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103322_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103289_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103322_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103323_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103323_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103738_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103336_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13312700_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103336_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13134199_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103339_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13311151_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103339_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13135538_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103339_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13312698_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103349_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13312700_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103349_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13312770_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103350_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13312770_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103439_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13103481_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13103439_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13103485_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13103478_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13312704_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13103478_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13134162_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13103485_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13312704_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13103485_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13312772_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13103486_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13312772_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13103521_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13312708_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103521_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13312725_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103595_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103596_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103595_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13312708_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103596_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13312698_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103738_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13312725_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103803_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103803_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315638_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103814_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315650_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103814_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103825_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315644_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103825_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103834_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13141070_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103834_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13141074_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103845_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315662_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103845_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315670_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103881_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104765_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103881_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13139905_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103890_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315871_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103890_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315873_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103908_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13139839_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103908_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104530_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103919_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13140547_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103919_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13140557_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103952_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13344751_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103952_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103963_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 44
Port_13103963_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 44
Port_13103974_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104143_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13103974_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104143_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13140548_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104332_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13140316_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13104332_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13104365_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104530_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104365_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315920_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104376_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104549_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104376_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104646_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104418_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13139905_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104418_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315871_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104549_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315920_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104568_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104661_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104568_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104701_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104579_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104661_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104579_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104590_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104701_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104590_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104646_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104662_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104646_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104647_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104647_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104661_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104662_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104759_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105206_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104759_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104765_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104792_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105202_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104792_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13141070_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104856_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315638_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104856_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315640_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104893_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315646_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104893_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315642_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104971_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315642_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104971_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315644_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104977_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315646_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104977_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315648_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104977_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13315650_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104990_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105065_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13104990_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105001_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105065_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105001_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105065_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105066_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105066_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13316015_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105202_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105286_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105206_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105266_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105266_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13316124_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105275_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13135550_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105275_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13316122_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105285_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13316124_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105285_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13316126_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105285_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105473_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105286_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13316126_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105351_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13316128_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105351_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13316013_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105473_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105503_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105503_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105504_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105503_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13316128_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105504_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13316122_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13105580_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13105661_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13105580_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13105665_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13105630_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13105666_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13105634_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13105652_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13105652_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13316130_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13105665_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13316130_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13105665_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13316132_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13105666_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13316132_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
InPort_13105839_1 | SINK | PIPE | HEATING
OutPort_13105839_2 | SOURCE | PIPE | HEATING
Port_13105889_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13105930_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13105889_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13105930_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13144306_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13105930_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13105931_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13106028_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13144305_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13106044_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13106189_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13106044_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13106074_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13106239_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13106074_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13106085_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13106351_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13106085_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13106096_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13106396_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13106096_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13106118_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13106118_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13106475_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13106127_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144768_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13106127_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144772_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13106138_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13144500_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13106138_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
