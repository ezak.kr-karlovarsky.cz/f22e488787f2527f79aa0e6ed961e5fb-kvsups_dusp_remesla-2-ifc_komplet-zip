Properties of the parts of a building model (IFC4), part 64 of 72

# IfcPipeSegment: Typy trubek:Ocel_uhlíková (1186)
Name (Typy trubek:Ocel_uhlíková:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Tloušťka izolace (mm) | Celková velikost | Relativní drsnost | CCI Technický systém | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Obrátit výšku (mm) | Plocha (m2) | Průměr (mm) | Řez | Délka (mm) | Velikost | Vnější průměr (mm) | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group | Sklon
13103336 | 1.NP_SO-102 | 3499.12 | 0.000568237 | 0.295707 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 3189.2 | 0.219856 | 20 | 374 | 3499.12 | ø20 | 26.9 | 21.6 | TR02.02.0662 | 0662 | yes | HT_vratné vodní (45 °C) 13 | 0
13103350 | 1.NP_SO-102 | 5003.57 | 0.000568237 | 0.422846 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 3189.2 | 0.314384 | 20 | 388 | 5003.57 | ø20 | 26.9 | 21.6 | TR02.02.0663 | 0663 | yes | HT_vratné vodní (45 °C) 13 | 0
13103439 | 1.NP_SO-102 | 55.775 | 0.000891835 | 0.00590499 | 0 | ø25 mm | 0.00367647 | HD | 1.NP_SO-102 | 3281.06 | 3225.29 | 3281.06 | 3225.29 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 3225.29 | 0.00438056 | 25 | 274 | 55.775 | ø25 | 33.7 | 27.2 | TR02.02.0664 | 0664 | yes | HT_přívodní vodní (55 °C) 19
13103478 | 1.NP_SO-102 | 3499.12 | 0.000568237 | 0.295707 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 3189.2 | 0.219856 | 20 | 360 | 3499.12 | ø20 | 26.9 | 21.6 | TR02.02.0665 | 0665 | yes | HT_přívodní vodní (55 °C) 19 | 0
13103486 | 1.NP_SO-102 | 5303.57 | 0.000568237 | 0.448199 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 3189.2 | 0.333233 | 20 | 375 | 5303.57 | ø20 | 26.9 | 21.6 | TR02.02.0666 | 0666 | yes | HT_přívodní vodní (55 °C) 19 | 0
13103521 | 1.NP_SO-102 | 3205.14 | 0.000356274 | 0.214475 | 0 | ø15 mm | 0.00625 | HD | 1.NP_SO-102 | 3165.87 | -39.2688 | 3165.87 | -39.2688 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | -39.2688 | 0.151039 | 15 | 376 | 3205.14 | ø15 | 21.3 | 16 | TR02.02.0667 | 0667 | no | HT_vratné vodní (45 °C) 13
13103596 | 1.NP_SO-102 | 581.413 | 0.000891835 | 0.0615552 | 0 | ø25 mm | 0.00367647 | HD | 1.NP_SO-102 | 3216.85 | 3200 | 3200 | 3183.15 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 3186.4 | 0.0456641 | 25 | 41 | 581.413 | ø25 | 33.7 | 27.2 | TR02.02.0668 | 0668 | yes | HT_vratné vodní (45 °C) 13 | 0
13103834 | 3.NP_SO-102 | 3556.78 | 0.000568237 | 0.30058 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10789.2 | 0.223479 | 20 | 438 | 3556.78 | ø20 | 26.9 | 21.6 | TR02.02.0672 | 0672 | yes | HT_vratné vodní (45 °C) 13 | 0
13103881 | 3.NP_SO-102 | 359.432 | 0.000568237 | 0.0303752 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2863.45 | 2850 | 2850 | 2836.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10839.2 | 0.0225838 | 20 | 439 | 359.432 | ø20 | 26.9 | 21.6 | TR02.02.0674 | 0674 | yes | HT_vratné vodní (45 °C) 13 | 0
13103890 | 3.NP_SO-102 | 2486.14 | 0.000568237 | 0.210101 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2863.45 | 2850 | 2850 | 2836.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10839.2 | 0.156209 | 20 | 444 | 2486.14 | ø20 | 26.9 | 21.6 | TR02.02.0675 | 0675 | yes | HT_vratné vodní (45 °C) 13 | 0
13103908 | 3.NP_SO-102 | 455.075 | 0.000568237 | 0.0384579 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2863.45 | 2850 | 2850 | 2836.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10839.2 | 0.0285932 | 20 | 443 | 455.075 | ø20 | 26.9 | 21.6 | TR02.02.0676 | 0676 | yes | HT_vratné vodní (45 °C) 13 | 0
13104365 | 3.NP_SO-102 | 2871.04 | 0.000568237 | 0.242629 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2832.54 | -38.5062 | 2832.54 | -38.5063 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7961.49 | 0.180393 | 20 | 443 | 2871.04 | ø20 | 26.9 | 21.6 | TR02.02.0682 | 0682 | yes | HT_vratné vodní (45 °C) 13
13104418 | 3.NP_SO-102 | 1501.89 | 0.000568237 | 0.126923 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2863.45 | 2850 | 2850 | 2836.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10839.2 | 0.0943665 | 20 | 444 | 1501.89 | ø20 | 26.9 | 21.6 | TR02.02.0684 | 0684 | yes | HT_vratné vodní (45 °C) 13 | 0
13104759 | 3.NP_SO-102 | 165.075 | 0.000568237 | 0.0139503 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3032.54 | 2867.46 | 3032.54 | 2867.46 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10867.5 | 0.010372 | 20 | 439 | 165.075 | ø20 | 26.9 | 21.6 | TR02.02.0690 | 0690 | yes | HT_vratné vodní (45 °C) 13
13104792 | 3.NP_SO-102 | 215.075 | 0.000568237 | 0.0181757 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3032.54 | 2817.46 | 3032.54 | 2817.46 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10817.5 | 0.0135136 | 20 | 438 | 215.075 | ø20 | 26.9 | 21.6 | TR02.02.0691 | 0691 | yes | HT_vratné vodní (45 °C) 13
13105266 | 3.NP_SO-102 | 2070.06 | 0.000568237 | 0.174939 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3063.45 | 3050 | 3050 | 3036.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 11039.2 | 0.130066 | 20 | 439 | 2070.06 | ø20 | 26.9 | 21.6 | TR02.02.0696 | 0696 | yes | HT_vratné vodní (45 °C) 13 | 0
13105286 | 3.NP_SO-102 | 2979.57 | 0.000568237 | 0.2518 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3063.45 | 3050 | 3050 | 3036.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 11039.2 | 0.187212 | 20 | 438 | 2979.57 | ø20 | 26.9 | 21.6 | TR02.02.0697 | 0697 | yes | HT_vratné vodní (45 °C) 13 | 0
13105351 | 3.NP_SO-102 | 3056.82 | 0.000356274 | 0.20455 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 3011.11 | -45.7125 | 3011.11 | -45.7125 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7954.29 | 0.144049 | 15 | 82 | 3056.82 | ø15 | 21.3 | 16 | TR02.02.0698 | 0698 | no | HT_vratné vodní (45 °C) 13
13105473 | 3.NP_SO-102 | 220.885 | 0.00141175 | 0.0294227 | 0 | ø32 mm | 0.00278552 | HD | 3.NP_SO-102 | 3071.2 | 3050 | 3050 | 3028.8 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 11032 | 0.0222058 | 32 | 78 | 220.885 | ø32 | 42.4 | 35.9 | TR02.02.0699 | 0699 | yes | HT_vratné vodní (45 °C) 13 | 0
13105504 | 3.NP_SO-102 | 570.385 | 0.00141175 | 0.0759773 | 0 | ø32 mm | 0.00278552 | HD | 3.NP_SO-102 | 3071.2 | 3050 | 3050 | 3028.8 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 11032 | 0.0573414 | 32 | 67 | 570.385 | ø32 | 42.4 | 35.9 | TR02.02.0700 | 0700 | yes | HT_vratné vodní (45 °C) 13 | 0
13105580 | 3.NP_SO-102 | 46.025 | 0.00141175 | 0.00613069 | 0 | ø32 mm | 0.00278552 | HD | 3.NP_SO-102 | 3126.19 | 3080.16 | 3126.19 | 3080.16 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 11080.2 | 0.00462694 | 32 | 447 | 46.025 | ø32 | 42.4 | 35.9 | TR02.02.0701 | 0701 | yes | HT_přívodní vodní (55 °C) 19
13105652 | 3.NP_SO-102 | 3129.57 | 0.000568237 | 0.264476 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3063.45 | 3050 | 3050 | 3036.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 11039.2 | 0.196636 | 20 | 427 | 3129.57 | ø20 | 26.9 | 21.6 | TR02.02.0702 | 0702 | yes | HT_přívodní vodní (55 °C) 19 | 0
13105666 | 3.NP_SO-102 | 1920.06 | 0.000568237 | 0.162262 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3063.45 | 3050 | 3050 | 3036.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 11039.2 | 0.120641 | 20 | 416 | 1920.06 | ø20 | 26.9 | 21.6 | TR02.02.0703 | 0703 | yes | HT_přívodní vodní (55 °C) 19 | 0
13106127 | 4.NP_SO-102 | 1749.29 | 0.000568237 | 0.147831 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 14889.2 | 0.109911 | 20 | 491 | 1749.29 | ø20 | 26.9 | 21.6 | TR02.02.0712 | 0712 | yes | HT_vratné vodní (45 °C) 13 | 0
13106626 | 4.NP_SO-102 | 1833.11 | 0.000568237 | 0.154914 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 2913.45 | 2900 | 2900 | 2886.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 14889.2 | 0.115177 | 20 | 507 | 1833.11 | ø20 | 26.9 | 21.6 | TR02.02.0724 | 0724 | yes | HT_vratné vodní (45 °C) 13 | 0
13106868 | 4.NP_SO-102 | 265.075 | 0.000568237 | 0.0224012 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3182.54 | 3182.54 | 2917.46 | 2917.46 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 14917.5 | 0.0166552 | 20 | 507 | 265.075 | ø20 | 26.9 | 21.6 | TR02.02.0726 | 0726 | yes | HT_vratné vodní (45 °C) 13
13107634 | 4.NP_SO-102 | 39.675 | 0.00183197 | 0.00602024 | 0 | ø40 mm | 0.00239234 | HD | 4.NP_SO-102 | 3273.01 | 3273.01 | 3233.34 | 3233.34 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 15233.3 | 0.00498571 | 40 | 509 | 39.675 | ø40 | 48.3 | 41.8 | TR02.02.0727 | 0727 | yes | HT_přívodní vodní (55 °C) 19
13107637 | 4.NP_SO-102 | 5284.12 | 0.000568237 | 0.446555 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 15189.2 | 0.332011 | 20 | 493 | 5284.12 | ø20 | 26.9 | 21.6 | TR02.02.0728 | 0728 | yes | HT_přívodní vodní (55 °C) 19 | 0
13107760 | 4.NP_SO-102 | 2037.7 | 0.000568237 | 0.172203 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 15189.2 | 0.128032 | 20 | 491 | 2037.7 | ø20 | 26.9 | 21.6 | TR02.02.0729 | 0729 | yes | HT_vratné vodní (45 °C) 13 | 0
13107787 | 4.NP_SO-102 | 877.138 | 0.000356274 | 0.0586945 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3310.65 | 3300 | 3300 | 3289.35 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 15292 | 0.0413341 | 15 | 542 | 877.138 | ø15 | 21.3 | 16 | TR02.02.0730 | 0730 | yes | HT_vratné vodní (45 °C) 13 | 0
13107789 | 4.NP_SO-102 | 2327.48 | 0.000356274 | 0.155745 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3310.65 | 3300 | 3300 | 3289.35 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 15292 | 0.10968 | 15 | 542 | 2327.48 | ø15 | 21.3 | 16 | TR02.02.0731 | 0731 | yes | HT_vratné vodní (45 °C) 13 | 0
13107791 | 4.NP_SO-102 | 233.963 | 0.000356274 | 0.0156558 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3310.65 | 3300 | 3300 | 3289.35 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 15292 | 0.0110252 | 15 | 531 | 233.963 | ø15 | 21.3 | 16 | TR02.02.0732 | 0732 | yes | HT_vratné vodní (45 °C) 13 | 0
13107795 | 4.NP_SO-102 | 1391.27 | 0.000356274 | 0.093098 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | -39.35 | -50 | -50 | -60.65 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 11942 | 0.065562 | 15 | 108 | 1391.27 | ø15 | 21.3 | 16 | TR02.02.0733 | 0733 | no | HT_vratné vodní (45 °C) 13 | 0
13107839 | 4.NP_SO-102 | 8513.46 | 0.000356274 | 0.569686 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3310.65 | 3300 | 3300 | 3289.35 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 15292 | 0.401187 | 15 | 530 | 8513.46 | ø15 | 21.3 | 16 | TR02.02.0734 | 0734 | yes | HT_vratné vodní (45 °C) 13 | 0
13107863 | 4.NP_SO-102 | 3314.28 | 0.000356274 | 0.221778 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3287.3 | -26.9813 | 3287.3 | -26.9813 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 11973 | 0.156182 | 15 | 531 | 3314.28 | ø15 | 21.3 | 16 | TR02.02.0735 | 0735 | yes | HT_vratné vodní (45 °C) 13
13107931 | 4.NP_SO-102 | 57.9312 | 0.000356274 | 0.00387652 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3287.3 | 3287.3 | 3229.37 | 3229.37 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 15229.4 | 0.00272995 | 15 | 517 | 57.9312 | ø15 | 21.3 | 16 | TR02.02.0736 | 0736 | yes | HT_přívodní vodní (55 °C) 19
13107934 | 4.NP_SO-102 | 352.362 | 0.000568237 | 0.0297777 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 15189.2 | 0.0221395 | 20 | 154 | 352.362 | ø20 | 26.9 | 21.6 | TR02.02.0737 | 0737 | yes | HT_přívodní vodní (55 °C) 19 | 0
13107970 | 4.NP_SO-102 | 265.075 | 0.000568237 | 0.0224012 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3182.54 | 2917.46 | 3182.54 | 2917.46 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 14917.5 | 0.0166552 | 20 | 491 | 265.075 | ø20 | 26.9 | 21.6 | TR02.02.0738 | 0738 | yes | HT_vratné vodní (45 °C) 13
13108303 | 4.NP_SO-102 | 3202.06 | 0.000356274 | 0.214269 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3156.34 | 3156.34 | -45.7125 | -45.7125 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 11954.3 | 0.150893 | 15 | 529 | 3202.06 | ø15 | 21.3 | 16 | TR02.02.0743 | 0743 | no | HT_vratné vodní (45 °C) 13
13108358 | 4.NP_SO-102 | 2116.84 | 0.000568237 | 0.178892 | 0 | ø20 mm | 0.00462963 | HD | 4.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 15189.2 | 0.133005 | 20 | 507 | 2116.84 | ø20 | 26.9 | 21.6 | TR02.02.0744 | 0744 | yes | HT_vratné vodní (45 °C) 13 | 0
13108396 | 4.NP_SO-102 | 317.595 | 0.00183197 | 0.0481916 | 0 | ø40 mm | 0.00239234 | HD | 4.NP_SO-102 | 3224.15 | 3200 | 3200 | 3175.85 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 15179.1 | 0.0399102 | 40 | 525 | 317.595 | ø40 | 48.3 | 41.8 | TR02.02.0745 | 0745 | yes | HT_vratné vodní (45 °C) 13 | 0
13108410 | 4.NP_SO-102 | 580.819 | 0.00183197 | 0.0881328 | 0 | ø40 mm | 0.00239234 | HD | 4.NP_SO-102 | 3224.15 | 3200 | 3200 | 3175.85 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 15179.1 | 0.0729879 | 40 | 62 | 580.819 | ø40 | 48.3 | 41.8 | TR02.02.0746 | 0746 | yes | HT_vratné vodní (45 °C) 13 | 0
13108425 | 4.NP_SO-102 | 1235.78 | 0.000356274 | 0.0826931 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | -39.35 | -50 | -50 | -60.65 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11942 | 0.0582346 | 15 | 772 | 1235.78 | ø15 | 21.3 | 16 | TR02.02.0747 | 0747 | no | HT_vratné vodní (45 °C) 1 | 0
13108434 | 4.NP_SO-102 | 341.361 | 0.000356274 | 0.0228425 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 2790.65 | 2780 | 2780 | 2769.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 14772 | 0.0160863 | 15 | 772 | 341.361 | ø15 | 21.3 | 16 | TR02.02.0748 | 0748 | yes | HT_vratné vodní (45 °C) 1 | 0
13108504 | 4.NP_SO-102 | 2801.43 | 0.000356274 | 0.18746 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 2765.71 | 2765.71 | -35.7125 | -35.7125 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11964.3 | 0.132014 | 15 | 772 | 2801.43 | ø15 | 21.3 | 16 | TR02.02.0749 | 0749 | yes | HT_vratné vodní (45 °C) 1
13108514 | 4.NP_SO-102 | 1229.92 | 0.000356274 | 0.0823016 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 2790.65 | 2780 | 2780 | 2769.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 14772 | 0.0579589 | 15 | 772 | 1229.92 | ø15 | 21.3 | 16 | TR02.02.0750 | 0750 | yes | HT_vratné vodní (45 °C) 1 | 0
13108552 | 4.NP_SO-102 | 1240.5 | 0.000356274 | 0.0830093 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | -39.35 | -50 | -50 | -60.65 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 6 | 11942 | 0.0584573 | 15 | 1 | 1240.5 | ø15 | 21.3 | 16 | TR02.02.0751 | 0751 | no | HT_přívodní vodní (55 °C) 6 | 0
13108554 | 4.NP_SO-102 | 336.636 | 0.000356274 | 0.0225263 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 2860.65 | 2850 | 2850 | 2839.35 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 6 | 14842 | 0.0158636 | 15 | 1 | 336.636 | ø15 | 21.3 | 16 | TR02.02.0752 | 0752 | yes | HT_přívodní vodní (55 °C) 6 | 0
13108556 | 4.NP_SO-102 | 2871.43 | 0.000356274 | 0.192144 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 2835.71 | 2835.71 | -35.7125 | -35.7125 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 6 | 11964.3 | 0.135313 | 15 | 1 | 2871.43 | ø15 | 21.3 | 16 | TR02.02.0753 | 0753 | yes | HT_přívodní vodní (55 °C) 6
13108558 | 4.NP_SO-102 | 1083.57 | 0.000356274 | 0.0725084 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 2860.65 | 2850 | 2850 | 2839.35 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 6 | 14842 | 0.0510623 | 15 | 1 | 1083.57 | ø15 | 21.3 | 16 | TR02.02.0754 | 0754 | yes | HT_přívodní vodní (65 °C) 10; HT_přívodní vodní (55 °C) 6 | 0
13109123 | 4.NP_SO-102 | 3223.01 | 0.000356274 | 0.215671 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3287.3 | 64.2875 | 3287.3 | 64.2875 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 12064.3 | 0.151881 | 15 | 103 | 3223.01 | ø15 | 21.3 | 16 | TR02.02.0755 | 0755 | yes | HT_přívodní vodní (55 °C) 19
13109276 | 4.NP_SO-102 | 3221.43 | 0.000356274 | 0.215565 | 0 | ø15 mm | 0.00625 | HD | 4.NP_SO-102 | 3285.71 | 64.2875 | 3285.71 | 64.2875 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 12064.3 | 0.151806 | 15 | 542 | 3221.43 | ø15 | 21.3 | 16 | TR02.02.0756 | 0756 | yes | HT_vratné vodní (45 °C) 13
13109765 | -1.PP_SO-102 | 1785.93 | 0.000356274 | 0.119507 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 2560.65 | 2550 | 2550 | 2539.35 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | -1458 | 0.0841601 | 15 | 139 | 1785.93 | ø15 | 21.3 | 16 | TR02.02.0765 | 0765 | yes | HT_vratné vodní (45 °C) 13 | 0
13109975 | -1.PP_SO-102 | 2581.43 | 0.000356274 | 0.172738 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 2535.71 | -45.7125 | 2535.71 | -45.7125 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | -4045.71 | 0.121647 | 15 | 139 | 2581.43 | ø15 | 21.3 | 16 | TR02.02.0770 | 0770 | yes | HT_vratné vodní (45 °C) 13
13110030 | -1.PP_SO-102 | 1902.8 | 0.000568237 | 0.160803 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3353.45 | 3340 | 3340 | 3326.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | -670.8 | 0.119556 | 20 | 551 | 1902.8 | ø20 | 26.9 | 21.6 | TR02.02.0771 | 0771 | yes | HT_vratné vodní (45 °C) 13 | 0
13110068 | -1.PP_SO-102 | 1130.93 | 0.00141175 | 0.150644 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 3361.2 | 3340 | 3340 | 3318.8 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | -677.95 | 0.113694 | 32 | 366 | 1130.93 | ø32 | 42.4 | 35.9 | TR02.02.0772 | 0772 | yes | HT_vratné vodní (45 °C) 13 | 0
13110078 | -1.PP_SO-102 | 2581.43 | 0.000356274 | 0.172738 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 2535.71 | 2535.71 | -45.7125 | -45.7125 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | -4045.71 | 0.121647 | 15 | 159 | 2581.43 | ø15 | 21.3 | 16 | TR02.02.0773 | 0773 | no | HT_vratné vodní (45 °C) 13
13110248 | 1.NP_SO-102 | 3792.53 | 0.00141175 | 0.505179 | 0 | ø32 mm | 0.00278552 | HD | 1.NP_SO-102 | 3156.34 | -636.188 | 3156.34 | -636.188 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | -636.188 | 0.381267 | 32 | 366 | 3792.53 | ø32 | 42.4 | 35.9 | TR02.02.0774 | 0774 | yes | HT_vratné vodní (45 °C) 13
13110430 | -1.PP_SO-102 | 1442.33 | 0.00141175 | 0.192123 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 3361.2 | 3340 | 3340 | 3318.8 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | -677.95 | 0.144999 | 32 | 358 | 1442.33 | ø32 | 42.4 | 35.9 | TR02.02.0775 | 0775 | yes | HT_přívodní vodní (55 °C) 19 | 0
13111024 | -1.PP_SO-102 | 1741.24 | 0.000356274 | 0.116517 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 2560.65 | 2550 | 2550 | 2539.35 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | -1458 | 0.082054 | 15 | 159 | 1741.24 | ø15 | 21.3 | 16 | TR02.02.0776 | 0776 | no | HT_vratné vodní (45 °C) 13 | 0
13111181 | -1.PP_SO-102 | 646.025 | 0.00141175 | 0.0860528 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 3361.2 | 3340 | 3340 | 3318.8 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | -677.95 | 0.0649455 | 32 | 358 | 646.025 | ø32 | 42.4 | 35.9 | TR02.02.0777 | 0777 | yes | HT_přívodní vodní (55 °C) 19 | 0
13111960 | -1.PP_SO-102 | 2925.08 | 0.000568237 | 0.247195 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 2882.54 | -42.5375 | 2882.54 | -42.5375 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | -4042.54 | 0.183788 | 20 | 551 | 2925.08 | ø20 | 26.9 | 21.6 | TR02.02.0783 | 0783 | yes | HT_vratné vodní (45 °C) 13
13112523 | -1.PP_SO-102 | 736.819 | 0.000356274 | 0.0493049 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3301.11 | 2564.29 | 3301.11 | 2564.29 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | -1435.71 | 0.0347218 | 15 | 159 | 736.819 | ø15 | 21.3 | 16 | TR02.02.0786 | 0786 | no | HT_vratné vodní (45 °C) 13
13112526 | -1.PP_SO-102 | 546.025 | 0.00141175 | 0.0727325 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 3361.2 | 3340 | 3340 | 3318.8 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | -677.95 | 0.0548924 | 32 | 366 | 546.025 | ø32 | 42.4 | 35.9 | TR02.02.0787 | 0787 | yes | HT_vratné vodní (45 °C) 13 | 0
13112563 | -1.PP_SO-102 | 736.819 | 0.000356274 | 0.0493049 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3301.11 | 2564.29 | 3301.11 | 2564.29 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | -1435.71 | 0.0347218 | 15 | 316 | 736.819 | ø15 | 21.3 | 16 | TR02.02.0788 | 0788 | no | HT_přívodní vodní (55 °C) 19
13112566 | -1.PP_SO-102 | 6352 | 0.00141175 | 0.846109 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 3361.2 | 3340 | 3340 | 3318.8 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | -677.95 | 0.638573 | 32 | 356 | 6352 | ø32 | 42.4 | 35.9 | TR02.02.0789 | 0789 | yes | HT_přívodní vodní (55 °C) 19 | 0
13112619 | -1.PP_SO-102 | 736.819 | 0.000356274 | 0.0493049 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3301.11 | 2564.29 | 3301.11 | 2564.29 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | -1435.71 | 0.0347218 | 15 | 306 | 736.819 | ø15 | 21.3 | 16 | TR02.02.0790 | 0790 | yes | HT_přívodní vodní (55 °C) 19
13112622 | -1.PP_SO-102 | 346.582 | 0.000568237 | 0.0292893 | 0 | ø20 mm | 0.00462963 | HD | -1.PP_SO-102 | 3353.45 | 3340 | 3340 | 3326.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | -670.8 | 0.0217764 | 20 | 524 | 346.582 | ø20 | 26.9 | 21.6 | TR02.02.0791 | 0791 | yes | HT_přívodní vodní (55 °C) 19 | 0
13112659 | -1.PP_SO-102 | 736.819 | 0.000356274 | 0.0493049 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3301.11 | 2564.29 | 3301.11 | 2564.29 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | -1435.71 | 0.0347218 | 15 | 139 | 736.819 | ø15 | 21.3 | 16 | TR02.02.0792 | 0792 | yes | HT_vratné vodní (45 °C) 13
13112662 | -1.PP_SO-102 | 6352 | 0.00141175 | 0.846109 | 0 | ø32 mm | 0.00278552 | HD | -1.PP_SO-102 | 3361.2 | 3340 | 3340 | 3318.8 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | -677.95 | 0.638573 | 32 | 369 | 6352 | ø32 | 42.4 | 35.9 | TR02.02.0793 | 0793 | yes | HT_vratné vodní (45 °C) 13 | 0
13113192 | 2.NP_SO-102 | 500.8 | 0.000891835 | 0.0530205 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 2766.85 | 2750 | 2750 | 2733.15 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6736.4 | 0.0393327 | 25 | 625 | 500.8 | ø25 | 33.7 | 27.2 | TR02.02.0799 | 0799 | yes | HT_vratné vodní (45 °C) 1 | 0
13113201 | 2.NP_SO-102 | 2708.37 | 0.000891835 | 0.286739 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 2766.85 | 2750 | 2750 | 2733.15 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6736.4 | 0.212715 | 25 | 830 | 2708.37 | ø25 | 33.7 | 27.2 | TR02.02.0800 | 0800 | yes | HT_vratné vodní (45 °C) 1 | 0
13113210 | 2.NP_SO-102 | 6252.43 | 0.000891835 | 0.661955 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 2766.85 | 2750 | 2750 | 2733.15 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6736.4 | 0.491065 | 25 | 830 | 6252.43 | ø25 | 33.7 | 27.2 | TR02.02.0801 | 0801 | yes | HT_vratné vodní (45 °C) 1 | 0
13113219 | 2.NP_SO-102 | 1416.88 | 0.000891835 | 0.150007 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 3016.85 | 3000 | 3000 | 2983.15 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6986.4 | 0.111281 | 25 | 830 | 1416.88 | ø25 | 33.7 | 27.2 | TR02.02.0802 | 0802 | yes | HT_vratné vodní (45 °C) 1 | 0
13113297 | 2.NP_SO-102 | 601.687 | 0.000891835 | 0.0637016 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 3166.85 | 3150 | 3150 | 3133.15 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 7136.4 | 0.0472564 | 25 | 29 | 601.687 | ø25 | 33.7 | 27.2 | TR02.02.0803 | 0803 | yes | HT/CL_vratné vodní 1 | 0
13113306 | 2.NP_SO-102 | 2913.81 | 0.000891835 | 0.30849 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 3166.85 | 3150 | 3150 | 3133.15 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 7136.4 | 0.22885 | 25 | 29 | 2913.81 | ø25 | 33.7 | 27.2 | TR02.02.0804 | 0804 | yes | HT/CL_vratné vodní 1 | 0
13113315 | 2.NP_SO-102 | 6252.43 | 0.000891835 | 0.661955 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 3166.85 | 3150 | 3150 | 3133.15 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 7136.4 | 0.491065 | 25 | 29 | 6252.43 | ø25 | 33.7 | 27.2 | TR02.02.0805 | 0805 | yes | HT/CL_vratné vodní 1 | 0
13113324 | 2.NP_SO-102 | 1261.87 | 0.000891835 | 0.133597 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 3166.85 | 3150 | 3150 | 3133.15 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 7136.4 | 0.0991074 | 25 | 29 | 1261.87 | ø25 | 33.7 | 27.2 | TR02.02.0806 | 0806 | yes | HT/CL_vratné vodní 1 | 0
13113400 | 2.NP_SO-102 | 5819.15 | 0.000891835 | 0.616083 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 2666.85 | 2650 | 2650 | 2633.15 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 6636.4 | 0.457035 | 25 | 38 | 5819.15 | ø25 | 33.7 | 27.2 | TR02.02.0807 | 0807 | yes | HT/CL_vratné vodní 1 | 0
13113563 | 2.NP_SO-102 | 152.375 | 0.000891835 | 0.0161322 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 2623.01 | 2470.64 | 2623.01 | 2470.64 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 6470.64 | 0.0119675 | 25 | 34 | 152.375 | ø25 | 33.7 | 27.2 | TR02.02.0808 | 0808 | yes | HT/CL_přívodní vodní 1
13113566 | 2.NP_SO-102 | 3604.38 | 0.000568237 | 0.304602 | 0 | ø20 mm | 0.00462963 | HE | 2.NP_SO-102 | 2663.45 | 2650 | 2650 | 2636.55 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 6639.2 | 0.22647 | 20 | 45 | 3604.38 | ø20 | 26.9 | 21.6 | TR02.02.0809 | 0809 | yes | HT/CL_přívodní vodní 1 | 0
13113602 | 2.NP_SO-102 | 337.837 | 0.000891835 | 0.0357674 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 2466.85 | 2450 | 2450 | 2433.15 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6436.4 | 0.0265337 | 25 | 630 | 337.837 | ø25 | 33.7 | 27.2 | TR02.02.0810 | 0810 | yes | HT_vratné vodní (45 °C) 1 | 0
13113678 | 2.NP_SO-102 | 247.837 | 0.000891835 | 0.026239 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 2723.92 | 2476.08 | 2723.92 | 2476.08 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6476.08 | 0.0194651 | 25 | 628 | 247.837 | ø25 | 33.7 | 27.2 | TR02.02.0811 | 0811 | yes | HT_vratné vodní (45 °C) 1
13113711 | 2.NP_SO-102 | 127.337 | 0.000891835 | 0.0134814 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 2603.42 | 2476.08 | 2603.42 | 2476.08 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6476.08 | 0.0100011 | 25 | 632 | 127.337 | ø25 | 33.7 | 27.2 | TR02.02.0812 | 0812 | yes | HT_vratné vodní (45 °C) 1
13113714 | 2.NP_SO-102 | 4285.6 | 0.00183197 | 0.650292 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2674.15 | 2650 | 2650 | 2625.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6629.1 | 0.538544 | 40 | 48 | 4285.6 | ø40 | 48.3 | 41.8 | TR02.02.0813 | 0813 | yes | HT_vratné vodní (45 °C) 1 | 0
13113749 | 2.NP_SO-102 | 127.337 | 0.000891835 | 0.0134814 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 2603.42 | 2476.08 | 2603.42 | 2476.08 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6476.08 | 0.0100011 | 25 | 465 | 127.337 | ø25 | 33.7 | 27.2 | TR02.02.0814 | 0814 | yes | HT_přívodní vodní (55 °C) 9
13113752 | 2.NP_SO-102 | 4515.6 | 0.00183197 | 0.685192 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2674.15 | 2650 | 2650 | 2625.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6629.1 | 0.567447 | 40 | 77 | 4515.6 | ø40 | 48.3 | 41.8 | TR02.02.0815 | 0815 | yes | HT_přívodní vodní (55 °C) 9 | 0
13113787 | 2.NP_SO-102 | 452.375 | 0.000891835 | 0.0478937 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 3129.36 | 3129.36 | 2676.99 | 2676.99 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 6676.99 | 0.0355294 | 25 | 29 | 452.375 | ø25 | 33.7 | 27.2 | TR02.02.0816 | 0816 | yes | HT/CL_vratné vodní 1
13113790 | 2.NP_SO-102 | 3404.38 | 0.000568237 | 0.2877 | 0 | ø20 mm | 0.00462963 | HE | 2.NP_SO-102 | 2663.45 | 2650 | 2650 | 2636.55 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 6639.2 | 0.213903 | 20 | 36 | 3404.38 | ø20 | 26.9 | 21.6 | TR02.02.0817 | 0817 | yes | HT/CL_vratné vodní 1 | 0
13114615 | 2.NP_SO-102 | 382.538 | 0.000568237 | 0.0323278 | 0 | ø20 mm | 0.00462963 | HE | 2.NP_SO-102 | 2663.45 | 2650 | 2650 | 2636.55 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 6639.2 | 0.0240355 | 20 | 36 | 382.538 | ø20 | 26.9 | 21.6 | TR02.02.0818 | 0818 | yes | HT/CL_vratné vodní 1 | 0
13115567 | 2.NP_SO-102 | 2649.13 | 0.000356274 | 0.177269 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 2603.42 | 2603.42 | -45.7125 | -45.7125 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3954.29 | 0.124837 | 15 | 16 | 2649.13 | ø15 | 21.3 | 16 | TR02.02.0842 | 0842 | no | HT_vratné vodní (45 °C) 1
13115628 | 2.NP_SO-102 | 2639.13 | 0.000356274 | 0.1766 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 2603.42 | 2603.42 | -35.7125 | -35.7125 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 3964.29 | 0.124366 | 15 | 45 | 2639.13 | ø15 | 21.3 | 16 | TR02.02.0844 | 0844 | no | HT_přívodní vodní (55 °C) 9
13116018 | 2.NP_SO-102 | 1449.53 | 0.00183197 | 0.21995 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2674.15 | 2650 | 2650 | 2625.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6629.1 | 0.182153 | 40 | 78 | 1449.53 | ø40 | 48.3 | 41.8 | TR02.02.0847 | 0847 | yes | HT_přívodní vodní (55 °C) 9 | 0
13116055 | 2.NP_SO-102 | 1449.53 | 0.00183197 | 0.21995 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2674.15 | 2650 | 2650 | 2625.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6629.1 | 0.182153 | 40 | 44 | 1449.53 | ø40 | 48.3 | 41.8 | TR02.02.0848 | 0848 | yes | HT_vratné vodní (45 °C) 1 | 0
13116853 | 2.NP_SO-102 | 4808.73 | 0.000891835 | 0.509108 | 0 | ø25 mm | 0.00367647 | HE | 2.NP_SO-102 | 7979.36 | 7979.36 | 3170.64 | 3170.64 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 7170.64 | 0.377676 | 25 | 29 | 4808.73 | ø25 | 33.7 | 27.2 | TR02.02.0851 | 0851 | yes | HT/CL_vratné vodní 1
13116864 | 2.NP_SO-102 | 896.281 | 0.000891835 | 0.0948908 | 0 | ø25 mm | 0.00367647 | HD | 2.NP_SO-102 | 3916.92 | 3916.92 | 3020.64 | 3020.64 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7020.64 | 0.0703938 | 25 | 830 | 896.281 | ø25 | 33.7 | 27.2 | TR02.02.0852 | 0852 | yes | HT_vratné vodní (45 °C) 1
13117707 | 3.NP_SO-102 | 3954.36 | 0.000356274 | 0.264609 | 0 | ø15 mm | 0.00625 | HD | 3.NP_SO-102 | 3929.27 | -25.0873 | 3929.27 | -25.0873 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7974.91 | 0.186345 | 15 | 735 | 3954.36 | ø15 | 21.3 | 16 | TR02.02.0861 | 0861 | no | HT_vratné vodní (45 °C) 1
13117803 | 4.NP_SO-102 | 319.363 | 0.000891835 | 0.0338114 | 0 | ø25 mm | 0.00367647 | HE | 4.NP_SO-102 | 16.85 | 0 | 0 | -16.85 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 11986.4 | 0.0250827 | 25 | 29 | 319.363 | ø25 | 33.7 | 27.2 | TR02.02.0863 | 0863 | yes | HT/CL_vratné vodní 1 | 0
13118262 | 1.NP_SO-102 | 6667.25 | 0.000568237 | 0.563442 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 6632.54 | -34.7125 | 6632.54 | -34.7125 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -34.7125 | 0.418916 | 20 | 821 | 6667.25 | ø20 | 26.9 | 21.6 | TR02.02.0864 | 0864 | yes | HT_vratné vodní (45 °C) 1
13118285 | 2.NP_SO-102 | 796.702 | 0.00183197 | 0.120891 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2674.15 | 2650 | 2650 | 2625.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6629.1 | 0.100117 | 40 | 48 | 796.702 | ø40 | 48.3 | 41.8 | TR02.02.0865 | 0865 | yes | HT_vratné vodní (45 °C) 1 | 0
13119318 | 1.NP_SO-102 | 3949.54 | 0.000356274 | 0.264287 | 0 | ø15 mm | 0.00625 | HD | 1.NP_SO-102 | 3914.77 | 3914.77 | -34.7688 | -34.7688 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 32 | -34.7688 | 0.186118 | 15 | 23 | 3949.54 | ø15 | 21.3 | 16 | TR02.02.0879 | 0879 | no | HT_vratné vodní (45 °C) 32
13120279 | -1.PP_SO-102 | 3971.43 | 0.000356274 | 0.265752 | 0 | ø15 mm | 0.00625 | HD | -1.PP_SO-102 | 3935.71 | -35.7125 | 3935.71 | -35.7125 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 28 | -4035.71 | 0.187149 | 15 | 13 | 3971.43 | ø15 | 21.3 | 16 | TR02.02.0889 | 0889 | no | HT_vratné vodní (45 °C) 28
13122275 | 2.NP_SO-102 | 391.425 | 0.000356274 | 0.0261926 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 2860.65 | 2850 | 2850 | 2839.35 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6842 | 0.0184455 | 15 | 558 | 391.425 | ø15 | 21.3 | 16 | TR02.02.0917 | 0917 | yes | HT_přívodní vodní (55 °C) 9 | 0
13122326 | 2.NP_SO-102 | 2871.42 | 0.000356274 | 0.192144 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 2835.71 | -35.7125 | 2835.71 | -35.7125 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 3964.29 | 0.135313 | 15 | 558 | 2871.42 | ø15 | 21.3 | 16 | TR02.02.0919 | 0919 | yes | HT_přívodní vodní (55 °C) 9
13122351 | 2.NP_SO-102 | 391.425 | 0.000356274 | 0.0261926 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 2860.65 | 2850 | 2850 | 2839.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6842 | 0.0184455 | 15 | 822 | 391.425 | ø15 | 21.3 | 16 | TR02.02.0920 | 0920 | yes | HT_vratné vodní (45 °C) 1 | 0
13122419 | 2.NP_SO-102 | 2881.43 | 0.000356274 | 0.192813 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 2835.71 | 2835.71 | -45.7125 | -45.7125 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3954.29 | 0.135784 | 15 | 822 | 2881.43 | ø15 | 21.3 | 16 | TR02.02.0922 | 0922 | yes | HT_vratné vodní (45 °C) 1
13122546 | 2.NP_SO-102 | 904.131 | 0.000356274 | 0.0605008 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 3935.71 | 3935.71 | 3031.58 | 3031.58 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 7031.58 | 0.0426062 | 15 | 7 | 904.131 | ø15 | 21.3 | 16 | TR02.02.0924 | 0924 | no | HT_přívodní vodní (55 °C) 12
13122778 | 2.NP_SO-102 | 901.581 | 0.000356274 | 0.0603301 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 3935.71 | 3935.71 | 3034.13 | 3034.13 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 7034.13 | 0.042486 | 15 | 17 | 901.581 | ø15 | 21.3 | 16 | TR02.02.0925 | 0925 | no | HT_vratné vodní (45 °C) 9
13122938 | 2.NP_SO-102 | 3245.24 | 0.00141175 | 0.432277 | 0 | ø32 mm | 0.00278552 | HC | 2.NP_SO-102 | 7346.98 | 7346.98 | 4101.74 | 4101.74 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 8101.74 | 0.326247 | 32 | 53 | 3245.24 | ø32 | 42.4 | 35.9 | TR02.02.0926 | 0926 | yes | CL_přívodní vodní (10 °C) 1
13123571 | 1.NP_SO-102 | 560.904 | 0.00141175 | 0.0747144 | 0 | ø32 mm | 0.00278552 | HD | 1.NP_SO-102 | 3301.2 | 3280 | 3280 | 3258.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3262.05 | 0.0563882 | 32 | 435 | 560.904 | ø32 | 42.4 | 35.9 | TR02.02.0927 | 0927 | yes | HT_vratné vodní (45 °C) 1 | 0
13123637 | 1.NP_SO-102 | 2088.99 | 0.000568237 | 0.176538 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3269.2 | 0.131255 | 20 | 434 | 2088.99 | ø20 | 26.9 | 21.6 | TR02.02.0928 | 0928 | yes | HT_vratné vodní (45 °C) 1 | 0
13123647 | 1.NP_SO-102 | 3813.32 | 0.00183197 | 0.57863 | 40 | ø120 mm | 0.00239234 | HD | 1.NP_SO-102 | 7126.66 | 3313.34 | 7126.66 | 3313.34 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3313.34 | 0.479197 | 40 | 361 | 3813.32 | ø40 | 48.3 | 41.8 | TR02.02.0929 | 0929 | yes | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13123677 | 1.NP_SO-102 | 3285.17 | 0.000356274 | 0.21983 | 0 | ø15 mm | 0.00625 | HD | 1.NP_SO-102 | 3241.11 | -44.0625 | 3241.11 | -44.0625 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -44.0625 | 0.15481 | 15 | 437 | 3285.17 | ø15 | 21.3 | 16 | TR02.02.0930 | 0930 | no | HT_vratné vodní (45 °C) 1
13123705 | 1.NP_SO-102 | 202.315 | 0.00141175 | 0.0269491 | 0 | ø32 mm | 0.00278552 | HD | 1.NP_SO-102 | 3301.2 | 3280 | 3280 | 3258.8 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3262.05 | 0.0203389 | 32 | 432 | 202.315 | ø32 | 42.4 | 35.9 | TR02.02.0931 | 0931 | yes | HT_vratné vodní (45 °C) 1 | 0
13125370 | 2.NP_SO-102 | 6215.69 | 0.000356274 | 0.415928 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 3110.65 | 3100 | 3100 | 3089.35 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 7092 | 0.292907 | 15 | 37 | 6215.69 | ø15 | 21.3 | 16 | TR02.02.0936 | 0936 | yes | HT_přívodní vodní (55 °C) 12 | 0
13126120 | 2.NP_SO-102 | 30.0675 | 0.00183197 | 0.00456241 | 40 | ø120 mm | 0.00239234 | HD | 2.NP_SO-102 | 3324.15 | 3300 | 3300 | 3275.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 11 | 7279.1 | 0.00377839 | 40 | 1 | 30.0675 | ø40 | 48.3 | 41.8 | TR02.02.0939 | 0939 | yes | HT_přívodní vodní (55 °C) 11 | 0 | Izolace - Typ izolace: Tepelná
13127761 | 2.NP_SO-102 | 1793.14 | 0.00183197 | 0.272089 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2074.15 | 2050 | 2050 | 2025.85 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 6029.1 | 0.225332 | 40 | 38 | 1793.14 | ø40 | 48.3 | 41.8 | TR02.02.0945 | 0945 | yes | HT_přívodní vodní (55 °C) 12 | 0
13127950 | 2.NP_SO-102 | 1815.03 | 0.00183197 | 0.275411 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 2074.15 | 2050 | 2050 | 2025.85 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 6029.1 | 0.228083 | 40 | 151 | 1815.03 | ø40 | 48.3 | 41.8 | TR02.02.0946 | 0946 | yes | HT_vratné vodní (45 °C) 9 | 0
13128829 | 2.NP_SO-102 | 3486.36 | 0.000356274 | 0.233293 | 0 | ø15 mm | 0.00625 | HD | 2.NP_SO-102 | 2540.65 | 2530 | 2530 | 2519.35 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 6522 | 0.164291 | 15 | 129 | 3486.36 | ø15 | 21.3 | 16 | TR02.02.0953 | 0953 | yes | HT_vratné vodní (45 °C) 9 | 0
13130020 | 2.NP_SO-102 | 3225.08 | 0.000568237 | 0.272547 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3182.54 | -42.5375 | 3182.54 | -42.5375 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3957.46 | 0.202637 | 20 | 555 | 3225.08 | ø20 | 26.9 | 21.6 | TR02.02.0960 | 0960 | yes | HT_vratné vodní (45 °C) 1
13130053 | 2.NP_SO-102 | 3295.07 | 0.000568237 | 0.278463 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3262.54 | -32.5375 | 3262.54 | -32.5375 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 14 | 3967.46 | 0.207036 | 20 | 1 | 3295.07 | ø20 | 26.9 | 21.6 | TR02.02.0961 | 0961 | yes | HT_přívodní vodní (55 °C) 14
13130197 | 2.NP_SO-102 | 2509.69 | 0.000568237 | 0.212091 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6789.2 | 0.157689 | 20 | 514 | 2509.69 | ø20 | 26.9 | 21.6 | TR02.02.0963 | 0963 | yes | HT_přívodní vodní (55 °C) 9 | 0
13130205 | 2.NP_SO-102 | 740.075 | 0.000568237 | 0.0625429 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6789.2 | 0.0465003 | 20 | 514 | 740.075 | ø20 | 26.9 | 21.6 | TR02.02.0964 | 0964 | yes | HT_přívodní vodní (55 °C) 9 | 0
13130346 | 2.NP_SO-102 | 540.075 | 0.000568237 | 0.0456411 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2813.45 | 2800 | 2800 | 2786.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6789.2 | 0.0339339 | 20 | 683 | 540.075 | ø20 | 26.9 | 21.6 | TR02.02.0967 | 0967 | yes | HT_vratné vodní (45 °C) 1 | 0
13130841 | 2.NP_SO-102 | 2433.58 | 0.000568237 | 0.205659 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3273.45 | 3260 | 3260 | 3246.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7249.2 | 0.152907 | 20 | 281 | 2433.58 | ø20 | 26.9 | 21.6 | TR02.02.0971 | 0971 | yes | HT_přívodní vodní (55 °C) 9 | 0
13130972 | 2.NP_SO-102 | 2433.58 | 0.000568237 | 0.205659 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3273.45 | 3260 | 3260 | 3246.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7249.2 | 0.152907 | 20 | 300 | 2433.58 | ø20 | 26.9 | 21.6 | TR02.02.0973 | 0973 | yes | HT_vratné vodní (45 °C) 1 | 0
13131969 | 1.NP_SO-102 | 2925.08 | 0.000568237 | 0.247195 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 2882.54 | 2882.54 | -42.5375 | -42.5375 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -42.5375 | 0.183788 | 20 | 247 | 2925.08 | ø20 | 26.9 | 21.6 | TR02.02.0977 | 0977 | yes | HT_vratné vodní (45 °C) 1
13132486 | 1.NP_SO-102 | 3301.04 | 0.000568237 | 0.278967 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3262.54 | 3262.54 | -38.5063 | -38.5063 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | -38.5063 | 0.207411 | 20 | 594 | 3301.04 | ø20 | 26.9 | 21.6 | TR02.02.0981 | 0981 | yes | HT_vratné vodní (45 °C) 1
13132531 | 1.NP_SO-102 | 3291.04 | 0.000568237 | 0.278122 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3262.54 | 3262.54 | -28.5062 | -28.5062 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 16 | -28.5062 | 0.206782 | 20 | 1 | 3291.04 | ø20 | 26.9 | 21.6 | TR02.02.0982 | 0982 | yes | HT_přívodní vodní (55 °C) 16
13132828 | 1.NP_SO-102 | 325.075 | 0.000568237 | 0.0274717 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 3189.2 | 0.0204251 | 20 | 375 | 325.075 | ø20 | 26.9 | 21.6 | TR02.02.0983 | 0983 | yes | HT_přívodní vodní (55 °C) 19 | 0
13132931 | 1.NP_SO-102 | 175.075 | 0.000568237 | 0.0147954 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 3189.2 | 0.0110003 | 20 | 388 | 175.075 | ø20 | 26.9 | 21.6 | TR02.02.0984 | 0984 | yes | HT_vratné vodní (45 °C) 13 | 0
13133212 | 1.NP_SO-102 | 3211.04 | 0.000568237 | 0.271362 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3182.54 | -28.5063 | 3182.54 | -28.5063 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | -28.5063 | 0.201756 | 20 | 375 | 3211.04 | ø20 | 26.9 | 21.6 | TR02.02.0987 | 0987 | yes | HT_přívodní vodní (55 °C) 19
13133449 | 1.NP_SO-102 | 3221.04 | 0.000568237 | 0.272207 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3182.54 | 3182.54 | -38.5063 | -38.5063 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | -38.5063 | 0.202384 | 20 | 388 | 3221.04 | ø20 | 26.9 | 21.6 | TR02.02.0988 | 0988 | yes | HT_vratné vodní (45 °C) 13
13133823 | 1.NP_SO-102 | 262.125 | 0.000568237 | 0.0221519 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 3189.2 | 0.0164698 | 20 | 360 | 262.125 | ø20 | 26.9 | 21.6 | TR02.02.0996 | 0996 | yes | HT_přívodní vodní (55 °C) 19 | 0
13133862 | 1.NP_SO-102 | 871.319 | 0.000568237 | 0.0736342 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | -36.55 | -50 | -50 | -63.45 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | -60.8 | 0.0547466 | 20 | 360 | 871.319 | ø20 | 26.9 | 21.6 | TR02.02.0998 | 0998 | no | HT_přívodní vodní (55 °C) 19 | 0
13133932 | 1.NP_SO-102 | 1021.32 | 0.000568237 | 0.0863105 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | -46.55 | -60 | -60 | -73.45 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | -70.8 | 0.0641714 | 20 | 374 | 1021.32 | ø20 | 26.9 | 21.6 | TR02.02.0999 | 0999 | no | HT_vratné vodní (45 °C) 13 | 0
13134006 | 1.NP_SO-102 | 112.125 | 0.000568237 | 0.00947555 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3213.45 | 3200 | 3200 | 3186.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 3189.2 | 0.00704502 | 20 | 374 | 112.125 | ø20 | 26.9 | 21.6 | TR02.02.1000 | 1000 | yes | HT_vratné vodní (45 °C) 13 | 0
13134152 | 1.NP_SO-102 | 3212.13 | 0.000568237 | 0.271453 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3181.06 | 3181.06 | -31.0625 | -31.0625 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | -31.0625 | 0.201824 | 20 | 360 | 3212.13 | ø20 | 26.9 | 21.6 | TR02.02.1001 | 1001 | yes | HT_přívodní vodní (55 °C) 19
13134189 | 1.NP_SO-102 | 3222.12 | 0.000568237 | 0.272298 | 0 | ø20 mm | 0.00462963 | HD | 1.NP_SO-102 | 3181.06 | 3181.06 | -41.0625 | -41.0625 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | -41.0625 | 0.202452 | 20 | 374 | 3222.12 | ø20 | 26.9 | 21.6 | TR02.02.1002 | 1002 | yes | HT_vratné vodní (45 °C) 13
13134300 | 2.NP_SO-102 | 455.075 | 0.000568237 | 0.0384579 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3263.45 | 3250 | 3250 | 3236.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7239.2 | 0.0285932 | 20 | 381 | 455.075 | ø20 | 26.9 | 21.6 | TR02.02.1005 | 1005 | yes | HT_přívodní vodní (55 °C) 19 | 0
13134506 | 2.NP_SO-102 | 305.075 | 0.000568237 | 0.0257815 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3263.45 | 3250 | 3250 | 3236.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7239.2 | 0.0191684 | 20 | 392 | 305.075 | ø20 | 26.9 | 21.6 | TR02.02.1010 | 1010 | yes | HT_vratné vodní (45 °C) 13 | 0
13134633 | 2.NP_SO-102 | 3261.04 | 0.000568237 | 0.275587 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3232.54 | -28.5062 | 3232.54 | -28.5062 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 3971.49 | 0.204897 | 20 | 381 | 3261.04 | ø20 | 26.9 | 21.6 | TR02.02.1011 | 1011 | yes | HT_přívodní vodní (55 °C) 19
13134678 | 2.NP_SO-102 | 3271.04 | 0.000568237 | 0.276432 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3232.54 | -38.5063 | 3232.54 | -38.5063 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 3961.49 | 0.205526 | 20 | 392 | 3271.04 | ø20 | 26.9 | 21.6 | TR02.02.1012 | 1012 | yes | HT_vratné vodní (45 °C) 13
13135328 | 2.NP_SO-102 | 6674.4 | 0.000568237 | 0.564045 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3263.45 | 3250 | 3250 | 3236.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7239.2 | 0.419365 | 20 | 392 | 6674.4 | ø20 | 26.9 | 21.6 | TR02.02.1013 | 1013 | yes | HT_vratné vodní (45 °C) 13 | 0
13135538 | 1.NP_SO-102 | 3803.96 | 0.00183197 | 0.577208 | 0 | ø40 mm | 0.00239234 | HD | 1.NP_SO-102 | 7037.29 | 3233.34 | 7037.29 | 3233.34 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 3233.34 | 0.478019 | 40 | 39 | 3803.96 | ø40 | 48.3 | 41.8 | TR02.02.1014 | 1014 | yes | HT_vratné vodní (45 °C) 13
13135550 | 2.NP_SO-102 | 3733.32 | 0.00183197 | 0.566491 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 7016.66 | 3283.34 | 7016.66 | 3283.34 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7283.34 | 0.469143 | 40 | 33 | 3733.32 | ø40 | 48.3 | 41.8 | TR02.02.1015 | 1015 | yes | HT_vratné vodní (45 °C) 13
13136137 | 2.NP_SO-102 | 245.075 | 0.000568237 | 0.020711 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3082.54 | 2837.46 | 3082.54 | 2837.46 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 6837.46 | 0.0153985 | 20 | 388 | 245.075 | ø20 | 26.9 | 21.6 | TR02.02.1018 | 1018 | yes | HT_přívodní vodní (55 °C) 19
13136218 | 2.NP_SO-102 | 53.9563 | 0.00183197 | 0.00818726 | 0 | ø40 mm | 0.00239234 | HD | 2.NP_SO-102 | 3216.66 | 3162.71 | 3216.66 | 3162.71 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 7162.71 | 0.00678034 | 40 | 339 | 53.9563 | ø40 | 48.3 | 41.8 | TR02.02.1019 | 1019 | yes | HT_vratné vodní (45 °C) 13
13136315 | 2.NP_SO-102 | 245.075 | 0.000568237 | 0.020711 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3082.54 | 2837.46 | 3082.54 | 2837.46 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 6837.46 | 0.0153985 | 20 | 409 | 245.075 | ø20 | 26.9 | 21.6 | TR02.02.1021 | 1021 | yes | HT_vratné vodní (45 °C) 13
13136430 | 2.NP_SO-102 | 365.075 | 0.000568237 | 0.0308521 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2833.45 | 2820 | 2820 | 2806.55 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 6809.2 | 0.0229383 | 20 | 388 | 365.075 | ø20 | 26.9 | 21.6 | TR02.02.1023 | 1023 | no | HT_přívodní vodní (55 °C) 19 | 0
13136522 | 2.NP_SO-102 | 615.075 | 0.000568237 | 0.0519793 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2833.45 | 2820 | 2820 | 2806.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 6809.2 | 0.0386463 | 20 | 409 | 615.075 | ø20 | 26.9 | 21.6 | TR02.02.1025 | 1025 | no | HT_vratné vodní (45 °C) 13 | 0
13136719 | 2.NP_SO-102 | 2831.04 | 0.000568237 | 0.239248 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2802.54 | 2802.54 | -28.5062 | -28.5062 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 3971.49 | 0.17788 | 20 | 388 | 2831.04 | ø20 | 26.9 | 21.6 | TR02.02.1028 | 1028 | no | HT_přívodní vodní (55 °C) 19
13136756 | 2.NP_SO-102 | 2841.04 | 0.000568237 | 0.240093 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2802.54 | 2802.54 | -38.5062 | -38.5063 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 3961.49 | 0.178508 | 20 | 409 | 2841.04 | ø20 | 26.9 | 21.6 | TR02.02.1029 | 1029 | no | HT_vratné vodní (45 °C) 13
13137450 | 2.NP_SO-102 | 2821.04 | 0.000568237 | 0.238403 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2782.54 | -38.5063 | 2782.54 | -38.5063 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3961.49 | 0.177251 | 20 | 683 | 2821.04 | ø20 | 26.9 | 21.6 | TR02.02.1032 | 1032 | yes | HT_vratné vodní (45 °C) 1
13137521 | 2.NP_SO-102 | 2811.04 | 0.000568237 | 0.237558 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 2782.54 | -28.5062 | 2782.54 | -28.5062 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 3971.49 | 0.176623 | 20 | 514 | 2811.04 | ø20 | 26.9 | 21.6 | TR02.02.1033 | 1033 | yes | HT_přívodní vodní (55 °C) 9
13137631 | 2.NP_SO-102 | 210.306 | 0.000568237 | 0.0177727 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3027.77 | 2817.46 | 3027.77 | 2817.46 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 6817.46 | 0.0132139 | 20 | 683 | 210.306 | ø20 | 26.9 | 21.6 | TR02.02.1038 | 1038 | yes | HT_vratné vodní (45 °C) 1
13137704 | 2.NP_SO-102 | 210.306 | 0.000568237 | 0.0177727 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3027.77 | 2817.46 | 3027.77 | 2817.46 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 6817.46 | 0.0132139 | 20 | 514 | 210.306 | ø20 | 26.9 | 21.6 | TR02.02.1040 | 1040 | yes | HT_přívodní vodní (55 °C) 9
13138185 | 2.NP_SO-102 | 1615.08 | 0.000568237 | 0.136488 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3273.45 | 3260 | 3260 | 3246.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7249.2 | 0.101478 | 20 | 281 | 1615.08 | ø20 | 26.9 | 21.6 | TR02.02.1041 | 1041 | yes | HT_přívodní vodní (55 °C) 9 | 0
13138223 | 2.NP_SO-102 | 161.619 | 0.000568237 | 0.0136582 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3273.45 | 3260 | 3260 | 3246.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7249.2 | 0.0101548 | 20 | 281 | 161.619 | ø20 | 26.9 | 21.6 | TR02.02.1042 | 1042 | yes | HT_přívodní vodní (55 °C) 9 | 0
13138367 | 2.NP_SO-102 | 311.619 | 0.000568237 | 0.0263345 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3273.45 | 3260 | 3260 | 3246.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7249.2 | 0.0195796 | 20 | 300 | 311.619 | ø20 | 26.9 | 21.6 | TR02.02.1043 | 1043 | yes | HT_vratné vodní (45 °C) 1 | 0
13138429 | 2.NP_SO-102 | 1600.52 | 0.000568237 | 0.135258 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3273.45 | 3260 | 3260 | 3246.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7249.2 | 0.100563 | 20 | 300 | 1600.52 | ø20 | 26.9 | 21.6 | TR02.02.1044 | 1044 | yes | HT_vratné vodní (45 °C) 1 | 0
13138473 | 2.NP_SO-102 | 3281.04 | 0.000568237 | 0.277277 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3242.54 | 3242.54 | -38.5063 | -38.5063 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 3961.49 | 0.206154 | 20 | 300 | 3281.04 | ø20 | 26.9 | 21.6 | TR02.02.1045 | 1045 | yes | HT_vratné vodní (45 °C) 1
13138510 | 2.NP_SO-102 | 3271.04 | 0.000568237 | 0.276432 | 0 | ø20 mm | 0.00462963 | HD | 2.NP_SO-102 | 3242.54 | 3242.54 | -28.5062 | -28.5062 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 3971.49 | 0.205526 | 20 | 281 | 3271.04 | ø20 | 26.9 | 21.6 | TR02.02.1046 | 1046 | yes | HT_přívodní vodní (55 °C) 9
13139130 | 3.NP_SO-102 | 3028.55 | 0.000568237 | 0.255939 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 11269.2 | 0.190289 | 20 | 519 | 3028.55 | ø20 | 26.9 | 21.6 | TR02.02.1047 | 1047 | yes | HT_přívodní vodní (55 °C) 9; HT_přívodní vodní (65 °C) 26 | 0
13139138 | 3.NP_SO-102 | 585.075 | 0.000568237 | 0.049444 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 17 | 11269.2 | 0.0367613 | 20 | 12 | 585.075 | ø20 | 26.9 | 21.6 | TR02.02.1048 | 1048 | yes | HT_přívodní vodní (55 °C) 17; HT_přívodní vodní (65 °C) 26 | 0
13139183 | 3.NP_SO-102 | 735.075 | 0.000568237 | 0.0621203 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3293.45 | 3280 | 3280 | 3266.55 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 11269.2 | 0.0461861 | 20 | 694 | 735.075 | ø20 | 26.9 | 21.6 | TR02.02.1049 | 1049 | yes | HT_vratné vodní (45 °C) 1 | 0
13139540 | 3.NP_SO-102 | 3301.04 | 0.000568237 | 0.278967 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3262.54 | -38.5063 | 3262.54 | -38.5063 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 7961.49 | 0.207411 | 20 | 694 | 3301.04 | ø20 | 26.9 | 21.6 | TR02.02.1055 | 1055 | yes | HT_vratné vodní (45 °C) 1
13139575 | 3.NP_SO-102 | 3291.04 | 0.000568237 | 0.278122 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 3262.54 | -28.5063 | 3262.54 | -28.5063 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 17 | 7971.49 | 0.206782 | 20 | 12 | 3291.04 | ø20 | 26.9 | 21.6 | TR02.02.1056 | 1056 | yes | HT_přívodní vodní (55 °C) 17
13139906 | 3.NP_SO-102 | 9338.73 | 0.000568237 | 0.789205 | 0 | ø20 mm | 0.00462963 | HD | 3.NP_SO-102 | 2863.45 | 2850 | 2850 | 2836.55 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 10839.2 | 0.586769 | 20 | 443 | 9338.73 | ø20 | 26.9 | 21.6 | TR02.02.1057 | 1057 | yes | HT_vratné vodní (45 °C) 13 | 0
