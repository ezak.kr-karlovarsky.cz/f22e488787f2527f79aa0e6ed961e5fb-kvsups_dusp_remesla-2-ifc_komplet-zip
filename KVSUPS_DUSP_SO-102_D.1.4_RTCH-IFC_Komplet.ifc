Properties of the parts of a building model (IFC4), part 57 of 72

# IfcPipeFitting: M_Spoj T, obecný:Standardní (358)
Name (M_Spoj T, obecný:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Úhel (deg) | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) = Štítek, od středu ke konci (mm) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Úhel tvarovky 1 (sdílený) (deg) = Úhel 1 (deg) | Vnější poloměr tvarovky (mm) | Group
13249051 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT02.02.1121 | 1121 | yes | 90 | 14.2875 | CL_přívodní vodní (10 °C) 4
13249356 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT02.02.1122 | 1122 | yes | 90 | 14.2875 | CL_přívodní vodní (10 °C) 4
13249730 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT02.02.1124 | 1124 | yes | 90 | 14.2875 | CL_vratné vodní (15 °C) 11
13249818 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT02.02.1127 | 1127 | yes | 90 | 14.2875 | CL_vratné vodní (15 °C) 11
13250029 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm-ø25 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 11 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT02.02.1128 | 1128 | yes | 90 | 14.2875 | CL_vratné vodní (15 °C) 11
13250530 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 3000 | Fáze 1 | HT/CL_vratné vodní | Zpětné vedení teplé vody | HT/CL_vratné vodní 1 | 90 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT02.02.1132 | 1132 | yes | 90 | 33.3375 | HT/CL_vratné vodní 1
13250562 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm-ø65 mm | HE | 2.NP_SO-102 | 3000 | Fáze 1 | HT/CL_přívodní vodní | Přívod teplé vody | HT/CL_přívodní vodní 1 | 90 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT02.02.1134 | 1134 | yes | 90 | 33.3375 | HT/CL_přívodní vodní 1
13255710 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.1144 | 1144 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13255727 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.1145 | 1145 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13256719 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.1148 | 1148 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13256738 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.1149 | 1149 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13259734 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.1150 | 1150 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9
13259754 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.1151 | 1151 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13268435 | 1.NP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HC | 1.NP_SO-102 | 2750 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.1166 | 1166 | yes | 90 | 7.9375 | CL_přívodní vodní (10 °C) 9
13268665 | 1.NP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HC | 1.NP_SO-102 | 2750 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.1173 | 1173 | yes | 90 | 7.9375 | CL_vratné vodní (15 °C) 9
13269135 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2820 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.1175 | 1175 | yes | 90 | 7.9375 | CL_vratné vodní (15 °C) 9
13269156 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2750 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.1176 | 1176 | yes | 90 | 7.9375 | CL_přívodní vodní (10 °C) 9
13278380 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2500 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 21 | 90 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT02.02.1186 | 1186 | yes | 90 | 33.3375 | HT_vratné vodní (45 °C) 21; CL_vratné vodní (15 °C) 5
13278412 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2500 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 26 | 90 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT02.02.1189 | 1189 | yes | 90 | 33.3375 | HT_přívodní vodní (55 °C) 26
13278446 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 20 | 90 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT02.02.1192 | 1192 | yes | 90 | 33.3375 | HT_vratné vodní (45 °C) 20; CL_vratné vodní (15 °C) 6
13278485 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm-ø65 mm | HD | 2.NP_SO-102 | 2500 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 13 | 90 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT02.02.1196 | 1196 | yes | 90 | 33.3375 | HT_přívodní vodní (55 °C) 13
13281018 | 2.NP_SO-102 | 0 | ø65 mm-ø65 mm-ø65 mm | HC | 2.NP_SO-102 | 2200 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 90 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT02.02.1204 | 1204 | yes | 90 | 33.3375 | CL_přívodní vodní (10 °C) 4
13283000 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2500 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.1223 | 1223 | yes | 90 | 11.1125 | HT_vratné vodní (45 °C) 26
13283036 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.1225 | 1225 | yes | 90 | 11.1125 | HT_přívodní vodní (55 °C) 25
13294151 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2750 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.1281 | 1281 | yes | 90 | 11.1125 | HT_přívodní vodní (65 °C) 27
13294235 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2650 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.1283 | 1283 | yes | 90 | 11.1125 | HT_vratné vodní (45 °C) 26
13299389 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.1313 | 1313 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13299404 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.1314 | 1314 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13304307 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm-ø80 mm | HC | -1.PP_SO-102 | 3000 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.1318 | 1318 | yes | 90 | 39.6875 | CL_vratné vodní (15 °C) 8
13304505 | -1.PP_SO-102 | 0 | ø80 mm-ø80 mm-ø80 mm | HC | -1.PP_SO-102 | 3000 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.1320 | 1320 | yes | 90 | 39.6875 | CL_přívodní vodní (10 °C) 4
13315791 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 2800 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.1516 | 1516 | yes | 90 | 11.1125 | HT_přívodní vodní (55 °C) 19
13316519 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -60 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.1540 | 1540 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 1
13316544 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 34 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.1542 | 1542 | no | 90 | 9.5875 | HT_přívodní vodní (65 °C) 34
13333595 | 2.NP_SO-102 | 40 | ø120 mm-ø120 mm-ø120 mm | HD | 2.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.1617 | 1617 | yes | 90 | 20.6375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13337953 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2400 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.1652 | 1652 | yes | 90 | 11.1125 | HT_vratné vodní (45 °C) 26
13338014 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2450 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 25 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.1655 | 1655 | yes | 90 | 11.1125 | HT_přívodní vodní (55 °C) 25
13340109 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2820 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.1663 | 1663 | yes | 90 | 7.9375 | CL_vratné vodní (15 °C) 9
13340370 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2750 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.1669 | 1669 | yes | 90 | 7.9375 | CL_přívodní vodní (10 °C) 9
13340641 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2820 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 9 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.1672 | 1672 | yes | 90 | 7.9375 | CL_vratné vodní (15 °C) 9
13340675 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 2750 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 9 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.1675 | 1675 | yes | 90 | 7.9375 | CL_přívodní vodní (10 °C) 9
13342507 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.1682 | 1682 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 9
13343196 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.1683 | 1683 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13343219 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.1684 | 1684 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13343240 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.1685 | 1685 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13343261 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.1686 | 1686 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13344751 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.1691 | 1691 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13346991 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 3100 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.1692 | 1692 | yes | 90 | 7.9375 | CL_vratné vodní (15 °C) 8
13347012 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm-ø15 mm | HC | -1.PP_SO-102 | 3100 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 90 | 7.5 | 15 | 0.0000109205 | 20.6375 | ø15-ø15-ø15 | 6.35 | 15.875 | TT02.02.1693 | 1693 | yes | 90 | 7.9375 | CL_přívodní vodní (10 °C) 4
13347037 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 3100 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.1694 | 1694 | yes | 90 | 11.1125 | HT_vratné vodní (45 °C) 26
13347058 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.1695 | 1695 | yes | 90 | 11.1125 | HT_přívodní vodní (65 °C) 27
13347586 | 4.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | 4.NP_SO-102 | 2920 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.1698 | 1698 | yes | 90 | 11.1125 | HT_vratné vodní (45 °C) 1
13349210 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 2400 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.1706 | 1706 | yes | 90 | 11.1125 | HT_vratné vodní (45 °C) 26
13362100 | 2.NP_SO-102 | 60 | ø200 mm-ø200 mm-ø200 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.1736 | 1736 | yes | 90 | 39.6875 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13362456 | 2.NP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | 2.NP_SO-102 | 3250 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.1739 | 1739 | yes | 90 | 11.1125 | HT_přívodní vodní (55 °C) 9
13372808 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.1754 | 1754 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13372827 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.1755 | 1755 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13373427 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.1756 | 1756 | no | 90 | 9.5875 | HT_přívodní vodní (55 °C) 19
13373503 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -60 | Fáze 2 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 13 | 90 | 8 | 16 | 0.0000169575 | 22.2875 | ø16-ø16-ø16 | 7.67 | 19.175 | TT02.02.1757 | 1757 | no | 90 | 9.5875 | HT_vratné vodní (45 °C) 13
13385840 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 3200 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 90 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT02.02.1765 | 1765 | yes | 90 | 33.3375 | HT_PRIMÁR_vratné 7 | Izolace - Typ izolace: Tepelná
13391644 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.1785 | 1785 | yes | 90 | 39.6875 | HT_vratné vodní (45 °C) 23
13391682 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.1789 | 1789 | yes | 90 | 39.6875 | HT_přívodní vodní (65 °C) 8
13391806 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.1793 | 1793 | yes | 90 | 39.6875 | HT_vratné vodní (45 °C) 23
13391847 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.1796 | 1796 | yes | 90 | 39.6875 | HT_přívodní vodní (65 °C) 8
13395495 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.1815 | 1815 | yes | 90 | 39.6875 | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13395529 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 3100 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 90 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT02.02.1817 | 1817 | yes | 90 | 33.3375 | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13395561 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 90 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT02.02.1820 | 1820 | yes | 90 | 33.3375 | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13395607 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 3100 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.1824 | 1824 | yes | 90 | 39.6875 | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13395629 | 4.NP_SO-102 | 60 | ø200 mm-ø200 mm-ø200 mm | HD | 4.NP_SO-102 | 3000 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 3 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.1825 | 1825 | yes | 90 | 39.6875 | HT_PRIMÁR_vratné 3 | Izolace - Typ izolace: Tepelná
13395671 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 3100 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 3 | 90 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT02.02.1828 | 1828 | yes | 90 | 33.3375 | HT_PRIMÁR_přívodní 3 | Izolace - Typ izolace: Tepelná
13401317 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.1846 | 1846 | yes | 90 | 39.6875 | HT_PRIMÁR_přívodní 4
13401347 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.1849 | 1849 | yes | 90 | 39.6875 | HT_PRIMÁR_přívodní 4
13401377 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.1852 | 1852 | yes | 90 | 39.6875 | HT_PRIMÁR_vratné 7
13401577 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.1855 | 1855 | yes | 90 | 39.6875 | HT_PRIMÁR_vratné 7
13402035 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 4 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.1859 | 1859 | yes | 90 | 39.6875 | HT_PRIMÁR_přívodní 4
13403482 | 4.NP_SO-102 | 0 | ø65 mm-ø65 mm-ø65 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 5 | 90 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT02.02.1884 | 1884 | yes | 90 | 33.3375 | HT_PRIMÁR_vratné 5
13404069 | 4.NP_SO-102 | 0 | ø80 mm-ø80 mm-ø80 mm | HD | 4.NP_SO-102 | 2950 | Fáze 1 | HT_PRIMÁR_vratné | Zpětné vedení teplé vody | HT_PRIMÁR_vratné 7 | 90 | 40 | 80 | 0.000610963 | 52.3875 | ø80-ø80-ø80 | 31.75 | 79.375 | TT02.02.1886 | 1886 | yes | 90 | 39.6875 | HT_PRIMÁR_vratné 7
13408065 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 3000 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 90 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT02.02.1952 | 1952 | yes | 90 | 26.9875 | CL_vratné vodní (15 °C) 8
13408147 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 3000 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 90 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT02.02.1958 | 1958 | yes | 90 | 26.9875 | CL_přívodní vodní (10 °C) 4
13409012 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 1800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.1966 | 1966 | yes | 90 | 17.4625 | HT_přívodní vodní (65 °C) 8
13409031 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 1800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.1968 | 1968 | yes | 90 | 17.4625 | HT_přívodní vodní (65 °C) 8
13409146 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 1800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.1972 | 1972 | yes | 90 | 17.4625 | HT_vratné vodní (45 °C) 23
13409165 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 1800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.1974 | 1974 | yes | 90 | 17.4625 | HT_vratné vodní (45 °C) 23
13409323 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 1800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 8 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.1978 | 1978 | yes | 90 | 17.4625 | HT_přívodní vodní (65 °C) 8
13409351 | -1.PP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HD | -1.PP_SO-102 | 1800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 23 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.1980 | 1980 | yes | 90 | 17.4625 | HT_vratné vodní (45 °C) 23
13419269 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 27 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.2048 | 2048 | yes | 90 | 11.1125 | HT_přívodní vodní (65 °C) 27
13419301 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm-ø20 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 26 | 90 | 10 | 20 | 0.0000240538 | 23.8125 | ø20-ø20-ø20 | 8.89 | 22.225 | TT02.02.2051 | 2051 | yes | 90 | 11.1125 | HT_vratné vodní (45 °C) 26
13419341 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 2800 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 4 | 90 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT02.02.2054 | 2054 | yes | 90 | 26.9875 | CL_přívodní vodní (10 °C) 4
13419379 | -1.PP_SO-102 | 0 | ø50 mm-ø50 mm-ø50 mm | HC | -1.PP_SO-102 | 2800 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 8 | 90 | 25 | 50 | 0.000220005 | 39.6875 | ø50-ø50-ø50 | 21.59 | 53.975 | TT02.02.2058 | 2058 | yes | 90 | 26.9875 | CL_vratné vodní (15 °C) 8
13431261 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HC | 2.NP_SO-102 | 2900 | Fáze 1 | CL_vratné vodní (15 °C) | Zpětné vedení teplé vody | CL_vratné vodní (15 °C) 2 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.2132 | 2132 | yes | 90 | 17.4625 | CL_vratné vodní (15 °C) 2
13431356 | 2.NP_SO-102 | 0 | ø32 mm-ø32 mm-ø32 mm | HC | 2.NP_SO-102 | 2900 | Fáze 1 | CL_přívodní vodní (10 °C) | Přívod teplé vody | CL_přívodní vodní (10 °C) 1 | 90 | 16 | 32 | 0.0000724839 | 30.1625 | ø32-ø32-ø32 | 13.97 | 34.925 | TT02.02.2134 | 2134 | yes | 90 | 17.4625 | CL_přívodní vodní (10 °C) 1
13431594 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm-ø25 mm | HD | 2.NP_SO-102 | 3000 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 90 | 12.5 | 25 | 0.0000441423 | 26.9875 | ø25-ø25-ø25 | 11.43 | 28.575 | TT02.02.2140 | 2140 | no | 90 | 14.2875 | HT_vratné vodní (45 °C) 9
13434281 | 2.NP_SO-102 | 40 | ø120 mm-ø120 mm-ø120 mm | HD | 2.NP_SO-102 | 3200 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 1 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.2151 | 2151 | yes | 90 | 20.6375 | HT_vratné vodní (45 °C) 1 | Izolace - Typ izolace: Tepelná
13445691 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2600 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 12 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.2223 | 2223 | yes | 90 | 20.6375 | HT_přívodní vodní (55 °C) 12
13445714 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2600 | Fáze 1 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 9 | 90 | 20 | 40 | 0.000110376 | 33.3375 | ø40-ø40-ø40 | 16.51 | 41.275 | TT02.02.2224 | 2224 | yes | 90 | 20.6375 | HT_vratné vodní (45 °C) 9
13454040 | 4.NP_SO-102 | 60 | ø185 mm-ø185 mm-ø185 mm | HD | 4.NP_SO-102 | 2800 | Fáze 1 | HT_PRIMÁR_přívodní | Přívod teplé vody | HT_PRIMÁR_přívodní 1 | 90 | 32.5 | 65 | 0.000383404 | 46.0375 | ø65-ø65-ø65 | 26.67 | 66.675 | TT02.02.2293 | 2293 |  | 90 | 33.3375 | HT_PRIMÁR_přívodní 1 | Izolace - Typ izolace: Tepelná

# IfcPipeFitting: M_Uzavření, obecné:Standardní (2)
In: 2.NP_SO-102
Type - Material: 0-128-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Metoda ztrát: Není definováno
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; Kód sestavy: TT05; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 05; Popis sestavy: Záslepka
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Uzavření, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT05 Uniformat (Uniformat)
Qto_PipeFittingBaseQuantities - Length: 39.6875 mm; GrossCrossSectionArea: 0.00494765 m2; NetCrossSectionArea: 0.00494765 m2; OuterSurfaceArea: 0.00989663 m2
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø80 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: H; CCI Komponenta: XMB; CCI Technický systém: HD
Vazby - Podlaží: 2.NP_SO-102; Výška od podlaží: 1559.5 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: no
Kóty - Jmenovitý poloměr: 40 mm; Jmenovitý průměr: 80 mm; Maximální velikost: 80 mm; Minimální velikost: 80 mm; Objem: 0.000196377 m3; Velikost: ø80; Vnější průměr tvarovky: 79.375 mm; Výš.: 39.6875 mm
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 1486833; Rodina: M_Uzavření, obecné; Rodina a typ: M_Uzavření, obecné: Standardní; Vnější poloměr tvarovky: 39.6875 mm
Name (M_Uzavření, obecné:Standardní:...) | Typ systému | Klasifikace systému | Název systému = Group | Kód prvku | Označení
13408448 | HT_vratné vodní (45 °C) | Zpětné vedení teplé vody | HT_vratné vodní (45 °C) 31 | TT05.05.1964 | 1964
13408455 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 28 | TT05.05.1965 | 1965

# IfcPipeSegment: Typy trubek:Kompozit PE-Xa_RAUTITAN flex (676)
Type - Material: 255-128-128
Type - Požární ochrana - Požární odolnost: B2
Type - Identifikační data - ID kategorie: TR; Kód sestavy: TR13; Model: RAUTITAN flex; Název typu: Kompozit PE-Xa_RAUTITAN flex; Označení typu: 03; Popis: PE-Xa/EVAL; Popis sestavy: Cross-Linked Polyethylene (PEX); Výrobce: Rehau
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR13 Uniformat (Uniformat)
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Reynoldsovo číslo: 0; Stav průtoku: Laminární; Třecí faktor: 0; Tření: 0; Doplňkový průtok: 0 m3/s; Průtok: 0 m3/s; Rychlost: 0 m/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: H; CCI Komponenta: WPA; CCI Technický systém: HD
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Mechanické - Typ přípoje: Obecné
Jiné - Rodina: Typy trubek; Id typu: 8027472; Rodina a typ: Typy trubek: Kompozit PE-Xa_RAUTITAN flex; Typ: Kompozit PE-Xa_RAUTITAN flex
Name (Typy trubek:Kompozit PE-Xa_RAUTITAN flex:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Celková velikost | Relativní drsnost | Sklon | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Typ systému | Drsnost (mm) | Klasifikace systému | Materiál | Název systému | Obrátit výšku (mm) | Popis úseku | Průměr (mm) = Vnější průměr (mm) | Řez | Úsek potrubí | Výkaz/typ | Velikost | Vnitřní průměr (mm) | Kód prvku | Označení | Páteřní trasa | Group
13020541 | 2.NP_SO-102 | 630.569 | 0.000201032 | 0.0316959 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 11 | 3944.2 | RAU–PE–Xa | 16 | 4 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0017 | 0017 | no | HT_přívodní vodní (65 °C) 11
13020567 | 2.NP_SO-102 | 377.713 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 11 | 3944.2 | RAU–PE–Xa | 16 | 3 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0018 | 0018 | no | HT_přívodní vodní (65 °C) 11
13020586 | 2.NP_SO-102 | 8116.2 | 0.000201032 | 0.407965 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 11 | 3944.2 | RAU–PE–Xa | 16 | 2 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0019 | 0019 | no | HT_přívodní vodní (65 °C) 11
13020597 | 2.NP_SO-102 | 1294.43 | 0.000201032 | 0.0650652 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 11 | 3944.2 | RAU–PE–Xa | 16 | 1 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0020 | 0020 | no | HT_přívodní vodní (65 °C) 11
13020694 | 2.NP_SO-102 | 384.063 | 0.000201032 | 0.0193051 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 11 | 3944.2 | RAU–PE–Xa | 16 | 2 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0021 | 0021 | no | HT_přívodní vodní (65 °C) 11
13020767 | 2.NP_SO-102 | 4632.42 | 0.000201032 | 0.232851 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 11 | 3944.2 | RAU–PE–Xa | 16 | 6 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0022 | 0022 | no | HT_přívodní vodní (65 °C) 11
13020777 | 2.NP_SO-102 | 2201.13 | 0.000201032 | 0.110641 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 11 | 3944.2 | RAU–PE–Xa | 16 | 1 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0023 | 0023 | no | HT_přívodní vodní (65 °C) 11
13020846 | 2.NP_SO-102 | 384.063 | 0.000201032 | 0.0193051 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 20 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0024 | 0024 | no | HT_přívodní vodní (55 °C) 9
13020863 | 2.NP_SO-102 | 384.063 | 0.000201032 | 0.0193051 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 340 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0025 | 0025 | no | HT_přívodní vodní (55 °C) 9
13020883 | 2.NP_SO-102 | 377.713 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 366 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0026 | 0026 | no | HT_přívodní vodní (55 °C) 9
13020983 | 2.NP_SO-102 | 384.063 | 0.000201032 | 0.0193051 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 14 | 3944.2 | RAU–PE–Xa | 16 | 1 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0027 | 0027 | no | HT_přívodní vodní (65 °C) 14
13021002 | 2.NP_SO-102 | 384.063 | 0.000201032 | 0.0193051 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 14 | 3944.2 | RAU–PE–Xa | 16 | 2 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0028 | 0028 | no | HT_přívodní vodní (65 °C) 14
13021022 | 2.NP_SO-102 | 377.713 | 0.000201032 | 0.0189859 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 14 | 3944.2 | RAU–PE–Xa | 16 | 3 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0029 | 0029 | no | HT_přívodní vodní (65 °C) 14
13021031 | 2.NP_SO-102 | 7249.33 | 0.000201032 | 0.364391 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 14 | 3944.2 | RAU–PE–Xa | 16 | 1 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0030 | 0030 | no | HT_přívodní vodní (65 °C) 14
13021163 | 2.NP_SO-102 | 7486.18 | 0.000201032 | 0.376297 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 14 | 3944.2 | RAU–PE–Xa | 16 | 12 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0032 | 0032 | no | HT_přívodní vodní (65 °C) 14
13021184 | 2.NP_SO-102 | 6365.72 | 0.000201032 | 0.319976 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 14 | 3944.2 | RAU–PE–Xa | 16 | 2 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0033 | 0033 | no | HT_přívodní vodní (65 °C) 14
13023139 | 3.NP_SO-102 | 6471.59 | 0.000201032 | 0.325298 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 17 | 7944.2 | RAU–PE–Xa | 16 | 11 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0040 | 0040 | no | HT_přívodní vodní (55 °C) 17
13023349 | 3.NP_SO-102 | 483.063 | 0.000201032 | 0.0242814 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 13 | 7944.2 | RAU–PE–Xa | 16 | 8 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0041 | 0041 | no | HT_přívodní vodní (65 °C) 13
13023358 | 3.NP_SO-102 | 8120.73 | 0.000201032 | 0.408192 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 13 | 7944.2 | RAU–PE–Xa | 16 | 8 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0042 | 0042 | no | HT_přívodní vodní (65 °C) 13
13023368 | 3.NP_SO-102 | 476.713 | 0.000201032 | 0.0239622 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 13 | 7944.2 | RAU–PE–Xa | 16 | 10 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0043 | 0043 | no | HT_přívodní vodní (65 °C) 13
13023381 | 3.NP_SO-102 | 2308.55 | 0.000201032 | 0.11604 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 7944.2 | RAU–PE–Xa | 16 | 523 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0044 | 0044 | no | HT_přívodní vodní (55 °C) 9
13023395 | 3.NP_SO-102 | 3261 | 0.000201032 | 0.163916 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 7944.2 | RAU–PE–Xa | 16 | 523 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0046 | 0046 | no | HT_přívodní vodní (55 °C) 9
13023430 | 2.NP_SO-102 | 2290.87 | 0.000201032 | 0.115152 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 24 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0047 | 0047 | no | HT_přívodní vodní (55 °C) 9
13023432 | 2.NP_SO-102 | 3261 | 0.000201032 | 0.163916 | ø16 mm | 0.000862069 | 0 | 2.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 3944.2 | RAU–PE–Xa | 16 | 24 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0048 | 0048 | no | HT_přívodní vodní (55 °C) 9
13023678 | 3.NP_SO-102 | 6239.06 | 0.000201032 | 0.313609 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 18 | 7944.2 | RAU–PE–Xa | 16 | 22 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0050 | 0050 | no | HT_přívodní vodní (55 °C) 18
13024072 | 3.NP_SO-102 | 483.063 | 0.000201032 | 0.0242814 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 22 | 7944.2 | RAU–PE–Xa | 16 | 1 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0051 | 0051 | no | HT_přívodní vodní (65 °C) 22
13024089 | 3.NP_SO-102 | 483.063 | 0.000201032 | 0.0242814 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 22 | 7944.2 | RAU–PE–Xa | 16 | 4 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0052 | 0052 | no | HT_přívodní vodní (65 °C) 22
13024106 | 3.NP_SO-102 | 476.712 | 0.000201032 | 0.0239622 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 22 | 7944.2 | RAU–PE–Xa | 16 | 3 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0053 | 0053 | no | HT_přívodní vodní (65 °C) 22
13024115 | 3.NP_SO-102 | 7153.34 | 0.000201032 | 0.359566 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 22 | 7944.2 | RAU–PE–Xa | 16 | 1 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0054 | 0054 | no | HT_přívodní vodní (65 °C) 22
13024628 | 3.NP_SO-102 | 476.713 | 0.000201032 | 0.0239622 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 22 | 7944.2 | RAU–PE–Xa | 16 | 16 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0055 | 0055 | no | HT_přívodní vodní (65 °C) 22
13024821 | 3.NP_SO-102 | 3849.27 | 0.000201032 | 0.193485 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 13 | 7944.2 | RAU–PE–Xa | 16 | 12 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0056 | 0056 | no | HT_přívodní vodní (65 °C) 13
13024893 | 3.NP_SO-102 | 483.063 | 0.000201032 | 0.0242814 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 13 | 7944.2 | RAU–PE–Xa | 16 | 12 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0057 | 0057 | no | HT_přívodní vodní (65 °C) 13
13025031 | 3.NP_SO-102 | 274.992 | 0.000201032 | 0.0138226 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 15 | 7944.2 | RAU–PE–Xa | 16 | 30 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0058 | 0058 | no | HT_přívodní vodní (65 °C) 15
13025167 | 3.NP_SO-102 | 6060.93 | 0.000201032 | 0.304656 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 15 | 7944.2 | RAU–PE–Xa | 16 | 39 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0059 | 0059 | no | HT_přívodní vodní (65 °C) 15
13025176 | 3.NP_SO-102 | 2834.06 | 0.000201032 | 0.142456 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 15 | 7944.2 | RAU–PE–Xa | 16 | 41 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0060 | 0060 | no | HT_přívodní vodní (65 °C) 15
13025203 | 3.NP_SO-102 | 2658.19 | 0.000201032 | 0.133615 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 15 | 7944.2 | RAU–PE–Xa | 16 | 36 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0061 | 0061 | no | HT_přívodní vodní (65 °C) 15
13025209 | 3.NP_SO-102 | 3940.8 | 0.000201032 | 0.198086 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 20 | 7944.2 | RAU–PE–Xa | 16 | 33 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0062 | 0062 | no | HT_přívodní vodní (55 °C) 20
13025274 | 3.NP_SO-102 | 284.063 | 0.000201032 | 0.0142785 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 15 | 7944.2 | RAU–PE–Xa | 16 | 33 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0063 | 0063 | no | HT_přívodní vodní (65 °C) 15
13025287 | 3.NP_SO-102 | 187.088 | 0.000201032 | 0.00940406 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 15 | 7944.2 | RAU–PE–Xa | 16 | 44 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0064 | 0064 | no | HT_přívodní vodní (65 °C) 15
13025296 | 3.NP_SO-102 | 5790.86 | 0.000201032 | 0.29108 | ø16 mm | 0.000862069 | 0 | 3.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 15 | 7944.2 | RAU–PE–Xa | 16 | 41 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0065 | 0065 | no | HT_přívodní vodní (65 °C) 15
13025300 | 4.NP_SO-102 | 2309.9 | 0.000201032 | 0.116108 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 11944.2 | RAU–PE–Xa | 16 | 26 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0066 | 0066 | no | HT_přívodní vodní (55 °C) 9
13025314 | 4.NP_SO-102 | 3261 | 0.000201032 | 0.163916 | ø16 mm | 0.000862069 | 0 | 4.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | 11944.2 | RAU–PE–Xa | 16 | 26 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0068 | 0068 | no | HT_přívodní vodní (55 °C) 9
13025654 | 1.NP_SO-102 | 580.044 | 0.000201032 | 0.0291562 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -55.8 | RAU–PE–Xa | 16 | 407 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0073 | 0073 | no | HT_přívodní vodní (55 °C) 9
13025751 | 1.NP_SO-102 | 341.275 | 0.000201032 | 0.0171544 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 20 | -55.8 | RAU–PE–Xa | 16 | 9 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0075 | 0075 | no | HT_přívodní vodní (65 °C) 20
13025768 | 1.NP_SO-102 | 226.712 | 0.000201032 | 0.0113958 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 20 | -55.8 | RAU–PE–Xa | 16 | 2 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0076 | 0076 | no | HT_přívodní vodní (65 °C) 20
13025978 | 1.NP_SO-102 | 2115.15 | 0.000201032 | 0.106319 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 20 | -55.8 | RAU–PE–Xa | 16 | 9 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0077 | 0077 | no | HT_přívodní vodní (65 °C) 20
13026022 | 1.NP_SO-102 | 233.062 | 0.000201032 | 0.011715 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 20 | -55.8 | RAU–PE–Xa | 16 | 3 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0078 | 0078 | no | HT_přívodní vodní (65 °C) 20
13026031 | 1.NP_SO-102 | 7514.81 | 0.000201032 | 0.377736 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 20 | -55.8 | RAU–PE–Xa | 16 | 3 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0079 | 0079 | no | HT_přívodní vodní (65 °C) 20
13026034 | 1.NP_SO-102 | 424.063 | 0.000201032 | 0.0213157 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 21 | -55.8 | RAU–PE–Xa | 16 | 8 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0080 | 0080 | no | HT_přívodní vodní (65 °C) 21
13026046 | 1.NP_SO-102 | 417.713 | 0.000201032 | 0.0209965 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 21 | -55.8 | RAU–PE–Xa | 16 | 53 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0081 | 0081 | no | HT_přívodní vodní (65 °C) 21
13026175 | 1.NP_SO-102 | 1269.53 | 0.000201032 | 0.0638133 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 20 | -55.8 | RAU–PE–Xa | 16 | 10 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0082 | 0082 | no | HT_přívodní vodní (65 °C) 20
13026185 | 1.NP_SO-102 | 716.962 | 0.000201032 | 0.0360385 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 20 | -55.8 | RAU–PE–Xa | 16 | 12 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0083 | 0083 | no | HT_přívodní vodní (65 °C) 20
13026232 | 1.NP_SO-102 | 153.425 | 0.000201032 | 0.00771198 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 20 | -55.8 | RAU–PE–Xa | 16 | 1 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0084 | 0084 | no | HT_přívodní vodní (65 °C) 20
13026251 | 1.NP_SO-102 | 7627.11 | 0.000201032 | 0.38338 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (55 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (55 °C) 9 | -55.8 | RAU–PE–Xa | 16 | 407 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0085 | 0085 | no | HT_přívodní vodní (55 °C) 9
13026531 | 1.NP_SO-102 | 4205.72 | 0.000201032 | 0.211403 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 21 | -55.8 | RAU–PE–Xa | 16 | 8 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0088 | 0088 | no | HT_přívodní vodní (65 °C) 21
13026585 | 1.NP_SO-102 | 3957.56 | 0.000201032 | 0.198929 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 21 | -55.8 | RAU–PE–Xa | 16 | 39 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0089 | 0089 | no | HT_přívodní vodní (65 °C) 21
13026593 | 1.NP_SO-102 | 417.712 | 0.000201032 | 0.0209965 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 21 | -55.8 | RAU–PE–Xa | 16 | 52 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0090 | 0090 | no | HT_přívodní vodní (65 °C) 21
13026602 | 1.NP_SO-102 | 4374.5 | 0.000201032 | 0.219886 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 21 | -55.8 | RAU–PE–Xa | 16 | 35 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0091 | 0091 | no | HT_přívodní vodní (65 °C) 21
13026605 | 1.NP_SO-102 | 424.063 | 0.000201032 | 0.0213157 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 21 | -55.8 | RAU–PE–Xa | 16 | 39 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0092 | 0092 | no | HT_přívodní vodní (65 °C) 21
13026623 | 1.NP_SO-102 | 664.222 | 0.000201032 | 0.0333874 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 21 | -55.8 | RAU–PE–Xa | 16 | 48 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0093 | 0093 | no | HT_přívodní vodní (65 °C) 21
13026630 | 1.NP_SO-102 | 3861.21 | 0.000201032 | 0.194086 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 21 | -55.8 | RAU–PE–Xa | 16 | 42 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0094 | 0094 | no | HT_přívodní vodní (65 °C) 21
13026901 | 1.NP_SO-102 | 6613.22 | 0.000201032 | 0.332417 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 29 | -55.8 | RAU–PE–Xa | 16 | 31 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0099 | 0099 | no | HT_přívodní vodní (65 °C) 29
13026918 | 1.NP_SO-102 | 274.062 | 0.000201032 | 0.0137759 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 29 | -55.8 | RAU–PE–Xa | 16 | 31 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0100 | 0100 | no | HT_přívodní vodní (65 °C) 29
13026937 | 1.NP_SO-102 | 7865.76 | 0.000201032 | 0.395376 | ø16 mm | 0.000862069 | 0 | 1.NP_SO-102 | -42 | -50 | -50 | -58 | Fáze 1 | HT_přívodní vodní (65 °C) | 0.01 | Přívod teplé vody | RAU–PE–Xa | HT_přívodní vodní (65 °C) 1 | -55.8 | RAU–PE–Xa | 16 | 357 | RAU–PE–Xa - Univerzální trubka RAUTITAN flex | Univerzální trubka RAUTITAN flex | ø16 | 11.6 | TR13.03.0101 | 0101 | no | HT_přívodní vodní (65 °C) 1
