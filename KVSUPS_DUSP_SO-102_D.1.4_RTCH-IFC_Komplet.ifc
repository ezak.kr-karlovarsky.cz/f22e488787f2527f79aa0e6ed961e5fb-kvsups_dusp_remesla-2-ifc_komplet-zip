Properties of the parts of a building model (IFC4), part 44 of 72

# IfcDistributionPort (10261)
Name | FlowDirection | PredefinedType | SystemType | Group
Port_13426601_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13426580_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13426597_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13426580_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13426601_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13426591_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13426593_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13426591_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13426597_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13426726_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13426742_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13426736_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13426742_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13426736_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13426821_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13426744_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13426836_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13426744_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13426840_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13426819_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13426821_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13426819_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13426840_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13426830_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13426832_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13426830_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
Port_13426836_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 39
InPort_13428000_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13426873_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13426891_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13428002_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13428006_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13426891_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13426962_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13426960_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13426960_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13428006_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
Port_13427269_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13427271_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13427269_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13427273_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13427280_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13427282_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13427280_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13427284_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13427560_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13427711_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13427580_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13427672_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13427670_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13427672_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13427670_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13427687_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13427709_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13427711_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13427709_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13427727_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
InPort_13427757_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
OutPort_13427901_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
Port_13427776_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13427861_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13427859_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13427861_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13427859_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
Port_13427877_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 2
InPort_13427901_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
OutPort_13427899_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
InPort_13427899_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
OutPort_13427917_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 6
InPort_13427998_0 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13428000_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
InPort_13428002_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
OutPort_13427998_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 5
Port_13431261_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13438851_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
InPort_13431261_3 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
OutPort_13431430_0 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13431356_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13431357_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13431356_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13438792_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13431357_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13440209_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
InPort_13431459_2 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
OutPort_13431414_0 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 2
InPort_13431414_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
OutPort_13431461_2 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 2
InPort_13431430_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
OutPort_13431459_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13431554_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13431564_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13431554_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13431594_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13431595_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13431594_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13431602_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13431595_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13437944_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13432217_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13432293_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13432232_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13432330_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13432291_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13432293_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13432291_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13432305_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 9
Port_13432328_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13432330_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13432328_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13432342_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13434252_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
OutPort_13434521_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
Port_13434281_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13434282_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13434281_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13434290_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13434293_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13434501_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13434501_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13434604_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13434521_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
OutPort_13434657_1 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
Port_13434579_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13434604_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13434579_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
Port_13434606_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 1
InPort_13434657_2 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
OutPort_13434632_0 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
InPort_13434632_1 | SINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
OutPort_13434659_2 | SOURCE | PIPE | HEATING | HT_přívodní vodní (65 °C) 12
Port_13435597_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13435599_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13435597_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13435601_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
InPort_12857599_7 | SINK | PIPE | HEATING | HT_PRIMÁR_vratné 4
OutPort_13436252_2 | SOURCE | PIPE | HEATING | HT_PRIMÁR_vratné 4
Port_13437944_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13437946_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13437946_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13445715_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13438118_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13438120_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13438257_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13438359_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13438257_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13438259_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13438259_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13445692_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13438261_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13438263_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13438263_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13445671_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13438359_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13438377_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13438367_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13438377_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13438367_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13438401_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13438399_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13438401_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13438399_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13438411_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13438757_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13438843_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13438757_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13438873_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13438792_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13438903_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13438841_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13438843_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13438851_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13438877_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13438861_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13438873_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13438861_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13438877_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13438887_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13438899_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13438887_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13438903_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13440004_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13440006_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13440100_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13440158_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 2
Port_13440178_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13440205_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13440207_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
Port_13440209_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 1
InPort_13444369_0 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13444371_2 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13444453_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13444369_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13444379_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13444381_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13444379_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13444417_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
InPort_13445426_0 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13445645_2 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13445649_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13445426_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13445544_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13445633_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13445544_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13445637_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13445629_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13445631_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13445629_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13445633_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
InPort_13445641_0 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13445643_2 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
InPort_13445645_1 | SINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
OutPort_13445641_1 | SOURCE | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13445671_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13445714_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13445691_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13445692_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13445691_3 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13445761_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13445714_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13445715_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13445714_3 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13445729_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13445729_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13445830_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13445737_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13445826_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13445737_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13445830_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13445761_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13445819_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13445769_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13445815_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13445769_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13445819_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13445811_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13445813_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13445811_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13445815_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 12
Port_13445822_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13445824_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13445822_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13445826_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 9
Port_13446102_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13446169_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13446110_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13446169_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13446110_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13446172_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13446159_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13446161_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13446159_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13446172_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 3
Port_13447036_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447055_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447036_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447120_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447049_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447051_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447049_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447055_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447059_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447130_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447118_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447120_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447118_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447130_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447141_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447156_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447141_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447226_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447150_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447152_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447150_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447156_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447160_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447236_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447224_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447226_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447224_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447236_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447442_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447859_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447459_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447812_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447788_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447816_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447788_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447820_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447799_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447801_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447799_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447820_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447810_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447812_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447810_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447816_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (55 °C) 19
Port_13447835_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447863_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447835_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447867_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447846_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447848_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447846_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447867_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447857_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447859_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447857_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13447863_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 13
Port_13449360_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13449376_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13449360_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13449384_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13449378_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13449384_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13449378_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13449397_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13449386_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13449397_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 8
Port_13449406_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13449416_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13449406_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13449424_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13449418_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13449424_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13449418_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13449437_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13449426_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13449437_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 23
Port_13449655_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13450049_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13449701_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13450090_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13449746_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13450131_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13449776_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13450172_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13450047_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13450049_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13450047_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13450059_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13450088_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13450090_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13450088_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13450100_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13450129_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13450131_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13450129_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13450141_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13450170_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13450172_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13450170_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13450182_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13450245_0 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13450247_2 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13450245_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13450249_1 | SOURCEANDSINK | PIPE | HEATING | CL_přívodní vodní (10 °C) 4
Port_13450254_0 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13450256_2 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13450254_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13450258_1 | SOURCEANDSINK | PIPE | HEATING | CL_vratné vodní (15 °C) 8
Port_13450265_0 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13450267_2 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13450265_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13450269_1 | SOURCEANDSINK | PIPE | HEATING | HT_vratné vodní (45 °C) 26
Port_13450274_0 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13450276_2 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13450274_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13450278_1 | SOURCEANDSINK | PIPE | HEATING | HT_přívodní vodní (65 °C) 27
Port_13450632_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13450636_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13450632_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13450638_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13450633_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13450638_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13450633_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13450643_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13450654_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13450658_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13450654_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13450660_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13450655_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13450660_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13450655_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13450664_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13450906_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13450908_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13450906_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13450912_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 7
Port_13450921_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13450923_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13450921_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13450927_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 4
Port_13453411_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13453436_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13453411_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454119_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13453421_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13453436_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13453421_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13453664_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13453685_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13453695_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13453685_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13453703_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13453697_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13453703_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13453697_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13454183_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13454038_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454040_3 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454038_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454052_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454040_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454072_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454041_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454127_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454041_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454072_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454106_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454123_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454106_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454127_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454117_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454119_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454117_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454123_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454172_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13454187_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13454172_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13454191_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13454181_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13454183_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13454181_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13454187_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13454208_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454210_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454208_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454214_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_přívodní 1
Port_13454240_0 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13454242_2 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13454240_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5
Port_13454252_1 | SOURCEANDSINK | PIPE | HEATING | HT_PRIMÁR_vratné 5

# IfcDistributionSystem: CL_přívodní vodní (10 °C) (9)
PredefinedType: HEATING
Name
CL_přívodní vodní (10 °C) 5
CL_přívodní vodní (10 °C) 6
CL_přívodní vodní (10 °C) 7
CL_přívodní vodní (10 °C) 1
CL_přívodní vodní (10 °C) 4
CL_přívodní vodní (10 °C) 2
CL_přívodní vodní (10 °C) 3
CL_přívodní vodní (10 °C) 12
CL_přívodní vodní (10 °C) 9

# IfcDistributionSystem: CL_vratné vodní (15 °C) (10)
PredefinedType: HEATING
Name
CL_vratné vodní (15 °C) 5
CL_vratné vodní (15 °C) 6
CL_vratné vodní (15 °C) 4
CL_vratné vodní (15 °C) 2
CL_vratné vodní (15 °C) 8
CL_vratné vodní (15 °C) 1
CL_vratné vodní (15 °C) 3
CL_vratné vodní (15 °C) 13
CL_vratné vodní (15 °C) 11
CL_vratné vodní (15 °C) 9

# IfcDistributionSystem: HT/CL_přívodní chladivový, HT/CL_přívodní chladivový 1
PredefinedType: HEATING

# IfcDistributionSystem: HT/CL_přívodní vodní, HT/CL_přívodní vodní 1
PredefinedType: HEATING

# IfcDistributionSystem: HT/CL_vratné chladivový, HT/CL_vratné chladivový 1
PredefinedType: HEATING

# IfcDistributionSystem: HT/CL_vratné vodní, HT/CL_vratné vodní 1
PredefinedType: HEATING

# IfcDistributionSystem: HT_PRIMÁR_přívodní (3)
PredefinedType: HEATING
Name
HT_PRIMÁR_přívodní 1
HT_PRIMÁR_přívodní 4
HT_PRIMÁR_přívodní 3

# IfcDistributionSystem: HT_PRIMÁR_vratné (6)
PredefinedType: HEATING
Name
HT_PRIMÁR_vratné 4
HT_PRIMÁR_vratné 1
HT_PRIMÁR_vratné 7
HT_PRIMÁR_vratné 3
HT_PRIMÁR_vratné 5
HT_PRIMÁR_vratné 6

# IfcDistributionSystem: HT_přívodní vodní (45 °C) (3)
PredefinedType: HEATING
Name
HT_přívodní vodní (45 °C) 3
HT_přívodní vodní (45 °C) 5
HT_přívodní vodní (45 °C) 2

# IfcDistributionSystem: HT_přívodní vodní (55 °C) (25)
PredefinedType: HEATING
Name
HT_přívodní vodní (55 °C) 28
HT_přívodní vodní (55 °C) 25
HT_přívodní vodní (55 °C) 12
HT_přívodní vodní (55 °C) 2
HT_přívodní vodní (55 °C) 9
HT_přívodní vodní (55 °C) 1
HT_přívodní vodní (55 °C) 13
HT_přívodní vodní (55 °C) 26
HT_přívodní vodní (55 °C) 15
HT_přívodní vodní (55 °C) 19
HT_přívodní vodní (55 °C) 8
HT_přívodní vodní (55 °C) 17
HT_přívodní vodní (55 °C) 18
HT_přívodní vodní (55 °C) 20
HT_přívodní vodní (55 °C) 3
HT_přívodní vodní (55 °C) 4
HT_přívodní vodní (55 °C) 5
HT_přívodní vodní (55 °C) 6
HT_přívodní vodní (55 °C) 11
HT_přívodní vodní (55 °C) 14
HT_přívodní vodní (55 °C) 16
HT_přívodní vodní (55 °C) 22
HT_přívodní vodní (55 °C) 21
HT_přívodní vodní (55 °C) 23
HT_přívodní vodní (55 °C) 24

# IfcDistributionSystem: HT_přívodní vodní (65 °C) (36)
PredefinedType: HEATING
Name
HT_přívodní vodní (65 °C) 8
HT_přívodní vodní (65 °C) 5
HT_přívodní vodní (65 °C) 36
HT_přívodní vodní (65 °C) 31
HT_přívodní vodní (65 °C) 32
HT_přívodní vodní (65 °C) 17
HT_přívodní vodní (65 °C) 16
HT_přívodní vodní (65 °C) 24
HT_přívodní vodní (65 °C) 3
HT_přívodní vodní (65 °C) 11
HT_přívodní vodní (65 °C) 14
HT_přívodní vodní (65 °C) 12
HT_přívodní vodní (65 °C) 13
HT_přívodní vodní (65 °C) 22
HT_přívodní vodní (65 °C) 15
HT_přívodní vodní (65 °C) 20
HT_přívodní vodní (65 °C) 21
HT_přívodní vodní (65 °C) 23
HT_přívodní vodní (65 °C) 29
HT_přívodní vodní (65 °C) 1
HT_přívodní vodní (65 °C) 25
HT_přívodní vodní (65 °C) 18
HT_přívodní vodní (65 °C) 2
HT_přívodní vodní (65 °C) 34
HT_přívodní vodní (65 °C) 9
HT_přívodní vodní (65 °C) 4
HT_přívodní vodní (65 °C) 10
HT_přívodní vodní (65 °C) 7
HT_přívodní vodní (65 °C) 6
HT_přívodní vodní (65 °C) 28
HT_přívodní vodní (65 °C) 44
HT_přívodní vodní (65 °C) 26
HT_přívodní vodní (65 °C) 33
HT_přívodní vodní (65 °C) 35
HT_přívodní vodní (65 °C) 40
HT_přívodní vodní (65 °C) 27

# IfcDistributionSystem: HT_přívodní vodní (75 °C), HT_přívodní vodní (75 °C) 1
PredefinedType: HEATING

# IfcDistributionSystem: HT_vratné vodní (45 °C) (23)
PredefinedType: HEATING
Name
HT_vratné vodní (45 °C) 31
HT_vratné vodní (45 °C) 26
HT_vratné vodní (45 °C) 9
HT_vratné vodní (45 °C) 10
HT_vratné vodní (45 °C) 1
HT_vratné vodní (45 °C) 20
HT_vratné vodní (45 °C) 21
HT_vratné vodní (45 °C) 23
HT_vratné vodní (45 °C) 5
HT_vratné vodní (45 °C) 4
HT_vratné vodní (45 °C) 6
HT_vratné vodní (45 °C) 8
HT_vratné vodní (45 °C) 39
HT_vratné vodní (45 °C) 18
HT_vratné vodní (45 °C) 2
HT_vratné vodní (45 °C) 22
HT_vratné vodní (45 °C) 13
HT_vratné vodní (45 °C) 29
HT_vratné vodní (45 °C) 14
HT_vratné vodní (45 °C) 24
HT_vratné vodní (45 °C) 28
HT_vratné vodní (45 °C) 32
HT_vratné vodní (45 °C) 7

# IfcDistributionSystem: HT_vratné vodní (65 °C), HT_vratné vodní (65 °C) 1
PredefinedType: HEATING

# IfcPipeFitting: M_Koleno, obecné:Standardní (1543)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: K; Kód sestavy: TT01; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 01; Popis: Koleno; Popis sestavy: Koleno
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Koleno, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT01 Uniformat (Uniformat)
Text - CCI Funkční systém: H; CCI Komponenta: XMB
Grafika - Použít měřítko poznámky: no
Jiné - Typ: Standardní; Id typu: 3326550; Rodina: M_Koleno, obecné; Rodina a typ: M_Koleno, obecné: Standardní
Name (M_Koleno, obecné:Standardní:...) | In | Tloušťka izolace (mm) | Celková velikost | CCI Technický systém | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Jmenovitý poloměr (mm) | Jmenovitý průměr (mm) = Maximální velikost (mm) = Minimální velikost (mm) | Objem (m3) | Od středu ke konci (mm) | Úhel (deg) = Úhel tvarovky 1 (sdílený) (deg) | Velikost | Velikost značky (mm) | Vnější průměr tvarovky (mm) | Kód prvku | Označení | Páteřní trasa | Střední poloměr (mm) | Vnější poloměr tvarovky (mm) | Group
12978746 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0001 | 0001 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (55 °C) 9
12978750 | 2.NP_SO-102 | 0 | ø80 mm-ø80 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 40 | 80 | 0.000357829 | 46.0375 | 90 | ø80-ø80 | 31.75 | 79.375 | TT01.01.0002 | 0002 | yes | 46.0375 | 39.6875 | HT_přívodní vodní (55 °C) 9
12978877 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 2650 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0003 | 0003 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 9
12978881 | 2.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 2.NP_SO-102 | 3100 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0004 | 0004 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 9
12979432 | -1.PP_SO-102 | 60 | ø152 mm-ø152 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 36 | 16 | 32 | 0.0000358323 | 23.8125 | 90 | ø32-ø32 | 13.97 | 34.925 | TT01.01.0005 | 0005 | yes | 23.8125 | 17.4625 | HT_přívodní vodní (65 °C) 36 | Izolace - Typ izolace: Tepelná
12985797 | -1.PP_SO-102 | 0 | ø40 mm-ø40 mm | HD | -1.PP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 32 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0006 | 0006 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (65 °C) 32 | Mechanické – tok - Tlaková ztráta: 0 Pa
12985831 | -1.PP_SO-102 | 60 | ø170 mm-ø170 mm | HD | -1.PP_SO-102 | 2800 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 31 | 25 | 50 | 0.000119816 | 33.3375 | 90 | ø50-ø50 | 21.59 | 53.975 | TT01.01.0007 | 0007 | yes | 33.3375 | 26.9875 | HT_přívodní vodní (65 °C) 31 | Izolace - Typ izolace: Tepelná
13020651 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 11 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0009 | 0009 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 11
13020702 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 11 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0010 | 0010 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 11
13020874 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0012 | 0012 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13021000 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 14 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0014 | 0014 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 14
13023342 | 3.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 3.NP_SO-102 | 3280 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0016 | 0016 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13023366 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0017 | 0017 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 13
13023401 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0020 | 0020 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13023581 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0021 | 0021 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13024087 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 22 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0023 | 0023 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 22
13024678 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 22 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0025 | 0025 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 22
13024901 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 13 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0026 | 0026 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 13
13025046 | 3.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 3.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 15 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0027 | 0027 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 15
13025516 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 2900 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0030 | 0030 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13025652 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 2900 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0031 | 0031 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13025743 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 2900 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0032 | 0032 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13025747 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0033 | 0033 | no | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13025759 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0034 | 0034 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9 | Mechanické – tok - Tlaková ztráta: 0 Pa
13025917 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 20 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0035 | 0035 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 20
13026110 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 21 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0037 | 0037 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 21
13026164 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 20 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0038 | 0038 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 20
13026580 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 21 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0042 | 0042 | no | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 21 | Mechanické – tok - Tlaková ztráta: 0 Pa
13026613 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 21 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0044 | 0044 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 21
13026711 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 21 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0045 | 0045 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 21 | Mechanické – tok - Tlaková ztráta: 0 Pa
13026724 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 2850 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 21 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0046 | 0046 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 21 | Mechanické – tok - Tlaková ztráta: 0 Pa
13026732 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3070.78 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 21 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0047 | 0047 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 21 | Mechanické – tok - Tlaková ztráta: 0 Pa
13026839 | 1.NP_SO-102 | 0 | ø20 mm-ø20 mm | HD | 1.NP_SO-102 | 3070.78 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 21 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0048 | 0048 | yes | 17.4625 | 11.1125 | HT_přívodní vodní (65 °C) 21 | Mechanické – tok - Tlaková ztráta: 0 Pa
13026953 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 1 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0049 | 0049 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 1
13027811 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0051 | 0051 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13028106 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 3200 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0052 | 0052 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13028110 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 2700 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0053 | 0053 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13028392 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0054 | 0054 | no | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13029354 | 2.NP_SO-102 | 0 | ø25 mm-ø25 mm | HD | 2.NP_SO-102 | 2750 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 12.5 | 25 | 0.0000207886 | 20.6375 | 90 | ø25-ø25 | 11.43 | 28.575 | TT01.01.0055 | 0055 | yes | 20.6375 | 14.2875 | HT_přívodní vodní (55 °C) 9
13030566 | -1.PP_SO-102 | 0 | ø20 mm-ø20 mm | HD | -1.PP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 10 | 20 | 0.0000106411 | 17.4625 | 90 | ø20-ø20 | 8.89 | 22.225 | TT01.01.0056 | 0056 | no | 17.4625 | 11.1125 | HT_přívodní vodní (55 °C) 9
13030664 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0057 | 0057 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13030672 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0058 | 0058 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13030759 | 1.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0060 | 0060 | no | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13030763 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0061 | 0061 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13030886 | -1.PP_SO-102 | 0 | ø16 mm-ø16 mm | HD | -1.PP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0062 | 0062 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13031598 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0063 | 0063 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13031606 | 1.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 1.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0064 | 0064 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13031777 | 1.NP_SO-102 | 0 | ø22 mm-ø22 mm | HD | 1.NP_SO-102 | 3950 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 11 | 22 | 0.0000148067 | 18.9375 | 90 | ø22-ø22 | 10.07 | 25.175 | TT01.01.0065 | 0065 | no | 18.9375 | 12.5875 | HT_přívodní vodní (55 °C) 9
13031945 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0067 | 0067 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13032528 | 2.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 2.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0068 | 0068 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 9
13032960 | 1.NP_SO-102 | 40 | ø95 mm-ø95 mm | HD | 1.NP_SO-102 | 2290 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0070 | 0070 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13032975 | 1.NP_SO-102 | 40 | ø95 mm-ø95 mm | HD | 1.NP_SO-102 | 2290 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0071 | 0071 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9 | Izolace - Typ izolace: Tepelná
13033153 | -1.PP_SO-102 | 0 | ø15 mm-ø15 mm | HD | -1.PP_SO-102 | 2700 | Fáze 1 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 9 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0072 | 0072 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 9
13033822 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 25 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0074 | 0074 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 25
13033854 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 25 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0075 | 0075 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 25
13035548 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 1 | HT_přívodní vodní (65 °C) | Přívod teplé vody | HT_přívodní vodní (65 °C) 34 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0077 | 0077 | no | 15.9375 | 9.5875 | HT_přívodní vodní (65 °C) 34
13036088 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0079 | 0079 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13036775 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0081 | 0081 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13036844 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0083 | 0083 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13037797 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0084 | 0084 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13037799 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0085 | 0085 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13038398 | 4.NP_SO-102 | 0 | ø40 mm-ø40 mm | HD | 4.NP_SO-102 | 3300 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 20 | 40 | 0.0000567196 | 26.9875 | 90 | ø40-ø40 | 16.51 | 41.275 | TT01.01.0088 | 0088 | yes | 26.9875 | 20.6375 | HT_přívodní vodní (55 °C) 19
13038475 | 4.NP_SO-102 | 0 | ø16 mm-ø16 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 8 | 16 | 0.00000722916 | 15.9375 | 90 | ø16-ø16 | 7.67 | 19.175 | TT01.01.0090 | 0090 | no | 15.9375 | 9.5875 | HT_přívodní vodní (55 °C) 19
13039101 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 3300 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0092 | 0092 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 19
13039207 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | 3300 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0094 | 0094 | yes | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 19
13039211 | 4.NP_SO-102 | 0 | ø15 mm-ø15 mm | HD | 4.NP_SO-102 | -50 | Fáze 2 | HT_přívodní vodní (55 °C) | Přívod teplé vody | HT_přívodní vodní (55 °C) 19 | 7.5 | 15 | 0.00000444202 | 14.2875 | 90 | ø15-ø15 | 6.35 | 15.875 | TT01.01.0095 | 0095 | no | 14.2875 | 7.9375 | HT_přívodní vodní (55 °C) 19
