Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0], RevitIdentifiers [VersionGUID: b7aa2472-2532-4000-9078-077286ea89c8, NumberOfSaves: 82], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Vnitřní]
File name: 220055
Time: 2023-10-13T16:48:29
Written by: ODA IFC SDK 22.8
Made in: 22.1.30.34 - Exporter 22.6.0.0 - Alternate UI 22.6.0.0

# IfcProject, 220055
LongName: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; Phase: DUSP

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Identifikační data - EBC_ID projektu: KVSUPS; EBC_ID stavebního objektu: "SO-XXX"; EBC_Zodpovědný projektant: Ing. Michal Pávek; EBC_Zpracovatel části: Energy Benefit Centre a.s.; EBC_Zpracovatel části adresa: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz internet: www.energy-benefit.cz; Název budovy: "NÁZEV STAVEBNÍHO OBJEKTU"; Název organizace: Energy Benefit Centre a.s.; Popis organizace: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz internet: www.energy-benefit.cz; Projektant: Ing. Lukáš Hovorka
Jiné - Adresa projektu: Nám. 17. listopadu 710/12, Karlovy Vary – Rybáře, č. p.: 394/1 až 394/3, 395/1 až 395/5, 396, 397; Číslo projektu: 220055; Datum vydání projektu: 30.05.2023; EBC_Hlavní architekt: prof. Ing. Mgr. akad. arch. Petr Hájek; EBC_Hlavní projektant: Ing. Libor Truhelka; EBC_ID profese: D.1.4; EBC_Nadmořská výška: 389,970; EBC_Název profese: PLYNOVÁ ODBĚRNÁ ZAŘÍZENÍ; EBC_Stavebník adresa: Závodní 353/88, 360 06 Karlovy Vary, IČ: 70891168; EBC_Zástupce hlavního projektanta: Ing. Miroslav Zyma; EBC_Zkratka profese: PLN; Intenzita deště návrhová (l/s/m2): 0.03; Jméno klienta: Karlovarský kraj; Kategorie: Informace o projektu; Název projektu: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; Stav projektu: DUSP; Úhrn srážek/nejhorší měsíc: 84; Úhrn srážek/rok: 729

# IfcBuilding, "NÁZEV STAVEBNÍHO OBJEKTU"
LongName: "NÁZEV STAVEBNÍHO OBJEKTU"
Identifikační data - EBC_ID projektu: KVSUPS; EBC_ID stavebního objektu: "SO-XXX"; EBC_Zodpovědný projektant: Ing. Michal Pávek; EBC_Zpracovatel části: Energy Benefit Centre a.s.; EBC_Zpracovatel části adresa: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz internet: www.energy-benefit.cz; Název budovy: "NÁZEV STAVEBNÍHO OBJEKTU"; Název organizace: Energy Benefit Centre a.s.; Popis organizace: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz internet: www.energy-benefit.cz; Projektant: Ing. Lukáš Hovorka
Jiné - Adresa projektu: Nám. 17. listopadu 710/12, Karlovy Vary – Rybáře, č. p.: 394/1 až 394/3, 395/1 až 395/5, 396, 397; Číslo projektu: 220055; Datum vydání projektu: 30.05.2023; EBC_Hlavní architekt: prof. Ing. Mgr. akad. arch. Petr Hájek; EBC_Hlavní projektant: Ing. Libor Truhelka; EBC_ID profese: D.1.4; EBC_Nadmořská výška: 389,970; EBC_Název profese: PLYNOVÁ ODBĚRNÁ ZAŘÍZENÍ; EBC_Stavebník adresa: Závodní 353/88, 360 06 Karlovy Vary, IČ: 70891168; EBC_Zástupce hlavního projektanta: Ing. Miroslav Zyma; EBC_Zkratka profese: PLN; Intenzita deště návrhová (l/s/m2): 0.03; Jméno klienta: Karlovarský kraj; Kategorie: Informace o projektu; Název projektu: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; Stav projektu: DUSP; Úhrn srážek/nejhorší měsíc: 84; Úhrn srážek/rok: 729

# IfcBuildingStorey: Podlaží:Podlaží (5)
In: "NÁZEV STAVEBNÍHO OBJEKTU"
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes
Jiné - Id typu: 305; Kategorie: Podlaží; Rodina: Podlaží; Rodina a typ: Podlaží: Podlaží; Typ: Podlaží
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Barva: 0; Symbol: EBC_Záhlaví podlaží : Běžné; Symbol na konci 1 – výchozí: yes; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Vzor čáry: EB_Tečkovaná 1/50
Identifikační data(Type) - Název typu: Podlaží
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží
Name | LongName = Název | Elevation (mm) = Výška (mm) | Podlaží nad
-2.PP_SO-102 | -2.PP_SO-102 | -8000 | -1.PP_SO-102
-1.PP_SO-102 | -1.PP_SO-102 | -4000 | 1.NP_SO-102
2.NP_SO-102 | 2.NP_SO-102 | 4000 | 3.NP_SO-102
3.NP_SO-102 | 3.NP_SO-102 | 8000 | 4.NP_SO-102
4.NP_SO-102 | 4.NP_SO-102 | 12000

# IfcBuildingStorey: Podlaží:Podlaží ±0,000, 1.NP_SO-102
In: "NÁZEV STAVEBNÍHO OBJEKTU"
LongName: 1.NP_SO-102; Elevation: 7.58007e-12 mm
Vazby - Podlaží nad: 2.NP_SO-102; Výška: 0 mm
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes; Název: 1.NP_SO-102
Jiné - Kategorie: Podlaží; Rodina: Podlaží; Id typu: 237447; Rodina a typ: Podlaží: Podlaží ±0,000; Typ: Podlaží ±0,000
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Vzor čáry: EB_Tečkovaná 1/50; Barva: 16711935; Symbol: EBC_Záhlaví podlaží : +-0,000; Symbol na konci 1 – výchozí: no
Identifikační data(Type) - Název typu: Podlaží ±0,000
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží

# IfcDistributionPort (42)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: PIPE; SystemType: USERDEFINED; Group: GS_NTL vnitřní 1
Name
Port_13273130_0
Port_13277540_1
Port_13273130_1
Port_13273206_0
Port_13277536_2
Port_13273206_1
Port_13277540_2
Port_13273346_0
Port_13277906_1
Port_13273346_1
Port_13277908_2
Port_13273688_0
Port_13277510_2
Port_13273688_1
Port_13277526_1
Port_13274330_0
Port_13277898_1
Port_13274330_1
Port_13274359_1
Port_13274338_0
Port_13277980_2
Port_13274338_1
Port_13274359_2
Port_13277510_1
Port_13277645_0
Port_13277518_0
Port_13277526_2
Port_13277518_1
Port_13277536_1
Port_13277645_1
Port_13277741_1
Port_13277739_0
Port_13277741_2
Port_13277739_1
Port_13277908_1
Port_13277890_0
Port_13277898_2
Port_13277890_1
Port_13277906_2
Port_13277931_0
Port_13277980_1
Port_13277931_1

# IfcDistributionSystem: GS_NTL vnitřní, GS_NTL vnitřní 1
PredefinedType: USERDEFINED

# IfcPipeFitting: M_Koleno, obecné:Standardní (10)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.60.30.11.14; ID kategorie: K; Kód sestavy: TT01; Nadpis OmniClass: Pipework Fittings; Název typu: Standardní; Označení typu: 01; Popis: Koleno; Popis sestavy: Koleno
Type - Jiné - Kategorie: Tvarovky; Název rodiny: M_Koleno, obecné; Název vyhledávací tabulky: M_Pipe Fitting - Generic
Classification: TT01 Uniformat (Uniformat); Group: GS_NTL vnitřní 1
Izolace - Tloušťka izolace: 0 mm; Celková velikost: ø65 mm-ø65 mm
Text - CCI Funkční systém: E; CCI Komponenta: WPA; CCI Technický systém: HA
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: GS_NTL vnitřní; Klasifikace systému: Ostatní; Název systému: GS_NTL vnitřní 1
Grafika - Použít měřítko poznámky: no
Kóty - Jmenovitý poloměr: 32.5 mm; Jmenovitý průměr: 65 mm; Maximální velikost: 65 mm; Minimální velikost: 65 mm; Objem: 0.000217659 m3; Od středu ke konci: 39.6875 mm; Úhel: 90 deg; Velikost: ø65-ø65; Velikost značky: 26.67 mm; Vnější průměr tvarovky: 66.675 mm
Jiné - Páteřní trasa: yes; Id typu: 3326550; Rodina: M_Koleno, obecné; Rodina a typ: M_Koleno, obecné: Standardní; Střední poloměr: 39.6875 mm; Typ: Standardní; Úhel tvarovky 1 (sdílený): 90 deg; Vnější poloměr tvarovky: 33.3375 mm
Name (M_Koleno, obecné:Standardní:...) | In | Podlaží | Výška od podlaží (mm) | Kód prvku | Označení
13274359 | -1.PP_SO-102 | -1.PP_SO-102 | 7300 | TT01.01.0001 | 0001
13277510 | 1.NP_SO-102 | 1.NP_SO-102 | 7311.16 | TT01.01.0002 | 0002
13277526 | 1.NP_SO-102 | 1.NP_SO-102 | -118.657 | TT01.01.0003 | 0003
13277536 | 1.NP_SO-102 | 1.NP_SO-102 | -118.657 | TT01.01.0004 | 0004
13277540 | -1.PP_SO-102 | -1.PP_SO-102 | 1948.57 | TT01.01.0005 | 0005
13277741 | 1.NP_SO-102 | 1.NP_SO-102 | 7311.16 | TT01.01.0006 | 0006
13277898 | 1.NP_SO-102 | 1.NP_SO-102 | 3300 | TT01.01.0007 | 0007
13277906 | 1.NP_SO-102 | 1.NP_SO-102 | 3300 | TT01.01.0008 | 0008
13277908 | 1.NP_SO-102 | 1.NP_SO-102 | 3300 | TT01.01.0009 | 0009
13277980 | -1.PP_SO-102 | -1.PP_SO-102 | 7300 | TT01.01.0010 | 0010

# IfcPipeSegment: Typy trubek:Ocel_černá (11)
Type - Material: 255-192- 0
Type - Požární ochrana - Požární odolnost: –
Type - Identifikační data - ID kategorie: TR; Kód sestavy: TR02; Název typu: Ocel_černá; Označení typu: 01; Popis: OC; Popis sestavy: Ocel
Type - Jiné - Kategorie: Trubky; MJ: m; Název rodiny: Typy trubek
Classification: TR02 Uniformat (Uniformat); Group: GS_NTL vnitřní 1
Qto_PipeSegmentBaseQuantities - GrossCrossSectionArea: 0.00454772 m2; NetCrossSectionArea: 0.00454772 m2
Izolace - Celková velikost: ø65 mm; Tloušťka izolace: 0 mm
Text - CCI Funkční systém: E; CCI Komponenta: WPA; CCI Technický systém: HA
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Drsnost: 0.1 mm; Klasifikace systému: Ostatní; Materiál: Kov, ocel; Název systému: GS_NTL vnitřní 1; Popis úseku: FE; Průměr: 65 mm; Řez: 15; Typ přípoje: Obecné; Typ systému: GS_NTL vnitřní; Úsek potrubí: Kov, ocel - ČERNÁ SVAŘOVANÁ; Výkaz/typ: ČERNÁ SVAŘOVANÁ
Kóty - Velikost: ø65; Vnější průměr: 76.1 mm; Vnitřní průměr: 68.9 mm
Jiné - Id typu: 12487561; Páteřní trasa: yes; Rodina: Typy trubek; Rodina a typ: Typy trubek: Ocel_černá; Typ: Ocel_černá
Name (Typy trubek:Ocel_černá:...) | In | Length (mm) = Délka (mm) | OuterSurfaceArea (m2) | Relativní drsnost | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Sklon | Spodní výška (mm) | Obrátit výšku (mm) | Plocha (m2) | Kód prvku | Označení
13273130 | -1.PP_SO-102 | 160.313 | 0.0383267 | 0.000662252 | 1986.62 | 1948.57 | 1948.57 | -1.PP_SO-102 | 0 | 1910.52 | -2085.88 | 0.0327364 | TR02.01.0001 | 0001
13273206 | -1.PP_SO-102 | 1853.4 | 0.443102 | 0 | 3841.66 | 1988.25 | 3841.66 | -1.PP_SO-102 |  | 1988.25 | -2011.75 | 0.378471 | TR02.01.0002 | 0002
13273346 | 1.NP_SO-102 | 18101.2 | 4.32755 | 0.00145138 | 3338.05 | 3300 | 3300 | 1.NP_SO-102 | 0 | 3261.95 | 3265.55 | 3.69633 | TR02.01.0003 | 0003 | Identifikační data - Komentáře: VEDENO POD STROPEM
13273688 | 1.NP_SO-102 | 7350.44 | 1.75731 | 0 | 7271.47 | -78.969 | 7271.47 | 1.NP_SO-102 |  | -78.969 | -78.969 | 1.50099 | TR02.01.0004 | 0004 | Identifikační data - Komentáře: VEDENO V MEZIPROSTORU FASÁDY
13274330 | 1.NP_SO-102 | 1880.94 | 0.449686 | 0.00145138 | 3338.05 | 3300 | 3300 | 1.NP_SO-102 | 0 | 3261.95 | 3265.55 | 0.384094 | TR02.01.0005 | 0005
13274338 | -1.PP_SO-102 | 1495.3 | 0.357488 | 0.00145138 | 7338.05 | 7300 | 7300 | -1.PP_SO-102 | 0 | 7261.95 | 3265.55 | 0.305345 | TR02.01.0006 | 0006
13277518 | 1.NP_SO-102 | 4502.93 | 1.07654 | 0.00145138 | -80.6065 | -118.657 | -118.657 | 1.NP_SO-102 | 0 | -156.707 | -153.107 | 0.919515 | TR02.01.0007 | 0007 | Identifikační data - Komentáře: VEDENO V MEZIPROSTORU FASÁDY
13277645 | 1.NP_SO-102 | 10199.7 | 2.4385 | 0.00145138 | 7349.21 | 7311.16 | 7311.16 | 1.NP_SO-102 | 0 | 7273.11 | 7276.71 | 2.08282 | TR02.01.0008 | 0008 | Identifikační data - Komentáře: VEDENO POD STROPEM
13277739 | 1.NP_SO-102 | 3931.79 | 0.939993 | 0 | 7271.47 | 3339.69 | 7271.47 | 1.NP_SO-102 |  | 3339.69 | 3339.69 | 0.802885 | TR02.01.0009 | 0009
13277890 | 1.NP_SO-102 | 1916.6 | 0.458211 | 0.00145138 | 3338.05 | 3300 | 3300 | 1.NP_SO-102 | 0 | 3261.95 | 3265.55 | 0.391376 | TR02.01.0010 | 0010
13277931 | -1.PP_SO-102 | 760.313 | 0.181772 | 0.00145138 | 7338.05 | 7300 | 7300 | -1.PP_SO-102 | 0 | 7261.95 | 3265.55 | 0.155258 | TR02.01.0011 | 0011
