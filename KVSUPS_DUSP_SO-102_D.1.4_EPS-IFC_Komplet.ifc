Properties of the parts of a building model (IFC4), part 1 of 3

# File
Description: ViewDefinition [DesignTransferView_V1.0], RevitIdentifiers [VersionGUID: 23d701d3-a6be-47c2-8664-04d79d28e89c, NumberOfSaves: 203], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Vnitřní]
File name: 220055
Time: 2023-10-13T16:52:16
Written by: ODA IFC SDK 22.8
Made in: 22.1.30.34 - Exporter 22.6.0.0 - Alternate UI 22.6.0.0

# IfcProject, 220055
LongName: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; Phase: DUSP

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Text - EBC_Hlavní architekt: prof. Ing. Mgr. akad. arch. Petr Hájek; EBC_Hlavní projektant: Ing. Libor Truhelka; EBC_ID profese: D.1.4; EBC_ID projektu: KVSUPS; EBC_Nadmořská výška: 389,970; EBC_Název profese: ELEKTRICKÁ POŽÁRNÍ SIGNALIZACE; EBC_Zástupce hlavního projektanta: Ing. Miroslav Zyma; EBC_Zkratka profese: EPS; EBC_Zodpovědný projektant: Martin Frühauf; EBC_Zpracovatel části: Projekce elektro s.r.o.; EBC_Zpracovatel části adresa: II. ulice 75, 273 07 Vinařice tel.: +420 603 897 422 e-mail: mf@martinfruhauf.cz
Identifikační data - Název budovy: Budova E; Název organizace: Energy Benefit Centre a.s.; Popis organizace: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz; Projektant: Martin Frühauf, Ing. Petra Frühaufová
Jiné - Adresa projektu: Nám. 17. listopadu 710/12, Karlovy Vary – Rybáře, č. p.: 394/1 až 394/3, 395/1 až 395/5, 396, 397; Číslo projektu: 220055; Datum vydání projektu: 30.05.2023; EBC_Stavebník adresa: Závodní 353/88, 360 06 Karlovy Vary, IČ: 70891168; Jméno klienta: Karlovarský kraj; Kategorie: Informace o projektu; Název projektu: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; OBJEKT: ETAPA; PROFESNÍ ČÁST: ELEKTRICKÁ POŽÁRNÍ SIGNALIZACE; Stav projektu: DUSP; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 11:29

# IfcBuilding, Budova E
LongName: Budova E
Text - EBC_Hlavní architekt: prof. Ing. Mgr. akad. arch. Petr Hájek; EBC_Hlavní projektant: Ing. Libor Truhelka; EBC_ID profese: D.1.4; EBC_ID projektu: KVSUPS; EBC_Nadmořská výška: 389,970; EBC_Název profese: ELEKTRICKÁ POŽÁRNÍ SIGNALIZACE; EBC_Zástupce hlavního projektanta: Ing. Miroslav Zyma; EBC_Zkratka profese: EPS; EBC_Zodpovědný projektant: Martin Frühauf; EBC_Zpracovatel části: Projekce elektro s.r.o.; EBC_Zpracovatel části adresa: II. ulice 75, 273 07 Vinařice tel.: +420 603 897 422 e-mail: mf@martinfruhauf.cz
Identifikační data - Název budovy: Budova E; Název organizace: Energy Benefit Centre a.s.; Popis organizace: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz; Projektant: Martin Frühauf, Ing. Petra Frühaufová
Jiné - Adresa projektu: Nám. 17. listopadu 710/12, Karlovy Vary – Rybáře, č. p.: 394/1 až 394/3, 395/1 až 395/5, 396, 397; Číslo projektu: 220055; Datum vydání projektu: 30.05.2023; EBC_Stavebník adresa: Závodní 353/88, 360 06 Karlovy Vary, IČ: 70891168; Jméno klienta: Karlovarský kraj; Kategorie: Informace o projektu; Název projektu: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; OBJEKT: ETAPA; PROFESNÍ ČÁST: ELEKTRICKÁ POŽÁRNÍ SIGNALIZACE; Stav projektu: DUSP; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 11:29

# IfcBuildingStorey: Podlaží:Podlaží, 2.NP_SO-102
In: Budova E
LongName: 2.NP_SO-102; Elevation: 4000 mm
Vazby - Výška: 4000 mm
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes; Název: 2.NP_SO-102
Jiné - Kategorie: Podlaží; Rodina: Podlaží; Id typu: 11292; Rodina a typ: Podlaží: Podlaží; Typ: Podlaží; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.20 03:33
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Symbol: Výšková kačena.CC : Výšková kačena; Symbol na konci 1 – výchozí: no; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Barva: 16711680; Vzor čáry: Čerchovaná
Identifikační data(Type) - Název typu: Podlaží
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží

# IfcBuildingStorey: Podlaží:Pomocné (5)
In: Budova E
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes
Jiné - Id typu: 1520; Kategorie: Podlaží; Rodina: Podlaží; Rodina a typ: Podlaží: Pomocné; Typ: Pomocné
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Barva: 0; Symbol: Výšková kačena.CC : Výšková kačena; Symbol na konci 1 – výchozí: no; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Vzor čáry: Tečkovaná
Identifikační data(Type) - Název typu: Pomocné
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží
Name | LongName = Název | Elevation (mm) | Výška (mm) | UPRAVIL
-2.PP_SO-102 | -2.PP_SO-102 | -8000 | -8000 | Fruhauf.vinarice@seznam.cz 2023.06.20 03:14
-1.PP_SO-102 | -1.PP_SO-102 | -4000 | -4000 | Fruhauf.vinarice@seznam.cz 2023.06.20 03:34
1.NP_SO-102 | 1.NP_SO-102 | -7.27687e-10 | 0 | Fruhauf.vinarice@seznam.cz 2023.06.20 03:34
3.NP_SO-102 | 3.NP_SO-102 | 8000 | 8000 | Fruhauf.vinarice@seznam.cz 2023.06.20 03:34
4.NP_SO-102 | 4.NP_SO-102 | 12000 | 12000 | Fruhauf.vinarice@seznam.cz 2023.06.20 03:34

# IfcAlarm: Automatický požární hlásič.CC:APH (284)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 3450 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Grafika - Symbol: yes; Typ APH: Automatický požární hlásič.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.00.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP04; Komentáře k typům: automatický; Model: Model; Nadpis OmniClass: Information and Communication; Název typu: APH; Označení typu: 03; Popis: Požární hlásič; Popis sestavy: Optický/tepelný multikriteriální hlásič; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; FAKTOR ÚČINNOSTI: 1; Název rodiny: Automatický požární hlásič.CC
Classification: EP04 Uniformat (Uniformat)
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: L; CCI Komponenta: BBB; CCI Technický systém: LB
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000471217 m3
Jiné - Id typu: 275002; Rodina: Automatický požární hlásič.CC; Rodina a typ: Automatický požární hlásič.CC: APH; Typ: APH
Name (Automatický požární hlásič.CC:APH:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení | UPRAVIL
969258 | -2.PP_SO-102 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 3100 | Fáze 1 | EP04.03.0005 | 0005 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:44
969262 | -2.PP_SO-102 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 3100 | Fáze 1 | EP04.03.0006 | 0006 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969266 | -2.PP_SO-102 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 3100 | Fáze 1 | EP04.03.0007 | 0007 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969321 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0008 | 0008 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969325 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0009 | 0009 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969409 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0024 | 0024 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969413 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0025 | 0025 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969417 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0026 | 0026 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969430 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0027 | 0027 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969434 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0028 | 0028 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969438 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0029 | 0029 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969442 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0030 | 0030 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969446 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0031 | 0031 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969450 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0032 | 0032 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969454 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0033 | 0033 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969458 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0034 | 0034 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969462 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0035 | 0035 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969466 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0036 | 0036 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969470 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0037 | 0037 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969474 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 2 | EP04.03.0038 | 0038 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969478 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 2 | EP04.03.0039 | 0039 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969482 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 2 | EP04.03.0040 | 0040 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969486 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 2 | EP04.03.0041 | 0041 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969490 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 2 | EP04.03.0042 | 0042 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969494 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0043 | 0043 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969498 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0044 | 0044 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969502 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0045 | 0045 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969506 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 2 | EP04.03.0046 | 0046 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969510 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 2 | EP04.03.0047 | 0047 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969514 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 2 | EP04.03.0048 | 0048 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969518 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 2 | EP04.03.0049 | 0049 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969522 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 2 | EP04.03.0050 | 0050 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969526 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 2 | EP04.03.0051 | 0051 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969530 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 2 | EP04.03.0052 | 0052 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969534 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 2 | EP04.03.0053 | 0053 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969559 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 2 | EP04.03.0054 | 0054 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969563 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 2 | EP04.03.0055 | 0055 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969567 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 2 | EP04.03.0056 | 0056 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969571 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 2 | EP04.03.0057 | 0057 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969575 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 2 | EP04.03.0058 | 0058 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969579 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 2 | EP04.03.0059 | 0059 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969588 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0060 | 0060 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969592 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0061 | 0061 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969596 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0062 | 0062 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969600 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0063 | 0063 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969604 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 2 | EP04.03.0064 | 0064 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969608 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0065 | 0065 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969612 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0066 | 0066 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969616 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0067 | 0067 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969620 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0068 | 0068 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969624 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0069 | 0069 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969628 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0070 | 0070 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969632 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 2 | EP04.03.0071 | 0071 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969643 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0072 | 0072 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
969647 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0073 | 0073 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
970928 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0075 | 0075 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
970935 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0076 | 0076 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
970939 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0077 | 0077 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
970943 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0078 | 0078 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
970947 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0079 | 0079 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
970951 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0080 | 0080 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
970955 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0081 | 0081 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
970963 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0082 | 0082 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
970967 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0083 | 0083 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
970971 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0084 | 0084 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
970975 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0085 | 0085 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
970979 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0086 | 0086 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
970986 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0087 | 0087 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
970990 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0088 | 0088 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
970999 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0089 | 0089 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971073 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0090 | 0090 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971077 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0091 | 0091 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971081 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0092 | 0092 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971085 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0093 | 0093 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971089 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0094 | 0094 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971093 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0095 | 0095 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971097 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0096 | 0096 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971101 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0097 | 0097 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971105 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0098 | 0098 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971109 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0099 | 0099 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971113 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0100 | 0100 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971117 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0101 | 0101 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971121 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0102 | 0102 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971125 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0103 | 0103 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971129 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0104 | 0104 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971133 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0105 | 0105 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971192 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0106 | 0106 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971196 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0107 | 0107 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971200 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0108 | 0108 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971204 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0109 | 0109 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971208 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0110 | 0110 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971224 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0111 | 0111 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971407 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0121 | 0121 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971411 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0122 | 0122 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971415 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0123 | 0123 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971667 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0124 | 0124 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971671 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0125 | 0125 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971675 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0126 | 0126 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971679 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0127 | 0127 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971683 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0128 | 0128 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971687 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0129 | 0129 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971704 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0131 | 0131 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971708 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0132 | 0132 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971712 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0133 | 0133 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971716 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0134 | 0134 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971720 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0135 | 0135 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971724 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0136 | 0136 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971728 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0137 | 0137 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971732 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0138 | 0138 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971736 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0139 | 0139 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971740 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0140 | 0140 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971744 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0141 | 0141 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971748 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0142 | 0142 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971752 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0143 | 0143 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971756 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0144 | 0144 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971760 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0145 | 0145 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971764 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0146 | 0146 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971768 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0147 | 0147 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971772 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0148 | 0148 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971776 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0149 | 0149 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971780 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0150 | 0150 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971784 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0151 | 0151 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971788 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0152 | 0152 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971792 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0153 | 0153 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971796 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0154 | 0154 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971800 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0155 | 0155 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971804 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0156 | 0156 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971808 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0157 | 0157 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971812 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0158 | 0158 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971816 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0159 | 0159 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971820 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0160 | 0160 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971824 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0161 | 0161 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971828 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0162 | 0162 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971832 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0163 | 0163 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971836 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0164 | 0164 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971840 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0165 | 0165 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971902 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0166 | 0166 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971906 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0167 | 0167 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971910 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0168 | 0168 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
971914 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0169 | 0169 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972008 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0170 | 0170 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972012 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0171 | 0171 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972016 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0172 | 0172 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972020 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0173 | 0173 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972086 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0185 | 0185 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972090 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0186 | 0186 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972094 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0187 | 0187 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972098 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0188 | 0188 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972102 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0189 | 0189 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972106 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0190 | 0190 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972110 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0191 | 0191 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972114 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0192 | 0192 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972118 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0193 | 0193 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972122 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0194 | 0194 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972126 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0195 | 0195 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972130 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0196 | 0196 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972134 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0197 | 0197 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972185 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0198 | 0198 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972189 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0199 | 0199 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972193 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0200 | 0200 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972197 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0201 | 0201 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972201 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0202 | 0202 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972209 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0203 | 0203 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972213 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0204 | 0204 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972217 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0205 | 0205 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972221 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0206 | 0206 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972225 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0207 | 0207 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972229 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0208 | 0208 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972233 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0209 | 0209 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972237 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0210 | 0210 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972241 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0211 | 0211 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972245 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0212 | 0212 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972249 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0213 | 0213 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972253 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0214 | 0214 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972257 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0215 | 0215 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972261 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0216 | 0216 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972265 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0217 | 0217 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972269 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0218 | 0218 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972273 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0219 | 0219 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972277 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0220 | 0220 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972281 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0221 | 0221 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972304 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0222 | 0222 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972308 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0223 | 0223 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972319 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0224 | 0224 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972323 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0225 | 0225 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972334 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0226 | 0226 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972338 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0227 | 0227 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972342 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0228 | 0228 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972346 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0229 | 0229 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972350 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0230 | 0230 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972354 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0231 | 0231 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972358 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0232 | 0232 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972362 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0233 | 0233 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972366 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0234 | 0234 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972370 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0235 | 0235 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972374 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0236 | 0236 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972382 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0237 | 0237 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972386 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0238 | 0238 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972390 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0239 | 0239 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972394 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0240 | 0240 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972398 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0241 | 0241 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972402 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0242 | 0242 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972683 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0243 | 0243 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972687 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0244 | 0244 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972691 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0245 | 0245 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972695 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0246 | 0246 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972699 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0247 | 0247 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972703 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0248 | 0248 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972707 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0249 | 0249 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972804 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0268 | 0268 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972808 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0269 | 0269 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972812 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0270 | 0270 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972816 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0271 | 0271 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972820 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0272 | 0272 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972824 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0273 | 0273 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972828 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0274 | 0274 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972832 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0275 | 0275 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972836 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0276 | 0276 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972840 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0277 | 0277 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972844 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0278 | 0278 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972848 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0279 | 0279 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972852 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0280 | 0280 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972856 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0281 | 0281 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972860 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0282 | 0282 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972864 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0283 | 0283 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972868 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0284 | 0284 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972872 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0285 | 0285 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972876 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0286 | 0286 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972887 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0287 | 0287 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972891 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0288 | 0288 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972895 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0289 | 0289 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972903 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0290 | 0290 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972907 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0291 | 0291 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972911 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0292 | 0292 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972915 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0293 | 0293 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972919 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0294 | 0294 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972923 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0295 | 0295 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972927 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0296 | 0296 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972931 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0297 | 0297 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972935 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0298 | 0298 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972939 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0299 | 0299 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972943 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0300 | 0300 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972947 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0301 | 0301 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972951 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0302 | 0302 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972955 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0303 | 0303 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972959 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0304 | 0304 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972963 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0305 | 0305 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972967 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0306 | 0306 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972971 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0307 | 0307 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972975 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0308 | 0308 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972979 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0309 | 0309 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972983 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0310 | 0310 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
972987 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0311 | 0311 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
973086 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0312 | 0312 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
973868 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0319 | 0319 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
973872 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0320 | 0320 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
973946 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0321 | 0321 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
973954 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0322 | 0322 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
973958 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0323 | 0323 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
973962 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0324 | 0324 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
973970 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0325 | 0325 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
973974 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0326 | 0326 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
973982 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0327 | 0327 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
974067 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0328 | 0328 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
974071 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0329 | 0329 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
974075 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0330 | 0330 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
974318 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0331 | 0331 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
974387 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0332 | 0332 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
974444 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0333 | 0333 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
974519 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0334 | 0334 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
974994 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0335 | 0335 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
975355 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0336 | 0336 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
975356 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0337 | 0337 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
975357 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0338 | 0338 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
975358 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0339 | 0339 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
975705 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0340 | 0340 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
993078 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0377 | 0377 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
993084 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0378 | 0378 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
1030609 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0413 | 0413 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
1033364 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP04.03.0426 | 0426 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
1033408 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0427 | 0427 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
1033507 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 2 | EP04.03.0432 | 0432 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
1070577 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0518 | 0518 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43
1072109 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3450 | Fáze 1 | EP04.03.0525 | 0525 | Fruhauf.vinarice@seznam.cz 2023.06.26 02:43

# IfcAlarm: Klíčový trezor požární ochrany.CC:Klíčový trezor požární ochrany.CC, Klíčový trezor požární ochrany.CC:Klíčový trezor požární ochrany.CC:970867
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes
Type - Kóty - Délka: 165 mm; Šířka: 300 mm; Výška: 220 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: PI02; Komentáře k typům: požární ochrany, klíčový; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Klíčový trezor požární ochrany.CC; Označení typu: 04; Popis: Trezor; Popis sestavy: Klíčový trezor požární ochrany; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; Název rodiny: Klíčový trezor požární ochrany.CC
Classification: PI02 Uniformat (Uniformat)
Text - CCI Funkční systém: L; CCI Komponenta: SGF; CCI Technický systém: LB
Vazby - Podlaží: -1.PP_SO-102; Hostitel: Podlaží : -1.PP_SO-102; Odsazení od hostitele: 1200 mm; Výška od podlaží: 1200 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - HLOUBKA: 200 mm; Objem: 0.0172804 m3; ŠÍŘKA: 300 mm; VÝŠKA: 300 mm
Identifikační data - Kód prvku: PI02.04.0074; Označení: 0074
Jiné - Id typu: 970851; Rodina: Klíčový trezor požární ochrany.CC; Rodina a typ: Klíčový trezor požární ochrany.CC: Klíčový trezor požární ochrany.CC; Typ: Klíčový trezor požární ochrany.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:44

# IfcAlarm: Lineární optický hlásič.CC:Lineární optický hlásič.CC (2)
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Přijímač a vysílač: no
Type - Kóty - HLOUBKA: 120 mm; ŠÍŘKA: 120 mm; VÝŠKA: 210 mm
Type - Identifikační data - COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP08; Název typu: Lineární optický hlásič.CC; Označení typu: 11; Popis sestavy: Lineární hlásič; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Požární poplachová zařízení; Název rodiny: Lineární optický hlásič.CC; Q: 140 mm; T: 10 mm; V: 120 mm
Classification: EP08 Uniformat (Uniformat)
Text - CCI Funkční systém: L; CCI Komponenta: BRA; CCI Technický systém: LB
Vazby - Délka: 30950 mm; Odsazení od hostitele: 3000 mm; Pracovní rovina: Podlaží : 1.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Kóty - Objem: 0.003168 m3; Plocha: 0.0816 m2
Jiné - H: 120 mm; Id typu: 987885; Rodina: Lineární optický hlásič.CC; Rodina a typ: Lineární optický hlásič.CC: Lineární optický hlásič.CC; Typ: Lineární optický hlásič.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:43; X: no
Name (Lineární optický hlásič.CC:Lineární optický hlásič.CC:...) | Kód prvku | Označení
1052183 | EP08.11.0495 | 0495
1052323 | EP08.11.0496 | 0496

# IfcAlarm: Lineární teplotní hlásič - vyhodnocovací jednotka.CC:2 Vstupy, Lineární teplotní hlásič - vyhodnocovací jednotka.CC:2 Vstupy:1052398
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.21.11.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP08; Komentáře k typům: Komentáře k typům; Model: Model; Nadpis OmniClass: Temperature Monitors; Název typu: 2 Vstupy; Označení typu: 12; Popis: Popis; Popis sestavy: Lineární hlásič; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; Název rodiny: Lineární teplotní hlásič - vyhodnocovací jednotka.CC
Classification: EP08 Uniformat (Uniformat)
Text - CCI Funkční systém: L; CCI Komponenta: BTB; CCI Technický systém: LB
Vazby - Odsazení od hostitele: 0 mm; Podlaží: -1.PP_SO-102; Výška od podlaží: 0 mm; Hostitel: Podlaží : -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000139343 m3
Identifikační data - Kód prvku: EP08.12.0497; Označení: 0497
Jiné - Id typu: 986908; Rodina: Lineární teplotní hlásič - vyhodnocovací jednotka.CC; Rodina a typ: Lineární teplotní hlásič - vyhodnocovací jednotka.CC: 2 Vstupy; Typ: 2 Vstupy; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:45

# IfcAlarm: Lineární teplotní hlásič - vyhodnocovací jednotka.CC:4 Vstupy, Lineární teplotní hlásič - vyhodnocovací jednotka.CC:4 Vstupy:1052407
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.21.11.11.17; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP08; Komentáře k typům: Komentáře k typům; Model: Model; Nadpis OmniClass: Temperature Monitors; Název typu: 4 Vstupy; Označení typu: 13; Popis: Popis; Popis sestavy: Lineární hlásič; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; Název rodiny: Lineární teplotní hlásič - vyhodnocovací jednotka.CC
Classification: EP08 Uniformat (Uniformat)
Text - CCI Funkční systém: L; CCI Komponenta: BTB; CCI Technický systém: LB
Vazby - Odsazení od hostitele: 0 mm; Podlaží: -1.PP_SO-102; Výška od podlaží: 0 mm; Hostitel: Podlaží : -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000139343 m3
Identifikační data - Kód prvku: EP08.13.0498; Označení: 0498
Jiné - Rodina: Lineární teplotní hlásič - vyhodnocovací jednotka.CC; Id typu: 986912; Rodina a typ: Lineární teplotní hlásič - vyhodnocovací jednotka.CC: 4 Vstupy; Typ: 4 Vstupy; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:45

# IfcAlarm: Napájecí zdroj s akumulátorem_Požární.CC :Napájecí zdroj s akumulátorem Horizontální, Napájecí zdroj s akumulátorem_Požární.CC :Napájecí zdroj s akumulátorem Horizontální:1052766
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 0 V; PROUD: 0 A
Type - Grafika - Symbol: yes; Svislé umístění: no; Vodorovné umístění: yes
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP14; Komentáře k typům: s akumulátorem, požární, horizontální; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Napájecí zdroj s akumulátorem Horizontální; Označení typu: 16; Popis: Napájecí zdroj; Popis sestavy: Zdroj napájení pro EPS; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; Název rodiny: Napájecí zdroj s akumulátorem_Požární.CC
Classification: EP14 Uniformat (Uniformat)
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W
Text - CCI Funkční systém: L; CCI Komponenta: GBA; CCI Technický systém: LB
Vazby - Odsazení od hostitele: 0 mm; Podlaží: -1.PP_SO-102; Výška od podlaží: 0 mm; Hostitel: Podlaží : -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - DÉLKA: 350 mm; HLOUBKA: 200 mm; Objem: 0.0315161 m3; ŠÍŘKA: 450 mm
Identifikační data - Kód prvku: EP14.16.0501; Označení: 0501
Jiné - Rodina: Napájecí zdroj s akumulátorem_Požární.CC; a: 140 mm; b: 135 mm; Id typu: 989409; Rodina a typ: Napájecí zdroj s akumulátorem_Požární.CC : Napájecí zdroj s akumulátorem Horizontální; Typ: Napájecí zdroj s akumulátorem Horizontální; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:45

# IfcAlarm: Napájecí zdroj s akumulátorem_Požární.CC :Napájecí zdroj s akumulátorem Vertikální, Napájecí zdroj s akumulátorem_Požární.CC :Napájecí zdroj s akumulátorem Vertikální:1052759
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 0 V; PROUD: 0 A
Type - Grafika - Symbol: yes; Svislé umístění: yes; Vodorovné umístění: no
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP14; Komentáře k typům: s akumulátorem, požární, vertikální; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Napájecí zdroj s akumulátorem Vertikální; Označení typu: 15; Popis: Napájecí zdroj; Popis sestavy: Zdroj napájení pro EPS; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; Název rodiny: Napájecí zdroj s akumulátorem_Požární.CC
Classification: EP14 Uniformat (Uniformat)
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W
Text - CCI Funkční systém: L; CCI Komponenta: GBA; CCI Technický systém: LB
Vazby - Odsazení od hostitele: 0 mm; Podlaží: -1.PP_SO-102; Výška od podlaží: 0 mm; Hostitel: Podlaží : -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - DÉLKA: 350 mm; HLOUBKA: 200 mm; Objem: 0.0315161 m3; ŠÍŘKA: 450 mm
Identifikační data - Kód prvku: EP14.15.0500; Označení: 0500
Jiné - a: 140 mm; b: 135 mm; Id typu: 989411; Rodina: Napájecí zdroj s akumulátorem_Požární.CC; Rodina a typ: Napájecí zdroj s akumulátorem_Požární.CC : Napájecí zdroj s akumulátorem Vertikální; Typ: Napájecí zdroj s akumulátorem Vertikální; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:45

# IfcAlarm: Nasávací kouřový hlásič.CC:Nasávací kouřový hlásič.CC (3)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - DÉLKA: 200 mm; ŠÍŘKA: 120 mm; VÝŠKA: 300 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP09; Komentáře k typům: Komentáře k typům; Model: Model; Název typu: Nasávací kouřový hlásič.CC; Označení typu: 02; Popis: Popis; Popis sestavy: Nasávací systém; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; Název rodiny: Nasávací kouřový hlásič.CC
Classification: EP09 Uniformat (Uniformat)
Text - CCI Funkční systém: L; CCI Komponenta: BBB; CCI Technický systém: LB
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.0072 m3
Jiné - Id typu: 969200; Rodina: Nasávací kouřový hlásič.CC; Rodina a typ: Nasávací kouřový hlásič.CC: Nasávací kouřový hlásič.CC; Typ: Nasávací kouřový hlásič.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:45
Name (Nasávací kouřový hlásič.CC:Nasávací kouřový hlásič.CC:...) | In | Hostitel | Podlaží | Kód prvku | Označení
969216 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | EP09.02.0003 | 0003
969224 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | -2.PP_SO-102 | EP09.02.0004 | 0004
969337 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | EP09.02.0010 | 0010

# IfcAlarm: Optická signalizace - maják.CC:Optická signalizace - maják.CC (5)
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP00; Komentáře k typům: optická - maják; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Optická signalizace - maják.CC; Označení typu: 17; Popis: Signalizace; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; Název rodiny: Optická signalizace - maják.CC
Classification: EP00 Uniformat (Uniformat)
Text - CCI Funkční systém: L; CCI Komponenta: EAA; CCI Technický systém: LB
Vazby - Podlaží: 1.NP_SO-102; Hostitel: Podlaží : 1.NP_SO-102
Grafika - Posun horizontální: 0; Posun vertikální: 0; Nástěnný: no
Kóty - Objem: 0.00023256 m3
Jiné - A: 90 deg; Id typu: 978425; Rodina: Optická signalizace - maják.CC; Rodina a typ: Optická signalizace - maják.CC: Optická signalizace - maják.CC; Typ: Optická signalizace - maják.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:46
Name (Optická signalizace - maják.CC:Optická signalizace - maják.CC:...) | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení
1056783 | 2000 | Fáze 2 | EP00.17.0513 | 0513
1056790 | 2000 | Fáze 1 | EP00.17.0514 | 0514
1056848 | 2000 | Fáze 2 | EP00.17.0515 | 0515
1056852 | 2000 | Fáze 2 | EP00.17.0516 | 0516
1056861 | 1500 | Fáze 2 | EP00.17.0517 | 0517

# IfcAlarm: Ovládané a pomocné zařízení EP.CC:APH (35)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Grafika - Symbol: yes; Typ APH: Ovládané a pomocné zařízení EPS.CC
