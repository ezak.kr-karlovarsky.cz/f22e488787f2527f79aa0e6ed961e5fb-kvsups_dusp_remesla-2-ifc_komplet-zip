Properties of the parts of a building model (IFC4), part 2 of 3

# IfcAlarm: Ovládané a pomocné zařízení EP.CC:APH (35)
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.00.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP16; Komentáře k typům: Ovládané a pomocné zařízení EPS; Model: Model; Nadpis OmniClass: Information and Communication; Název typu: APH; Označení typu: 06; Popis: Zařízení EPS; Popis sestavy: Vstupně/výstupní prvek (koppler); URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; FAKTOR ÚČINNOSTI: 1; Název rodiny: Ovládané a pomocné zařízení EP.CC
Classification: EP16 Uniformat (Uniformat)
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: L; CCI Komponenta: KEC; CCI Technický systém: LB
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000384 m3
Jiné - Typ: APH; Id typu: 980592; Rodina: Ovládané a pomocné zařízení EP.CC; Rodina a typ: Ovládané a pomocné zařízení EP.CC: APH; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:47
Name (Ovládané a pomocné zařízení EP.CC:APH:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení
980608 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP16.06.0342 | 0342
980624 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 0 | Fáze 1 | EP16.06.0343 | 0343
980628 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 0 | Fáze 1 | EP16.06.0344 | 0344
984464 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 2 | EP16.06.0360 | 0360
984503 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1700 | Fáze 1 | EP16.06.0362 | 0362
984515 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | EP16.06.0364 | 0364
984527 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | EP16.06.0366 | 0366
984541 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 1 | EP16.06.0368 | 0368
984550 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | EP16.06.0370 | 0370
984562 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 2 | EP16.06.0372 | 0372
984574 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 0 | Fáze 1 | EP16.06.0374 | 0374
984583 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 0 | Fáze 2 | EP16.06.0376 | 0376
1033260 | -2.PP_SO-102 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 0 | Fáze 1 | EP16.06.0423 | 0423
1034880 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP16.06.0434 | 0434
1053655 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 0 | Fáze 1 | EP16.06.0504 | 0504
1053656 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 0 | Fáze 1 | EP16.06.0505 | 0505
1053683 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP16.06.0506 | 0506
1053692 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP16.06.0507 | 0507
1053705 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP16.06.0508 | 0508
1053714 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP16.06.0509 | 0509
1053723 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP16.06.0510 | 0510
1055945 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | EP16.06.0511 | 0511
1055946 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | EP16.06.0512 | 0512
1072046 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | EP16.06.0522 | 0522
1072058 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | EP16.06.0523 | 0523
1072070 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | EP16.06.0524 | 0524
1072158 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3000 | Fáze 1 | EP16.06.0526 | 0526
1072191 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3000 | Fáze 1 | EP16.06.0527 | 0527
1072200 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3000 | Fáze 1 | EP16.06.0528 | 0528
1072225 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3000 | Fáze 1 | EP16.06.0529 | 0529
1072247 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3000 | Fáze 1 | EP16.06.0530 | 0530
1072258 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3000 | Fáze 1 | EP16.06.0531 | 0531
1072269 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3000 | Fáze 1 | EP16.06.0532 | 0532
1072278 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3000 | Fáze 1 | EP16.06.0533 | 0533
1072287 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3000 | Fáze 1 | EP16.06.0534 | 0534

# IfcAlarm: Ovládané a pomocné zařízení EP.CC:PK (60)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 3000 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Grafika - Symbol: yes; Typ APH: Ovládané a pomocné zařízení EPS.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.00.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: PK00; Komentáře k typům: Ovládané a pomocné zařízení EPS; Model: Model; Nadpis OmniClass: Information and Communication; Název typu: PK; Označení typu: 10; Popis: Zařízení EPS; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; FAKTOR ÚČINNOSTI: 1; Název rodiny: Ovládané a pomocné zařízení EP.CC
Classification: PK00 Uniformat (Uniformat)
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: L; CCI Komponenta: KEC; CCI Technický systém: LB
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000384 m3
Jiné - Rodina: Ovládané a pomocné zařízení EP.CC; Id typu: 1033167; Rodina a typ: Ovládané a pomocné zařízení EP.CC: PK; Typ: PK; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:47
Name (Ovládané a pomocné zařízení EP.CC:PK:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení
1033160 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | PK00.10.0418 | 0418
1048452 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0436 | 0436
1048456 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2200 | Fáze 1 | PK00.10.0437 | 0437
1048460 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0438 | 0438
1048464 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0439 | 0439
1048468 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0440 | 0440
1048472 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0441 | 0441
1048476 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0442 | 0442
1048480 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0443 | 0443
1048484 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0444 | 0444
1048488 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0445 | 0445
1048492 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0446 | 0446
1048496 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0447 | 0447
1048630 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 2 | PK00.10.0448 | 0448
1048641 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 2 | PK00.10.0449 | 0449
1048834 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0450 | 0450
1048866 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0451 | 0451
1048870 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0452 | 0452
1048874 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0453 | 0453
1048906 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0454 | 0454
1048929 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3000 | Fáze 2 | PK00.10.0455 | 0455
1048933 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3000 | Fáze 2 | PK00.10.0456 | 0456
1048976 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0457 | 0457
1048980 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0458 | 0458
1048984 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0459 | 0459
1048988 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0460 | 0460
1048995 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3000 | Fáze 2 | PK00.10.0461 | 0461
1048999 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3000 | Fáze 2 | PK00.10.0462 | 0462
1049007 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0463 | 0463
1049954 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0464 | 0464
1049958 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3000 | Fáze 1 | PK00.10.0465 | 0465
1050669 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 2 | PK00.10.0466 | 0466
1050673 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 2 | PK00.10.0467 | 0467
1050719 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | PK00.10.0468 | 0468
1050720 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | PK00.10.0469 | 0469
1050721 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | PK00.10.0470 | 0470
1050722 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | PK00.10.0471 | 0471
1050723 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | PK00.10.0472 | 0472
1050724 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | PK00.10.0473 | 0473
1050725 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | PK00.10.0474 | 0474
1050726 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | PK00.10.0475 | 0475
1050742 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | PK00.10.0476 | 0476
1050758 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | PK00.10.0477 | 0477
1050762 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | PK00.10.0478 | 0478
1050766 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | PK00.10.0479 | 0479
1050770 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | PK00.10.0480 | 0480
1050774 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | PK00.10.0481 | 0481
1050778 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | PK00.10.0482 | 0482
1050786 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | PK00.10.0483 | 0483
1050790 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | PK00.10.0484 | 0484
1050800 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 2 | PK00.10.0485 | 0485
1050804 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 2 | PK00.10.0486 | 0486
1050808 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 2 | PK00.10.0487 | 0487
1050812 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 2 | PK00.10.0488 | 0488
1050816 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 2 | PK00.10.0489 | 0489
1050820 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 2 | PK00.10.0490 | 0490
1050824 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 2 | PK00.10.0491 | 0491
1050862 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | PK00.10.0492 | 0492
1051197 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | PK00.10.0493 | 0493
1051205 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 0 | Fáze 1 | PK00.10.0494 | 0494

# IfcAlarm: Přídržný magnet.CC:Přídržný magnet.CC (14)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - DÉLKA: 5 mm; ŠÍŘKA: 50 mm; VÝŠKA: 50 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP00; Komentáře k typům: Přídržný magnet; Model: Model; Název typu: Přídržný magnet.CC; Označení typu: 09; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; d: -5 mm; l2: -17.5 mm; -l2: 17.5 mm; Název rodiny: Přídržný magnet.CC; R: 5 mm
Classification: EP00 Uniformat (Uniformat)
Text - CCI Funkční systém: L; CCI Komponenta: MBB; CCI Technický systém: LB
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000061212 m3
Jiné - Id typu: 981864; Rodina: Přídržný magnet.CC; Rodina a typ: Přídržný magnet.CC: Přídržný magnet.CC; Typ: Přídržný magnet.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:48
Name (Přídržný magnet.CC:Přídržný magnet.CC:...) | In | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
1029778 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | EP00.09.0392 | 0392
1029787 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | EP00.09.0393 | 0393
1029791 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | EP00.09.0394 | 0394
1029826 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | EP00.09.0395 | 0395
1029902 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | EP00.09.0397 | 0397
1029906 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | EP00.09.0398 | 0398
1029910 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | EP00.09.0399 | 0399
1029914 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | EP00.09.0400 | 0400
1030028 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | EP00.09.0402 | 0402
1030032 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | EP00.09.0403 | 0403
1030036 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | EP00.09.0404 | 0404
1030040 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | EP00.09.0405 | 0405
1033426 | 1.NP_SO-102 | 1500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | EP00.09.0428 | 0428
1033435 | 1.NP_SO-102 | 1500 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | EP00.09.0429 | 0429

# IfcAlarm: Světelná signalizace.CC:Světelná signalizace Vertikální, Světelná signalizace.CC:Světelná signalizace Vertikální:979365
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes; Horizontální: no; Vertikální: yes
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP11; Komentáře k typům: světelná, vertikální; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Světelná signalizace Vertikální; Označení typu: 05; Popis: Signalizace; Popis sestavy: Siréna s majákem; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; Název rodiny: Světelná signalizace.CC
Classification: EP11 Uniformat (Uniformat)
Text - CCI Funkční systém: L; CCI Komponenta: EAA; CCI Technický systém: LB
Vazby - Podlaží: 1.NP_SO-102; Hostitel: Podlaží : 1.NP_SO-102; Odsazení od hostitele: 1500 mm; Přesunout s blízkými prvky: no; Výška od podlaží: 1500 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.0000284651 m3
Identifikační data - Kód prvku: EP11.05.0341; Označení: 0341
Jiné - Id typu: 251083; Rodina: Světelná signalizace.CC; Rodina a typ: Světelná signalizace.CC: Světelná signalizace Vertikální; Typ: Světelná signalizace Vertikální; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:49

# IfcAlarm: Tlačítkový požární hlásič.CC:Tlačítkový požární hlásič.CC (70)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 1500 mm
Type - Grafika - Symbol: yes
Type - Kóty - HLOUBKA: 20 mm; ŠÍŘKA: 88 mm; VÝŠKA: 88 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP10; Komentáře k typům: tlačítkový; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Tlačítkový požární hlásič.CC; Označení typu: 01; Popis: Požární hlásič; Popis sestavy: Tlačítkový hlásič; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; Název rodiny: Tlačítkový požární hlásič.CC
Classification: EP10 Uniformat (Uniformat)
Text - CCI Funkční systém: L; CCI Komponenta: SJB; CCI Technický systém: LB
Vazby - Odsazení od hostitele: 1500 mm; Výška od podlaží: 1500 mm
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.0000865641 m3
Jiné - Id typu: 968045; Rodina: Tlačítkový požární hlásič.CC; Rodina a typ: Tlačítkový požární hlásič.CC: Tlačítkový požární hlásič.CC; Typ: Tlačítkový požární hlásič.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:51
Name (Tlačítkový požární hlásič.CC:Tlačítkový požární hlásič.CC:...) | In | Hostitel | Podlaží | Fáze vytvoření | Kód prvku | Označení
968065 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | -2.PP_SO-102 | Fáze 1 | EP10.01.0001 | 0001
968077 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | -2.PP_SO-102 | Fáze 1 | EP10.01.0002 | 0002
969345 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | EP10.01.0011 | 0011
969349 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | EP10.01.0012 | 0012
969353 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | EP10.01.0013 | 0013
969357 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | EP10.01.0014 | 0014
969361 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | EP10.01.0015 | 0015
969365 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | EP10.01.0016 | 0016
969369 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | EP10.01.0017 | 0017
969373 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | EP10.01.0018 | 0018
969377 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | EP10.01.0019 | 0019
969390 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 2 | EP10.01.0020 | 0020
969394 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 2 | EP10.01.0021 | 0021
969398 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 2 | EP10.01.0022 | 0022
969402 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | EP10.01.0023 | 0023
971368 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | EP10.01.0112 | 0112
971372 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | EP10.01.0113 | 0113
971376 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | EP10.01.0114 | 0114
971380 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | EP10.01.0115 | 0115
971384 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | EP10.01.0116 | 0116
971388 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | EP10.01.0117 | 0117
971392 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | EP10.01.0118 | 0118
971396 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 2 | EP10.01.0119 | 0119
971400 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 2 | EP10.01.0120 | 0120
971697 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | EP10.01.0130 | 0130
972039 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | EP10.01.0174 | 0174
972043 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | EP10.01.0175 | 0175
972047 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | EP10.01.0176 | 0176
972051 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | EP10.01.0177 | 0177
972055 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | EP10.01.0178 | 0178
972059 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | EP10.01.0179 | 0179
972063 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | EP10.01.0180 | 0180
972067 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 2 | EP10.01.0181 | 0181
972071 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 2 | EP10.01.0182 | 0182
972075 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | EP10.01.0183 | 0183
972079 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | EP10.01.0184 | 0184
972714 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3.NP_SO-102 | Fáze 1 | EP10.01.0250 | 0250
972718 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3.NP_SO-102 | Fáze 1 | EP10.01.0251 | 0251
972722 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3.NP_SO-102 | Fáze 1 | EP10.01.0252 | 0252
972726 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3.NP_SO-102 | Fáze 1 | EP10.01.0253 | 0253
972730 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3.NP_SO-102 | Fáze 1 | EP10.01.0254 | 0254
972734 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3.NP_SO-102 | Fáze 1 | EP10.01.0255 | 0255
972738 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3.NP_SO-102 | Fáze 1 | EP10.01.0256 | 0256
972742 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3.NP_SO-102 | Fáze 2 | EP10.01.0257 | 0257
972746 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3.NP_SO-102 | Fáze 2 | EP10.01.0258 | 0258
972750 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3.NP_SO-102 | Fáze 1 | EP10.01.0259 | 0259
972757 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | EP10.01.0260 | 0260
972773 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 4.NP_SO-102 | Fáze 1 | EP10.01.0261 | 0261
972777 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 4.NP_SO-102 | Fáze 1 | EP10.01.0262 | 0262
972781 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 4.NP_SO-102 | Fáze 1 | EP10.01.0263 | 0263
972785 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 4.NP_SO-102 | Fáze 1 | EP10.01.0264 | 0264
972789 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 4.NP_SO-102 | Fáze 1 | EP10.01.0265 | 0265
972793 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 4.NP_SO-102 | Fáze 2 | EP10.01.0266 | 0266
972797 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 4.NP_SO-102 | Fáze 2 | EP10.01.0267 | 0267
973154 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 4.NP_SO-102 | Fáze 1 | EP10.01.0313 | 0313
973278 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 4.NP_SO-102 | Fáze 1 | EP10.01.0314 | 0314
973415 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3.NP_SO-102 | Fáze 2 | EP10.01.0315 | 0315
973431 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | EP10.01.0316 | 0316
973534 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | EP10.01.0317 | 0317
973589 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | EP10.01.0318 | 0318
1030327 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | EP10.01.0406 | 0406
1030349 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | EP10.01.0407 | 0407
1030359 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | EP10.01.0408 | 0408
1030434 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1.NP_SO-102 | Fáze 1 | EP10.01.0409 | 0409
1033190 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | EP10.01.0419 | 0419
1033215 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | EP10.01.0420 | 0420
1033223 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | EP10.01.0421 | 0421
1033300 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | EP10.01.0424 | 0424
1033333 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | -1.PP_SO-102 | Fáze 1 | EP10.01.0425 | 0425
1033635 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2.NP_SO-102 | Fáze 1 | EP10.01.0433 | 0433

# IfcAlarm: Tlačítkový požární hlásič.CC:Tlačítkový spínač PBZ.CC 2, Tlačítkový požární hlásič.CC:Tlačítkový spínač PBZ.CC 2:1052667
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 1500 mm
Type - Grafika - Symbol: yes
Type - Kóty - HLOUBKA: 20 mm; ŠÍŘKA: 88 mm; VÝŠKA: 88 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: LV; Komentáře k typům: tlačítkový; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Tlačítkový spínač PBZ.CC 2; Označení typu: 14; Popis: Požární hlásič; Popis sestavy: Klapka; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; Název rodiny: Tlačítkový požární hlásič.CC
Classification: LV Uniformat (Uniformat)
Text - CCI Funkční systém: L; CCI Komponenta: SJB; CCI Technický systém: LB
Vazby - Podlaží: -1.PP_SO-102; Hostitel: Podlaží : -1.PP_SO-102; Odsazení od hostitele: 1500 mm; Výška od podlaží: 1500 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.0000865641 m3
Identifikační data - Kód prvku: LV.14.0499; Označení: 0499
Jiné - Rodina: Tlačítkový požární hlásič.CC; Id typu: 1052678; Rodina a typ: Tlačítkový požární hlásič.CC: Tlačítkový spínač PBZ.CC 2; Typ: Tlačítkový spínač PBZ.CC 2; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:43

# IfcAlarm: Vstupně - výstupní modul.CC:Vstupně - výstupní modul Horizontální (38)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 3; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 0 V
Type - Grafika - Symbol: yes; Svislé umístění: no; Vodorovné umístění: yes
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP16; Komentáře k typům: Vstupně - výstupní modul; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Vstupně - výstupní modul Horizontální; Označení typu: 07; Popis: Popis; Popis sestavy: Vstupně/výstupní prvek (koppler); URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; FAKTOR ÚČINNOSTI: 1; Název rodiny: Vstupně - výstupní modul.CC
Classification: EP16 Uniformat (Uniformat)
Elektroinstalace – obvody - Údaje k elektroinstalaci: 0 V/3-0.0 kW
Text - CCI Funkční systém: L; CCI Komponenta: KEC; CCI Technický systém: LB
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - DÉLKA: 200 mm; HLOUBKA: 50 mm; Objem: 0.001509 m3; ŠÍŘKA: 150 mm
Jiné - a: 80 mm; b: 45 mm; Id typu: 983016; Rodina: Vstupně - výstupní modul.CC; Rodina a typ: Vstupně - výstupní modul.CC: Vstupně - výstupní modul Horizontální; Typ: Vstupně - výstupní modul Horizontální; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:51
Name (Vstupně - výstupní modul.CC:Vstupně - výstupní modul Horizontální:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Fáze vytvoření | Kód prvku | Označení
983034 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2200 | Fáze 2 | EP16.07.0345 | 0345
984208 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2200 | Fáze 2 | EP16.07.0346 | 0346
984275 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0347 | 0347
984277 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0348 | 0348
984290 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0349 | 0349
984299 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0350 | 0350
984308 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2200 | Fáze 2 | EP16.07.0351 | 0351
984317 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2200 | Fáze 2 | EP16.07.0352 | 0352
984385 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0353 | 0353
984388 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0354 | 0354
984391 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2200 | Fáze 2 | EP16.07.0355 | 0355
984394 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2200 | Fáze 2 | EP16.07.0356 | 0356
984430 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2200 | Fáze 2 | EP16.07.0357 | 0357
984433 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2200 | Fáze 2 | EP16.07.0358 | 0358
1009630 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0379 | 0379
1009650 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0380 | 0380
1009659 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0381 | 0381
1009687 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0382 | 0382
1009698 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0383 | 0383
1009719 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0384 | 0384
1009727 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0385 | 0385
1009753 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0386 | 0386
1009761 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0387 | 0387
1009779 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0388 | 0388
1009796 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0389 | 0389
1009805 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0390 | 0390
1009828 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0391 | 0391
1029883 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0396 | 0396
1030006 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0401 | 0401
1030527 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0410 | 0410
1030544 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0411 | 0411
1030563 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2200 | Fáze 1 | EP16.07.0412 | 0412
1033022 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP16.07.0414 | 0414
1033032 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1800 | Fáze 1 | EP16.07.0415 | 0415
1033039 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 1750 | Fáze 1 | EP16.07.0416 | 0416
1033250 | -2.PP_SO-102 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 1800 | Fáze 1 | EP16.07.0422 | 0422
1033460 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1800 | Fáze 2 | EP16.07.0430 | 0430
1033468 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1800 | Fáze 2 | EP16.07.0431 | 0431

# IfcAlarm: Vstupně - výstupní modul.CC:Vstupně - výstupní modul Vertikální (16)
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 3; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 1800 mm
Type - Elektrotechnika - NAPĚTÍ: 0 V
Type - Grafika - Symbol: yes; Svislé umístění: yes; Vodorovné umístění: no
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP16; Komentáře k typům: vstupně - výstupní; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Vstupně - výstupní modul Vertikální; Označení typu: 08; Popis: Modul; Popis sestavy: Vstupně/výstupní prvek (koppler); URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Požární poplachová zařízení; FAKTOR ÚČINNOSTI: 1; Název rodiny: Vstupně - výstupní modul.CC
Classification: EP16 Uniformat (Uniformat)
Elektroinstalace – obvody - Údaje k elektroinstalaci: 0 V/3-0.0 kW
Text - CCI Funkční systém: L; CCI Komponenta: KEC; CCI Technický systém: LB
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - DÉLKA: 200 mm; HLOUBKA: 50 mm; Objem: 0.001509 m3; ŠÍŘKA: 150 mm
Jiné - Rodina: Vstupně - výstupní modul.CC; a: 80 mm; b: 45 mm; Id typu: 983018; Rodina a typ: Vstupně - výstupní modul.CC: Vstupně - výstupní modul Vertikální; Typ: Vstupně - výstupní modul Vertikální; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:51
Name (Vstupně - výstupní modul.CC:Vstupně - výstupní modul Vertikální:...) | In | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
984456 | -1.PP_SO-102 | 0 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | EP16.08.0359 | 0359
984502 | -1.PP_SO-102 | 1600 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | EP16.08.0361 | 0361
984514 | -1.PP_SO-102 | 0 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | EP16.08.0363 | 0363
984526 | -1.PP_SO-102 | 0 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | EP16.08.0365 | 0365
984540 | 2.NP_SO-102 | 2200 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | EP16.08.0367 | 0367
984549 | -1.PP_SO-102 | 0 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | EP16.08.0369 | 0369
984561 | -1.PP_SO-102 | 0 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | EP16.08.0371 | 0371
984573 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | EP16.08.0373 | 0373
984582 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | EP16.08.0375 | 0375
1033055 | -1.PP_SO-102 | 1750 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | EP16.08.0417 | 0417
1034881 | -1.PP_SO-102 | 0 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | EP16.08.0435 | 0435
1053627 | 2.NP_SO-102 | 2200 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | EP16.08.0502 | 0502
1053635 | 2.NP_SO-102 | 2200 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | EP16.08.0503 | 0503
1071989 | -1.PP_SO-102 | 1750 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | EP16.08.0519 | 0519
1071998 | -1.PP_SO-102 | 1750 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | EP16.08.0520 | 0520
1072009 | -1.PP_SO-102 | 1750 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | EP16.08.0521 | 0521

# IfcBuildingElementProxy: Autonomní požární hlásič.CC:APH.1, Autonomní požární hlásič.CC:APH.1:1056378
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Grafika - Symbol: yes; Typ symbolu: Automatický požární hlásič.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.00.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP02; Komentáře k typům: automatický; Model: Model; Nadpis OmniClass: Information and Communication; Název typu: APH.1; Označení typu: 04; Popis: Požární hlásič; Popis sestavy: Optický hlásič; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - FAKTOR ÚČINNOSTI: 1; Kategorie: Zabezpečovací zařízení; Název rodiny: Autonomní požární hlásič.CC
Classification: EP02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.073507 m2; NetVolume: 0.000471217 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: L; CCI Komponenta: BBB; CCI Technický systém: LB
Vazby - Podlaží: 1.NP_SO-102; Hostitel: Podlaží : 1.NP_SO-102; Odsazení od hostitele: 1500 mm; Výška od podlaží: 1500 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000471217 m3
Identifikační data - Kód prvku: EP02.04.0019; Označení: 0019
Jiné - Id typu: 276771; Rodina: Autonomní požární hlásič.CC; Rodina a typ: Autonomní požární hlásič.CC: APH.1; Typ: APH.1; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:44

# IfcBuildingElementProxy: Autonomní požární hlásič.CC:APH.2, Autonomní požární hlásič.CC:APH.2:1056532
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Elektroinstalace - POČET FÁZÍ: 1; PŘÍKON: 0 W
Type - Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 230 V
Type - Grafika - Symbol: yes; Typ symbolu: Automatický požární hlásič.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.00.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP02; Komentáře k typům: automatický; Model: Model; Nadpis OmniClass: Information and Communication; Název typu: APH.2; Označení typu: 06; Popis: Požární hlásič; Popis sestavy: Optický hlásič; URL: www.cadconsulting.cz; Version: 1.0; Výrobce: Výrobce
Type - Jiné - FAKTOR ÚČINNOSTI: 1; Kategorie: Zabezpečovací zařízení; Název rodiny: Autonomní požární hlásič.CC
Classification: EP02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.073507 m2; NetVolume: 0.000471217 m3
Elektroinstalace – obvody - Údaje k elektroinstalaci: 230 V/1-0.0 kW
Text - CCI Funkční systém: L; CCI Komponenta: BBB; CCI Technický systém: LB
Vazby - Podlaží: 1.NP_SO-102; Hostitel: Podlaží : 1.NP_SO-102; Odsazení od hostitele: 2250 mm; Výška od podlaží: 2250 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000471217 m3
Identifikační data - Kód prvku: EP02.06.0021; Označení: 0021
Jiné - Rodina: Autonomní požární hlásič.CC; Id typu: 1056480; Rodina a typ: Autonomní požární hlásič.CC: APH.2; Typ: APH.2; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:44

# IfcBuildingElementProxy: Siréna.CC:Siréna bez optické signalizace, Siréna.CC:Siréna bez optické signalizace:1056389
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Elektroinstalace - PŘÍKON: 0 W
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - NAPĚTÍ: 0 V
Type - Grafika - Symbol: yes; Maják: no; Typ symbolu: kombinovaná siréna.CC : Kombinovaná siréna.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP11; Komentáře k typům: Siréna bez optické signalizace; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Siréna bez optické signalizace; Označení typu: 05; Popis: Siréna bez optické signalizace; Popis sestavy: Siréna s majákem; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Zabezpečovací zařízení; Název rodiny: Siréna.CC
Classification: EP11 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0361906 m2; NetVolume: 0.000550788 m3
Text - CCI Funkční systém: L; CCI Komponenta: PJB; CCI Technický systém: LB
Vazby - Podlaží: 1.NP_SO-102; Hostitel: Podlaží : 1.NP_SO-102; Odsazení od hostitele: 1500 mm; Výška od podlaží: 1500 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000550788 m3; Plocha: 0.00157063 m2
Identifikační data - Kód prvku: EP11.05.0020; Označení: 0020
Jiné - Id typu: 644641; Rodina: Siréna.CC; Rodina a typ: Siréna.CC: Siréna bez optické signalizace; Typ: Siréna bez optické signalizace; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:49

# IfcBuildingElementProxy: Tlačítko nouzové.CC:Tlačítko nouzové - CS.CC, Tlačítko nouzové.CC:Tlačítko nouzové - CS.CC:978452
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: SI09; Komentáře k typům: emergency; Model: Model; Nadpis OmniClass: Access Controls; Název typu: Tlačítko nouzové - CS.CC; Označení typu: 02; Popis: CENTRAL STOP; Popis sestavy: Tlačítko 1/10; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Zabezpečovací zařízení; Název rodiny: Tlačítko nouzové.CC
Classification: SI09 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0274649 m2; NetVolume: 0.000242872 m3
Text - CCI Funkční systém: L; CCI Komponenta: SJB; CCI Technický systém: LB
Vazby - Podlaží: 1.NP_SO-102; Hostitel: Podlaží : 1.NP_SO-102; Odsazení od hostitele: 1700 mm; Výška od podlaží: 1700 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000242872 m3
Identifikační data - Kód prvku: SI09.02.0002; Označení: 0002
Jiné - Rodina: Tlačítko nouzové.CC; Id typu: 254939; Rodina a typ: Tlačítko nouzové.CC: Tlačítko nouzové - CS.CC; Typ: Tlačítko nouzové - CS.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.27 02:42

# IfcBuildingElementProxy: Tlačítko nouzové.CC:Tlačítko nouzové - TS.CC, Tlačítko nouzové.CC:Tlačítko nouzové - TS.CC:978448
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: SI09; Komentáře k typům: emergency; Model: Model; Nadpis OmniClass: Access Controls; Název typu: Tlačítko nouzové - TS.CC; Označení typu: 01; Popis: TOTAL STOP; Popis sestavy: Tlačítko 1/10; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Zabezpečovací zařízení; Název rodiny: Tlačítko nouzové.CC
Classification: SI09 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0274649 m2; NetVolume: 0.000242872 m3
Text - CCI Funkční systém: L; CCI Komponenta: SJB; CCI Technický systém: LB
Vazby - Podlaží: 1.NP_SO-102; Hostitel: Podlaží : 1.NP_SO-102; Odsazení od hostitele: 1700 mm; Výška od podlaží: 1700 mm
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000242872 m3
Identifikační data - Kód prvku: SI09.01.0001; Označení: 0001
Jiné - Id typu: 1030260; Rodina: Tlačítko nouzové.CC; Rodina a typ: Tlačítko nouzové.CC: Tlačítko nouzové - TS.CC; Typ: Tlačítko nouzové - TS.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.27 02:41

# IfcBuildingElementProxy: Tlačítko odchodové.CC:Tlačítko odchodové.CC (16)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: SI09; Komentáře k typům: odchodové; Model: Model; Nadpis OmniClass: Access Controls; Název typu: Tlačítko odchodové.CC; Označení typu: 03; Popis: Tlačítko; Popis sestavy: Tlačítko 1/10; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Zabezpečovací zařízení; Název rodiny: Tlačítko odchodové.CC
Classification: SI09 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0601622 m2; NetVolume: 0.000757411 m3
Text - CCI Funkční systém: L; CCI Komponenta: SJB; CCI Technický systém: LB
Vazby - Odsazení od hostitele: 1500 mm; Výška od podlaží: 1500 mm
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000757411 m3
Jiné - Id typu: 984159; Rodina: Tlačítko odchodové.CC; Rodina a typ: Tlačítko odchodové.CC: Tlačítko odchodové.CC; Typ: Tlačítko odchodové.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:51
Name (Tlačítko odchodové.CC:Tlačítko odchodové.CC:...) | In | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
984175 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | SI09.03.0003 | 0003
984209 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | SI09.03.0004 | 0004
984276 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | SI09.03.0005 | 0005
984278 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | SI09.03.0006 | 0006
984291 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | SI09.03.0007 | 0007
984300 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | SI09.03.0008 | 0008
984309 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | SI09.03.0009 | 0009
984318 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | SI09.03.0010 | 0010
984386 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | SI09.03.0011 | 0011
984389 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | SI09.03.0012 | 0012
984392 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | SI09.03.0013 | 0013
984395 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | SI09.03.0014 | 0014
984431 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | SI09.03.0015 | 0015
984434 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | SI09.03.0016 | 0016
1029884 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | SI09.03.0017 | 0017
1030413 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | SI09.03.0018 | 0018

# IfcBuildingElementProxy: Ústředna_Požární.CC:OPPO_Požární.CC, Ústředna_Požární.CC:OPPO_Požární.CC:914633
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes
Type - Kóty - HLOUBKA: 95 mm; ŠÍŘKA: 270 mm; VÝŠKA: 185 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP01; Komentáře k typům: požární; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: OPPO_Požární.CC; Označení typu: 01; Popis: Ovládací požární pole; Popis sestavy: Ústředna EPS; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Ústředna_Požární.CC
Classification: EP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.19065 m2; NetVolume: 0.004675 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 0 V/1-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: L; CCI Komponenta: XDC; CCI Technický systém: LB
Vazby - Hostitel: Podlaží : 1.NP_SO-102; Odsazení od hostitele: 1400 mm; Podlaží: 1.NP_SO-102; Výška od podlaží: 1400 mm
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - NAPĚTÍ: 0 V; POČET FÁZÍ: 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.004675 m3
Identifikační data - Kód prvku: EP01.01.0001; Označení: 0001
Jiné - Id typu: 914628; Rodina: Ústředna_Požární.CC; Rodina a typ: Ústředna_Požární.CC: OPPO_Požární.CC; Typ: OPPO_Požární.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:51

# IfcBuildingElementProxy: Ústředna_Požární.CC:Tablo obsluhy_Požární_1.CC, Ústředna_Požární.CC:Tablo obsluhy_Požární_1.CC:1052900
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes
Type - Kóty - HLOUBKA: 300 mm; ŠÍŘKA: 500 mm; VÝŠKA: 600 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP01; Komentáře k typům: požární; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Tablo obsluhy_Požární_1.CC; Označení typu: 04; Popis: Ústředna; Popis sestavy: Ústředna EPS; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Ústředna_Požární.CC
Classification: EP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.29998 m2; NetVolume: 0.089645 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 0 V/1-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: L; CCI Komponenta: XDC; CCI Technický systém: LB
Vazby - Podlaží: 1.NP_SO-102; Hostitel: Podlaží : 1.NP_SO-102; Odsazení od hostitele: 1500 mm; Výška od podlaží: 1500 mm
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - POČET FÁZÍ: 1; NAPĚTÍ: 0 V
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.089645 m3
Identifikační data - Kód prvku: EP01.04.0004; Označení: 0004
Jiné - Rodina: Ústředna_Požární.CC; Páteřní trasa: yes; Id typu: 1052814; Rodina a typ: Ústředna_Požární.CC: Tablo obsluhy_Požární_1.CC; Typ: Tablo obsluhy_Požární_1.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:51

# IfcBuildingElementProxy: Ústředna_Požární.CC:Tablo obsluhy_Požární_2.CC, Ústředna_Požární.CC:Tablo obsluhy_Požární_2.CC:1052827
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes
Type - Kóty - HLOUBKA: 300 mm; ŠÍŘKA: 500 mm; VÝŠKA: 600 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP01; Komentáře k typům: požární; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Tablo obsluhy_Požární_2.CC; Označení typu: 03; Popis: Ústředna; Popis sestavy: Ústředna EPS; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Ústředna_Požární.CC
Classification: EP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.29998 m2; NetVolume: 0.089645 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 0 V/1-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: L; CCI Komponenta: XDC; CCI Technický systém: LB
Vazby - Podlaží: 1.NP_SO-102; Hostitel: Podlaží : 1.NP_SO-102; Odsazení od hostitele: 1500 mm; Výška od podlaží: 1500 mm
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - POČET FÁZÍ: 1; NAPĚTÍ: 0 V
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.089645 m3
Identifikační data - Kód prvku: EP01.03.0003; Označení: 0003
Jiné - Rodina: Ústředna_Požární.CC; Páteřní trasa: yes; Id typu: 1052816; Rodina a typ: Ústředna_Požární.CC: Tablo obsluhy_Požární_2.CC; Typ: Tablo obsluhy_Požární_2.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:52

# IfcBuildingElementProxy: Ústředna_Požární.CC:Tablo obsluhy_Požární_3.CC, Ústředna_Požární.CC:Tablo obsluhy_Požární_3.CC:1053033
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes
Type - Kóty - HLOUBKA: 300 mm; ŠÍŘKA: 500 mm; VÝŠKA: 600 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP01; Komentáře k typům: požární; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Tablo obsluhy_Požární_3.CC; Označení typu: 05; Popis: Ústředna; Popis sestavy: Ústředna EPS; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Ústředna_Požární.CC
Classification: EP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.29998 m2; NetVolume: 0.089645 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 0 V/1-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: L; CCI Komponenta: XDC; CCI Technický systém: LB
Vazby - Podlaží: 1.NP_SO-102; Hostitel: Podlaží : 1.NP_SO-102; Odsazení od hostitele: 1500 mm; Výška od podlaží: 1500 mm
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - POČET FÁZÍ: 1; NAPĚTÍ: 0 V
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.089645 m3
Identifikační data - Kód prvku: EP01.05.0005; Označení: 0005
Jiné - Rodina: Ústředna_Požární.CC; Páteřní trasa: yes; Id typu: 1052818; Rodina a typ: Ústředna_Požární.CC: Tablo obsluhy_Požární_3.CC; Typ: Tablo obsluhy_Požární_3.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:52

# IfcBuildingElementProxy: Ústředna_Požární.CC:Tablo obsluhy_Požární_5.CC, Ústředna_Požární.CC:Tablo obsluhy_Požární_5.CC:1053357
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes
Type - Kóty - HLOUBKA: 300 mm; ŠÍŘKA: 500 mm; VÝŠKA: 600 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP01; Komentáře k typům: požární; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Tablo obsluhy_Požární_5.CC; Označení typu: 06; Popis: Ústředna; Popis sestavy: Ústředna EPS; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Ústředna_Požární.CC
Classification: EP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.29998 m2; NetVolume: 0.089645 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 0 V/1-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: L; CCI Komponenta: XDC; CCI Technický systém: LB
Vazby - Odsazení od hostitele: 0 mm; Podlaží: -1.PP_SO-102; Výška od podlaží: 0 mm; Hostitel: Podlaží : -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 2
Elektrotechnika - POČET FÁZÍ: 1; NAPĚTÍ: 0 V
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.089645 m3
Identifikační data - Kód prvku: EP01.06.0006; Označení: 0006
Jiné - Rodina: Ústředna_Požární.CC; Páteřní trasa: yes; Id typu: 1052824; Rodina a typ: Ústředna_Požární.CC: Tablo obsluhy_Požární_5.CC; Typ: Tablo obsluhy_Požární_5.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:52

# IfcBuildingElementProxy: Ústředna_Požární.CC:Ústředna_Požární.CC, Ústředna_Požární.CC:Ústředna_Požární.CC:973793
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Symbol: yes
Type - Kóty - HLOUBKA: 300 mm; ŠÍŘKA: 500 mm; VÝŠKA: 600 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.30.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: EP01; Komentáře k typům: požární; Model: Model; Nadpis OmniClass: Safety and Security Information Systems; Název typu: Ústředna_Požární.CC; Označení typu: 02; Popis: Ústředna; Popis sestavy: Ústředna EPS; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Ústředna_Požární.CC
Classification: EP01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.29998 m2; NetVolume: 0.089645 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 0 V/1-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: L; CCI Komponenta: XDC; CCI Technický systém: LB
Vazby - Podlaží: -1.PP_SO-102; Hostitel: Podlaží : -1.PP_SO-102; Odsazení od hostitele: 900 mm; Výška od podlaží: 900 mm
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - POČET FÁZÍ: 1; NAPĚTÍ: 0 V
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.089645 m3
Identifikační data - Kód prvku: EP01.02.0002; Označení: 0002
Jiné - Rodina: Ústředna_Požární.CC; Id typu: 256501; Páteřní trasa: yes; Rodina a typ: Ústředna_Požární.CC: Ústředna_Požární.CC; Typ: Ústředna_Požární.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 02:52

# IfcDistributionPort (1385)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: CABLE
Name | SystemType
Port_914633_1 | ELECTROACOUSTIC
Port_914633_2 | ELECTRICAL
Port_968065_1 | ELECTROACOUSTIC
Port_968077_1 | ELECTROACOUSTIC
Port_969216_2 | ELECTROACOUSTIC
Port_969224_2 | ELECTROACOUSTIC
Port_969258_1 | ELECTROACOUSTIC
Port_969258_2 | SECURITY
Port_969258_3 | ELECTRICAL
Port_969262_1 | ELECTROACOUSTIC
Port_969262_2 | SECURITY
Port_969262_3 | ELECTRICAL
Port_969266_1 | ELECTROACOUSTIC
Port_969266_2 | SECURITY
Port_969266_3 | ELECTRICAL
Port_969321_1 | ELECTROACOUSTIC
Port_969321_2 | SECURITY
Port_969321_3 | ELECTRICAL
Port_969325_1 | ELECTROACOUSTIC
Port_969325_2 | SECURITY
Port_969325_3 | ELECTRICAL
Port_969337_2 | ELECTROACOUSTIC
Port_969345_1 | ELECTROACOUSTIC
Port_969349_1 | ELECTROACOUSTIC
Port_969353_1 | ELECTROACOUSTIC
Port_969357_1 | ELECTROACOUSTIC
Port_969361_1 | ELECTROACOUSTIC
Port_969365_1 | ELECTROACOUSTIC
Port_969369_1 | ELECTROACOUSTIC
Port_969373_1 | ELECTROACOUSTIC
Port_969377_1 | ELECTROACOUSTIC
Port_969390_1 | ELECTROACOUSTIC
Port_969394_1 | ELECTROACOUSTIC
Port_969398_1 | ELECTROACOUSTIC
Port_969402_1 | ELECTROACOUSTIC
Port_969409_1 | ELECTROACOUSTIC
Port_969409_2 | SECURITY
Port_969409_3 | ELECTRICAL
Port_969413_1 | ELECTROACOUSTIC
Port_969413_2 | SECURITY
Port_969413_3 | ELECTRICAL
Port_969417_1 | ELECTROACOUSTIC
Port_969417_2 | SECURITY
Port_969417_3 | ELECTRICAL
Port_969430_1 | ELECTROACOUSTIC
Port_969430_2 | SECURITY
Port_969430_3 | ELECTRICAL
Port_969434_1 | ELECTROACOUSTIC
Port_969434_2 | SECURITY
Port_969434_3 | ELECTRICAL
Port_969438_1 | ELECTROACOUSTIC
Port_969438_2 | SECURITY
Port_969438_3 | ELECTRICAL
Port_969442_1 | ELECTROACOUSTIC
Port_969442_2 | SECURITY
Port_969442_3 | ELECTRICAL
Port_969446_1 | ELECTROACOUSTIC
Port_969446_2 | SECURITY
Port_969446_3 | ELECTRICAL
Port_969450_1 | ELECTROACOUSTIC
Port_969450_2 | SECURITY
Port_969450_3 | ELECTRICAL
Port_969454_1 | ELECTROACOUSTIC
Port_969454_2 | SECURITY
Port_969454_3 | ELECTRICAL
Port_969458_1 | ELECTROACOUSTIC
Port_969458_2 | SECURITY
Port_969458_3 | ELECTRICAL
Port_969462_1 | ELECTROACOUSTIC
Port_969462_2 | SECURITY
Port_969462_3 | ELECTRICAL
Port_969466_1 | ELECTROACOUSTIC
Port_969466_2 | SECURITY
Port_969466_3 | ELECTRICAL
Port_969470_1 | ELECTROACOUSTIC
Port_969470_2 | SECURITY
Port_969470_3 | ELECTRICAL
Port_969474_1 | ELECTROACOUSTIC
Port_969474_2 | SECURITY
Port_969474_3 | ELECTRICAL
Port_969478_1 | ELECTROACOUSTIC
Port_969478_2 | SECURITY
Port_969478_3 | ELECTRICAL
Port_969482_1 | ELECTROACOUSTIC
Port_969482_2 | SECURITY
Port_969482_3 | ELECTRICAL
Port_969486_1 | ELECTROACOUSTIC
Port_969486_2 | SECURITY
Port_969486_3 | ELECTRICAL
Port_969490_1 | ELECTROACOUSTIC
Port_969490_2 | SECURITY
Port_969490_3 | ELECTRICAL
Port_969494_1 | ELECTROACOUSTIC
Port_969494_2 | SECURITY
Port_969494_3 | ELECTRICAL
Port_969498_1 | ELECTROACOUSTIC
Port_969498_2 | SECURITY
Port_969498_3 | ELECTRICAL
Port_969502_1 | ELECTROACOUSTIC
Port_969502_2 | SECURITY
Port_969502_3 | ELECTRICAL
Port_969506_1 | ELECTROACOUSTIC
Port_969506_2 | SECURITY
Port_969506_3 | ELECTRICAL
Port_969510_1 | ELECTROACOUSTIC
Port_969510_2 | SECURITY
Port_969510_3 | ELECTRICAL
Port_969514_1 | ELECTROACOUSTIC
Port_969514_2 | SECURITY
Port_969514_3 | ELECTRICAL
Port_969518_1 | ELECTROACOUSTIC
Port_969518_2 | SECURITY
Port_969518_3 | ELECTRICAL
Port_969522_1 | ELECTROACOUSTIC
Port_969522_2 | SECURITY
Port_969522_3 | ELECTRICAL
Port_969526_1 | ELECTROACOUSTIC
Port_969526_2 | SECURITY
Port_969526_3 | ELECTRICAL
Port_969530_1 | ELECTROACOUSTIC
Port_969530_2 | SECURITY
Port_969530_3 | ELECTRICAL
Port_969534_1 | ELECTROACOUSTIC
Port_969534_2 | SECURITY
Port_969534_3 | ELECTRICAL
Port_969559_1 | ELECTROACOUSTIC
Port_969559_2 | SECURITY
Port_969559_3 | ELECTRICAL
Port_969563_1 | ELECTROACOUSTIC
Port_969563_2 | SECURITY
Port_969563_3 | ELECTRICAL
Port_969567_1 | ELECTROACOUSTIC
Port_969567_2 | SECURITY
Port_969567_3 | ELECTRICAL
Port_969571_1 | ELECTROACOUSTIC
Port_969571_2 | SECURITY
Port_969571_3 | ELECTRICAL
Port_969575_1 | ELECTROACOUSTIC
Port_969575_2 | SECURITY
Port_969575_3 | ELECTRICAL
Port_969579_1 | ELECTROACOUSTIC
Port_969579_2 | SECURITY
Port_969579_3 | ELECTRICAL
Port_969588_1 | ELECTROACOUSTIC
Port_969588_2 | SECURITY
Port_969588_3 | ELECTRICAL
Port_969592_1 | ELECTROACOUSTIC
Port_969592_2 | SECURITY
Port_969592_3 | ELECTRICAL
Port_969596_1 | ELECTROACOUSTIC
Port_969596_2 | SECURITY
Port_969596_3 | ELECTRICAL
Port_969600_1 | ELECTROACOUSTIC
Port_969600_2 | SECURITY
Port_969600_3 | ELECTRICAL
Port_969604_1 | ELECTROACOUSTIC
Port_969604_2 | SECURITY
Port_969604_3 | ELECTRICAL
Port_969608_1 | ELECTROACOUSTIC
Port_969608_2 | SECURITY
Port_969608_3 | ELECTRICAL
Port_969612_1 | ELECTROACOUSTIC
Port_969612_2 | SECURITY
Port_969612_3 | ELECTRICAL
Port_969616_1 | ELECTROACOUSTIC
Port_969616_2 | SECURITY
Port_969616_3 | ELECTRICAL
Port_969620_1 | ELECTROACOUSTIC
Port_969620_2 | SECURITY
Port_969620_3 | ELECTRICAL
Port_969624_1 | ELECTROACOUSTIC
Port_969624_2 | SECURITY
Port_969624_3 | ELECTRICAL
Port_969628_1 | ELECTROACOUSTIC
Port_969628_2 | SECURITY
Port_969628_3 | ELECTRICAL
Port_969632_1 | ELECTROACOUSTIC
Port_969632_2 | SECURITY
Port_969632_3 | ELECTRICAL
Port_969643_1 | ELECTROACOUSTIC
Port_969643_2 | SECURITY
Port_969643_3 | ELECTRICAL
Port_969647_1 | ELECTROACOUSTIC
Port_969647_2 | SECURITY
Port_969647_3 | ELECTRICAL
Port_970867_1 | ELECTROACOUSTIC
Port_970928_1 | ELECTROACOUSTIC
Port_970928_2 | SECURITY
Port_970928_3 | ELECTRICAL
Port_970935_1 | ELECTROACOUSTIC
Port_970935_2 | SECURITY
Port_970935_3 | ELECTRICAL
Port_970939_1 | ELECTROACOUSTIC
Port_970939_2 | SECURITY
Port_970939_3 | ELECTRICAL
Port_970943_1 | ELECTROACOUSTIC
Port_970943_2 | SECURITY
Port_970943_3 | ELECTRICAL
Port_970947_1 | ELECTROACOUSTIC
Port_970947_2 | SECURITY
Port_970947_3 | ELECTRICAL
