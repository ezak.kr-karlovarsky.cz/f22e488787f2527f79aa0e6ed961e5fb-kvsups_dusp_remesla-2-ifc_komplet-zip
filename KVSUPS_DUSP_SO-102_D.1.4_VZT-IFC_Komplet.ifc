Properties of the parts of a building model (IFC4), part 30 of 45

# IfcDuctFitting: M_Hranatý přechod, úhel:45 stupňů (66)
Name (M_Hranatý přechod, úhel:45 stupňů:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Rozdíl šířek (mm) | Šířkové odsazení (mm) | Délka potrubí (mm) = Max. rozdíl (mm) = Vypočítaná délka (mm) | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Poloviční šířka 1 (mm) | Poloviční šířka 2 (mm) | Poloviční výška 1 (mm) | Poloviční výška 2 (mm) | Rozdíl výšek (mm) | Šířka potrubí 1 (mm) | Šířka potrubí 2 (mm) | Velikost | Výška potrubí 1 (mm) | Výška potrubí 2 (mm) | Výškové odsazení (mm) | Kód prvku | Označení | Páteřní trasa | Čís.1 | Čís.2 | Čís.3 | Čís.4 | Čís.6 | Delta 1 (mm) | Čís.5 | Čís.7 | Čís.8 | Délka 1 (mm) | Délka 2 (mm) | Delta 2 (mm)
13097600 | 2.NP_SO-102 | 450 | 0.48 | 1.37184 | 450 mm × 1100 mm-450 mm × 500 mm | 0 | 2.NP_SO-102 | 1414 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 0 | 3048 | 600 | 0.216 | 225 | 850 | 0.705935 | 225 | 225 | 550 | 250 | 600 | 450 | 450 | 450 × 1100-450 × 500 | 1100 | 500 | 3348 | TA00.06.0014 | 0014 | yes | 1 | 1 | 1 | 1 | 0 | 0 | 24 | 144 | 12 | 600 | 60.3553 | 300
13106116 | 2.NP_SO-102 | 400 | 0.28125 | 1.14142 | 1250 mm × 400 mm-1000 mm × 400 mm | 0 | 2.NP_SO-102 | 2920 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 250 | 2923 | 250 | 0.1125 | 375 | 200 | 0.566605 | 500 | 625 | 200 | 200 | 0 | 1000 | 1250 | 1250 × 400-1000 × 400 | 400 | 400 | 3048 | TA00.06.0021 | 0021 | yes | 10 | 0 | 25 | 5 | 1 | 125 | 1 | 1 | 1 | 60.3553 | 250 | 0
13106118 | 2.NP_SO-102 | 1250 | 0.02125 | 1.21339 | 1250 mm × 450 mm-1250 mm × 400 mm |  | 2.NP_SO-102 | 2895 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 0 | 3048 | 50 | 0.0265625 | 625 | 250 | 0.342439 | 625 | 625 | 225 | 200 | 50 | 1250 | 1250 | 1250 × 450-1250 × 400 | 450 | 400 | 3073 | TA00.06.0022 | 0022 | yes | 1 | 1 | 1 | 1 | 0 | 0 | 2 | 1 | 1 | 50 | 60.3553 | 25
13648025 | -1.PP_SO-102 | 500 | 0.482843 | 1.52263 | 1200 mm × 500 mm-800 mm × 500 mm |  | -1.PP_SO-102 | 1109 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 400 | 3048 | 482.843 | 0.241421 | 600 | 250 | 0.863499 | 600 | 400 | 250 | 250 | 0 | 1200 | 800 | 1200 × 500-800 × 500 | 500 | 500 | 3048 | TA00.06.0167 | 0167 | yes | 8 | 8 | 64 | 8 | 1 | 0 | 1 | 1 | 1 | 60.3553 | 482.843 | 0
13744705 | 3.NP_SO-102 | 630 | 0.074901 | 0.739766 | 450 mm × 630 mm-280 mm × 630 mm | 0 | 3.NP_SO-102 | 3710.48 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 170 | 3048 | 205.208 | 0.0471876 | 140 | 315 | 0.259842 | 140 | 225 | 315 | 315 | 0 | 280 | 450 | 450 × 630-280 × 630 | 630 | 630 | 3048 | TA00.06.0228 | 0228 | yes | 3.4 | 3.4 | 11.56 | 3.4 | 1 | 0 | 1 | 1 | 1 | 60.3553 | 205.208 | 0
13745242 | 2.NP_SO-102 | 710 | 0.114977 | 1.18 | 710 mm × 710 mm-710 mm × 560 mm | 0 | 2.NP_SO-102 | 2800 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 0 | 3048 | 181.066 | 0.0816336 | 355 | 280 | 0.416766 | 355 | 355 | 280 | 355 | 150 | 710 | 710 | 710 × 710-710 × 560 | 560 | 710 | 3048 | TA00.06.0230 | 0230 | yes | 1 | 1 | 1 | 1 | 3 | 0 | 3 | 9 | 3 | 181.066 | 60.3553 | 0
13766946 | 2.NP_SO-102 | 500 | 0.088662 | 0.734853 | 500 mm × 630 mm-500 mm × 500 mm | 0 | 2.NP_SO-102 | 3165 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 0 | 3048 | 156.924 | 0.044331 | 250 | 315 | 0.267275 | 250 | 250 | 315 | 250 | 130 | 500 | 500 | 500 × 630-500 × 500 | 630 | 500 | 3048 | TA00.06.0267 | 0267 | yes | 1 | 1 | 1 | 1 | 2.6 | 0 | 2.6 | 6.76 | 2.6 | 156.924 | 60.3553 | 0
13766964 | 3.NP_SO-102 | 500 | 0.10357 | 0.677444 | 500 mm × 500 mm-500 mm × 280 mm | 0 | 3.NP_SO-102 | 3260 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 0 | 3048 | 265.563 | 0.0517849 | 250 | 250 | 0.287537 | 250 | 250 | 250 | 140 | 220 | 500 | 500 | 500 × 500-500 × 280 | 500 | 280 | 3048 | TA00.06.0268 | 0268 | yes | 1 | 1 | 1 | 1 | 4.4 | 0 | 4.4 | 19.36 | 4.4 | 265.563 | 60.3553 | 0
13767569 | -1.PP_SO-102 | 400 | 0.153363 | 0.703503 | 710 mm × 400 mm-500 mm × 400 mm | 0 | -1.PP_SO-102 | 2499.7 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 210 | 3048 | 253.492 | 0.0613452 | 250 | 200 | 0.329239 | 250 | 355 | 200 | 200 | 0 | 500 | 710 | 710 × 400-500 × 400 | 400 | 400 | 3048 | TA00.06.0270 | 0270 | yes | 4.2 | 4.2 | 17.64 | 4.2 | 1 | 0 | 1 | 1 | 1 | 60.3553 | 253.492 | 0
13788846 | -1.PP_SO-102 |  |  |  | 1600 mm × 560 mm-1400 mm × 560 mm |  | -1.PP_SO-102 | 2405.78 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 200 | 3048 | 241.421 | 0.202794 | 800 | 282.535 | 0.85532 | 800 | 700 | 280 | 280 | 0 | 1600 | 1400 | 1600 × 560-1400 × 560 | 560 | 560 | 3050.54 | TA00.06.0296 | 0296 | yes | 4 | 4 | 16 | 4 | 1 | 0 | 1 | 1 | 1 | 60.3553 | 241.421 | 2.53531
13789192 | -1.PP_SO-102 | 1120 | 0.01 | 1.08375 | 1120 mm × 400 mm-1120 mm × 400 mm |  | -1.PP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 0 | 3048 | 25 | 0.0112 | 560 | 280 | 0.322873 | 560 | 560 | 200 | 200 | 0 | 1120 | 1120 | 1120 × 400-1120 × 400 | 400 | 400 | 3128 | TA00.06.0300 | 0300 | yes | 1 | 1 | 1 | 1 | 1 | 0 | 1 | 1 | 1 | 60.3553 | 60.3553 | 80
13792035 | 3.NP_SO-102 | 280 | 0.0871079 | 0.410804 | 630 mm × 280 mm-500 mm × 280 mm | 0 | 3.NP_SO-102 | 3050 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 130 | 3070.32 | 154.173 | 0.0243902 | 337.319 | 140 | 0.189809 | 315 | 250 | 140 | 140 | 0 | 630 | 500 | 630 × 280-500 × 280 | 280 | 280 | 3048 | TA00.06.0305 | 0305 | yes | 3.49275 | 1.70725 | 6.76 | 2.6 | 1 | 22.3187 | 1 | 1 | 1 | 60.3553 | 154.173 | 0
13792182 | 3.NP_SO-102 | 500 | 0.10357 | 0.677444 | 500 mm × 500 mm-500 mm × 280 mm |  | 3.NP_SO-102 | 3641.36 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 0 | 3048 | 265.563 | 0.0517849 | 250 | 250 | 0.287537 | 250 | 250 | 250 | 140 | 220 | 500 | 500 | 500 × 500-500 × 280 | 500 | 280 | 3048 | TA00.06.0306 | 0306 | yes | 1 | 1 | 1 | 1 | 4.4 | 0 | 4.4 | 19.36 | 4.4 | 265.563 | 60.3553 | 0
13792184 | 4.NP_SO-102 | 280 | 0.0834871 | 0.409118 | 280 mm × 630 mm-280 mm × 500 mm |  | 4.NP_SO-102 | 2755 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 0 | 3048 | 147.765 | 0.0233764 | 140 | 275 | 0.167653 | 140 | 140 | 315 | 250 | 130 | 280 | 280 | 280 × 630-280 × 500 | 630 | 500 | 3008 | TA00.06.0308 | 0308 | yes | 1 | 1 | 1 | 1 | 1 | 0 | 4.2 | 6.76 | 2.6 | 147.765 | 60.3553 | 40
13792333 | 2.NP_SO-102 | 500 | 0.088662 | 0.734853 | 500 mm × 630 mm-500 mm × 500 mm |  | 2.NP_SO-102 | 3274.82 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 0 | 3048 | 156.924 | 0.044331 | 250 | 250 | 0.267275 | 250 | 250 | 250 | 315 | 130 | 500 | 500 | 500 × 630-500 × 500 | 500 | 630 | 3048 | TA00.06.0309 | 0309 | yes | 1 | 1 | 1 | 1 | 2.6 | 0 | 2.6 | 6.76 | 2.6 | 156.924 | 60.3553 | 0
13792405 | 2.NP_SO-102 | 280 | 0.0861037 | 0.410339 | 630 mm × 280 mm-500 mm × 280 mm | 0 | 2.NP_SO-102 | 2807.72 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 130 | 3076.49 | 152.396 | 0.024109 | 343.495 | 140 | 0.188688 | 315 | 250 | 140 | 140 | 0 | 630 | 500 | 630 × 280-500 × 280 | 280 | 280 | 3048 | TA00.06.0311 | 0311 | yes | 3.7398 | 1.4602 | 6.76 | 2.6 | 1 | 28.4949 | 1 | 1 | 1 | 60.3553 | 152.396 | 0
13846868 | 2.NP_SO-102 | 1250 | 0.0280049 | 1.58066 | 1250 mm × 600 mm-1250 mm × 560 mm | 0 | 2.NP_SO-102 | 2800 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 0 | 3048 | 48.2843 | 0.0350061 | 625 | 280 | 0.439344 | 625 | 625 | 280 | 300 | 40 | 1250 | 1250 | 1250 × 600-1250 × 560 | 560 | 600 | 3048 | TA00.06.0417 | 0417 | yes | 1 | 1 | 1 | 1 | 0.8 | 0 | 0.8 | 0.64 | 0.8 | 48.2843 | 60.3553 | 0
13847146 | 2.NP_SO-102 | 1250 | 0.0280049 | 1.58066 | 1250 mm × 600 mm-1250 mm × 560 mm | 0 | 2.NP_SO-102 | 2800 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 0 | 3048 | 48.2843 | 0.0350061 | 625 | 300 | 0.439344 | 625 | 625 | 300 | 280 | 40 | 1250 | 1250 | 1250 × 600-1250 × 560 | 600 | 560 | 3048 | TA00.06.0419 | 0419 | yes | 1 | 1 | 1 | 1 | 0.8 | 0 | 0.8 | 0.64 | 0.8 | 48.2843 | 60.3553 | 0
13854302 | -1.PP_SO-102 | 1120 | 0.0768 | 1.50783 | 1120 mm × 560 mm-1120 mm × 400 mm |  | -1.PP_SO-102 | 2485.78 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 0 | 3048 | 160 | 0.086016 | 560 | 120 | 0.496976 | 560 | 560 | 200 | 280 | 160 | 1120 | 1120 | 1120 × 560-1120 × 400 | 400 | 560 | 2968 | TA00.06.0443 | 0443 | yes | 1 | 1 | 1 | 1 | 0 | 0 | 6.4 | 10.24 | 3.2 | 160 | 60.3553 | 80
13863668 | 2.NP_SO-102 |  |  |  | 2000 mm × 900 mm-1800 mm × 710 mm | 0 | 2.NP_SO-102 | 1809 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 200 | 3048 | 241.421 | 0.370018 | 900 | 355 | 1.3505 | 900 | 1000 | 355 | 450 | 190 | 1800 | 2000 | 2000 × 900-1800 × 710 | 710 | 900 | 3048 | TA00.06.0450 | 0450 | yes | 4 | 4 | 16 | 4 | 3.8 | 0 | 3.8 | 14.44 | 3.8 | 229.35 | 241.421 | 0
13865966 | -1.PP_SO-102 | 315 | 0.0444366 | 0.277211 | 315 mm × 315 mm-315 mm × 160 mm |  | -1.PP_SO-102 | 2580 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 97 | ETA | 0 | 3048 | 187.102 | 0.0139975 | 157.5 | 157.5 | 0.12099 | 157.5 | 157.5 | 157.5 | 80 | 155 | 315 | 315 | 315 × 315-315 × 160 | 315 | 160 | 3048 | TA00.06.0455 | 0455 | yes | 1 | 1 | 1 | 1 | 3.1 | 0 | 3.1 | 9.61 | 3.1 | 187.102 | 60.3553 | 0
13935325 | 2.NP_SO-102 | 1250 | 0.0543198 | 1.45164 | 1250 mm × 500 mm-1250 mm × 400 mm | 0 | 2.NP_SO-102 | 2920 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 0 | 3048 | 120.711 | 0.0678998 | 625 | 200 | 0.465514 | 625 | 625 | 200 | 250 | 100 | 1250 | 1250 | 1250 × 500-1250 × 400 | 400 | 500 | 3048 | TA00.06.0730 | 0730 | yes | 1 | 1 | 1 | 1 | 2 | 0 | 2 | 4 | 2 | 120.711 | 60.3553 | 0
13935327 | 2.NP_SO-102 | 1250 | 0.0543198 | 1.45164 | 1250 mm × 500 mm-1250 mm × 400 mm | 0 | 2.NP_SO-102 | 2920 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 0 | 3048 | 120.711 | 0.0678998 | 625 | 200 | 0.465514 | 625 | 625 | 200 | 250 | 100 | 1250 | 1250 | 1250 × 500-1250 × 400 | 400 | 500 | 3048 | TA00.06.0731 | 0731 | yes | 1 | 1 | 1 | 1 | 2 | 0 | 2 | 4 | 2 | 120.711 | 60.3553 | 0
13935415 | 2.NP_SO-102 |  |  |  | 1250 mm × 400 mm-1120 mm × 315 mm | 0 | 2.NP_SO-102 | 2920 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 130 | 3048 | 156.924 | 0.0666233 | 625 | 200 | 0.432866 | 625 | 560 | 200 | 157.5 | 85 | 1250 | 1120 | 1250 × 400-1120 × 315 | 400 | 315 | 3048 | TA00.06.0732 | 0732 | yes | 2.6 | 2.6 | 6.76 | 2.6 | 1.7 | 0 | 1.7 | 2.89 | 1.7 | 102.604 | 156.924 | 0
13938263 | 2.NP_SO-102 |  |  |  | 425 mm × 225 mm-400 mm × 180 mm | 0 | 2.NP_SO-102 | 2850 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 25 | 3048 | 54.3198 | 0.00454249 | 212.5 | 112.5 | 0.0708799 | 212.5 | 200 | 112.5 | 90 | 45 | 425 | 400 | 425 × 225-400 × 180 | 225 | 180 | 3048 | TA00.06.0755 | 0755 | yes | 0.5 | 0.5 | 0.25 | 0.5 | 0.9 | 0 | 0.9 | 0.81 | 0.9 | 54.3198 | 30.1777 | 0
13946467 | -1.PP_SO-102 | 160 | 0.0221655 | 0.117577 | 315 mm × 160 mm-250 mm × 160 mm |  | -1.PP_SO-102 | 2580 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 97 | ETA | 65 | 3048 | 78.4619 | 0.00354648 | 157.5 | 80 | 0.0515596 | 157.5 | 125 | 80 | 80 | 0 | 315 | 250 | 315 × 160-250 × 160 | 160 | 160 | 3048 | TA00.06.0771 | 0771 | yes | 1.3 | 1.3 | 1.69 | 1.3 | 1 | 0 | 1 | 1 | 1 | 60.3553 | 78.4619 | 0
13947311 | -1.PP_SO-102 |  |  |  | 500 mm × 400 mm-400 mm × 250 mm |  | -1.PP_SO-102 | 2980 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 100 | 3048 | 181.066 | 0.0267072 | 200 | 125 | 0.190361 | 200 | 250 | 125 | 200 | 150 | 400 | 500 | 500 × 400-400 × 250 | 250 | 400 | 3048 | TA00.06.0774 | 0774 | yes | 2 | 2 | 4 | 2 | 3 | 0 | 3 | 9 | 3 | 181.066 | 120.711 | 0
13978791 | 4.NP_SO-102 | 160 | 0.113166 | 0.224525 | 160 mm × 500 mm-160 mm × 250 mm | 0 | 4.NP_SO-102 | 2827.52 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 0 | 3048 | 301.777 | 0.0181066 | 80 | 250 | 0.136857 | 80 | 80 | 250 | 125 | 250 | 160 | 160 | 160 × 500-160 × 250 | 500 | 250 | 3048 | TA00.06.0862 | 0862 | no | 1 | 1 | 1 | 1 | 5 | 0 | 5 | 25 | 5 | 301.777 | 60.3553 | 0
14006812 | -1.PP_SO-102 | 800 | 0.0543198 | 0.92905 | 800 mm × 500 mm-800 mm × 400 mm |  | -1.PP_SO-102 | 3070 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 0 | 3048 | 120.711 | 0.0434558 | 400 | 250 | 0.307707 | 400 | 400 | 250 | 200 | 100 | 800 | 800 | 800 × 500-800 × 400 | 500 | 400 | 3048 | TA00.06.0943 | 0943 | yes | 1 | 1 | 1 | 1 | 2 | 0 | 2 | 4 | 2 | 120.711 | 60.3553 | 0
14010723 | 2.NP_SO-102 |  |  |  | 2400 mm × 1100 mm-900 mm × 1000 mm | 0 | 2.NP_SO-102 | 2159 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 11 | ETA | 1500 | 3798 | 1500 | 2.6175 | 1200 | 450 | 4.31128 | 450 | 1200 | 500 | 550 | 100 | 900 | 2400 | 2400 × 1100-900 × 1000 | 1000 | 1100 | 2998 | TA00.06.0955 | 0955 | yes | 60 | 0 | 900 | 30 | 0 | 750 | 4 | 4 | 2 | 100 | 1500 | 50
14030551 | 2.NP_SO-102 |  |  |  | 900 mm × 1000 mm-1000 mm × 400 mm | 0 | 2.NP_SO-102 | 2159 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 11 | ETA | 100 | 3048 | 724.264 | 0.478014 | 500 | 200 | 1.29549 | 500 | 450 | 200 | 500 | 600 | 1000 | 900 | 900 × 1000-1000 × 400 | 400 | 1000 | 3048 | TA00.06.0981 | 0981 | yes | 2 | 2 | 4 | 2 | 12 | 0 | 12 | 144 | 12 | 724.264 | 120.711 | 0
14033458 | 2.NP_SO-102 |  |  |  | 630 mm × 500 mm-500 mm × 225 mm | 0 | 2.NP_SO-102 | 2925 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 130 | 3048 | 331.954 | 0.0689774 | 250 | 112.5 | 0.363465 | 250 | 315 | 112.5 | 250 | 275 | 500 | 630 | 630 × 500-500 × 225 | 225 | 500 | 3048 | TA00.06.0991 | 0991 | yes | 2.6 | 2.6 | 6.76 | 2.6 | 5.5 | 0 | 5.5 | 30.25 | 5.5 | 331.954 | 156.924 | 0
14033537 | 2.NP_SO-102 |  |  |  | 630 mm × 500 mm-500 mm × 225 mm | 0 | 2.NP_SO-102 | 2925 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 130 | 3048 | 331.954 | 0.0689774 | 315 | 250 | 0.363465 | 315 | 250 | 250 | 112.5 | 275 | 630 | 500 | 630 × 500-500 × 225 | 500 | 225 | 3048 | TA00.06.0992 | 0992 | yes | 2.6 | 2.6 | 6.76 | 2.6 | 5.5 | 0 | 5.5 | 30.25 | 5.5 | 331.954 | 156.924 | 0
14038116 | 2.NP_SO-102 |  |  |  | 630 mm × 500 mm-500 mm × 225 mm | 0 | 2.NP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 130 | 3048 | 331.954 | 0.0689774 | 250 | 112.5 | 0.363465 | 250 | 315 | 112.5 | 250 | 275 | 500 | 630 | 630 × 500-500 × 225 | 225 | 500 | 3048 | TA00.06.1013 | 1013 | yes | 2.6 | 2.6 | 6.76 | 2.6 | 5.5 | 0 | 5.5 | 30.25 | 5.5 | 331.954 | 156.924 | 0
14038117 | 2.NP_SO-102 |  |  |  | 630 mm × 500 mm-500 mm × 225 mm | 0 | 2.NP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 130 | 3048 | 331.954 | 0.0689774 | 250 | 112.5 | 0.363465 | 250 | 315 | 112.5 | 250 | 275 | 500 | 630 | 630 × 500-500 × 225 | 225 | 500 | 3048 | TA00.06.1014 | 1014 | yes | 2.6 | 2.6 | 6.76 | 2.6 | 5.5 | 0 | 5.5 | 30.25 | 5.5 | 331.954 | 156.924 | 0
14041518 | 2.NP_SO-102 | 1250 | 0.038386 | 1.52098 | 1250 mm × 560 mm-1250 mm × 500 mm | 0 | 2.NP_SO-102 | 2800 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 0 | 3048 | 72.4264 | 0.0479825 | 625 | 280 | 0.444706 | 625 | 625 | 280 | 250 | 60 | 1250 | 1250 | 1250 × 560-1250 × 500 | 560 | 500 | 3048 | TA00.06.1033 | 1033 | yes | 1 | 1 | 1 | 1 | 1.2 | 0 | 1.2 | 1.44 | 1.2 | 72.4264 | 60.3553 | 0
14041520 | 2.NP_SO-102 | 1250 | 0.038386 | 1.52098 | 1250 mm × 560 mm-1250 mm × 500 mm | 0 | 2.NP_SO-102 | 2800 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 0 | 3048 | 72.4264 | 0.0479825 | 625 | 280 | 0.444706 | 625 | 625 | 280 | 250 | 60 | 1250 | 1250 | 1250 × 560-1250 × 500 | 560 | 500 | 3048 | TA00.06.1034 | 1034 | yes | 1 | 1 | 1 | 1 | 1.2 | 0 | 1.2 | 1.44 | 1.2 | 72.4264 | 60.3553 | 0
14059871 | -1.PP_SO-102 | 500 | 0.37515 | 1.40991 | 1120 mm × 500 mm-710 mm × 500 mm |  | -1.PP_SO-102 | 3080 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 410 | 2843 | 410 | 0.187575 | 150 | 250 | 0.727628 | 355 | 560 | 250 | 250 | 0 | 710 | 1120 | 1120 × 500-710 × 500 | 500 | 500 | 3048 | TA00.06.1103 | 1103 | yes | 16.4 | 0 | 67.24 | 8.2 | 1 | 205 | 1 | 1 | 1 | 60.3553 | 410 | 0
14078017 | 2.NP_SO-102 | 1250 | 0.02375 | 1.33839 | 1250 mm × 500 mm-1250 mm × 450 mm |  | 2.NP_SO-102 | 2895 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 0 | 3048 | 50 | 0.0296875 | 625 | 200 | 0.374939 | 625 | 625 | 225 | 250 | 50 | 1250 | 1250 | 1250 × 500-1250 × 450 | 450 | 500 | 3023 | TA00.06.1139 | 1139 | yes | 1 | 1 | 1 | 1 | 0 | 0 | 2 | 1 | 1 | 50 | 60.3553 | 25
14078018 | 2.NP_SO-102 |  |  |  | 1800 mm × 800 mm-1250 mm × 500 mm | 0 | 2.NP_SO-102 | 1559 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 550 | 3047.96 | 663.909 | 0.667228 | 899.963 | 400 | 1.77502 | 900 | 625 | 400 | 250 | 300 | 1800 | 1250 | 1800 × 800-1250 × 500 | 800 | 500 | 3048 | TA00.06.1140 | 1140 | yes | 11.0015 | 10.9985 | 121 | 11 | 6 | 0.0367297 | 6 | 36 | 6 | 362.132 | 663.909 | 0
14078019 | 2.NP_SO-102 |  |  |  | 1500 mm × 600 mm-1250 mm × 500 mm |  | 2.NP_SO-102 | 2870 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 250 | 3048 | 301.777 | 0.228847 | 750 | 300 | 0.888848 | 750 | 625 | 300 | 250 | 100 | 1500 | 1250 | 1500 × 600-1250 × 500 | 600 | 500 | 3048 | TA00.06.1141 | 1141 | yes | 5 | 5 | 25 | 5 | 2 | 0 | 2 | 4 | 2 | 120.711 | 301.777 | 0
14078020 | 2.NP_SO-102 |  |  |  | 1500 mm × 600 mm-1250 mm × 500 mm |  | 2.NP_SO-102 | 2870 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 250 | 3048 | 301.777 | 0.228847 | 750 | 300 | 0.888848 | 750 | 625 | 300 | 250 | 100 | 1500 | 1250 | 1500 × 600-1250 × 500 | 600 | 500 | 3048 | TA00.06.1142 | 1142 | yes | 5 | 5 | 25 | 5 | 2 | 0 | 2 | 4 | 2 | 120.711 | 301.777 | 0
14079428 | -1.PP_SO-102 |  |  |  | 500 mm × 400 mm-400 mm × 250 mm |  | -1.PP_SO-102 | 2980 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 100 | 3048 | 181.066 | 0.0267072 | 200 | 125 | 0.190361 | 200 | 250 | 125 | 200 | 150 | 400 | 500 | 500 × 400-400 × 250 | 250 | 400 | 3048 | TA00.06.1154 | 1154 | yes | 2 | 2 | 4 | 2 | 3 | 0 | 3 | 9 | 3 | 181.066 | 120.711 | 0
14079454 | -1.PP_SO-102 | 400 | 0.04925 | 0.39743 | 400 mm × 400 mm-400 mm × 280 mm |  | -1.PP_SO-102 | 2980 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 0 | 3048 | 144.853 | 0.0197 | 200 | 200 | 0.152953 | 200 | 200 | 200 | 140 | 120 | 400 | 400 | 400 × 400-400 × 280 | 400 | 280 | 3048 | TA00.06.1155 | 1155 | yes | 1 | 1 | 1 | 1 | 2.4 | 0 | 2.4 | 5.76 | 2.4 | 144.853 | 60.3553 | 0
14083822 | 2.NP_SO-102 | 1000 | 0.506985 | 2.96788 | 1000 mm × 1000 mm-1000 mm × 400 mm | 0 | 2.NP_SO-102 | 1779 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 11 | ETA | 0 | 3048 | 724.264 | 0.506985 | 500 | 500 | 1.35759 | 500 | 500 | 500 | 200 | 600 | 1000 | 1000 | 1000 × 1000-1000 × 400 | 1000 | 400 | 3048 | TA00.06.1178 | 1178 | yes | 1 | 1 | 1 | 1 | 12 | 0 | 12 | 144 | 12 | 724.264 | 60.3553 | 0
14084168 | 2.NP_SO-102 |  |  |  | 1250 mm × 400 mm-1120 mm × 315 mm | 0 | 2.NP_SO-102 | 2920 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 130 | 3048 | 156.924 | 0.0666233 | 560 | 157.5 | 0.432866 | 560 | 625 | 157.5 | 200 | 85 | 1120 | 1250 | 1250 × 400-1120 × 315 | 315 | 400 | 3048 | TA00.06.1179 | 1179 | yes | 2.6 | 2.6 | 6.76 | 2.6 | 1.7 | 0 | 1.7 | 2.89 | 1.7 | 102.604 | 156.924 | 0
14104005 | -1.PP_SO-102 | 315 | 0.0444366 | 0.277211 | 315 mm × 315 mm-315 mm × 160 mm | 0 | -1.PP_SO-102 | 2580 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 97 | ETA | 0 | 3048 | 187.102 | 0.0139975 | 157.5 | 157.5 | 0.12099 | 157.5 | 157.5 | 157.5 | 80 | 155 | 315 | 315 | 315 × 315-315 × 160 | 315 | 160 | 3048 | TA00.06.1184 | 1184 | yes | 1 | 1 | 1 | 1 | 3.1 | 0 | 3.1 | 9.61 | 3.1 | 187.102 | 60.3553 | 0
14109452 | -1.PP_SO-102 | 800 | 0.0748255 | 0.987123 | 800 mm × 500 mm-800 mm × 355 mm |  | -1.PP_SO-102 | 3080 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 0 | 3048 | 175.03 | 0.0598604 | 400 | 250 | 0.354206 | 400 | 400 | 250 | 177.5 | 145 | 800 | 800 | 800 × 500-800 × 355 | 500 | 355 | 3048 | TA00.06.1187 | 1187 | yes | 1 | 1 | 1 | 1 | 2.9 | 0 | 2.9 | 8.41 | 2.9 | 175.03 | 60.3553 | 0
14110297 | -1.PP_SO-102 | 710 | 0.0205057 | 0.619539 | 710 mm × 400 mm-710 mm × 355 mm | 0 | -1.PP_SO-102 | 3150 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 0 | 3048 | 54.3198 | 0.0145591 | 355 | 177.5 | 0.184421 | 355 | 355 | 177.5 | 200 | 45 | 710 | 710 | 710 × 400-710 × 355 | 355 | 400 | 3048 | TA00.06.1198 | 1198 | yes | 1 | 1 | 1 | 1 | 0.9 | 0 | 0.9 | 0.81 | 0.9 | 54.3198 | 60.3553 | 0
14110299 | -1.PP_SO-102 | 355 | 0.0820229 | 0.619539 | 800 mm × 355 mm-710 mm × 355 mm |  | -1.PP_SO-102 | 3150 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 3048 | 108.64 | 0.0291181 | 400 | 177.5 | 0.236908 | 400 | 355 | 177.5 | 177.5 | 0 | 800 | 710 | 800 × 355-710 × 355 | 355 | 355 | 3048 | TA00.06.1200 | 1200 | yes | 1.8 | 1.8 | 3.24 | 1.8 | 1 | 0 | 1 | 1 | 1 | 60.3553 | 108.64 | 0
14114159 | -1.PP_SO-102 | 1120 | 0.0543198 | 1.30067 | 1120 mm × 500 mm-1120 mm × 400 mm |  | -1.PP_SO-102 | 3080 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 0 | 3048.04 | 120.711 | 0.0608382 | 560.039 | 200 | 0.419925 | 560 | 560 | 200 | 250 | 100 | 1120 | 1120 | 1120 × 500-1120 × 400 | 400 | 500 | 3048 | TA00.06.1211 | 1211 | yes | 1 | 1 | 1 | 1 | 2 | 0.0391003 | 2 | 4 | 2 | 120.711 | 60.3553 | 0
14116059 | -1.PP_SO-102 | 800 | 0.0748255 | 0.987123 | 800 mm × 500 mm-800 mm × 355 mm | 0 | -1.PP_SO-102 | 2930 | Fáze 2 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | 0 | 3048 | 175.03 | 0.0598604 | 400 | 250 | 0.354206 | 400 | 400 | 250 | 177.5 | 145 | 800 | 800 | 800 × 500-800 × 355 | 500 | 355 | 3048 | TA00.06.1226 | 1226 | yes | 1 | 1 | 1 | 1 | 2.9 | 0 | 2.9 | 8.41 | 2.9 | 175.03 | 60.3553 | 0
14122399 | -1.PP_SO-102 | 800 | 0.0927058 | 1.10248 | 800 mm × 560 mm-800 mm × 400 mm |  | -1.PP_SO-102 | 2400 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 0 | 3048 | 193.137 | 0.0741646 | 400 | 200 | 0.399228 | 400 | 400 | 200 | 280 | 160 | 800 | 800 | 800 × 560-800 × 400 | 400 | 560 | 3048 | TA00.06.1278 | 1278 | yes | 1 | 1 | 1 | 1 | 3.2 | 0 | 3.2 | 10.24 | 3.2 | 193.137 | 60.3553 | 0
14122739 | -1.PP_SO-102 | 800 | 0.0927058 | 1.10248 | 800 mm × 560 mm-800 mm × 400 mm |  | -1.PP_SO-102 | 2400 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 0 | 3048 | 193.137 | 0.0741646 | 400 | 200 | 0.399228 | 400 | 400 | 200 | 280 | 160 | 800 | 800 | 800 × 560-800 × 400 | 400 | 560 | 3048 | TA00.06.1281 | 1281 | yes | 1 | 1 | 1 | 1 | 3.2 | 0 | 3.2 | 10.24 | 3.2 | 193.137 | 60.3553 | 0
14129236 | 4.NP_SO-102 |  |  |  | 500 mm × 280 mm-525 mm × 225 mm | 0 | 4.NP_SO-102 | 3060 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 25 | 3048 | 66.3909 | 0.00858379 | 262.5 | 112.5 | 0.108487 | 262.5 | 250 | 112.5 | 140 | 55 | 525 | 500 | 500 × 280-525 × 225 | 225 | 280 | 3048 | TA00.06.1303 | 1303 | no | 0.5 | 0.5 | 0.25 | 0.5 | 1.1 | 0 | 1.1 | 1.21 | 1.1 | 66.3909 | 30.1777 | 0
14129237 | 3.NP_SO-102 |  |  |  | 500 mm × 280 mm-525 mm × 225 mm | 0 | 3.NP_SO-102 | 3095 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 25 | 3048 | 66.3909 | 0.00858379 | 262.5 | 112.5 | 0.108487 | 262.5 | 250 | 112.5 | 140 | 55 | 525 | 500 | 500 × 280-525 × 225 | 225 | 280 | 3048 | TA00.06.1304 | 1304 | yes | 0.5 | 0.5 | 0.25 | 0.5 | 1.1 | 0 | 1.1 | 1.21 | 1.1 | 66.3909 | 30.1777 | 0
14129238 | 2.NP_SO-102 |  |  |  | 500 mm × 280 mm-525 mm × 225 mm | 0 | 2.NP_SO-102 | 3000 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 25 | 3048 | 66.3909 | 0.00858379 | 262.5 | 112.5 | 0.108487 | 262.5 | 250 | 112.5 | 140 | 55 | 525 | 500 | 500 × 280-525 × 225 | 225 | 280 | 3048 | TA00.06.1305 | 1305 | no | 0.5 | 0.5 | 0.25 | 0.5 | 1.1 | 0 | 1.1 | 1.21 | 1.1 | 66.3909 | 30.1777 | 0
14129239 | 1.NP_SO-102 |  |  |  | 500 mm × 280 mm-525 mm × 225 mm | 0 | 1.NP_SO-102 | 3028.08 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 25 | 3048 | 66.3909 | 0.00858379 | 262.5 | 112.5 | 0.108487 | 262.5 | 250 | 112.5 | 140 | 55 | 525 | 500 | 500 × 280-525 × 225 | 225 | 280 | 3048 | TA00.06.1306 | 1306 | no | 0.5 | 0.5 | 0.25 | 0.5 | 1.1 | 0 | 1.1 | 1.21 | 1.1 | 66.3909 | 30.1777 | 0
14129240 | 2.NP_SO-102 |  |  |  | 425 mm × 225 mm-400 mm × 180 mm | 0 | 2.NP_SO-102 | 2850 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 25 | 3048 | 54.2876 | 0.0045398 | 212.5 | 111.068 | 0.0709839 | 212.5 | 200 | 112.5 | 90 | 45 | 425 | 400 | 425 × 225-400 × 180 | 225 | 180 | 3046.57 | TA00.06.1307 | 1307 | yes | 0.5 | 0.5 | 0.25 | 0.5 | 0.84273 | 0 | 0.95727 | 0.81 | 0.9 | 54.2876 | 30.1777 | 1.43175
14129241 | 2.NP_SO-102 |  |  |  | 425 mm × 225 mm-400 mm × 180 mm | 0 | 2.NP_SO-102 | 2850 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 25 | 3048 | 54.2876 | 0.0045398 | 212.5 | 111.068 | 0.0709839 | 212.5 | 200 | 112.5 | 90 | 45 | 425 | 400 | 425 × 225-400 × 180 | 225 | 180 | 3046.57 | TA00.06.1308 | 1308 | yes | 0.5 | 0.5 | 0.25 | 0.5 | 0.84273 | 0 | 0.95727 | 0.81 | 0.9 | 54.2876 | 30.1777 | 1.43175
14129242 | 2.NP_SO-102 |  |  |  | 425 mm × 225 mm-400 mm × 180 mm | 0 | 2.NP_SO-102 | 2901.43 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 25 | 3048 | 54.3198 | 0.00454249 | 212.5 | 112.5 | 0.0708799 | 212.5 | 200 | 112.5 | 90 | 45 | 425 | 400 | 425 × 225-400 × 180 | 225 | 180 | 3048 | TA00.06.1309 | 1309 | yes | 0.5 | 0.5 | 0.25 | 0.5 | 0.9 | 0 | 0.9 | 0.81 | 0.9 | 54.3198 | 30.1777 | 0
14129243 | 2.NP_SO-102 |  |  |  | 425 mm × 225 mm-400 mm × 180 mm | 0 | 2.NP_SO-102 | 2901.43 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 25 | 3048 | 54.3198 | 0.00454249 | 212.5 | 112.5 | 0.0708799 | 212.5 | 200 | 112.5 | 90 | 45 | 425 | 400 | 425 × 225-400 × 180 | 225 | 180 | 3048 | TA00.06.1310 | 1310 | yes | 0.5 | 0.5 | 0.25 | 0.5 | 0.9 | 0 | 0.9 | 0.81 | 0.9 | 54.3198 | 30.1777 | 0
14150119 | 2.NP_SO-102 | 710 | 0.182032 | 1.30598 | 710 mm × 710 mm-450 mm × 710 mm | 0 | 2.NP_SO-102 | 2800 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 260 | 3048 | 313.848 | 0.129243 | 225 | 355 | 0.508527 | 225 | 355 | 355 | 355 | 0 | 450 | 710 | 710 × 710-450 × 710 | 710 | 710 | 3048 | TA00.06.1357 | 1357 | yes | 5.2 | 5.2 | 27.04 | 5.2 | 1 | 0 | 1 | 1 | 1 | 60.3553 | 313.848 | 0
14165726 | 1.NP_SO-102 |  |  |  | 1000 mm × 450 mm-630 mm × 280 mm | 0 | 1.NP_SO-102 | 3200 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 11 | ETA | 370 | 3048 | 446.63 | 0.135202 | 500 | 310 | 0.612095 | 500 | 315 | 225 | 140 | 170 | 1000 | 630 | 1000 × 450-630 × 280 | 450 | 280 | 3133 | TA00.06.1392 | 1392 | yes | 7.4 | 7.4 | 54.76 | 7.4 | 0 | 0 | 6.8 | 11.56 | 3.4 | 170 | 446.63 | 85
14174883 | -1.PP_SO-102 | 355 | 0.0482172 | 0.351718 | 355 mm × 400 mm-355 mm × 280 mm | 0 | -1.PP_SO-102 | 3150 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 0 | 3048 | 141.815 | 0.0171171 | 177.5 | 222.5 | 0.135983 | 177.5 | 177.5 | 200 | 140 | 120 | 355 | 355 | 355 × 400-355 × 280 | 400 | 280 | 3070.5 | TA00.06.1434 | 1434 | yes | 1 | 1 | 1 | 1 | 1.5 | 0 | 3.3 | 5.76 | 2.4 | 141.815 | 60.3553 | 22.5
14180998 | -1.PP_SO-102 | 315 | 0.0910008 | 0.409005 | 500 mm × 315 mm-315 mm × 315 mm | 0 | -1.PP_SO-102 | 3080 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 185 | 3048 | 223.315 | 0.0286652 | 157.5 | 157.5 | 0.193252 | 157.5 | 250 | 157.5 | 157.5 | 0 | 315 | 500 | 500 × 315-315 × 315 | 315 | 315 | 3048 | TA00.06.1456 | 1456 |  | 3.7 | 3.7 | 13.69 | 3.7 | 1 | 0 | 1 | 1 | 1 | 60.3553 | 223.315 | 0

# IfcDuctFitting: M_Hranatý spoj T:Standardní (10)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; ID kategorie: O; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 07; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Hranatý spoj T
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes
Kóty - Rameno: 25 mm
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 1559782; Rodina: M_Hranatý spoj T; Rodina a typ: M_Hranatý spoj T: Standardní
Name (M_Hranatý spoj T:Standardní:...) | In | Length (mm) = Výška potrubí (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Délka1a (mm) | Délka3a (mm) | Délka potrubí 1 (mm) | Délka potrubí 3 (mm) | Objem (m3) | Šířka potrubí 1 (mm) | Šířka potrubí 3 (mm) | Velikost | Kód prvku | Označení
13107177 | 2.NP_SO-102 | 400 | 0.515125 | 1.344 | 1250 mm × 400 mm-1250 mm × 400 mm-355 mm × 400 mm | 2.NP_SO-102 | 2880 | Fáze 1 | SUP 9 | 177.5 | 625 | 202.5 | 650 | 0.20605 | 1250 | 355 | 1250 × 400-1250 × 400-355 × 400 | TA00.07.0023 | 0023
13636234 | 2.NP_SO-102 | 450 | 0.29125 | 0.9765 | 560 mm × 450 mm-560 mm × 450 mm-450 mm × 450 mm | 2.NP_SO-102 | 3080 | Fáze 1 | SUP 13 | 225 | 280 | 250 | 305 | 0.131062 | 560 | 450 | 560 × 450-560 × 450-450 × 450 | TA00.07.0147 | 0147
13636308 | 3.NP_SO-102 | 450 | 0.29125 | 0.9765 | 560 mm × 450 mm-560 mm × 450 mm-450 mm × 450 mm | 3.NP_SO-102 | 3099.91 | Fáze 1 | SUP 13 | 225 | 280 | 250 | 305 | 0.131062 | 560 | 450 | 560 × 450-560 × 450-450 × 450 | TA00.07.0150 | 0150
13793885 | 3.NP_SO-102 | 500 | 0.4471 | 1.345 | 710 mm × 500 mm-710 mm × 500 mm-560 mm × 500 mm | 3.NP_SO-102 | 3040 | Fáze 1 | SUP 24 | 280 | 355 | 305 | 380 | 0.22355 | 710 | 560 | 710 × 500-710 × 500-560 × 500 | TA00.07.0316 | 0316
13793962 | 2.NP_SO-102 | 500 | 0.7765 | 1.885 | 1250 mm × 500 mm-1250 mm × 500 mm-560 mm × 500 mm | 2.NP_SO-102 | 3039.68 | Fáze 1 | SUP 24 | 280 | 625 | 305 | 650 | 0.38825 | 1250 | 560 | 1250 × 500-1250 × 500-560 × 500 | TA00.07.0320 | 0320
13794177 | 1.NP_SO-102 | 500 | 0.7 | 1.825 | 1250 mm × 500 mm-1250 mm × 500 mm-500 mm × 500 mm | 1.NP_SO-102 | 3095 | Fáze 1 | SUP 24 | 250 | 625 | 275 | 650 | 0.35 | 1250 | 500 | 1250 × 500-1250 × 500-500 × 500 | TA00.07.0323 | 0323
13873057 | 3.NP_SO-102 | 500 | 0.1225 | 0.725 | 400 mm × 500 mm-250 mm × 500 mm-250 mm × 500 mm | 3.NP_SO-102 | 3145.16 | Fáze 1 | SUP 9 | 200 | 125 | 225 | 150 | 0.06125 | 250 | 400 | 400 × 500-250 × 500-250 × 500 | TA00.07.0510 | 0510
14032671 | 2.NP_SO-102 | 800 | 1.33125 | 3.72 | 1250 mm × 800 mm-1000 mm × 800 mm-1000 mm × 800 mm | 2.NP_SO-102 | 809 | Fáze 1 | SUP 11 | 625 | 500 | 650 | 525 | 1.065 | 1000 | 1250 | 1250 × 800-1000 × 800-1000 × 800 | TA00.07.0985 | 0985
14051669 | 2.NP_SO-102 | 315 | 0.349375 | 0.9765 | 1250 mm × 315 mm-1250 mm × 315 mm-225 mm × 315 mm | 2.NP_SO-102 | 2880 | Fáze 1 | SUP 9 | 112.5 | 625 | 137.5 | 650 | 0.110053 | 1250 | 225 | 1250 × 315-1250 × 315-225 × 315 | TA00.07.1041 | 1041
14124009 | 3.NP_SO-102 | 280 | 0.264025 | 0.5936 | 630 mm × 280 mm-630 mm × 280 mm-355 mm × 280 mm | 3.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 177.5 | 315 | 202.5 | 340 | 0.073927 | 630 | 355 | 630 × 280-630 × 280-355 × 280 | TA00.07.1294 | 1294

# IfcDuctFitting: M_Hranatý spoj T:Standardní (3)
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; ID kategorie: O; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 07; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Hranatý spoj T
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 15 mm; Typ izolace: Protipožární
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes
Kóty - Délka1a: 140 mm; Délka potrubí 1: 165 mm; Rameno: 25 mm; Šířka potrubí 3: 280 mm
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 1559782; Rodina: M_Hranatý spoj T; Rodina a typ: M_Hranatý spoj T: Standardní
Name (M_Hranatý spoj T:Standardní:...) | In | Length (mm) = Výška potrubí (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost | Celková velikost | Podlaží | Výška od podlaží (mm) | Název systému = Group | Délka3a (mm) | Délka potrubí 3 (mm) | Objem (m3) | Šířka potrubí 1 (mm) | Velikost | Kód prvku | Označení
13803540 | 3.NP_SO-102 | 450 | 0.172 | 0.7695 | 500 mm × 450 mm-500 mm × 450 mm-280 mm × 450 mm | 530 mm × 480 mm-530 mm × 480 mm-310 mm × 480 mm | 3.NP_SO-102 | 3196.2 | ODA 25 | 250 | 275 | 0.0774 | 500 | 500 × 450-500 × 450-280 × 450 | TA00.07.0350 | 0350
13819021 | 2.NP_SO-102 | 450 | 0.172 | 0.7695 | 500 mm × 450 mm-500 mm × 450 mm-280 mm × 450 mm | 530 mm × 480 mm-530 mm × 480 mm-310 mm × 480 mm | 2.NP_SO-102 | 3096.2 | ODA 25 | 250 | 275 | 0.0774 | 500 | 500 × 450-500 × 450-280 × 450 | TA00.07.0392 | 0392
14066261 | -1.PP_SO-102 | 400 | 0.1555 | 0.644 | 450 mm × 400 mm-450 mm × 400 mm-280 mm × 400 mm | 480 mm × 430 mm-480 mm × 430 mm-310 mm × 430 mm | -1.PP_SO-102 | 2600 | ODA 12 | 225 | 250 | 0.0622 | 450 | 450 × 400-450 × 400-280 × 400 | TA00.07.1126 | 1126

# IfcDuctFitting: M_Hranatý spoj T:Standardní (13)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; ID kategorie: O; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 07; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Hranatý spoj T
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes
Kóty - Rameno: 25 mm
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 1559782; Rodina: M_Hranatý spoj T; Rodina a typ: M_Hranatý spoj T: Standardní
Name (M_Hranatý spoj T:Standardní:...) | In | Length (mm) = Výška potrubí (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Délka1a (mm) | Délka3a (mm) | Délka potrubí 1 (mm) | Délka potrubí 3 (mm) | Objem (m3) | Šířka potrubí 1 (mm) | Šířka potrubí 3 (mm) | Velikost | Kód prvku | Označení
13744806 | 3.NP_SO-102 | 630 | 0.26 | 1.2915 | 500 mm × 630 mm-450 mm × 630 mm-450 mm × 630 mm | 3.NP_SO-102 | 3000 | Fáze 1 | ETA 3 | 250 | 225 | 275 | 250 | 0.1638 | 450 | 500 | 500 × 630-450 × 630-450 × 630 | TA00.07.0229 | 0229
13766759 | 2.NP_SO-102 | 500 | 0.2149 | 0.985 | 630 mm × 500 mm-630 mm × 500 mm-280 mm × 500 mm | 2.NP_SO-102 | 3000 | Fáze 2 | ETA 7 | 140 | 315 | 165 | 340 | 0.10745 | 630 | 280 | 630 × 500-630 × 500-280 × 500 | TA00.07.0263 | 0263
13766828 | 1.NP_SO-102 | 500 | 0.2149 | 0.985 | 630 mm × 500 mm-630 mm × 500 mm-280 mm × 500 mm | 1.NP_SO-102 | 3028.08 | Fáze 2 | ETA 7 | 140 | 315 | 165 | 340 | 0.10745 | 630 | 280 | 630 × 500-630 × 500-280 × 500 | TA00.07.0264 | 0264
13766859 | 3.NP_SO-102 | 500 | 0.172 | 0.855 | 500 mm × 500 mm-500 mm × 500 mm-280 mm × 500 mm | 3.NP_SO-102 | 3095 | Fáze 2 | ETA 7 | 140 | 250 | 165 | 275 | 0.086 | 500 | 280 | 500 × 500-500 × 500-280 × 500 | TA00.07.0265 | 0265
13792025 | 3.NP_SO-102 | 500 | 0.172 | 0.855 | 500 mm × 500 mm-500 mm × 500 mm-280 mm × 500 mm | 3.NP_SO-102 | 3050 | Fáze 1 | ETA 7 | 140 | 250 | 165 | 275 | 0.086 | 500 | 280 | 500 × 500-500 × 500-280 × 500 | TA00.07.0304 | 0304
13792397 | 2.NP_SO-102 | 500 | 0.2149 | 0.985 | 630 mm × 500 mm-630 mm × 500 mm-280 mm × 500 mm | 2.NP_SO-102 | 2807.72 | Fáze 1 | ETA 7 | 140 | 315 | 165 | 340 | 0.10745 | 630 | 280 | 630 × 500-630 × 500-280 × 500 | TA00.07.0310 | 0310
13792457 | 1.NP_SO-102 | 500 | 0.2149 | 0.985 | 630 mm × 500 mm-630 mm × 500 mm-280 mm × 500 mm | 1.NP_SO-102 | 2800 | Fáze 1 | ETA 7 | 140 | 315 | 165 | 340 | 0.10745 | 630 | 280 | 630 × 500-630 × 500-280 × 500 | TA00.07.0312 | 0312
13865852 | -1.PP_SO-102 | 315 | 0.12285 | 0.44415 | 315 mm × 315 mm-315 mm × 315 mm-315 mm × 315 mm | -1.PP_SO-102 | 2580 | Fáze 1 | ETA 97 | 157.5 | 157.5 | 182.5 | 182.5 | 0.0386977 | 315 | 315 | 315 × 315-315 × 315-315 × 315 | TA00.07.0454 | 0454
14017064 | 3.NP_SO-102 | 500 | 0.109 | 0.735 | 500 mm × 500 mm-500 mm × 500 mm-160 mm × 500 mm | 3.NP_SO-102 | 2739.7 | Fáze 1 | ETA 7 | 80 | 250 | 105 | 275 | 0.0545 | 500 | 160 | 500 × 500-500 × 500-160 × 500 | TA00.07.0963 | 0963
14040833 | 2.NP_SO-102 | 710 | 0.1531 | 1.3419 | 710 mm × 710 mm-710 mm × 710 mm-160 mm × 710 mm | 2.NP_SO-102 | 2800 | Fáze 1 | ETA 3 | 80 | 355 | 105 | 380 | 0.108701 | 710 | 160 | 710 × 710-710 × 710-160 × 710 | TA00.07.1030 | 1030
14055982 | 3.NP_SO-102 | 500 | 0.1363 | 0.865 | 630 mm × 500 mm-630 mm × 500 mm-160 mm × 500 mm | 3.NP_SO-102 | 3000 | Fáze 1 | ETA 3 | 80 | 315 | 105 | 340 | 0.06815 | 630 | 160 | 630 × 500-630 × 500-160 × 500 | TA00.07.1076 | 1076
14109721 | -1.PP_SO-102 | 355 | 0.1885 | 0.74905 | 800 mm × 355 mm-800 mm × 355 mm-180 mm × 355 mm | -1.PP_SO-102 | 3080 | Fáze 1 | ETA 7 | 90 | 400 | 115 | 425 | 0.0669175 | 800 | 180 | 800 × 355-800 × 355-180 × 355 | TA00.07.1190 | 1190
14114083 | -1.PP_SO-102 | 500 | 0.2392 | 1.355 | 1120 mm × 500 mm-1120 mm × 500 mm-160 mm × 500 mm | -1.PP_SO-102 | 3080 | Fáze 1 | ETA 7 | 80 | 560 | 105 | 585 | 0.1196 | 1120 | 160 | 1120 × 500-1120 × 500-160 × 500 | TA00.07.1208 | 1208

# IfcDuctFitting: M_Kulaté koleno:1 D (432)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Násobitel poloměru: 1
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; ID kategorie: K; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: 1 D; Označení typu: 04; Popis: Koleno; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulaté koleno
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Grafika - Použít měřítko poznámky: yes
Jiné - Id typu: 1452114; Rodina: M_Kulaté koleno; Rodina a typ: M_Kulaté koleno: 1 D; Typ: 1 D
Name (M_Kulaté koleno:1 D:...) | In | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Úhel (deg) | Délka1 (mm) | Objem (m3) | Poloměr potrubí (mm) | Střední poloměr (mm) | Velikost | Kód prvku | Označení | Páteřní trasa
13096137 | 2.NP_SO-102 | 450 mm-450 mm | 0 | 450 mm-450 mm | 0 | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 45 | 186.396 | 0.0562067 | 225 | 450 | 450-450 | TA00.04.0007 | 0007 | yes
13096318 | 2.NP_SO-102 | 450 mm-450 mm | 0 | 450 mm-450 mm | 0 | 2.NP_SO-102 | 2764 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 45 | 186.396 | 0.0562067 | 225 | 450 | 450-450 | TA00.04.0010 | 0010 | yes
13097767 | 2.NP_SO-102 | 450 mm-450 mm | 0 | 450 mm-450 mm | 0 | 2.NP_SO-102 | 2764 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 30 | 120.577 | 0.037471 | 225 | 450 | 450-450 | TA00.04.0017 | 0017 | yes
13097777 | 2.NP_SO-102 | 450 mm-450 mm | 0 | 450 mm-450 mm |  | 2.NP_SO-102 | 2851.43 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 30 | 120.577 | 0.037471 | 225 | 450 | 450-450 | TA00.04.0018 | 0018 | yes
13103758 | 1.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | 1.NP_SO-102 | 3200.1 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.0019 | 0019 | no
13107184 | 2.NP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | 0 | 2.NP_SO-102 | 2940 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.0025 | 0025 | yes
13151388 | 2.NP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm |  | 2.NP_SO-102 | 2910 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.0032 | 0032 | no
13151407 | 2.NP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm |  | 2.NP_SO-102 | 2910 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.0033 | 0033 | no
13155005 | 1.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm |  | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 2 | SUP | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0036 | 0036 | no
13156231 | 2.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm | 0 | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0040 | 0040 | no
13156257 | 2.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm | 0 | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0042 | 0042 | no
13157207 | 4.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0046 | 0046 | no
13157254 | 4.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0048 | 0048 | no
13157550 | 3.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm | 0 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.0053 | 0053 | no
13157571 | 3.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm | 0 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.0055 | 0055 | no
13157590 | 3.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm | 0 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0056 | 0056 | no
13157613 | 3.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm | 0 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0058 | 0058 | no
13157632 | 3.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm | 0 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0059 | 0059 | no
13157722 | 3.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0061 | 0061 | no
13157791 | 3.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0062 | 0062 | yes
13161035 | 1.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | 1.NP_SO-102 | 3150 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0064 | 0064 | yes
13168558 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 4.NP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 34 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0068 | 0068 | yes
13169215 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 4.NP_SO-102 | 3150 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0075 | 0075 | yes
13172053 | 3.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm | 0 | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0083 | 0083 | yes
13197813 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0086 | 0086 | yes
13198451 | 4.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm |  | 4.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 40 | SUP | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0088 | 0088 | no
13198930 | 3.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0090 | 0090 | no
13198943 | 3.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0091 | 0091 | no
13199251 | 3.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0092 | 0092 | no
13199275 | 3.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0094 | 0094 | no
13199809 | 3.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0099 | 0099 | yes
13200015 | 2.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm |  | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0100 | 0100 | no
13200028 | 2.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm |  | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 45 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0101 | 0101 | no
13302298 | 1.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0107 | 0107 | no
13302548 | 1.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm |  | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0108 | 0108 | no
13324246 | -1.PP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | -1.PP_SO-102 | 2350 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.0111 | 0111 | no
13429782 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0114 | 0114 | yes
13429963 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0116 | 0116 | no
13628626 | -1.PP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | -1.PP_SO-102 | 3160 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 8 | ETA | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0124 | 0124 | yes | Identifikační data - Komentáře: VZT 28
13628702 | -1.PP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | -1.PP_SO-102 | 3160 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 8 | ETA | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0125 | 0125 | no | Identifikační data - Komentáře: VZT 28
13628715 | -1.PP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | -1.PP_SO-102 | 3160 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 8 | ETA | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0126 | 0126 | yes | Identifikační data - Komentáře: VZT 28
13634309 | 3.NP_SO-102 | 500 mm-500 mm | 0 | 500 mm-500 mm |  | 3.NP_SO-102 | 3099.91 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 500 | 0.154205 | 250 | 500 | 500-500 | TA00.04.0140 | 0140 | yes
13635158 | 4.NP_SO-102 | 450 mm-450 mm | 0 | 450 mm-450 mm |  | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 450 | 0.112416 | 225 | 450 | 450-450 | TA00.04.0141 | 0141 | yes
13635347 | 3.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0142 | 0142 | yes
13636103 | 1.NP_SO-102 | 315 mm-315 mm | 0 | 315 mm-315 mm |  | 1.NP_SO-102 | 3150 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 315 | 0.0385592 | 157.5 | 315 | 315-315 | TA00.04.0145 | 0145 | yes
13636107 | 1.NP_SO-102 | 315 mm-315 mm | 0 | 315 mm-315 mm |  | 1.NP_SO-102 | 3150 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 315 | 0.0385592 | 157.5 | 315 | 315-315 | TA00.04.0146 | 0146 | yes
13636392 | 4.NP_SO-102 | 500 mm-500 mm | 0 | 500 mm-500 mm |  | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 500 | 0.154205 | 250 | 500 | 500-500 | TA00.04.0151 | 0151 | yes
13647672 | -1.PP_SO-102 | 500 mm-500 mm | 0 | 500 mm-500 mm |  | -1.PP_SO-102 | 3070 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 90 | 500 | 0.154205 | 250 | 500 | 500-500 | TA00.04.0164 | 0164 | yes
13702571 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 1.NP_SO-102 | 3250 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0179 | 0179 | no
13702580 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 1.NP_SO-102 | 3250 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0180 | 0180 | no
13706018 | 4.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm |  | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0183 | 0183 | no
13706098 | 4.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm |  | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 21 | SUP | 89.9806 | 224.924 | 0.0140491 | 112.5 | 225 | 225-225 | TA00.04.0184 | 0184 | no
13707529 | 2.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm | 0 | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0186 | 0186 | no
13707531 | 2.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm | 0 | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0187 | 0187 | no
13707944 | 2.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm | 0 | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0189 | 0189 | yes
13708172 | 2.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm |  | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 22 | SUP | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0190 | 0190 | yes
13711737 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 2350 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0195 | 0195 | no
13712965 | 2.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm |  | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 57 | SUP | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0196 | 0196 | no
13713072 | 2.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm |  | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0197 | 0197 | no
13713074 | 2.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm |  | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 59 | SUP | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0198 | 0198 | no
13713257 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0200 | 0200 | yes
13713526 | 2.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0202 | 0202 | no
13713541 | 2.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0203 | 0203 | no
13713641 | 2.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm | 0 | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.0204 | 0204 | no
13713662 | 2.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm | 0 | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.0206 | 0206 | no
13713939 | 2.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm |  | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 50 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0207 | 0207 | yes
13714031 | 2.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm |  | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0209 | 0209 | no
13714042 | 2.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm |  | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 48 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0210 | 0210 | no
13715136 | 3.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm | 0 | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.0216 | 0216 | yes
13717452 | 2.NP_SO-102 | 450 mm-450 mm | 0 | 450 mm-450 mm | 0 | 2.NP_SO-102 | 2937.5 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 45 | 186.396 | 0.0562067 | 225 | 450 | 450-450 | TA00.04.0218 | 0218 | yes
13718901 | 2.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | 2.NP_SO-102 | 2939.41 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.0226 | 0226 | no
13746580 | 2.NP_SO-102 | 560 mm-560 mm | 0 | 560 mm-560 mm |  | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 560 | 0.216656 | 280 | 560 | 560-560 | TA00.04.0233 | 0233 | yes
13746629 | 2.NP_SO-102 | 560 mm-560 mm | 0 | 560 mm-560 mm |  | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 30 | 150.052 | 0.0722183 | 280 | 560 | 560-560 | TA00.04.0234 | 0234 | yes
13746710 | 2.NP_SO-102 | 560 mm-560 mm | 0 | 560 mm-560 mm |  | 2.NP_SO-102 | 2700 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 30 | 150.052 | 0.0722183 | 280 | 560 | 560-560 | TA00.04.0235 | 0235 | yes
13746798 | 2.NP_SO-102 | 560 mm-560 mm | 0 | 560 mm-560 mm |  | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 30 | 150.052 | 0.0722183 | 280 | 560 | 560-560 | TA00.04.0237 | 0237 | yes
13746802 | 2.NP_SO-102 | 560 mm-560 mm | 0 | 560 mm-560 mm |  | 2.NP_SO-102 | 2700 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 30 | 150.052 | 0.0722183 | 280 | 560 | 560-560 | TA00.04.0238 | 0238 | yes
13747912 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 4.NP_SO-102 | 3150 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0243 | 0243 | no
13747921 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 4.NP_SO-102 | 3150 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0244 | 0244 | no
13748023 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 4.NP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 34 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0246 | 0246 | no
13748032 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 4.NP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 34 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0247 | 0247 | no
13748127 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 3.NP_SO-102 | 3020 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0248 | 0248 | no
13748136 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 3.NP_SO-102 | 3020 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0249 | 0249 | no
13748264 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 3.NP_SO-102 | 2995.73 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 34 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0252 | 0252 | no
13748273 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 3.NP_SO-102 | 2995.73 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 34 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0253 | 0253 | no
13765445 | -1.PP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | 0 | -1.PP_SO-102 | 2700 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 2 | ODA | 45 | 147.046 | 0.0275959 | 177.5 | 355 | 355-355 | TA00.04.0256 | 0256 | yes
13765488 | -1.PP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | 0 | -1.PP_SO-102 | 2700 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 2 | ODA | 45 | 147.046 | 0.0275959 | 177.5 | 355 | 355-355 | TA00.04.0257 | 0257 | yes
13765492 | -1.PP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | 0 | -1.PP_SO-102 | 3100 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 2 | ODA | 45 | 147.046 | 0.0275959 | 177.5 | 355 | 355-355 | TA00.04.0258 | 0258 | yes
13765791 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 1.NP_SO-102 | 3250 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0260 | 0260 | no
13765800 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 1.NP_SO-102 | 3250 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0261 | 0261 | no
13766018 | -1.PP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | 0 | -1.PP_SO-102 | 2700 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 1 | ODA | 45 | 147.046 | 0.027596 | 177.5 | 355 | 355-355 | TA00.04.0262 | 0262 | yes
13769078 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 2.NP_SO-102 | 3100 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0274 | 0274 | no
13769087 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 2.NP_SO-102 | 3100 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0275 | 0275 | no
13769169 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 2.NP_SO-102 | 3100 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0277 | 0277 | no
13769580 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 4.NP_SO-102 | 2950 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0283 | 0283 | no
13769642 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 4.NP_SO-102 | 2950 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0285 | 0285 | no
13769723 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 3.NP_SO-102 | 3100 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0286 | 0286 | no
13769734 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 3.NP_SO-102 | 3100 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0287 | 0287 | no
13769834 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 2.NP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0289 | 0289 | no
13769843 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 2.NP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0290 | 0290 | no
13769873 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 2.NP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 34 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0291 | 0291 | no
13769884 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 2.NP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 34 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0292 | 0292 | no
13769893 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 2.NP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 34 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0293 | 0293 | no
13791115 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 2895 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0302 | 0302 | no
