Properties of the parts of a building model (IFC4), part 33 of 45

# IfcDuctFitting: M_Kulatý přechod, úhel:45 stupňů (209)
Name (M_Kulatý přechod, úhel:45 stupňů:...) | In | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Dočas. šířka odsazení | Dočas. výška odsazení | Objem (m3) | Odsazení výšky od základny (mm) | Odskok – šířka = Poloměr potrubí 1 (mm) | Odskok – výška | Plocha (m2) | Poloměr potrubí 2 (mm) | Rozdíl odsazení (mm) | Rozdíl poloměrů (mm) = Délka 1 (mm) = Délka 2 (mm) | Velikost | Vypočítaná délka (mm) | Kód prvku | Označení | Páteřní trasa | Číslo 1 = Číslo 2 | Číslo 3 | Číslo 5 | Tlaková ztráta (Pa)
13935840 | 2.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 0.0277778 | 0.0277778 | 0.00107139 | 3048 | 100 | 100 | 0.0360101 | 112.5 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0737 | 0737 | no | 0.5 | 1 | 1.20711 | 0
13935842 | 2.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 0.0277778 | 0.0277778 | 0.00107139 | 3048 | 100 | 100 | 0.0360101 | 112.5 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0738 | 0738 | no | 0.5 | 1 | 1.20711 | 0
13936000 | 2.NP_SO-102 | 225 mm-180 mm | 0 | 225 mm-180 mm | 2.NP_SO-102 | 2700 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 0.025 | 0.025 | 0.00175647 | 3048 | 90 | 90 | 0.0436621 | 112.5 | 0 | 22.5 | 225-180 | 54.3198 | TA03.01.0741 | 0741 | no | 0.9 | 1.8 | 2.17279
13936424 | 2.NP_SO-102 | 180 mm-160 mm | 0 | 180 mm-160 mm | 2.NP_SO-102 | 2700 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 80 | 80 | 0.0230465 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.01.0742 | 0742 | no | 0.4 | 0.8 | 0.965685
13936678 | 2.NP_SO-102 | 225 mm-180 mm | 0 | 225 mm-180 mm | 2.NP_SO-102 | 2700 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 0.025 | 0.025 | 0.00175647 | 3048 | 90 | 90 | 0.0436621 | 112.5 | 0 | 22.5 | 225-180 | 54.3198 | TA03.01.0745 | 0745 | no | 0.9 | 1.8 | 2.17279
13937956 | 2.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 2.NP_SO-102 | 2850 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 0.0277778 | 0.0277778 | 0.00107139 | 3048 | 100 | 100 | 0.0360101 | 112.5 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0752 | 0752 | yes | 0.5 | 1 | 1.20711
13937958 | 2.NP_SO-102 | 200 mm-160 mm | 0 | 200 mm-160 mm | 2.NP_SO-102 | 2850 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 0.0277778 | 0.0277778 | 0.00123356 | 3048 | 100 | 100 | 0.0344984 | 80 | 0 | 20 | 200-160 | 48.2843 | TA03.01.0753 | 0753 | yes | 0.8 | 1.6 | 1.93137
13939370 | 2.NP_SO-102 | 400 mm-355 mm | 0 | 400 mm-355 mm | 2.NP_SO-102 | 2850 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 0.0555556 | 0.0555556 | 0.00608666 | 3048 | 200 | 200 | 0.114207 | 177.5 | 0 | 22.5 | 400-355 | 54.3198 | TA03.01.0759 | 0759 | yes | 0.9 | 1.8 | 2.17279 | 0
13940367 | -1.PP_SO-102 | 250 mm-225 mm | 0 | 250 mm-225 mm | -1.PP_SO-102 | 2350 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 0.0347222 | 0.0347222 | 0.00133803 | 3048 | 125 | 125 | 0.0432062 | 112.5 | 0 | 12.5 | 250-225 | 30.1777 | TA03.01.0765 | 0765 | no | 0.5 | 1 | 1.20711
13942257 | -1.PP_SO-102 | 250 mm-225 mm | 0 | 250 mm-225 mm | -1.PP_SO-102 | 2700 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 0.0347222 | 0.0347222 | 0.00133803 | 3048 | 125 | 125 | 0.0432062 | 112.5 | 0 | 12.5 | 250-225 | 30.1777 | TA03.01.0766 | 0766 | no | 0.5 | 1 | 1.20711
13947132 | -1.PP_SO-102 | 280 mm-180 mm | 0 | 280 mm-180 mm | -1.PP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 7 | SUP | 0.0388889 | 0.0388889 | 0.00509411 | 3048 | 140 | 140 | 0.0855144 | 90 | 0 | 50 | 280-180 | 120.711 | TA03.01.0772 | 0772 | yes | 2 | 4 | 4.82843
13947134 | -1.PP_SO-102 | 400 mm-280 mm | 0 | 400 mm-280 mm | -1.PP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 7 | SUP | 0.0388889 | 0.0388889 | 0.0132878 | 3048 | 140 | 140 | 0.162158 | 200 | 0 | 60 | 400-280 | 144.853 | TA03.01.0773 | 0773 | yes | 2.4 | 4.8 | 5.79411
13952813 | -1.PP_SO-102 | 400 mm-160 mm | 0 | 400 mm-160 mm | -1.PP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 7 | SUP | 0.0555556 | 0.0555556 | 0.0189296 | 3048 | 200 | 200 | 0.215319 | 80 | 0 | 120 | 400-160 | 289.706 | TA03.01.0797 | 0797 | yes | 4.8 | 9.6 | 11.5882
13959387 | -1.PP_SO-102 | 315 mm-250 mm | 0 | 315 mm-250 mm | -1.PP_SO-102 | 3080 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 0.04375 | 0.04375 | 0.00493938 | 3048 | 157.5 | 157.5 | 0.0865885 | 125 | 0 | 32.5 | 315-250 | 78.4619 | TA03.01.0818 | 0818 | no | 1.3 | 2.6 | 3.13848 | 0
13959417 | -1.PP_SO-102 | 315 mm-250 mm | 0 | 315 mm-250 mm | -1.PP_SO-102 | 3080 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 0.04375 | 0.04375 | 0.00493938 | 3048 | 157.5 | 157.5 | 0.0865885 | 125 | 0 | 32.5 | 315-250 | 78.4619 | TA03.01.0819 | 0819 | yes | 1.3 | 2.6 | 3.13848 | 0
13960047 | -1.PP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | -1.PP_SO-102 | 2600 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 0.0277778 | 0.0277778 | 0.00107139 | 3048 | 100 | 100 | 0.0360101 | 112.5 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0820 | 0820 | no | 0.5 | 1 | 1.20711 | 0
13960049 | -1.PP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | -1.PP_SO-102 | 2600 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 0.0277778 | 0.0277778 | 0.00107139 | 3048 | 100 | 100 | 0.0360101 | 112.5 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0821 | 0821 | no | 0.5 | 1 | 1.20711 | 0
13960181 | -1.PP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | -1.PP_SO-102 | 3240 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 0.0277778 | 0.0277778 | 0.00107139 | 3048 | 100 | 100 | 0.0360101 | 112.5 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0822 | 0822 | no | 0.5 | 1 | 1.20711 | 0
13960183 | -1.PP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | -1.PP_SO-102 | 3240 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 0.0277778 | 0.0277778 | 0.00107139 | 3048 | 100 | 100 | 0.0360101 | 112.5 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0823 | 0823 | no | 0.5 | 1 | 1.20711 | 0
13965343 | -1.PP_SO-102 | 250 mm-225 mm | 0 | 250 mm-225 mm | -1.PP_SO-102 | 2350.05 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 0.0347222 | 0.0347222 | 0.00133803 | 3048 | 125 | 125 | 0.0432062 | 112.5 | 0 | 12.5 | 250-225 | 30.1777 | TA03.01.0835 | 0835 | no | 0.5 | 1 | 1.20711
13966593 | -1.PP_SO-102 | 250 mm-225 mm | 0 | 250 mm-225 mm | -1.PP_SO-102 | 2700 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 0.0347222 | 0.0347222 | 0.00133803 | 3048 | 125 | 125 | 0.0432062 | 112.5 | 0 | 12.5 | 250-225 | 30.1777 | TA03.01.0842 | 0842 | no | 0.5 | 1 | 1.20711
13966664 | -1.PP_SO-102 | 250 mm-225 mm | 0 | 250 mm-225 mm | -1.PP_SO-102 | 2700 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 0.0347222 | 0.0347222 | 0.00133803 | 3048 | 125 | 125 | 0.0432062 | 112.5 | 0 | 12.5 | 250-225 | 30.1777 | TA03.01.0843 | 0843 | no | 0.5 | 1 | 1.20711
13966666 | -1.PP_SO-102 | 250 mm-225 mm | 0 | 250 mm-225 mm | -1.PP_SO-102 | 2700 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 0.0347222 | 0.0347222 | 0.00133803 | 3048 | 125 | 125 | 0.0432062 | 112.5 | 0 | 12.5 | 250-225 | 30.1777 | TA03.01.0844 | 0844 | no | 0.5 | 1 | 1.20711
13969148 | 2.NP_SO-102 | 280 mm-250 mm | 0 | 280 mm-250 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0347222 | 0.0347222 | 0.00199932 | 3048 | 125 | 125 | 0.0552087 | 140 | 0 | 15 | 280-250 | 36.2132 | TA03.01.0855 | 0855 | no | 0.6 | 1.2 | 1.44853 | 0
13981809 | 4.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0866 | 0866 | no | 0.5 | 1 | 1.20711
13981811 | 4.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 4.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 23 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0867 | 0867 | no | 0.5 | 1 | 1.20711
13984590 | 3.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 3.NP_SO-102 | 3099.91 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0878 | 0878 | no | 0.5 | 1 | 1.20711 | 0
13984592 | 3.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 3.NP_SO-102 | 3099.91 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0879 | 0879 | no | 0.5 | 1 | 1.20711 | 0
13984683 | 3.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0880 | 0880 | no | 0.5 | 1 | 1.20711 | 0
13984685 | 3.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0881 | 0881 | no | 0.5 | 1 | 1.20711 | 0
13985470 | 3.NP_SO-102 | 225 mm-180 mm | 0 | 225 mm-180 mm | 3.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.03125 | 0.03125 | 0.00175646 | 3048 | 112.5 | 112.5 | 0.0436621 | 90 | 0 | 22.5 | 225-180 | 54.3198 | TA03.01.0884 | 0884 | no | 0.9 | 1.8 | 2.17279 | 0
13987762 | -1.PP_SO-102 | 400 mm-355 mm | 0 | 400 mm-355 mm | -1.PP_SO-102 | 3150 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 18 | ETA | 0.0555556 | 0.0555556 | 0.00608666 | 3048 | 200 | 200 | 0.114207 | 177.5 | 0 | 22.5 | 400-355 | 54.3198 | TA03.01.0886 | 0886 | yes | 0.9 | 1.8 | 2.17279
13989264 | -1.PP_SO-102 | 355 mm-250 mm | 0 | 355 mm-250 mm | -1.PP_SO-102 | 3077.14 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 0.0493056 | 0.0493056 | 0.00919997 | 3048 | 177.5 | 177.5 | 0.126972 | 125 | 0 | 52.5 | 355-250 | 126.746 | TA03.01.0894 | 0894 | yes | 2.1 | 4.2 | 5.06985
13989324 | -1.PP_SO-102 | 250 mm-225 mm | 0 | 250 mm-225 mm | -1.PP_SO-102 | 3077.14 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 0.0347222 | 0.0347222 | 0.00133803 | 3048 | 125 | 125 | 0.0432062 | 112.5 | 0 | 12.5 | 250-225 | 30.1777 | TA03.01.0895 | 0895 | yes | 0.5 | 1 | 1.20711
13989556 | -1.PP_SO-102 | 250 mm-180 mm | 0 | 250 mm-180 mm | -1.PP_SO-102 | 3077.14 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 25 | SUP | 0.0347222 | 0.0347222 | 0.00309445 | 3048 | 125 | 125 | 0.0615557 | 90 | 0 | 35 | 250-180 | 84.4975 | TA03.01.0897 | 0897 | no | 1.4 | 2.8 | 3.3799 | 0
13989783 | -1.PP_SO-102 | 250 mm-180 mm | 0 | 250 mm-180 mm | -1.PP_SO-102 | 3077.14 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 25 | SUP | 0.0347222 | 0.0347222 | 0.00309445 | 3048 | 125 | 125 | 0.0615557 | 90 | 0 | 35 | 250-180 | 84.4975 | TA03.01.0898 | 0898 | no | 1.4 | 2.8 | 3.3799 | 0
13997791 | 4.NP_SO-102 | 280 mm-180 mm | 0 | 280 mm-180 mm | 4.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 0.0388889 | 0.0388889 | 0.00509411 | 3048 | 140 | 140 | 0.0855144 | 90 | 0 | 50 | 280-180 | 120.711 | TA03.01.0917 | 0917 | no | 2 | 4 | 4.82843
13998158 | 4.NP_SO-102 | 280 mm-200 mm | 0 | 280 mm-200 mm | 4.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 0.0388889 | 0.0388889 | 0.004409 | 3048 | 140 | 140 | 0.0778625 | 100 | 0 | 40 | 280-200 | 96.5685 | TA03.01.0918 | 0918 | no | 1.6 | 3.2 | 3.86274
14002963 | 4.NP_SO-102 | 500 mm-355 mm | 0 | 500 mm-355 mm | STŘECHA_SO-102 | 469.97 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 10 | ODA | 0.0694444 | 0.0694444 | 0.0253634 | 3048 | 250 | 250 | 0.249822 | 177.5 | 0 | 72.5 | 500-355 | 175.03 | TA03.01.0928 | 0928 | yes | 2.9 | 5.8 | 7.00122
14029005 | 1.NP_SO-102 | 180 mm-160 mm | 0 | 180 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 19 | ODA | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 80 | 80 | 0.0230465 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.01.0972 | 0972 | yes | 0.4 | 0.8 | 0.965685 | 0
14029278 | 1.NP_SO-102 | 180 mm-160 mm | 0 | 180 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 12 | EHA | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 80 | 80 | 0.0230465 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.01.0975 | 0975 | yes | 0.4 | 0.8 | 0.965685 | 0
14034587 | 3.NP_SO-102 | 315 mm-200 mm | 0 | 315 mm-200 mm | 3.NP_SO-102 | 3145.16 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 0.04375 | 0.04375 | 0.0073488 | 3048 | 157.5 | 157.5 | 0.109242 | 100 | 0 | 57.5 | 315-200 | 138.817 | TA03.01.0999 | 0999 | no | 2.3 | 4.6 | 5.55269
14034625 | 3.NP_SO-102 | 315 mm-200 mm | 0 | 315 mm-200 mm | 3.NP_SO-102 | 3145.16 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 0.04375 | 0.04375 | 0.0073488 | 3048 | 157.5 | 157.5 | 0.109242 | 100 | 0 | 57.5 | 315-200 | 138.817 | TA03.01.1000 | 1000 | no | 2.3 | 4.6 | 5.55269
14039254 | 1.NP_SO-102 | 315 mm-160 mm | 0 | 315 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 14 | SUP | 0.04375 | 0.04375 | 0.00858237 | 3048 | 157.5 | 157.5 | 0.123741 | 80 | 0 | 77.5 | 315-160 | 187.102 | TA03.01.1020 | 1020 | yes | 3.1 | 6.2 | 7.48406 | 0
14040582 | 1.NP_SO-102 | 180 mm-160 mm | 0 | 180 mm-160 mm | 1.NP_SO-102 | 2895 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 80 | 80 | 0.0230465 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.01.1027 | 1027 | no | 0.4 | 0.8 | 0.965685 | 0
14052218 | 2.NP_SO-102 | 180 mm-160 mm | 0 | 180 mm-160 mm | 2.NP_SO-102 | 2580 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 80 | 80 | 0.0230465 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.01.1048 | 1048 | no | 0.4 | 0.8 | 0.965685 | 0
14055696 | 3.NP_SO-102 | 225 mm-160 mm | 0 | 225 mm-160 mm | 3.NP_SO-102 | 3295.16 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 0.03125 | 0.03125 | 0.002305 | 3048 | 112.5 | 112.5 | 0.0505085 | 80 | 0 | 32.5 | 225-160 | 78.4619 | TA03.01.1071 | 1071 | no | 1.3 | 2.6 | 3.13848
14056401 | 1.NP_SO-102 | 315 mm-160 mm | 0 | 315 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 23 | ETA | 0.04375 | 0.04375 | 0.00858237 | 3048 | 157.5 | 157.5 | 0.123741 | 80 | 0 | 77.5 | 315-160 | 187.102 | TA03.01.1080 | 1080 | yes | 3.1 | 6.2 | 7.48406 | 0
14056661 | 1.NP_SO-102 | 180 mm-160 mm | 0 | 180 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 23 | ETA | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 80 | 80 | 0.0230465 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.01.1084 | 1084 | yes | 0.4 | 0.8 | 0.965685 | 0
14056663 | 1.NP_SO-102 | 180 mm-160 mm | 0 | 180 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 23 | ETA | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 80 | 80 | 0.0230465 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.01.1085 | 1085 | yes | 0.4 | 0.8 | 0.965685 | 0
14056807 | 1.NP_SO-102 | 180 mm-160 mm | 0 | 180 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 14 | SUP | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 80 | 80 | 0.0230465 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.01.1086 | 1086 | yes | 0.4 | 0.8 | 0.965685 | 0
14056809 | 1.NP_SO-102 | 180 mm-160 mm | 0 | 180 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 14 | SUP | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 80 | 80 | 0.0230465 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.01.1087 | 1087 | yes | 0.4 | 0.8 | 0.965685 | 0
14057462 | 1.NP_SO-102 | 250 mm-160 mm | 0 | 250 mm-160 mm | 1.NP_SO-102 | 3200 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 0.0222222 | 0.0222222 | 0.00364293 | 3048 | 80 | 80 | 0.0684022 | 125 | 0 | 45 | 250-160 | 108.64 | TA03.01.1095 | 1095 | no | 1.8 | 3.6 | 4.34558 | 0
14058965 | -1.PP_SO-102 | 225 mm-160 mm | 0 | 225 mm-160 mm | -1.PP_SO-102 | 2430 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0222222 | 0.0222222 | 0.00230491 | 3048 | 80 | 80 | 0.0505085 | 112.5 | 0 | 32.5 | 225-160 | 78.4619 | TA03.01.1101 | 1101 | no | 1.3 | 2.6 | 3.13848 | 0
14059219 | -1.PP_SO-102 | 225 mm-160 mm | 0 | 225 mm-160 mm | -1.PP_SO-102 | 2430 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.03125 | 0.03125 | 0.002305 | 3048 | 112.5 | 112.5 | 0.0505085 | 80 | 0 | 32.5 | 225-160 | 78.4619 | TA03.01.1102 | 1102 | no | 1.3 | 2.6 | 3.13848 | 0
14078521 | 1.NP_SO-102 | 355 mm-315 mm | 0 | 355 mm-315 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.04375 | 0.04375 | 0.00426072 | 3048 | 157.5 | 157.5 | 0.0899957 | 177.5 | 0 | 20 | 355-315 | 48.2843 | TA03.01.1147 | 1147 | yes | 0.8 | 1.6 | 1.93137
14080762 | -1.PP_SO-102 | 355 mm-315 mm | 15 | 385 mm-345 mm | -1.PP_SO-102 | 3077.14 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 0.0493056 | 0.0493056 | 0.00426067 | 3048 | 177.5 | 177.5 | 0.0899957 | 157.5 | 0 | 20 | 355-315 | 48.2843 | TA03.01.1156 | 1156 | yes | 0.8 | 1.6 | 1.93137 | 0 | Izolace - Typ izolace: Protipožární
14080764 | -1.PP_SO-102 | 355 mm-315 mm | 15 | 385 mm-345 mm | -1.PP_SO-102 | 3077.14 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 0.0493056 | 0.0493056 | 0.00426067 | 3048 | 177.5 | 177.5 | 0.0899957 | 157.5 | 0 | 20 | 355-315 | 48.2843 | TA03.01.1157 | 1157 | yes | 0.8 | 1.6 | 1.93137 | 0 | Izolace - Typ izolace: Protipožární
14081181 | 3.NP_SO-102 | 250 mm-160 mm | 0 | 250 mm-160 mm | 3.NP_SO-102 | 3755.28 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 0.0222222 | 0.0222222 | 0.00364293 | 3048 | 80 | 80 | 0.0684022 | 125 | 0 | 45 | 250-160 | 108.64 | TA03.01.1160 | 1160 | yes | 1.8 | 3.6 | 4.34558
14113526 | -1.PP_SO-102 | 160 mm-125 mm | 0 | 160 mm-125 mm | -1.PP_SO-102 | 2600 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 0.0222222 | 0.0222222 | 0.000677011 | 3048 | 80 | 80 | 0.0228432 | 62.5 | 0 | 17.5 | 160-125 | 42.2487 | TA03.01.1206 | 1206 | no | 0.7 | 1.4 | 1.68995 | 0
14113528 | -1.PP_SO-102 | 160 mm-125 mm | 0 | 160 mm-125 mm | -1.PP_SO-102 | 2600 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 0.0222222 | 0.0222222 | 0.000677011 | 3048 | 80 | 80 | 0.0228432 | 62.5 | 0 | 17.5 | 160-125 | 42.2487 | TA03.01.1207 | 1207 | no | 0.7 | 1.4 | 1.68995 | 0
14120170 | 1.NP_SO-102 | 315 mm-250 mm | 0 | 315 mm-250 mm | 1.NP_SO-102 | 2650 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.04375 | 0.04375 | 0.00493938 | 3048 | 157.5 | 157.5 | 0.0865885 | 125 | 0 | 32.5 | 315-250 | 78.4619 | TA03.01.1257 | 1257 | yes | 1.3 | 2.6 | 3.13848 | 0
14120577 | 2.NP_SO-102 | 355 mm-250 mm | 0 | 355 mm-250 mm | 2.NP_SO-102 | 2910 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 0.0493056 | 0.0493056 | 0.00919997 | 3048 | 177.5 | 177.5 | 0.126972 | 125 | 0 | 52.5 | 355-250 | 126.746 | TA03.01.1259 | 1259 | yes | 2.1 | 4.2 | 5.06985
14121850 | -1.PP_SO-102 | 200 mm-180 mm | 0 | 200 mm-180 mm | -1.PP_SO-102 | 3240 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 0.0277778 | 0.0277778 | 0.000685038 | 3048 | 100 | 100 | 0.0276519 | 90 | 0 | 10 | 200-180 | 24.1421 | TA03.01.1272 | 1272 | no | 0.4 | 0.8 | 0.965685
14123656 | 4.NP_SO-102 | 280 mm-200 mm | 0 | 280 mm-200 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0388889 | 0.0388889 | 0.004409 | 3048 | 140 | 140 | 0.0778625 | 100 | 0 | 40 | 280-200 | 96.5685 | TA03.01.1287 | 1287 | yes | 1.6 | 3.2 | 3.86274
14123977 | 4.NP_SO-102 | 280 mm-225 mm | 0 | 280 mm-225 mm | 4.NP_SO-102 | 2870 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.03125 | 0.03125 | 0.00333739 | 3048 | 112.5 | 112.5 | 0.0671648 | 140 | 0 | 27.5 | 280-225 | 66.3909 | TA03.01.1292 | 1292 | yes | 1.1 | 2.2 | 2.65563 | 0
14147413 | 2.NP_SO-102 | 450 mm-400 mm | 0 | 450 mm-400 mm | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.0555556 | 0.0555556 | 0.00857177 | 3048 | 200 | 200 | 0.14404 | 225 | 0 | 25 | 450-400 | 60.3553 | TA03.01.1346 | 1346 | yes | 1 | 2 | 2.41421
14150850 | 2.NP_SO-102 | 250 mm-225 mm | 0 | 250 mm-225 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0347222 | 0.0347222 | 0.00133803 | 3048 | 125 | 125 | 0.0432062 | 112.5 | 0 | 12.5 | 250-225 | 30.1777 | TA03.01.1359 | 1359 | yes | 0.5 | 1 | 1.20711 | 0
14150871 | 2.NP_SO-102 | 315 mm-250 mm | 0 | 315 mm-250 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.04375 | 0.04375 | 0.00493938 | 3048 | 157.5 | 157.5 | 0.0865885 | 125 | 0 | 32.5 | 315-250 | 78.4619 | TA03.01.1360 | 1360 | yes | 1.3 | 2.6 | 3.13848 | 0
14150873 | 2.NP_SO-102 | 250 mm-225 mm | 0 | 250 mm-225 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0347222 | 0.0347222 | 0.00133803 | 3048 | 125 | 125 | 0.0432062 | 112.5 | 0 | 12.5 | 250-225 | 30.1777 | TA03.01.1361 | 1361 | yes | 0.5 | 1 | 1.20711 | 0
14154950 | 2.NP_SO-102 | 355 mm-250 mm | 0 | 355 mm-250 mm | 2.NP_SO-102 | 2940 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 0.0493056 | 0.0493056 | 0.00919997 | 3048 | 177.5 | 177.5 | 0.126972 | 125 | 0 | 52.5 | 355-250 | 126.746 | TA03.01.1370 | 1370 | no | 2.1 | 4.2 | 5.06985
14185152 | 2.NP_SO-102 | 450 mm-400 mm | 0 | 450 mm-400 mm | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 0.0625 | 0.0625 | 0.00857183 | 3048 | 225 | 225 | 0.14404 | 200 | 0 | 25 | 450-400 | 60.3553 | TA03.01.1507 | 1507 |  | 1 | 2 | 2.41421 | 0

# IfcDuctFitting: M_Kulatý přechod, úhel:45 stupňů (7)
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA03; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 01; Popis sestavy: Přechod
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulatý přechod, úhel
Classification: TA03 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - Odsazení šířky od základny: 3048 mm; Rozdíl odsazení: 0 mm
Jiné - Páteřní trasa: yes; Číslo 4: 1; Délka 3: 0 mm; Id typu: 1446832; Rodina: M_Kulatý přechod, úhel; Rodina a typ: M_Kulatý přechod, úhel: 45 stupňů; Typ: 45 stupňů
Name (M_Kulatý přechod, úhel:45 stupňů:...) | In | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Odsazení výšky od základny (mm) | Dočas. šířka odsazení | Dočas. výška odsazení | Objem (m3) | Odskok – šířka = Poloměr potrubí 1 (mm) | Odskok – výška | Plocha (m2) | Poloměr potrubí 2 (mm) | Rozdíl poloměrů (mm) = Délka 1 (mm) = Délka 2 (mm) | Velikost | Vypočítaná délka (mm) | Kód prvku | Označení | Číslo 1 = Číslo 2 | Číslo 3 | Číslo 5
13807335 | 1.NP_SO-102 | 450 mm-315 mm | 1.NP_SO-102 | 2629.67 | Čerstvý | Přívod vzduchu | ODA 13 | ODA | 3048 | 0.0625 | 0.0625 | 0.0189193 | 225 | 225 | 0.205231 | 157.5 | 67.5 | 450-315 | 162.959 | TA03.01.0360 | 0360 | 2.7 | 5.4 | 6.51838
13807359 | 2.NP_SO-102 | 500 mm-450 mm | 2.NP_SO-102 | 2475.32 | Čerstvý | Přívod vzduchu | ODA 13 | ODA | 3048 | 0.0625 | 0.0625 | 0.010705 | 225 | 225 | 0.172825 | 250 | 25 | 500-450 | 60.3553 | TA03.01.0361 | 0361 | 1 | 2 | 2.41421
13848457 | 3.NP_SO-102 | 500 mm-450 mm | 3.NP_SO-102 | 3099.91 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 3048 | 0.0625 | 0.0625 | 0.010705 | 225 | 225 | 0.172825 | 250 | 25 | 500-450 | 60.3553 | TA03.01.0425 | 0425 | 1 | 2 | 2.41421
13877205 | 2.NP_SO-102 | 500 mm-450 mm | 2.NP_SO-102 | 3040 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 0.0625 | 0.0625 | 0.010705 | 225 | 225 | 0.172825 | 250 | 25 | 500-450 | 60.3553 | TA03.01.0538 | 0538 | 1 | 2 | 2.41421
14003002 | 4.NP_SO-102 | 500 mm-355 mm | STŘECHA_SO-102 | 469.97 | Čerstvý | Přívod vzduchu | ODA 10 | ODA | 3048.56 | 0.0694444 | 0.0692899 | 0.0253634 | 250 | 249.444 | 0.249868 | 177.5 | 72.5 | 500-355 | 175.03 | TA03.01.0932 | 0932 | 2.9 | 5.8 | 7.00122
14056970 | 1.NP_SO-102 | 315 mm-160 mm | 1.NP_SO-102 | 3095 | Čerstvý | Přívod vzduchu | ODA 19 | ODA | 3048 | 0.0222222 | 0.0222222 | 0.00858226 | 80 | 80 | 0.123741 | 157.5 | 77.5 | 315-160 | 187.102 | TA03.01.1090 | 1090 | 3.1 | 6.2 | 7.48406 | Mechanické – tok - Tlaková ztráta: 0 Pa
14084629 | 1.NP_SO-102 | 315 mm-160 mm | 1.NP_SO-102 | 3095 | Odváděný | Zpětný vzduch | ETA 101 | ETA | 3048 | 0.0222222 | 0.0222222 | 0.00858226 | 80 | 80 | 0.123741 | 157.5 | 77.5 | 315-160 | 187.102 | TA03.01.1183 | 1183 | 3.1 | 6.2 | 7.48406 | Mechanické – tok - Tlaková ztráta: 0 Pa

# IfcDuctFitting: M_Kulatý přechod, úhel:45 stupňů (127)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA03; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 01; Popis sestavy: Přechod
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulatý přechod, úhel
Classification: TA03 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Grafika - Použít měřítko poznámky: yes
Jiné - Číslo 4: 1; Id typu: 1446832; Rodina: M_Kulatý přechod, úhel; Rodina a typ: M_Kulatý přechod, úhel: 45 stupňů; Typ: 45 stupňů
Name (M_Kulatý přechod, úhel:45 stupňů:...) | In | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Odsazení šířky od základny (mm) | Odsazení výšky od základny (mm) | Rozdíl odsazení (mm) | Dočas. šířka odsazení | Dočas. výška odsazení | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Poloměr potrubí 1 (mm) | Poloměr potrubí 2 (mm) | Rozdíl poloměrů (mm) | Velikost | Vypočítaná délka (mm) | Kód prvku | Označení | Páteřní trasa | Délka 3 (mm) | Číslo 1 | Číslo 2 | Číslo 3 | Číslo 5 | Délka 1 (mm) | Délka 2 (mm) | Tlaková ztráta (Pa)
13168491 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3317.2 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 34 | ETA | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0066 | 0066 | yes | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15
13168514 | 3.NP_SO-102 | 250 mm-160 mm | 3.NP_SO-102 | 3317.2 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 34 | ETA | 3048 | 3048 | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 125 | 80 | 45 | 250-160 | 108.64 | TA03.01.0067 | 0067 | yes | 0 | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45
13169203 | 1.NP_SO-102 | 315 mm-280 mm | 1.NP_SO-102 | 3617.2 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 0 | 0.04375 | 0.04375 | 0.00294005 | 157.5 | 157.5 | 0.0705798 | 157.5 | 140 | 17.5 | 315-280 | 42.2487 | TA03.01.0072 | 0072 | yes | 0 | 0.7 | 0.7 | 1.4 | 1.68995 | 17.5 | 17.5
13169207 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3317.2 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0073 | 0073 | yes | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15
13169211 | 3.NP_SO-102 | 250 mm-160 mm | 3.NP_SO-102 | 3317.2 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 125 | 80 | 45 | 250-160 | 108.64 | TA03.01.0074 | 0074 | yes | 0 | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45
13226248 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3342.5 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0104 | 0104 | yes | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15
13356639 | -1.PP_SO-102 | 250 mm-160 mm | -1.PP_SO-102 | 2700 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 3048 | 3048 | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 125 | 80 | 45 | 250-160 | 108.64 | TA03.01.0112 | 0112 | no | 0 | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45
13628814 | -1.PP_SO-102 | 225 mm-100 mm | -1.PP_SO-102 | 3160 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 8 | ETA | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00328316 | 112.5 | 112.5 | 0.0662152 | 112.5 | 50 | 62.5 | 225-100 | 150.888 | TA03.01.0127 | 0127 | yes | 0 | 2.5 | 2.5 | 5 | 6.03553 | 62.5 | 62.5 | 0 | Identifikační data - Komentáře: VZT 28
13628817 | -1.PP_SO-102 | 225 mm-100 mm | -1.PP_SO-102 | 3160 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 8 | ETA | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00328316 | 112.5 | 112.5 | 0.0662152 | 112.5 | 50 | 62.5 | 225-100 | 150.888 | TA03.01.0128 | 0128 | yes | 0 | 2.5 | 2.5 | 5 | 6.03553 | 62.5 | 62.5 | 0 | Identifikační data - Komentáře: VZT 28
13629077 | -1.PP_SO-102 | 250 mm-225 mm | -1.PP_SO-102 | 3160 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 8 | ETA | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0130 | 0130 | yes | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0 | Identifikační data - Komentáře: VZT 28
13629080 | -1.PP_SO-102 | 250 mm-225 mm | -1.PP_SO-102 | 3160 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 8 | ETA | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0131 | 0131 | yes | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0 | Identifikační data - Komentáře: VZT 28
13629096 | -1.PP_SO-102 | 250 mm-225 mm | -1.PP_SO-102 | 3160 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 8 | ETA | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0132 | 0132 | no | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0 | Identifikační data - Komentáře: VZT 28
13629098 | -1.PP_SO-102 | 250 mm-225 mm | -1.PP_SO-102 | 3160 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 8 | ETA | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0133 | 0133 | no | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0 | Identifikační data - Komentáře: VZT 28
13818644 | 1.NP_SO-102 | 180 mm-160 mm | 1.NP_SO-102 | 2719.63 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0391 | 0391 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
13867161 | 4.NP_SO-102 | 180 mm-160 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0461 | 0461 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
13867279 | 4.NP_SO-102 | 180 mm-160 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0464 | 0464 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
13867281 | 4.NP_SO-102 | 180 mm-160 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0465 | 0465 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
13867568 | 4.NP_SO-102 | 250 mm-225 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0472 | 0472 | no | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13867917 | 4.NP_SO-102 | 250 mm-225 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0475 | 0475 | no | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13867919 | 4.NP_SO-102 | 250 mm-225 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0476 | 0476 | no | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13869321 | 4.NP_SO-102 | 180 mm-160 mm | 4.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 40 | SUP | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0495 | 0495 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
13869323 | 4.NP_SO-102 | 180 mm-160 mm | 4.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0496 | 0496 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
13869354 | 4.NP_SO-102 | 180 mm-160 mm | 4.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 40 | SUP | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0497 | 0497 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
13869356 | 4.NP_SO-102 | 180 mm-160 mm | 4.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 40 | SUP | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0498 | 0498 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
13875627 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 22 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0519 | 0519 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15
13875629 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 22 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0520 | 0520 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15
13875798 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0521 | 0521 | yes | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15 | 0
13875800 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0522 | 0522 | yes | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15 | 0
13875846 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0523 | 0523 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15 | 0
13875848 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0524 | 0524 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15 | 0
13875900 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0525 | 0525 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15
13875902 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 22 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0526 | 0526 | yes | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15
13877598 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0543 | 0543 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15 | 0
13877600 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0544 | 0544 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15 | 0
13877616 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0545 | 0545 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15
13877618 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 55 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0546 | 0546 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15
13877660 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0547 | 0547 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15
13877662 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 57 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0548 | 0548 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15
13877723 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0549 | 0549 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15
13877725 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 59 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0550 | 0550 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15
13877820 | 2.NP_SO-102 | 250 mm-225 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0551 | 0551 | no | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13877822 | 2.NP_SO-102 | 250 mm-225 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0552 | 0552 | no | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13877824 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0553 | 0553 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15 | 0
13877826 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0554 | 0554 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15 | 0
13877828 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 55 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0555 | 0555 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15
13877830 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 55 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0556 | 0556 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15
13877895 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 57 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0557 | 0557 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15
13877897 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 57 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0558 | 0558 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15
13877923 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 59 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0559 | 0559 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15
13877925 | 2.NP_SO-102 | 280 mm-250 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 59 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0560 | 0560 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15
13878389 | 2.NP_SO-102 | 250 mm-225 mm | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0561 | 0561 | no | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13878391 | 2.NP_SO-102 | 250 mm-225 mm | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0562 | 0562 | no | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13878457 | 2.NP_SO-102 | 250 mm-225 mm | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0564 | 0564 | no | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13884432 | 3.NP_SO-102 | 280 mm-250 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0583 | 0583 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15 | 0
13884434 | 3.NP_SO-102 | 280 mm-250 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0584 | 0584 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15 | 0
13884552 | 3.NP_SO-102 | 280 mm-250 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0588 | 0588 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15 | 0
13884554 | 3.NP_SO-102 | 280 mm-250 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0589 | 0589 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15 | 0
13884574 | 3.NP_SO-102 | 280 mm-250 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0590 | 0590 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15 | 0
13884576 | 3.NP_SO-102 | 280 mm-250 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0591 | 0591 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15 | 0
13884652 | 3.NP_SO-102 | 280 mm-250 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0592 | 0592 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15 | 0
13885164 | 3.NP_SO-102 | 250 mm-225 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0597 | 0597 | no | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13885166 | 3.NP_SO-102 | 250 mm-225 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0598 | 0598 | no | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13885168 | 3.NP_SO-102 | 250 mm-225 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0599 | 0599 | no | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13885170 | 3.NP_SO-102 | 250 mm-225 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0600 | 0600 | no | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13885178 | 3.NP_SO-102 | 250 mm-225 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0602 | 0602 | no | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13885180 | 3.NP_SO-102 | 250 mm-225 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0603 | 0603 | no | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13885182 | 3.NP_SO-102 | 250 mm-225 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0604 | 0604 | no | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13885482 | 3.NP_SO-102 | 280 mm-250 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0607 | 0607 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15 | 0
13885484 | 3.NP_SO-102 | 280 mm-250 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0608 | 0608 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15 | 0
13885649 | 3.NP_SO-102 | 280 mm-250 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0613 | 0613 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15 | 0
13885651 | 3.NP_SO-102 | 280 mm-250 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0614 | 0614 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15 | 0
13885681 | 3.NP_SO-102 | 280 mm-250 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0615 | 0615 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15 | 0
13885683 | 3.NP_SO-102 | 280 mm-250 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 3048 | 3048 | 0 | 0.0388889 | 0.0388889 | 0.00199942 | 140 | 140 | 0.0552087 | 140 | 125 | 15 | 280-250 | 36.2132 | TA03.01.0616 | 0616 | no | 0 | 0.6 | 0.6 | 1.2 | 1.44853 | 15 | 15 | 0
13885838 | 3.NP_SO-102 | 180 mm-160 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0617 | 0617 | yes | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
13885840 | 3.NP_SO-102 | 180 mm-160 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0618 | 0618 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
13908800 | 1.NP_SO-102 | 180 mm-160 mm | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0648 | 0648 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
13908802 | 1.NP_SO-102 | 180 mm-160 mm | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0649 | 0649 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
13911201 | 1.NP_SO-102 | 250 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.0347222 | 0.0347222 | 0.00364297 | 125 | 125 | 0.0684022 | 125 | 80 | 45 | 250-160 | 108.64 | TA03.01.0660 | 0660 | yes | 0 | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13911570 | 1.NP_SO-102 | 180 mm-160 mm | 1.NP_SO-102 | 2820 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 10 | ETA | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0663 | 0663 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
13911572 | 1.NP_SO-102 | 180 mm-160 mm | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0664 | 0664 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
13912111 | 1.NP_SO-102 | 355 mm-280 mm | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 3048 | 3048 | 0 | 0.0493056 | 0.0493056 | 0.00720068 | 177.5 | 177.5 | 0.110963 | 177.5 | 140 | 37.5 | 355-280 | 90.533 | TA03.01.0671 | 0671 | yes | 0 | 1.5 | 1.5 | 3 | 3.62132 | 37.5 | 37.5 | 0
13915145 | 2.NP_SO-102 | 180 mm-160 mm | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0694 | 0694 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
13926668 | 1.NP_SO-102 | 180 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 2 | SUP | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0709 | 0709 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
13926767 | 1.NP_SO-102 | 180 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 35 | SUP | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0711 | 0711 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
13926791 | 1.NP_SO-102 | 180 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 35 | SUP | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0712 | 0712 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
13926793 | 1.NP_SO-102 | 180 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 35 | SUP | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0713 | 0713 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
13926851 | 1.NP_SO-102 | 180 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0714 | 0714 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
13926853 | 1.NP_SO-102 | 180 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0715 | 0715 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
13927096 | 1.NP_SO-102 | 180 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0718 | 0718 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
13927098 | 1.NP_SO-102 | 180 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0719 | 0719 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
13935933 | 2.NP_SO-102 | 200 mm-180 mm | 2.NP_SO-102 | 2700 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000685056 | 90 | 90 | 0.0276519 | 90 | 100 | 10 | 200-180 | 24.1421 | TA03.01.0739 | 0739 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
13935936 | 2.NP_SO-102 | 200 mm-180 mm | 2.NP_SO-102 | 2700 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 16 | ETA | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000685056 | 90 | 90 | 0.0276519 | 90 | 100 | 10 | 200-180 | 24.1421 | TA03.01.0740 | 0740 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
13937610 | 2.NP_SO-102 | 315 mm-225 mm | 2.NP_SO-102 | 2850 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 3048 | 3048 | 0 | 0.04375 | 0.04375 | 0.00627741 | 157.5 | 157.5 | 0.0985447 | 157.5 | 112.5 | 45 | 315-225 | 108.64 | TA03.01.0747 | 0747 | yes | 0 | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45
13938609 | 2.NP_SO-102 | 315 mm-250 mm | 2.NP_SO-102 | 2850 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 3048 | 3048 | 0 | 0.0347222 | 0.0347222 | 0.00493936 | 125 | 125 | 0.0865885 | 125 | 157.5 | 32.5 | 315-250 | 78.4619 | TA03.01.0756 | 0756 | yes | 0 | 1.3 | 1.3 | 2.6 | 3.13848 | 32.5 | 32.5
13938718 | 2.NP_SO-102 | 250 mm-160 mm | 2.NP_SO-102 | 2850 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 3048 | 2988.28 | 59.7151 | 0.0347222 | 0.0513097 | 0.00364297 | 125 | 184.715 | 0.0691577 | 125 | 80 | 45 | 250-160 | 108.64 | TA03.01.0757 | 0757 | yes | 0 | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13961932 | -1.PP_SO-102 | 180 mm-160 mm | -1.PP_SO-102 | 3067.62 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 3048 | 3046.03 | 1.96751 | 0.025 | 0.0255465 | 0.000548535 | 90 | 91.9675 | 0.0229948 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.0826 | 0826 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
13965302 | -1.PP_SO-102 | 250 mm-225 mm | -1.PP_SO-102 | 2350 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0834 | 0834 | no | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5
13967158 | -1.PP_SO-102 | 200 mm-160 mm | -1.PP_SO-102 | 2350 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 3048 | 3048 | 0 | 0.0222222 | 0.0222222 | 0.00123354 | 80 | 80 | 0.0344984 | 80 | 100 | 20 | 200-160 | 48.2843 | TA03.01.0848 | 0848 | no | 0 | 0.8 | 0.8 | 1.6 | 1.93137 | 20 | 20 | 0
13967208 | -1.PP_SO-102 | 250 mm-180 mm | -1.PP_SO-102 | 2350 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.00309452 | 90 | 90 | 0.0615557 | 90 | 125 | 35 | 250-180 | 84.4975 | TA03.01.0849 | 0849 | no | 0 | 1.4 | 1.4 | 2.8 | 3.3799 | 35 | 35
13967323 | -1.PP_SO-102 | 180 mm-125 mm | -1.PP_SO-102 | 2350 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 3048 | 3048 | 0 | 0.0173611 | 0.0173611 | 0.00122551 | 62.5 | 62.5 | 0.0330897 | 62.5 | 90 | 27.5 | 180-125 | 66.3909 | TA03.01.0850 | 0850 | no | 0 | 1.1 | 1.1 | 2.2 | 2.65563 | 27.5 | 27.5
13982165 | 4.NP_SO-102 | 250 mm-225 mm | 4.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 23 | SUP | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0869 | 0869 | no | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5
13982167 | 4.NP_SO-102 | 250 mm-225 mm | 4.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 23 | SUP | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0870 | 0870 | no | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5
13984503 | 3.NP_SO-102 | 315 mm-225 mm | 3.NP_SO-102 | 3099.91 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 3048 | 3048 | 0 | 0.04375 | 0.04375 | 0.00627741 | 157.5 | 157.5 | 0.0985447 | 157.5 | 112.5 | 45 | 315-225 | 108.64 | TA03.01.0877 | 0877 | no | 0 | 1.8 | 1.8 | 3.6 | 4.34558 | 45 | 45 | 0
13989500 | -1.PP_SO-102 | 250 mm-225 mm | -1.PP_SO-102 | 3077.14 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 25 | SUP | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.00133805 | 112.5 | 112.5 | 0.0432062 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.0896 | 0896 | no | 0 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
13999716 | 2.NP_SO-102 | 355 mm-225 mm | 2.NP_SO-102 | 2910 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 3048 | 3048 | 0 | 0.03125 | 0.03125 | 0.0105382 | 112.5 | 112.5 | 0.138928 | 112.5 | 177.5 | 65 | 355-225 | 156.924 | TA03.01.0920 | 0920 | no | 0 | 2.6 | 2.6 | 5.2 | 6.27696 | 65 | 65
14034480 | 4.NP_SO-102 | 250 mm-225 mm | 4.NP_SO-102 | 3100 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 3048.01 | 3048 | 0.0108679 | 0.0347252 | 0.0347222 | 0.00133803 | 125.011 | 125 | 0.0432062 | 125 | 112.5 | 12.5 | 250-225 | 30.1777 | TA03.01.0998 | 0998 | no | 0.0108679 | 0.500435 | 0.499565 | 1 | 1.20711 | 12.5109 | 12.4891
14039104 | 1.NP_SO-102 | 180 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 12 | EHA | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.1016 | 1016 | yes | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
14052443 | 2.NP_SO-102 | 180 mm-160 mm | 2.NP_SO-102 | 2580 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.1052 | 1052 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
14053223 | 2.NP_SO-102 | 225 mm-225 mm | 2.NP_SO-102 | 2910 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 3048 | 2948 | 100 | 0.03125 | 0.0590278 | 0.00223637 | 112.5 | 212.5 | 0.0637841 | 112.5 | 112.5 | 0 | 225-225 | 56.25 | TA03.01.1055 | 1055 | no | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0
14053527 | 2.NP_SO-102 | 180 mm-160 mm | 2.NP_SO-102 | 2580 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.1061 | 1061 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
14056968 | 1.NP_SO-102 | 180 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 19 | ODA | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.1089 | 1089 | yes | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
14082517 | -1.PP_SO-102 | 225 mm-160 mm | -1.PP_SO-102 | 3160 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 8 | ETA | 3048 | 3047.97 | 0.0322031 | 0.03125 | 0.0312589 | 0.002305 | 112.5 | 112.532 | 0.0505074 | 112.5 | 80 | 32.5 | 225-160 | 78.4619 | TA03.01.1176 | 1176 | no | 0 | 1.3 | 1.3 | 2.6 | 3.13848 | 32.5 | 32.5
