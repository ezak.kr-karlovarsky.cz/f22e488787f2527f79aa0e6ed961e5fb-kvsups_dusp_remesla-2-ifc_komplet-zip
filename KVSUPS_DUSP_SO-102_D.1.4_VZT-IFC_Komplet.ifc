Properties of the parts of a building model (IFC4), part 41 of 45

# IfcDuctSegment: Kulaté potrubí:HLADKÉ POZINK/vývod (10)
Name (Kulaté potrubí:HLADKÉ POZINK/vývod:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Volná velikost = Celková velikost | Sklon | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Řez | Ekvivaletní průměr (mm) = Hydraulický průměr (mm) = Průměr (mm) = Velikost | Název systému = Group | Kód prvku | Označení
13711821 | 1.NP_SO-102 | 827.585 | 0.0201032 | 0.41599 | 160 mm | 0 | 1.NP_SO-102 | 2880 | 2800 | 2800 | 2720 | 2 | 160 | EHA 12 | PO02.05.0402 | 0402
13795290 | 1.NP_SO-102 | 3936.53 | 0.0989649 | 4.39027 | 355 mm |  | 1.NP_SO-102 | 3368 | 3368 | -568.528 | -568.528 | 4 | 355 | EHA 9 | PO02.05.0554 | 0554
13796652 | 1.NP_SO-102 | 20 | 0.0989649 | 0.0223053 | 355 mm | 0 | 1.NP_SO-102 | 3900.5 | 3723 | 3723 | 3545.5 | 1 | 355 | EHA 15 | PO02.05.0555 | 0555
13796724 | 1.NP_SO-102 | 20 | 0.0989649 | 0.0223053 | 355 mm | 0 | 1.NP_SO-102 | 3900.5 | 3723 | 3723 | 3545.5 | 1 | 355 | EHA 16 | PO02.05.0556 | 0556
13796958 | 2.NP_SO-102 | 4558 | 0.0201032 | 2.2911 | 160 mm |  | 2.NP_SO-102 | 3518 | 3518 | -1040 | -1040 | 2 | 160 | EHA 12 | PO02.05.0557 | 0557
13796970 | 2.NP_SO-102 | 41.3604 | 0.0201032 | 0.02079 | 160 mm | 0 | 2.NP_SO-102 | 3758 | 3678 | 3678 | 3598 | 2 | 160 | EHA 12 | PO02.05.0558 | 0558
13810728 | -1.PP_SO-102 | 4022.86 | 0.0989649 | 4.48656 | 355 mm | 0 | -1.PP_SO-102 | 3253.97 | 3076.47 | 3076.47 | 2898.97 | 4 | 355 | EHA 9 | PO02.05.0602 | 0602
13951649 | -1.PP_SO-102 | 668.191 | 0.0989649 | 0.74521 | 355 mm | 0 | -1.PP_SO-102 | 3253.97 | 3076.47 | 3076.47 | 2898.97 | 2 | 355 | EHA 9 | PO02.05.1072 | 1072
13951911 | -1.PP_SO-102 | 367.596 | 0.0989649 | 0.409967 | 355 mm | 0 | -1.PP_SO-102 | 3253.97 | 3076.47 | 3076.47 | 2898.97 | 2 | 355 | EHA 9 | PO02.05.1073 | 1073

# IfcDuctSegment: Kulaté potrubí:SPIRO POZINK/T spoj (978)
Type - Material: 0-0-255
Type - Požární ochrana - Požární odolnost: A1
Type - Materiály a povrchové úpravy - Materiál: Kov, pozink
Type - Stavba - Drsnost: 0.2 mm
Type - Identifikační data - ID kategorie: PO; Kód sestavy: PO02; Komentáře k typům: SPIRO; Název typu: SPIRO POZINK/T spoj; Označení typu: 01; Popis: Potrubí spiro pozink; Popis sestavy: Pozinkované
Type - Jiné - Kategorie: Potrubí; MJ: m; Název rodiny: Kulaté potrubí
Classification: PO02 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Mechanické – tok - Doplňkový průtok: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Mechanické - Uzamknutí velikosti: no
Jiné - Id typu: 352285; Rodina: Kulaté potrubí; Rodina a typ: Kulaté potrubí: SPIRO POZINK/T spoj; Typ: SPIRO POZINK/T spoj
Name (Kulaté potrubí:SPIRO POZINK/T spoj:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Volná velikost | Celková velikost | Tloušťka izolace (mm) | Dynamický tlak (Pa) | Průtok (m3/s) | Reynoldsovo číslo | Rychlost (m/s) | Tlaková ztráta (Pa) | Tření (kg/m2/s2) | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Sklon | Spodní výška (mm) | Fáze vytvoření | Ekvivaletní průměr (mm) = Hydraulický průměr (mm) = Průměr (mm) = Velikost | Klasifikace systému | Koeficient ztrát | Název systému | Řez | Typ systému | Zkratka systému | Kód prvku | Označení | Páteřní trasa | Group
12890935 | 2.NP_SO-102 | 4178.2 | 0.061566 | 3.67534 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3320 | 3180 | 3180 | 2.NP_SO-102 | 0 | 3040 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 17 | 110 | Přívodní | SUP | PO02.01.0001 | 0001 | yes | SUP 17
12890992 | 2.NP_SO-102 | 3003.43 | 0.0314112 | 1.88711 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3280 | 3180 | 3180 | 2.NP_SO-102 | 0 | 3080 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 17 | 106 | Přívodní | SUP | PO02.01.0002 | 0002 | yes | SUP 17
12891539 | 2.NP_SO-102 | 1248.06 | 0.0201032 | 0.627345 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2780 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2620 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 12 | 41 | Odváděný | ETA | PO02.01.0003 | 0003 | no | ETA 12
12891553 | 2.NP_SO-102 | 2081.09 | 0.0201032 | 1.04607 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2780 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2620 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 12 | 35 | Odváděný | ETA | PO02.01.0004 | 0004 | no | ETA 12
12891605 | 2.NP_SO-102 | 1560.39 | 0.0201032 | 0.784335 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2780 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2620 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 12 | 39 | Odváděný | ETA | PO02.01.0005 | 0005 | no | ETA 12
12891615 | 2.NP_SO-102 | 2081.09 | 0.0201032 | 1.04607 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2780 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2620 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 12 | 47 | Odváděný | ETA | PO02.01.0006 | 0006 | no | ETA 12
12891726 | 2.NP_SO-102 | 80.3588 | 0.0254431 | 0.0454418 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2790 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2610 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 12 | 29 | Odváděný | ETA | PO02.01.0007 | 0007 | no | ETA 12
12900268 | 2.NP_SO-102 | 4544.82 | 0.0201032 | 2.28447 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2680 | 2600 | 2600 | 2.NP_SO-102 | 0 | 2520 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 9 | 384 | Přívodní | SUP | PO02.01.0008 | 0008 | no | SUP 9
12901855 | 2.NP_SO-102 | 2812.9 | 0.0397548 | 1.98832 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3022.5 | 2910 | 2910 | 2.NP_SO-102 | 0 | 2797.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 14 | 245 | Odváděný | ETA | PO02.01.0009 | 0009 | no | ETA 14
12901964 | 2.NP_SO-102 | 4309.47 | 0.04908 | 3.38465 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3065 | 2940 | 2940 | 2.NP_SO-102 | 0 | 2815 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 9 | 298 | Přívodní | SUP | PO02.01.0010 | 0010 | no | SUP 9
12903094 | 3.NP_SO-102 | 3202.6 | 0.0314112 | 2.01226 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3245.16 | 3145.16 | 3145.16 | 3.NP_SO-102 | 0 | 3045.16 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 9 | 427 | Přívodní | SUP | PO02.01.0011 | 0011 | no | SUP 9
12904508 | 4.NP_SO-102 | 2003.9 | 0.04908 | 1.57386 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3225 | 3100 | 3100 | 4.NP_SO-102 | 0 | 2975 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 14 | 257 | Odváděný | ETA | PO02.01.0012 | 0012 | no | ETA 14 | Identifikační data - Komentáře: VZT25
12904518 | 4.NP_SO-102 | 5010.27 | 0.04908 | 3.93506 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3225 | 3100 | 3100 | 4.NP_SO-102 | 0 | 2975 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 14 | 257 | Odváděný | ETA | PO02.01.0013 | 0013 | no | ETA 14
12908056 | 2.NP_SO-102 | 2293.49 | 0.0397548 | 1.62117 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3050 | 2937.5 | 2937.5 | 2.NP_SO-102 | 0 | 2825 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 9 | 328 | Přívodní | SUP | PO02.01.0014 | 0014 | yes | SUP 9
12908099 | 2.NP_SO-102 | 2418.49 | 0.0397548 | 1.70953 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3050 | 2937.5 | 2937.5 | 2.NP_SO-102 | 0 | 2825 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 9 | 336 | Přívodní | SUP | PO02.01.0015 | 0015 | yes | SUP 9
12952477 | 1.NP_SO-102 | 13351.7 | 0.0201032 | 6.7113 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3230 | 3150 | 3150 | 1.NP_SO-102 | 0 | 3070 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 13 | 236 | Přívodní | SUP | PO02.01.0024 | 0024 | no | SUP 13
12959017 | 2.NP_SO-102 | 3314.41 | 0.04908 | 2.60313 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2689.41 | -625 | 2689.41 | 2.NP_SO-102 |  | -625.001 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 9 | 477 | Přívodní | SUP | PO02.01.0025 | 0025 | no | SUP 9
12961485 | 4.NP_SO-102 | 2511.6 | 0.061566 | 2.20932 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2900 | 388.401 | 2900 | 4.NP_SO-102 |  | 388.401 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 9 | 416 | Přívodní | SUP | PO02.01.0026 | 0026 | yes | SUP 9
13095679 | 2.NP_SO-102 | 215.521 | 0.159008 | 0.304685 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.3 | 3048.2 | 2895.8 | 2.NP_SO-102 | 100 | 2736.7 | Fáze 1 | 450 | Přívod vzduchu | 0 | SUP 17 | 158 | Přívodní | SUP | PO02.01.0032 | 0032 | yes | SUP 17
13095900 | 2.NP_SO-102 | 5211.41 | 0.061566 | 4.5842 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3320 | 3180 | 3180 | 2.NP_SO-102 | 0 | 3040 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 17 | 116 | Přívodní | SUP | PO02.01.0033 | 0033 | yes | SUP 17
13095966 | 2.NP_SO-102 | 2160.4 | 0.125636 | 2.71484 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3380 | 3180 | 3180 | 2.NP_SO-102 | 0 | 2980 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 17 | 137 | Přívodní | SUP | PO02.01.0034 | 0034 | yes | SUP 17
13096060 | 2.NP_SO-102 | 2221.3 | 0.0314112 | 1.39568 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3280 | 3180 | 3180 | 2.NP_SO-102 | 0 | 3080 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 17 | 14 | Přívodní | SUP | PO02.01.0035 | 0035 | yes | SUP 17
13096304 | 2.NP_SO-102 | 58.3679 | 0.159008 | 0.0825157 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2989 | 2764 | 2764 | 2.NP_SO-102 | 0 | 2539 | Fáze 1 | 450 | Přívod vzduchu | 0 | SUP 17 | 158 | Přívodní | SUP | PO02.01.0036 | 0036 | yes | SUP 17
13096388 | 2.NP_SO-102 | 2087.21 | 0.125636 | 2.62287 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3380 | 3180 | 3180 | 2.NP_SO-102 | 0 | 2980 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 17 | 18 | Přívodní | SUP | PO02.01.0037 | 0037 | yes | SUP 17
13097687 | 2.NP_SO-102 | 176.156 | 0.159008 | 0.249035 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2989 | 2764 | 2764 | 2.NP_SO-102 | 0 | 2539 | Fáze 1 | 450 | Zpětný vzduch | 0 | ETA 12 | 114 | Odváděný | ETA | PO02.01.0042 | 0042 | yes | ETA 12
13103740 | 1.NP_SO-102 | 6289.99 | 0.04908 | 4.94015 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3325.1 | 3200.1 | 3200.1 | 1.NP_SO-102 | 0 | 3075.1 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 9 | 364 | Přívodní | SUP | PO02.01.0043 | 0043 | no | SUP 9
13103750 | 1.NP_SO-102 | 6506.07 | 0.04908 | 5.10986 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3325.1 | 3200.1 | 3200.1 | 1.NP_SO-102 | 0 | 3075.1 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 9 | 360 | Přívodní | SUP | PO02.01.0044 | 0044 | no | SUP 9
13103797 | 1.NP_SO-102 | 4900 | 0.0254431 | 2.77088 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3290.1 | 3200.1 | 3200.1 | 1.NP_SO-102 | 0 | 3110.1 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 9 | 356 | Přívodní | SUP | PO02.01.0045 | 0045 | no | SUP 9
13103880 | 2.NP_SO-102 | 2237.24 | 0.0397548 | 1.58141 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3065 | 2952.5 | 2952.5 | 2.NP_SO-102 | 0 | 2840 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 9 | 320 | Přívodní | SUP | PO02.01.0046 | 0046 | yes | SUP 9
13107171 | 2.NP_SO-102 | 498.136 | 0.0989649 | 0.555554 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3117.5 | 2940 | 2940 | 2.NP_SO-102 | 0 | 2762.5 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 9 | 281 | Přívodní | SUP | PO02.01.0050 | 0050 | yes | SUP 9
13111254 | 2.NP_SO-102 | 1230.4 | 0.0201032 | 0.618464 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2990 | 2910 | 2910 | 2.NP_SO-102 | 0 | 2830 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 14 | 305 | Odváděný | ETA | PO02.01.0055 | 0055 | no | ETA 14
13151213 | 2.NP_SO-102 | 1293.5 | 0.159008 | 1.82865 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3162.5 | 2937.5 | 2937.5 | 2.NP_SO-102 | 0 | 2712.5 | Fáze 1 | 450 | Přívod vzduchu | 0 | SUP 9 | 215 | Přívodní | SUP | PO02.01.0061 | 0061 | yes | SUP 9
13151376 | 2.NP_SO-102 | 93.3579 | 0.0989649 | 0.104119 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3087.5 | 2910 | 2910 | 2.NP_SO-102 | 0 | 2732.5 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 14 | 328 | Odváděný | ETA | PO02.01.0062 | 0062 | no | ETA 14
13151391 | 2.NP_SO-102 | 2182.86 | 0.0989649 | 2.43446 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3087.5 | 2910 | 2910 | 2.NP_SO-102 | 0 | 2732.5 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 14 | 328 | Odváděný | ETA | PO02.01.0063 | 0063 | no | ETA 14
13151681 | 2.NP_SO-102 | 2660.26 | 0.0989649 | 2.9669 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3087.5 | 2910 | 2910 | 2.NP_SO-102 | 0 | 2732.5 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 14 | 297 | Odváděný | ETA | PO02.01.0065 | 0065 | yes | ETA 14
13152208 | 3.NP_SO-102 | 9567.09 | 0.0779194 | 9.46761 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3302.66 | 3145.16 | 3145.16 | 3.NP_SO-102 | 0 | 2987.66 | Fáze 1 | 315 | Přívod vzduchu | 0 | SUP 9 | 374 | Přívodní | SUP | PO02.01.0067 | 0067 | no | SUP 9
13154564 | 1.NP_SO-102 | 33.7061 | 0.0779194 | 0.0333556 | 315 mm | 345 mm | 15 | 0 | 0 | 0 | 0 | 0 | 0 | 2807.5 | 2650 | 2650 | 1.NP_SO-102 | 0 | 2492.5 | Fáze 1 | 315 | Přívod vzduchu | 0 | SUP 24 | 414 | Přívodní | SUP | PO02.01.0069 | 0069 | yes | SUP 24 | Izolace - Typ izolace: Protipožární
13154670 | 1.NP_SO-102 | 116.182 | 0.0254431 | 0.0656994 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3185 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3005 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 24 | 68 | Přívodní | SUP | PO02.01.0070 | 0070 | no | SUP 24
13154801 | 1.NP_SO-102 | 7843.68 | 0.01227 | 3.08021 | 125 mm | 125 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3157.5 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3032.5 | Fáze 1 | 125 | Přívod vzduchu | 0 | SUP 24 | 362 | Přívodní | SUP | PO02.01.0071 | 0071 | no | SUP 24
13154815 | 1.NP_SO-102 | 5720.97 | 0.125636 | 7.18918 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3295 | 3095 | 3095 | 1.NP_SO-102 | 0 | 2895 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 24 | 74 | Přívodní | SUP | PO02.01.0072 | 0072 | yes | SUP 24
13154830 | 1.NP_SO-102 | 163.879 | 0.0254431 | 0.0926715 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3185 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3005 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 24 | 63 | Přívodní | SUP | PO02.01.0073 | 0073 | no | SUP 24
13154848 | 1.NP_SO-102 | 63.6821 | 0.0254431 | 0.0360114 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3185 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3005 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 24 | 383 | Přívodní | SUP | PO02.01.0074 | 0074 | no | SUP 24
13154859 | 1.NP_SO-102 | 2117.9 | 0.0989649 | 2.36202 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.5 | 3095 | 3095 | 1.NP_SO-102 | 0 | 2917.5 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 24 | 57 | Přívodní | SUP | PO02.01.0075 | 0075 | yes | SUP 24
13154924 | 1.NP_SO-102 | 2439.48 | 0.0201032 | 1.22622 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 425 | Přívodní | SUP | PO02.01.0076 | 0076 | no | SUP 24
13154939 | 1.NP_SO-102 | 7972.54 | 0.0989649 | 8.8915 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.5 | 3095 | 3095 | 1.NP_SO-102 | 0 | 2917.5 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 24 | 417 | Přívodní | SUP | PO02.01.0077 | 0077 | yes | SUP 24
13155007 | 1.NP_SO-102 | 686.544 | 0.0254431 | 0.388232 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3185 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3005 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 35 | 8 | Přívodní | SUP | PO02.01.0078 | 0078 | no | SUP 35
13155011 | 1.NP_SO-102 | 6118.24 | 0.0254431 | 3.45978 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3185 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3005 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 35 | 16 | Přívodní | SUP | PO02.01.0079 | 0079 | no | SUP 35
13155646 | 2.NP_SO-102 | 7117.18 | 0.061566 | 6.2606 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 59 | 236 | Přívodní | SUP | PO02.01.0080 | 0080 | no | SUP 59
13155836 | 2.NP_SO-102 | 845.075 | 0.061566 | 0.743367 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 59 | 230 | Přívodní | SUP | PO02.01.0081 | 0081 | no | SUP 59
13155849 | 2.NP_SO-102 | 43.5167 | 0.061566 | 0.0382792 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 24 | 130 | Přívodní | SUP | PO02.01.0082 | 0082 | no | SUP 24
13155860 | 2.NP_SO-102 | 4658.51 | 0.246291 | 8.19568 | 560 mm | 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3320 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2760 | Fáze 1 | 560 | Přívod vzduchu | 0 | SUP 24 | 131 | Přívodní | SUP | PO02.01.0083 | 0083 | yes | SUP 24
13155972 | 2.NP_SO-102 | 2293.16 | 0.125636 | 2.88167 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3240 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2840 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 24 | 22 | Přívodní | SUP | PO02.01.0084 | 0084 | yes | SUP 24
13156095 | 2.NP_SO-102 | 7123.4 | 0.04908 | 5.5947 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3165 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2915 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 24 | 549 | Přívodní | SUP | PO02.01.0085 | 0085 | no | SUP 24
13156119 | 2.NP_SO-102 | 7093.22 | 0.0397548 | 5.0139 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3152.5 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2927.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 24 | 340 | Přívodní | SUP | PO02.01.0086 | 0086 | no | SUP 24
13156216 | 2.NP_SO-102 | 7087.18 | 0.061566 | 6.23421 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 24 | 346 | Přívodní | SUP | PO02.01.0087 | 0087 | no | SUP 24
13156225 | 2.NP_SO-102 | 80.0501 | 0.061566 | 0.0704157 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 24 | 202 | Přívodní | SUP | PO02.01.0088 | 0088 | no | SUP 24
13156234 | 2.NP_SO-102 | 102.729 | 0.061566 | 0.0903653 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 24 | 202 | Přívodní | SUP | PO02.01.0089 | 0089 | no | SUP 24
13156250 | 2.NP_SO-102 | 5833.7 | 0.125636 | 7.33085 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3240 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2840 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 24 | 26 | Přívodní | SUP | PO02.01.0090 | 0090 | yes | SUP 24
13156261 | 2.NP_SO-102 | 7087.18 | 0.061566 | 6.23421 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 55 | 227 | Přívodní | SUP | PO02.01.0091 | 0091 | no | SUP 55
13156279 | 2.NP_SO-102 | 77.7292 | 0.061566 | 0.0683742 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 24 | 448 | Přívodní | SUP | PO02.01.0092 | 0092 | no | SUP 24
13156293 | 2.NP_SO-102 | 3766.38 | 0.159008 | 5.32459 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3265 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2815 | Fáze 1 | 450 | Přívod vzduchu | 0 | SUP 24 | 24 | Přívodní | SUP | PO02.01.0093 | 0093 | yes | SUP 24
13156340 | 2.NP_SO-102 | 7087.18 | 0.061566 | 6.23421 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 57 | 232 | Přívodní | SUP | PO02.01.0094 | 0094 | no | SUP 57
13156349 | 2.NP_SO-102 | 889.542 | 0.061566 | 0.782482 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 57 | 226 | Přívodní | SUP | PO02.01.0095 | 0095 | no | SUP 57
13156358 | 2.NP_SO-102 | 110.681 | 0.061566 | 0.0973601 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 24 | 449 | Přívodní | SUP | PO02.01.0096 | 0096 | no | SUP 24
13156371 | 2.NP_SO-102 | 416.47 | 0.196306 | 0.654189 | 500 mm | 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3290 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2790 | Fáze 1 | 500 | Přívod vzduchu | 0 | SUP 24 | 15 | Přívodní | SUP | PO02.01.0097 | 0097 | yes | SUP 24
13156887 | 4.NP_SO-102 | 148.66 | 0.159008 | 0.210163 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3320 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2870 | Fáze 1 | 450 | Přívod vzduchu | 0 | SUP 24 | 529 | Přívodní | SUP | PO02.01.0098 | 0098 | yes | SUP 24
13156897 | 4.NP_SO-102 | 7770.62 | 0.061566 | 6.83539 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2955 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 24 | 150 | Přívodní | SUP | PO02.01.0099 | 0099 | yes | SUP 24
13156980 | 4.NP_SO-102 | 7133.01 | 0.0314112 | 4.4818 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3195 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2995 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 24 | 146 | Přívodní | SUP | PO02.01.0100 | 0100 | no | SUP 24
13157102 | 4.NP_SO-102 | 815.39 | 0.0314112 | 0.512325 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3195 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2995 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 24 | 534 | Přívodní | SUP | PO02.01.0101 | 0101 | yes | SUP 24
13157130 | 4.NP_SO-102 | 96.0808 | 0.0397548 | 0.0679155 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 39 | 154 | Přívodní | SUP | PO02.01.0102 | 0102 | no | SUP 39
13157139 | 4.NP_SO-102 | 91.7371 | 0.0397548 | 0.0648451 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 24 | 538 | Přívodní | SUP | PO02.01.0103 | 0103 | no | SUP 24
13157165 | 4.NP_SO-102 | 436.783 | 0.0989649 | 0.487129 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2917.5 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 24 | 530 | Přívodní | SUP | PO02.01.0104 | 0104 | yes | SUP 24
13157192 | 4.NP_SO-102 | 100.341 | 0.0397548 | 0.0709266 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 24 | 542 | Přívodní | SUP | PO02.01.0105 | 0105 | no | SUP 24
13157201 | 4.NP_SO-102 | 673.79 | 0.0397548 | 0.476274 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 24 | 540 | Přívodní | SUP | PO02.01.0106 | 0106 | no | SUP 24
13157236 | 4.NP_SO-102 | 93.2029 | 0.0397548 | 0.0658812 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 24 | 540 | Přívodní | SUP | PO02.01.0107 | 0107 | no | SUP 24
13157276 | 3.NP_SO-102 | 2113.03 | 0.196306 | 3.31914 | 500 mm | 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3290 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2790 | Fáze 1 | 500 | Přívod vzduchu | 0 | SUP 24 | 40 | Přívodní | SUP | PO02.01.0108 | 0108 | yes | SUP 24
13157387 | 3.NP_SO-102 | 9399.46 | 0.0989649 | 10.4829 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3217.5 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2862.5 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 1 | 169 | Přívodní | SUP | PO02.01.0109 | 0109 | yes | SUP 1
13157431 | 3.NP_SO-102 | 7195.19 | 0.0397548 | 5.08598 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3152.5 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2927.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 1 | 290 | Přívodní | SUP | PO02.01.0110 | 0110 | no | SUP 1
13157493 | 3.NP_SO-102 | 7120.63 | 0.04908 | 5.59253 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3165 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2915 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 1 | 302 | Přívodní | SUP | PO02.01.0111 | 0111 | no | SUP 1
13157502 | 3.NP_SO-102 | 378.958 | 0.04908 | 0.297633 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3165 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2915 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 1 | 258 | Přívodní | SUP | PO02.01.0112 | 0112 | no | SUP 1
13157535 | 3.NP_SO-102 | 7185.47 | 0.04908 | 5.64346 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3165 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2915 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 1 | 324 | Přívodní | SUP | PO02.01.0113 | 0113 | no | SUP 1
13157544 | 3.NP_SO-102 | 163.737 | 0.04908 | 0.128599 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3165 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2915 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 1 | 314 | Přívodní | SUP | PO02.01.0114 | 0114 | no | SUP 1
13157553 | 3.NP_SO-102 | 60.0403 | 0.04908 | 0.0471555 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3165 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2915 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 1 | 314 | Přívodní | SUP | PO02.01.0115 | 0115 | no | SUP 1
13157564 | 3.NP_SO-102 | 3411.47 | 0.125636 | 4.28697 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3240 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2840 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 1 | 43 | Přívodní | SUP | PO02.01.0116 | 0116 | yes | SUP 1
13157575 | 3.NP_SO-102 | 20.8694 | 0.061566 | 0.0183576 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 1 | 311 | Přívodní | SUP | PO02.01.0117 | 0117 | no | SUP 1
13157584 | 3.NP_SO-102 | 195.546 | 0.061566 | 0.172011 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 1 | 316 | Přívodní | SUP | PO02.01.0118 | 0118 | no | SUP 1
13157593 | 3.NP_SO-102 | 5.04028 | 0.061566 | 0.00443366 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 24 | 51 | Přívodní | SUP | PO02.01.0119 | 0119 | no | SUP 24
13157606 | 3.NP_SO-102 | 5388.95 | 0.159008 | 7.61845 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3265 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2815 | Fáze 1 | 450 | Přívod vzduchu | 0 | SUP 24 | 41 | Přívodní | SUP | PO02.01.0120 | 0120 | yes | SUP 24
13157617 | 3.NP_SO-102 | 20.9882 | 0.061566 | 0.0184622 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 1 | 52 | Přívodní | SUP | PO02.01.0121 | 0121 | no | SUP 1
13157626 | 3.NP_SO-102 | 61.8936 | 0.061566 | 0.0544445 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 1 | 323 | Přívodní | SUP | PO02.01.0122 | 0122 | no | SUP 1
13157635 | 3.NP_SO-102 | 19.1235 | 0.061566 | 0.0168219 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 1 | 323 | Přívodní | SUP | PO02.01.0123 | 0123 | no | SUP 1
13157651 | 3.NP_SO-102 | 4406.41 | 0.196306 | 6.92157 | 500 mm | 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3290 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2790 | Fáze 1 | 500 | Přívod vzduchu | 0 | SUP 24 | 16 | Přívodní | SUP | PO02.01.0124 | 0124 | yes | SUP 24
13157662 | 3.NP_SO-102 | 31.7282 | 0.0254431 | 0.0179419 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3130 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2950 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 24 | 421 | Přívodní | SUP | PO02.01.0125 | 0125 | no | SUP 24
13157712 | 3.NP_SO-102 | 87.9974 | 0.0254431 | 0.0497613 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3130 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2950 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 24 | 338 | Přívodní | SUP | PO02.01.0126 | 0126 | yes | SUP 24
13157772 | 3.NP_SO-102 | 326.325 | 0.0254431 | 0.184532 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3130 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2950 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 24 | 338 | Přívodní | SUP | PO02.01.0127 | 0127 | yes | SUP 24
13157783 | 3.NP_SO-102 | 1249.94 | 0.0254431 | 0.706824 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3130 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2950 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 24 | 338 | Přívodní | SUP | PO02.01.0128 | 0128 | yes | SUP 24
13159250 | 1.NP_SO-102 | 321.279 | 0.0201032 | 0.161493 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 413 | Přívodní | SUP | PO02.01.0129 | 0129 | no | SUP 24
13159258 | 1.NP_SO-102 | 620 | 0.0201032 | 0.311646 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 413 | Přívodní | SUP | PO02.01.0130 | 0130 | no | SUP 24
13160177 | 3.NP_SO-102 | 210 | 0.0254431 | 0.118752 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3190 | 3100 | 3100 | 3.NP_SO-102 | 0 | 3010 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 13 | 191 | Přívodní | SUP | PO02.01.0131 | 0131 | no | SUP 13
13160724 | 2.NP_SO-102 | 6369.48 | 0.0254431 | 3.60186 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3170 | 3080 | 3080 | 2.NP_SO-102 | 0 | 2990 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 13 | 216 | Přívodní | SUP | PO02.01.0132 | 0132 | no | SUP 13
13161020 | 1.NP_SO-102 | 421.437 | 0.0254431 | 0.238317 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3240 | 3150 | 3150 | 1.NP_SO-102 | 0 | 3060 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 13 | 51 | Přívodní | SUP | PO02.01.0133 | 0133 | no | SUP 13
13168448 | 2.NP_SO-102 | 187.203 | 0.061566 | 0.164672 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3317.2 | 3317.2 | 3130 | 2.NP_SO-102 |  | 3130 | Fáze 1 | 280 | Zpětný vzduch | 0 | ETA 34 | 7 | Odváděný | ETA | PO02.01.0134 | 0134 | yes | ETA 34
13168481 | 3.NP_SO-102 | 191.473 | 0.04908 | 0.150382 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3317.2 | 3317.2 | 3125.73 | 3.NP_SO-102 |  | 3125.73 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 34 | 5 | Odváděný | ETA | PO02.01.0135 | 0135 | yes | ETA 34
13168494 | 4.NP_SO-102 | 3414.16 | 0.0201032 | 1.71614 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2840 | 2840 | -574.158 | 4.NP_SO-102 |  | -574.158 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 34 | 80 | Odváděný | ETA | PO02.01.0136 | 0136 | yes | ETA 34 | Identifikační data - Komentáře: VZT18
13168548 | 4.NP_SO-102 | 484.78 | 0.0201032 | 0.243677 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2920 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 34 | 80 | Odváděný | ETA | PO02.01.0137 | 0137 | no | ETA 34 | Identifikační data - Komentáře: VZT 18
13168846 | 3.NP_SO-102 | 504.78 | 0.0201032 | 0.25373 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3075.73 | 2995.73 | 2995.73 | 3.NP_SO-102 | 0 | 2915.73 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 34 | 84 | Odváděný | ETA | PO02.01.0138 | 0138 | no | ETA 34
13168863 | 3.NP_SO-102 | 3512.31 | 0.04908 | 2.75857 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2865.73 | 2865.73 | -646.584 | 3.NP_SO-102 |  | -646.584 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 34 | 3 | Odváděný | ETA | PO02.01.0139 | 0139 | yes | ETA 34
13168978 | 2.NP_SO-102 | 488.867 | 0.0201032 | 0.245731 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2920 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 34 | 103 | Odváděný | ETA | PO02.01.0140 | 0140 | no | ETA 34 | Identifikační data - Komentáře: VZT18
13168989 | 3.NP_SO-102 | 3447.75 | 0.061566 | 3.0328 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1130 | -4577.75 | -1130 | 3.NP_SO-102 |  | -4577.75 | Fáze 1 | 280 | Zpětný vzduch | 0 | ETA 34 | 2 | Odváděný | ETA | PO02.01.0141 | 0141 | yes | ETA 34
13169015 | 1.NP_SO-102 | 439.155 | 0.0201032 | 0.220744 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3330 | 3250 | 3250 | 1.NP_SO-102 | 0 | 3170 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 87 | Odváděný | ETA | PO02.01.0142 | 0142 | no | ETA 7 | Identifikační data - Komentáře: VZT18
13169024 | 1.NP_SO-102 | 3705 | 0.0779194 | 3.66647 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3120 | 3120 | -585 | 1.NP_SO-102 |  | -585 | Fáze 1 | 315 | Zpětný vzduch | 0 | ETA 7 | 283 | Odváděný | ETA | PO02.01.0143 | 0143 | yes | ETA 7
13169134 | 1.NP_SO-102 | 323.68 | 0.0314112 | 0.203374 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3250 | 3150 | 3150 | 1.NP_SO-102 | 0 | 3050 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 13 | 224 | Přívodní | SUP | PO02.01.0144 | 0144 | no | SUP 13
13169156 | 1.NP_SO-102 | 2567.47 | 0.0254431 | 1.45187 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3240 | 3150 | 3150 | 1.NP_SO-102 | 0 | 3060 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 13 | 51 | Přívodní | SUP | PO02.01.0145 | 0145 | yes | SUP 13
13169199 | 1.NP_SO-102 | 237.203 | 0.0779194 | 0.234736 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3617.2 | 3617.2 | 3380 | 1.NP_SO-102 |  | 3380 | Fáze 1 | 315 | Zpětný vzduch | 0 | ETA 7 | 59 | Odváděný | ETA | PO02.01.0146 | 0146 | yes | ETA 7
13169201 | 2.NP_SO-102 | 187.203 | 0.061566 | 0.164672 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3317.2 | 3317.2 | 3130 | 2.NP_SO-102 |  | 3130 | Fáze 1 | 280 | Zpětný vzduch | 0 | ETA 7 | 17 | Odváděný | ETA | PO02.01.0147 | 0147 | yes | ETA 7
13169205 | 3.NP_SO-102 | 167.203 | 0.04908 | 0.131321 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3317.2 | 3317.2 | 3150 | 3.NP_SO-102 |  | 3150 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 7 | 19 | Odváděný | ETA | PO02.01.0148 | 0148 | yes | ETA 7
13169209 | 4.NP_SO-102 | 3564.16 | 0.0201032 | 1.79154 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2990 | 2990 | -574.158 | 4.NP_SO-102 |  | -574.158 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 78 | Odváděný | ETA | PO02.01.0149 | 0149 | yes | ETA 7
13169213 | 4.NP_SO-102 | 431.237 | 0.0201032 | 0.216763 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3230 | 3150 | 3150 | 4.NP_SO-102 | 0 | 3070 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 78 | Odváděný | ETA | PO02.01.0150 | 0150 | no | ETA 7 | Identifikační data - Komentáře: VZT18
13169217 | 3.NP_SO-102 | 494.233 | 0.0201032 | 0.248429 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3100 | 3020 | 3020 | 3.NP_SO-102 | 0 | 2940 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 82 | Odváděný | ETA | PO02.01.0151 | 0151 | no | ETA 7 | Identifikační data - Komentáře: VZT18
13169220 | 3.NP_SO-102 | 3536.58 | 0.04908 | 2.77763 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2890 | 2890 | -646.584 | 3.NP_SO-102 |  | -646.584 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 7 | 18 | Odváděný | ETA | PO02.01.0152 | 0152 | yes | ETA 7
13169223 | 2.NP_SO-102 | 519.951 | 0.0201032 | 0.261356 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2920 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 154 | Odváděný | ETA | PO02.01.0153 | 0153 | no | ETA 7 | Identifikační data - Komentáře: VZT18
13169226 | 3.NP_SO-102 | 3210.55 | 0.061566 | 2.82415 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1130 | -1130 | -4340.55 | 3.NP_SO-102 |  | -4340.55 | Fáze 1 | 280 | Zpětný vzduch | 0 | ETA 7 | 16 | Odváděný | ETA | PO02.01.0154 | 0154 | yes | ETA 7
13169472 | 1.NP_SO-102 | 13475.5 | 0.0314112 | 8.46691 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3250 | 3150 | 3150 | 1.NP_SO-102 | 0 | 3050 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 13 | 57 | Přívodní | SUP | PO02.01.0155 | 0155 | no | SUP 13
13169487 | 1.NP_SO-102 | 12184.3 | 0.04908 | 9.5695 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3275 | 3150 | 3150 | 1.NP_SO-102 | 0 | 3025 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 13 | 252 | Přívodní | SUP | PO02.01.0156 | 0156 | yes | SUP 13
13169843 | 1.NP_SO-102 | 2440 | 0.0254431 | 1.37979 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3190 | 3100 | 3100 | 1.NP_SO-102 | 0 | 3010 | Fáze 2 | 180 | Přívod vzduchu | 0 | SUP 12 | 51 | Přívodní | SUP | PO02.01.0157 | 0157 | no | SUP 12
13170554 | 1.NP_SO-102 | 2358.86 | 0.0201032 | 1.18569 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 1.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 12 | 172 | Přívodní | SUP | PO02.01.0158 | 0158 | no | SUP 12
13170618 | 1.NP_SO-102 | 3200 | 0.0201032 | 1.6085 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 1.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 12 | 227 | Přívodní | SUP | PO02.01.0159 | 0159 | no | SUP 12
13170667 | 1.NP_SO-102 | 9542.5 | 0.04908 | 7.49467 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3225 | 3100 | 3100 | 1.NP_SO-102 | 0 | 2975 | Fáze 2 | 250 | Přívod vzduchu | 0 | SUP 12 | 221 | Přívodní | SUP | PO02.01.0160 | 0160 | no | SUP 12
13170795 | 1.NP_SO-102 | 244.089 | 0.0989649 | 0.272224 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3277.5 | 3100 | 3100 | 1.NP_SO-102 | 0 | 2922.5 | Fáze 2 | 355 | Přívod vzduchu | 0 | SUP 12 | 213 | Přívodní | SUP | PO02.01.0161 | 0161 | no | SUP 12
13170809 | 1.NP_SO-102 | 3787.52 | 0.061566 | 3.33168 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3240 | 3100 | 3100 | 1.NP_SO-102 | 0 | 2960 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 12 | 225 | Přívodní | SUP | PO02.01.0162 | 0162 | no | SUP 12
13170925 | 1.NP_SO-102 | 7288.82 | 0.0254431 | 4.12173 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3190 | 3100 | 3100 | 1.NP_SO-102 | 0 | 3010 | Fáze 2 | 180 | Přívod vzduchu | 0 | SUP 12 | 230 | Přívodní | SUP | PO02.01.0163 | 0163 | no | SUP 12
13171125 | 2.NP_SO-102 | 187.5 | 0.0397548 | 0.132536 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 13 | 302 | Přívodní | SUP | PO02.01.0164 | 0164 | no | SUP 13
13171197 | 2.NP_SO-102 | 6607.67 | 0.0397548 | 4.67069 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 50 | 153 | Přívodní | SUP | PO02.01.0165 | 0165 | no | SUP 50
13171217 | 2.NP_SO-102 | 43.4958 | 0.0397548 | 0.0307454 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 13 | 300 | Přívodní | SUP | PO02.01.0166 | 0166 | no | SUP 13
13171226 | 2.NP_SO-102 | 7387.48 | 0.125636 | 9.28339 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3295 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2895 | Fáze 2 | 400 | Přívod vzduchu | 0 | SUP 13 | 60 | Přívodní | SUP | PO02.01.0167 | 0167 | yes | SUP 13
13171337 | 2.NP_SO-102 | 6800 | 0.061566 | 5.98159 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 22 | 101 | Přívodní | SUP | PO02.01.0168 | 0168 | no | SUP 22
13171512 | 2.NP_SO-102 | 833.204 | 0.061566 | 0.732925 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 22 | 97 | Přívodní | SUP | PO02.01.0169 | 0169 | yes | SUP 22
13171603 | 2.NP_SO-102 | 6876.83 | 0.061566 | 6.04917 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 101 | Přívodní | SUP | PO02.01.0170 | 0170 | no | SUP 24
13172049 | 3.NP_SO-102 | 514.652 | 0.061566 | 0.452712 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 493 | Přívodní | SUP | PO02.01.0171 | 0171 | no | SUP 24
13172217 | 3.NP_SO-102 | 7108.53 | 0.061566 | 6.25299 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 117 | Přívodní | SUP | PO02.01.0172 | 0172 | no | SUP 24
13172226 | 3.NP_SO-102 | 278.553 | 0.061566 | 0.245028 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 495 | Přívodní | SUP | PO02.01.0173 | 0173 | no | SUP 24
13172235 | 3.NP_SO-102 | 7.30243 | 0.061566 | 0.00642355 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 495 | Přívodní | SUP | PO02.01.0174 | 0174 | no | SUP 24
13172246 | 3.NP_SO-102 | 3409.49 | 0.061566 | 2.99914 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 491 | Přívodní | SUP | PO02.01.0175 | 0175 | yes | SUP 24
13172740 | 4.NP_SO-102 | 143.686 | 0.04908 | 0.112851 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3220 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2970 | Fáze 2 | 250 | Přívod vzduchu | 0 | SUP 18 | 157 | Přívodní | SUP | PO02.01.0176 | 0176 | no | SUP 18
13172742 | 4.NP_SO-102 | 5098.03 | 0.061566 | 4.48446 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 18 | 159 | Přívodní | SUP | PO02.01.0177 | 0177 | yes | SUP 18
13172766 | 4.NP_SO-102 | 7030.18 | 0.0201032 | 3.53375 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 4.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 24 | 237 | Přívodní | SUP | PO02.01.0178 | 0178 | no | SUP 24
13172796 | 4.NP_SO-102 | 180.178 | 0.04908 | 0.141511 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3220 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2970 | Fáze 2 | 250 | Přívod vzduchu | 0 | SUP 18 | 158 | Přívodní | SUP | PO02.01.0179 | 0179 | no | SUP 18
13172800 | 4.NP_SO-102 | 6200 | 0.04908 | 4.86947 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3220 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2970 | Fáze 2 | 250 | Přívod vzduchu | 0 | SUP 18 | 171 | Přívodní | SUP | PO02.01.0180 | 0180 | no | SUP 18
13172869 | 4.NP_SO-102 | 34.0447 | 0.0397548 | 0.0240648 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 24 | 167 | Přívodní | SUP | PO02.01.0181 | 0181 | yes | SUP 24
13172882 | 4.NP_SO-102 | 7000 | 0.0397548 | 4.94801 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 24 | 246 | Přívodní | SUP | PO02.01.0182 | 0182 | no | SUP 24
13172900 | 4.NP_SO-102 | 6979.85 | 0.0201032 | 3.50846 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 4.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 24 | 241 | Přívodní | SUP | PO02.01.0183 | 0183 | no | SUP 24
13197339 | 4.NP_SO-102 | 7100 | 0.0397548 | 5.01869 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 21 | 151 | Přívodní | SUP | PO02.01.0184 | 0184 | no | SUP 21
13197360 | 4.NP_SO-102 | 866.93 | 0.0397548 | 0.612797 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 21 | 151 | Přívodní | SUP | PO02.01.0185 | 0185 | no | SUP 21
13197366 | 4.NP_SO-102 | 157.713 | 0.0397548 | 0.11148 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 24 | 84 | Přívodní | SUP | PO02.01.0186 | 0186 | no | SUP 24
13197465 | 4.NP_SO-102 | 92.906 | 0.0397548 | 0.0656714 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 149 | Přívodní | SUP | PO02.01.0187 | 0187 | no | SUP 13
13197535 | 4.NP_SO-102 | 6196.57 | 0.196306 | 9.73356 | 500 mm | 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3345 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2845 | Fáze 1 | 500 | Přívod vzduchu | 0 | SUP 13 | 156 | Přívodní | SUP | PO02.01.0188 | 0188 | yes | SUP 13
13197801 | 4.NP_SO-102 | 4987.71 | 0.0201032 | 2.5071 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 4.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 24 | 180 | Přívodní | SUP | PO02.01.0189 | 0189 | yes | SUP 24
13198072 | 4.NP_SO-102 | 5600 | 0.0254431 | 3.16673 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3185 | 3095 | 3095 | 4.NP_SO-102 | 0 | 3005 | Fáze 2 | 180 | Přívod vzduchu | 0 | SUP 18 | 167 | Přívodní | SUP | PO02.01.0190 | 0190 | no | SUP 18
13198095 | 4.NP_SO-102 | 5600 | 0.0254431 | 3.16673 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3185 | 3095 | 3095 | 4.NP_SO-102 | 0 | 3005 | Fáze 2 | 180 | Přívod vzduchu | 0 | SUP 18 | 162 | Přívodní | SUP | PO02.01.0191 | 0191 | no | SUP 18
13198110 | 4.NP_SO-102 | 845.93 | 0.0254431 | 0.478362 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3185 | 3095 | 3095 | 4.NP_SO-102 | 0 | 3005 | Fáze 2 | 180 | Přívod vzduchu | 0 | SUP 18 | 149 | Přívodní | SUP | PO02.01.0192 | 0192 | yes | SUP 18
13198426 | 4.NP_SO-102 | 5120 | 0.0254431 | 2.89529 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3270 | 3180 | 3180 | 4.NP_SO-102 | 0 | 3090 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 40 | 169 | Přívodní | SUP | PO02.01.0193 | 0193 | no | SUP 40
13198433 | 4.NP_SO-102 | 154.7 | 0.0254431 | 0.087481 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3270 | 3180 | 3180 | 4.NP_SO-102 | 0 | 3090 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 40 | 169 | Přívodní | SUP | PO02.01.0194 | 0194 | no | SUP 40
13198558 | 3.NP_SO-102 | 1224.93 | 0.061566 | 1.0775 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 98 | Přívodní | SUP | PO02.01.0195 | 0195 | yes | SUP 24
13198657 | 3.NP_SO-102 | 7108.53 | 0.061566 | 6.25299 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 502 | Přívodní | SUP | PO02.01.0196 | 0196 | no | SUP 24
13198810 | 3.NP_SO-102 | 6426.38 | 0.0397548 | 4.54254 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 13 | 135 | Přívodní | SUP | PO02.01.0197 | 0197 | no | SUP 13
13198825 | 3.NP_SO-102 | 2270.1 | 0.125636 | 2.85269 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3295 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2895 | Fáze 2 | 400 | Přívod vzduchu | 0 | SUP 13 | 114 | Přívodní | SUP | PO02.01.0198 | 0198 | yes | SUP 13
13198916 | 3.NP_SO-102 | 162.595 | 0.0397548 | 0.114932 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 13 | 81 | Přívodní | SUP | PO02.01.0199 | 0199 | no | SUP 13
13198924 | 3.NP_SO-102 | 438.562 | 0.0397548 | 0.310001 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 13 | 129 | Přívodní | SUP | PO02.01.0200 | 0200 | no | SUP 13
13198933 | 3.NP_SO-102 | 6465.2 | 0.0397548 | 4.56998 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 13 | 129 | Přívodní | SUP | PO02.01.0201 | 0201 | no | SUP 13
13199019 | 3.NP_SO-102 | 6238.49 | 0.04908 | 4.8997 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3220 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2970 | Fáze 2 | 250 | Přívod vzduchu | 0 | SUP 13 | 108 | Přívodní | SUP | PO02.01.0202 | 0202 | yes | SUP 13
13199027 | 3.NP_SO-102 | 6688.15 | 0.04908 | 5.25286 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3220 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2970 | Fáze 2 | 250 | Přívod vzduchu | 0 | SUP 13 | 123 | Přívodní | SUP | PO02.01.0203 | 0203 | no | SUP 13
13199231 | 3.NP_SO-102 | 198.621 | 0.0397548 | 0.140397 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3212.5 | 3100 | 3100 | 3.NP_SO-102 | 0 | 2987.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 20 | Přívodní | SUP | PO02.01.0204 | 0204 | no | SUP 13
13199240 | 3.NP_SO-102 | 56.8985 | 0.0397548 | 0.0402192 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3212.5 | 3100 | 3100 | 3.NP_SO-102 | 0 | 2987.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 208 | Přívodní | SUP | PO02.01.0205 | 0205 | no | SUP 13
13199254 | 3.NP_SO-102 | 52.3744 | 0.0397548 | 0.0370213 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3212.41 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 2987.41 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 208 | Přívodní | SUP | PO02.01.0206 | 0206 | no | SUP 13
13199272 | 3.NP_SO-102 | 9629.52 | 0.125636 | 12.1008 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3299.91 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 2899.91 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 13 | 19 | Přívodní | SUP | PO02.01.0207 | 0207 | yes | SUP 13
13199313 | 3.NP_SO-102 | 4200 | 0.01227 | 1.64934 | 125 mm | 125 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3162.41 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 3037.41 | Fáze 1 | 125 | Přívod vzduchu | 0 | SUP 13 | 285 | Přívodní | SUP | PO02.01.0208 | 0208 | no | SUP 13
13199322 | 3.NP_SO-102 | 96.766 | 0.0201032 | 0.0486399 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3179.91 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 3019.91 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 13 | 85 | Přívodní | SUP | PO02.01.0209 | 0209 | no | SUP 13
13199356 | 3.NP_SO-102 | 1322.72 | 0.125636 | 1.66218 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3299.91 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 2899.91 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 13 | 144 | Přívodní | SUP | PO02.01.0210 | 0210 | yes | SUP 13
13199383 | 3.NP_SO-102 | 93.234 | 0.0201032 | 0.0468645 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 3.NP_SO-102 | 0 | 3020 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 13 | 289 | Přívodní | SUP | PO02.01.0211 | 0211 | no | SUP 13
13199405 | 3.NP_SO-102 | 1894.5 | 0.0201032 | 0.952282 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3179.91 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 3019.91 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 13 | 84 | Přívodní | SUP | PO02.01.0212 | 0212 | no | SUP 13
13199442 | 3.NP_SO-102 | 12806.2 | 0.196306 | 20.116 | 500 mm | 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3349.91 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 2849.91 | Fáze 1 | 500 | Přívod vzduchu | 0 | SUP 13 | 143 | Přívodní | SUP | PO02.01.0213 | 0213 | yes | SUP 13
13199582 | 3.NP_SO-102 | 17977.9 | 0.0397548 | 12.7078 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3212.41 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 2987.41 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 263 | Přívodní | SUP | PO02.01.0214 | 0214 | no | SUP 13
13200003 | 2.NP_SO-102 | 886.494 | 0.0397548 | 0.626625 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 45 | 149 | Přívodní | SUP | PO02.01.0215 | 0215 | no | SUP 45
13200018 | 2.NP_SO-102 | 6474.73 | 0.0397548 | 4.57672 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 45 | 149 | Přívodní | SUP | PO02.01.0216 | 0216 | no | SUP 45
13200232 | 2.NP_SO-102 | 166.759 | 0.061566 | 0.146689 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 95 | Přívodní | SUP | PO02.01.0217 | 0217 | no | SUP 24
13200240 | 2.NP_SO-102 | 1190.49 | 0.061566 | 1.04721 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 95 | Přívodní | SUP | PO02.01.0218 | 0218 | no | SUP 24
13200249 | 2.NP_SO-102 | 39.0815 | 0.0779194 | 0.0386751 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3252.5 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2937.5 | Fáze 2 | 315 | Přívod vzduchu | 0 | SUP 24 | 72 | Přívodní | SUP | PO02.01.0219 | 0219 | no | SUP 24
13200386 | 2.NP_SO-102 | 4698.55 | 0.061566 | 4.13306 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 93 | Přívodní | SUP | PO02.01.0220 | 0220 | yes | SUP 24
13200703 | 2.NP_SO-102 | 218.946 | 0.0254431 | 0.123811 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3270 | 3180 | 3180 | 2.NP_SO-102 | 0 | 3090 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 17 | 131 | Přívodní | SUP | PO02.01.0221 | 0221 | no | SUP 17
13221637 | 4.NP_SO-102 | 2586.12 | 0.061566 | 2.27487 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2803.61 | 217.487 | 2803.61 | 4.NP_SO-102 |  | 217.487 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 257 | Přívodní | SUP | PO02.01.0223 | 0223 | yes | SUP 24
13225996 | 1.NP_SO-102 | 632.5 | 0.0779194 | 0.625923 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3862.5 | 3862.5 | 3230 | 1.NP_SO-102 |  | 3230 | Fáze 2 | 315 | Zpětný vzduch | 0 | ETA 7 | 145 | Odváděný | ETA | PO02.01.0228 | 0228 | yes | ETA 7
13226148 | 2.NP_SO-102 | 112.5 | 0.061566 | 0.0989602 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3342.5 | 3342.5 | 3230 | 2.NP_SO-102 |  | 3230 | Fáze 2 | 280 | Zpětný vzduch | 0 | ETA 7 | 171 | Odváděný | ETA | PO02.01.0229 | 0229 | yes | ETA 7
13226238 | 3.NP_SO-102 | 416.642 | 0.04908 | 0.32723 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3646.64 | 3646.64 | 3230 | 3.NP_SO-102 |  | 3230 | Fáze 2 | 250 | Zpětný vzduch | 0 | ETA 7 | 148 | Odváděný | ETA | PO02.01.0230 | 0230 | yes | ETA 7
13226251 | 2.NP_SO-102 | 3064.72 | 0.0201032 | 1.5405 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 10820 | 10820 | 7755.28 | 2.NP_SO-102 |  | 7755.28 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 373 | Odváděný | ETA | PO02.01.0231 | 0231 | yes | ETA 7
13227280 | -1.PP_SO-102 | 518.365 | 0.0779194 | 0.512975 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3237.5 | 3080 | 3080 | -1.PP_SO-102 | 0 | 2922.5 | Fáze 1 | 315 | Zpětný vzduch | 0 | ETA 7 | 279 | Odváděný | ETA | PO02.01.0234 | 0234 | no | ETA 7
13227803 | 1.NP_SO-102 | 6052.62 | 0.196306 | 9.50743 | 500 mm | 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3345 | 3095 | 3095 | 1.NP_SO-102 | 0 | 2845 | Fáze 1 | 500 | Přívod vzduchu | 0 | SUP 24 | 450 | Přívodní | SUP | PO02.01.0236 | 0236 | yes | SUP 24
13227940 | 1.NP_SO-102 | 3397.46 | 0.159008 | 4.80305 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3320 | 3095 | 3095 | 1.NP_SO-102 | 0 | 2870 | Fáze 1 | 450 | Přívod vzduchu | 0 | SUP 24 | 420 | Přívodní | SUP | PO02.01.0237 | 0237 | yes | SUP 24
13228187 | 1.NP_SO-102 | 17288.4 | 0.0779194 | 17.1086 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3307.5 | 3150 | 3150 | 1.NP_SO-102 | 0 | 2992.5 | Fáze 1 | 315 | Přívod vzduchu | 0 | SUP 13 | 77 | Přívodní | SUP | PO02.01.0238 | 0238 | yes | SUP 13
13301985 | 1.NP_SO-102 | 5340.72 | 0.0254431 | 3.02011 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3190 | 3100 | 3100 | 1.NP_SO-102 | 0 | 3010 | Fáze 2 | 180 | Přívod vzduchu | 0 | SUP 12 | 51 | Přívodní | SUP | PO02.01.0239 | 0239 | no | SUP 12
13302069 | 1.NP_SO-102 | 3130 | 0.159008 | 4.42493 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2650 | -480 | 2650 | 1.NP_SO-102 |  | -480 | Fáze 2 | 450 | Přívod vzduchu | 0 | SUP 12 | 239 | Přívodní | SUP | PO02.01.0240 | 0240 | yes | SUP 12
13302533 | 1.NP_SO-102 | 298.534 | 0.0254431 | 0.168817 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2830 | 2740 | 2740 | 1.NP_SO-102 | 0 | 2650 | Fáze 2 | 180 | Zpětný vzduch | 0 | ETA 17 | 25 | Odváděný | ETA | PO02.01.0241 | 0241 | no | ETA 17
13302542 | 1.NP_SO-102 | 2282.48 | 0.0254431 | 1.29071 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2830 | 2740 | 2740 | 1.NP_SO-102 | 0 | 2650 | Fáze 2 | 180 | Zpětný vzduch | 0 | ETA 17 | 25 | Odváděný | ETA | PO02.01.0242 | 0242 | no | ETA 17
13302551 | 1.NP_SO-102 | 320 | 0.061566 | 0.281487 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2880 | 2740 | 2740 | 1.NP_SO-102 | 0 | 2600 | Fáze 2 | 280 | Zpětný vzduch | 0 | ETA 17 | 91 | Odváděný | ETA | PO02.01.0243 | 0243 | no | ETA 17
13302612 | 1.NP_SO-102 | 1211.83 | 0.0989649 | 1.35152 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2917.5 | 2740 | 2740 | 1.NP_SO-102 | 0 | 2562.5 | Fáze 2 | 355 | Zpětný vzduch | 0 | ETA 17 | 61 | Odváděný | ETA | PO02.01.0244 | 0244 | yes | ETA 17
13302632 | 1.NP_SO-102 | 14959.3 | 0.0254431 | 8.45929 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2830 | 2740 | 2740 | 1.NP_SO-102 | 0 | 2650 | Fáze 2 | 180 | Zpětný vzduch | 0 | ETA 17 | 72 | Odváděný | ETA | PO02.01.0245 | 0245 | yes | ETA 17
13302668 | 1.NP_SO-102 | 4063.14 | 0.0254431 | 2.29765 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2830 | 2740 | 2740 | 1.NP_SO-102 | 0 | 2650 | Fáze 2 | 180 | Zpětný vzduch | 0 | ETA 17 | 82 | Odváděný | ETA | PO02.01.0246 | 0246 | yes | ETA 17
13302811 | 1.NP_SO-102 | 2659.64 | 0.159008 | 3.75998 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2290 | -369.645 | 2290 | 1.NP_SO-102 |  | -369.645 | Fáze 2 | 450 | Zpětný vzduch | 0 | ETA 17 | 58 | Odváděný | ETA | PO02.01.0247 | 0247 | yes | ETA 17
13324216 | -1.PP_SO-102 | 880.01 | 0.01227 | 0.345579 | 125 mm | 125 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2412.5 | 2350 | 2350 | -1.PP_SO-102 | 0 | 2287.5 | Fáze 1 | 125 | Zpětný vzduch | 0 | ETA 27 | 36 | Odváděný | ETA | PO02.01.0248 | 0248 | no | ETA 27
13324226 | -1.PP_SO-102 | 3440.57 | 0.0201032 | 1.72942 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2430 | 2350 | 2350 | -1.PP_SO-102 | 0 | 2270 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 27 | 60 | Odváděný | ETA | PO02.01.0249 | 0249 | no | ETA 27
13324236 | -1.PP_SO-102 | 1238.26 | 0.04908 | 0.972525 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2475 | 2350 | 2350 | -1.PP_SO-102 | 0 | 2225 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 27 | 45 | Odváděný | ETA | PO02.01.0250 | 0250 | no | ETA 27
13324240 | -1.PP_SO-102 | 1925.61 | 0.0254431 | 1.08891 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2440 | 2350 | 2350 | -1.PP_SO-102 | 0 | 2260 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 27 | 34 | Odváděný | ETA | PO02.01.0251 | 0251 | no | ETA 27
13324268 | -1.PP_SO-102 | 1200.11 | 0.04908 | 0.942561 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2825 | 2700 | 2700 | -1.PP_SO-102 | 0 | 2575 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 4 | 67 | Přívodní | SUP | PO02.01.0252 | 0252 | no | SUP 4
13356637 | -1.PP_SO-102 | 661.647 | 0.0201032 | 0.33258 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2780 | 2700 | 2700 | -1.PP_SO-102 | 0 | 2620 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 4 | 21 | Přívodní | SUP | PO02.01.0253 | 0253 | no | SUP 4
13356658 | -1.PP_SO-102 | 2320.55 | 0.0201032 | 1.16644 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3149.6 | 3069.6 | 3069.6 | -1.PP_SO-102 | 0 | 2989.6 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 27 | 126 | Odváděný | ETA | PO02.01.0254 | 0254 | no | ETA 27
13390136 | -1.PP_SO-102 | 6952.68 | 0.061566 | 6.11589 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3020 | 2880 | 2880 | -1.PP_SO-102 | 0 | 2740 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 7 | 11 | Přívodní | SUP | PO02.01.0255 | 0255 | yes | SUP 7
13390156 | -1.PP_SO-102 | 6318.36 | 0.125636 | 7.93989 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 2880 | 2880 | -1.PP_SO-102 | 0 | 2680 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 7 | 7 | Přívodní | SUP | PO02.01.0256 | 0256 | yes | SUP 7
13390228 | -1.PP_SO-102 | 3942.25 | 0.0254431 | 2.22929 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2970 | 2880 | 2880 | -1.PP_SO-102 | 0 | 2790 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 7 | 15 | Přívodní | SUP | PO02.01.0257 | 0257 | yes | SUP 7
13390319 | -1.PP_SO-102 | 4469.53 | 0.0314112 | 2.80829 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3250 | 3150 | 3150 | -1.PP_SO-102 | 0 | 3050 | Fáze 1 | 200 | Zpětný vzduch | 0 | ETA 18 | 15 | Odváděný | ETA | PO02.01.0258 | 0258 | yes | ETA 18
13429370 | -1.PP_SO-102 | 2446.45 | 0.04908 | 1.92143 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3202.14 | 3077.14 | 3077.14 | -1.PP_SO-102 | 0 | 2952.14 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 4 | 61 | Přívodní | SUP | PO02.01.0263 | 0263 | no | SUP 4
13429380 | -1.PP_SO-102 | 419.322 | 0.0989649 | 0.467655 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3253.97 | 3076.47 | 3076.47 | -1.PP_SO-102 | 0 | 2898.97 | Fáze 1 | 355 | Přívod vzduchu | 0 | ODA 1 | 2 | Čerstvý | ODA | PO02.01.0264 | 0264 | yes | ODA 1
13429413 | -1.PP_SO-102 | 7.85151 | 0.0989649 | 0.00875651 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3254.03 | 3076.53 | 3076.53 | -1.PP_SO-102 | 0 | 2899.03 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 27 | 28 | Odváděný | ETA | PO02.01.0265 | 0265 | yes | ETA 27
13429748 | 1.NP_SO-102 | 614.342 | 0.0201032 | 0.308802 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 24 | 484 | Přívodní | SUP | PO02.01.0266 | 0266 | yes | SUP 24
