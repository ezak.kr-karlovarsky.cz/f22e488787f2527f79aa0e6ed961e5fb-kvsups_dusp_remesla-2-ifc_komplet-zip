Properties of the parts of a building model (IFC4), part 28 of 45

# IfcDistributionPort (8507)
Name | FlowDirection | SystemType | Group
OutPort_14081148_2 | SOURCE | VENTILATION | ETA 2
InPort_14081216_1 | SINK | VENTILATION | ETA 2
OutPort_14081136_1 | SOURCE | VENTILATION | ETA 2
InPort_14081148_1 | SINK | VENTILATION | ETA 2
OutPort_14081773_0 | SOURCE | VENTILATION | ETA 2
Port_14081190_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_14081208_0 | SINK | VENTILATION | ETA 2
OutPort_14081216_2 | SOURCE | VENTILATION | ETA 2
OutPort_14081208_1 | SOURCE | VENTILATION | ETA 2
InPort_14081417_1 | SINK | VENTILATION | ETA 2
OutPort_14081409_0 | SOURCE | VENTILATION | ETA 2
InPort_14081409_1 | SINK | VENTILATION | ETA 2
OutPort_14081660_1 | SOURCE | VENTILATION | ETA 2
InPort_14081660_0 | SINK | VENTILATION | ETA 2
OutPort_14081649_1 | SOURCE | VENTILATION | ETA 2
InPort_14081772_3 | SINK | VENTILATION | ETA 2
OutPort_14081764_0 | SOURCE | VENTILATION | ETA 2
InPort_14081764_1 | SINK | VENTILATION | ETA 2
OutPort_14081785_2 | SOURCE | VENTILATION | ETA 2
InPort_14081773_1 | SINK | VENTILATION | ETA 2
OutPort_14081772_2 | SOURCE | VENTILATION | ETA 2
InPort_14081785_1 | SINK | VENTILATION | ETA 2
OutPort_14081779_0 | SOURCE | VENTILATION | ETA 2
InPort_14081779_1 | SINK | VENTILATION | ETA 2
OutPort_14081796_1 | SOURCE | VENTILATION | ETA 2
InPort_14081796_2 | SINK | VENTILATION | ETA 2
OutPort_14081788_0 | SOURCE | VENTILATION | ETA 2
InPort_14081788_1 | SINK | VENTILATION | ETA 2
OutPort_14081853_1 | SOURCE | VENTILATION | ETA 2
InPort_14081853_0 | SINK | VENTILATION | ETA 2
OutPort_14081846_1 | SOURCE | VENTILATION | ETA 2
InPort_14081912_0 | SINK | VENTILATION | ETA 7
OutPort_14082210_1 | SOURCE | VENTILATION | ETA 7
InPort_14081984_1 | SINK | VENTILATION | ETA 7
OutPort_14081912_1 | SOURCE | VENTILATION | ETA 7
InPort_14081974_0 | SINK | VENTILATION | ETA 7
OutPort_14081984_2 | SOURCE | VENTILATION | ETA 7
InPort_14082080_2 | SINK | VENTILATION | ETA 7
OutPort_14081974_1 | SOURCE | VENTILATION | ETA 7
InPort_14082072_0 | SINK | VENTILATION | ETA 7
OutPort_14082080_1 | SOURCE | VENTILATION | ETA 7
InPort_14082089_1 | SINK | VENTILATION | ETA 7
OutPort_14082072_1 | SOURCE | VENTILATION | ETA 7
InPort_14082083_0 | SINK | VENTILATION | ETA 7
OutPort_14082089_2 | SOURCE | VENTILATION | ETA 7
InPort_14082318_1 | SINK | VENTILATION | ETA 7
OutPort_14082083_1 | SOURCE | VENTILATION | ETA 7
InPort_14082137_1 | SINK | VENTILATION | ETA 7
OutPort_14082344_0 | SOURCE | VENTILATION | ETA 7
InPort_14082210_0 | SINK | VENTILATION | ETA 7
OutPort_14082208_1 | SOURCE | VENTILATION | ETA 7
InPort_14082310_0 | SINK | VENTILATION | ETA 7
OutPort_14082318_2 | SOURCE | VENTILATION | ETA 7
InPort_14082356_1 | SINK | VENTILATION | ETA 7
OutPort_14082310_1 | SOURCE | VENTILATION | ETA 7
InPort_14082344_1 | SINK | VENTILATION | ETA 7
OutPort_14082356_2 | SOURCE | VENTILATION | ETA 7
InPort_14083781_2 | SINK | VENTILATION | ETA 11
OutPort_14083822_1 | SOURCE | VENTILATION | ETA 11
Port_14084278_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14084289_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14084278_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14084353_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14084291_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14084353_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14105796_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14105798_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14106592_1 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14155566_0 | SOURCEANDSINK | VENTILATION | ETA 97
InPort_14180998_2 | SINK | VENTILATION | ETA 7
OutPort_14108533_0 | SOURCE | VENTILATION | ETA 7
InPort_14108533_1 | SINK | VENTILATION | ETA 7
OutPort_14181001_1 | SOURCE | VENTILATION | ETA 7
InPort_14108756_1 | SINK | VENTILATION | ETA 7
OutPort_14108754_2 | SOURCE | VENTILATION | ETA 7
InPort_14181086_2 | SINK | VENTILATION | ETA 7
OutPort_14109036_0 | SOURCE | VENTILATION | ETA 7
InPort_14109036_1 | SINK | VENTILATION | ETA 7
OutPort_14181120_2 | SOURCE | VENTILATION | ETA 7
Port_14109686_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14109722_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14109721_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14109722_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14109721_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14109730_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14109726_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14137983_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14110069_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14159894_0 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_14110114_1 | SINK | VENTILATION | ETA 22
OutPort_14110114_2 | SOURCE | VENTILATION | ETA 22
InPort_14110118_1 | SINK | VENTILATION | ETA 7
OutPort_14110116_1 | SOURCE | VENTILATION | ETA 7
OutPort_14110118_2 | SOURCE | VENTILATION | ETA 7
Port_14110120_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14110268_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14110275_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14110268_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14110287_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14110278_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14110299_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14110278_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14110287_2 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_14110717_1 | SINK | VENTILATION | ODA 19
OutPort_14110703_0 | SOURCE | VENTILATION | ODA 19
InPort_14110703_1 | SINK | VENTILATION | ODA 19
OutPort_14110727_1 | SOURCE | VENTILATION | ODA 19
InPort_14110727_2 | SINK | VENTILATION | ODA 19
OutPort_14110719_1 | SOURCE | VENTILATION | ODA 19
InPort_14177471_1 | SINK | VENTILATION | ETA 11
OutPort_14112914_0 | SOURCE | VENTILATION | ETA 11
InPort_14112914_1 | SINK | VENTILATION | ETA 11
OutPort_14124622_2 | SOURCE | VENTILATION | ETA 11
InPort_14113506_1 | SINK | VENTILATION | ETA 7
OutPort_14113528_2 | SOURCE | VENTILATION | ETA 7
InPort_14113526_2 | SINK | VENTILATION | ETA 7
OutPort_14113506_2 | SOURCE | VENTILATION | ETA 7
InPort_14113524_1 | SINK | VENTILATION | ETA 7
OutPort_14113526_1 | SOURCE | VENTILATION | ETA 7
InPort_14113528_1 | SINK | VENTILATION | ETA 7
OutPort_14113879_0 | SOURCE | VENTILATION | ETA 7
InPort_14113879_1 | SINK | VENTILATION | ETA 7
OutPort_14113857_2 | SOURCE | VENTILATION | ETA 7
Port_14114083_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14114084_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_14114083_3 | SINK | VENTILATION | ETA 7
OutPort_14114091_0 | SOURCE | VENTILATION | ETA 7
Port_14114530_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_14114542_2 | SOURCEANDSINK | VENTILATION | ETA 12
Port_14114530_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_14114707_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_14114612_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_14114707_2 | SOURCEANDSINK | VENTILATION | ETA 12
Port_14114612_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_14114713_2 | SOURCEANDSINK | VENTILATION | ETA 12
InPort_14115432_1 | SINK | VENTILATION | ETA 17
OutPort_14117703_1 | SOURCE | VENTILATION | ETA 17
InPort_14115607_0 | SINK | VENTILATION | ETA 17
OutPort_14115615_2 | SOURCE | VENTILATION | ETA 17
InPort_14115637_2 | SINK | VENTILATION | ETA 17
OutPort_14115607_1 | SOURCE | VENTILATION | ETA 17
InPort_14115633_2 | SINK | VENTILATION | ETA 17
OutPort_14115617_0 | SOURCE | VENTILATION | ETA 17
InPort_14115617_1 | SINK | VENTILATION | ETA 17
OutPort_14115637_1 | SOURCE | VENTILATION | ETA 17
InPort_14115779_2 | SINK | VENTILATION | ETA 17
OutPort_14115629_0 | SOURCE | VENTILATION | ETA 17
InPort_14115629_1 | SINK | VENTILATION | ETA 17
OutPort_14115633_1 | SOURCE | VENTILATION | ETA 17
InPort_14115741_0 | SINK | VENTILATION | ETA 17
OutPort_14117734_2 | SOURCE | VENTILATION | ETA 17
InPort_14117736_2 | SINK | VENTILATION | ETA 17
OutPort_14115741_1 | SOURCE | VENTILATION | ETA 17
InPort_14115741_3 | SINK | VENTILATION | ETA 17
OutPort_14115779_1 | SOURCE | VENTILATION | ETA 17
InPort_14115933_0 | SINK | EXHAUST | EHA 7
OutPort_14116060_1 | SOURCE | EXHAUST | EHA 7
InPort_14115957_1 | SINK | EXHAUST | EHA 7
OutPort_14115933_1 | SOURCE | EXHAUST | EHA 7
InPort_14116059_1 | SINK | EXHAUST | EHA 7
OutPort_14116058_2 | SOURCE | EXHAUST | EHA 7
InPort_14116145_0 | SINK | EXHAUST | EHA 7
OutPort_14116059_2 | SOURCE | EXHAUST | EHA 7
InPort_14116147_0 | SINK | EXHAUST | EHA 7
OutPort_14116145_1 | SOURCE | EXHAUST | EHA 7
InPort_14116223_2 | SINK | VENTILATION | SUP 5
OutPort_14116215_0 | SOURCE | VENTILATION | SUP 5
InPort_14116215_1 | SINK | VENTILATION | SUP 5
OutPort_14116303_1 | SOURCE | VENTILATION | SUP 5
InPort_14116303_2 | SINK | VENTILATION | SUP 5
OutPort_14116228_0 | SOURCE | VENTILATION | SUP 5
InPort_14116228_1 | SINK | VENTILATION | SUP 5
OutPort_14116309_2 | SOURCE | VENTILATION | SUP 5
InPort_14116309_1 | SINK | VENTILATION | SUP 5
OutPort_14122039_2 | SOURCE | VENTILATION | SUP 5
InPort_14116511_0 | SINK | VENTILATION | ETA 17
OutPort_14116524_2 | SOURCE | VENTILATION | ETA 17
InPort_14116538_1 | SINK | VENTILATION | ETA 17
OutPort_14116511_1 | SOURCE | VENTILATION | ETA 17
InPort_14116520_0 | SINK | VENTILATION | ETA 17
OutPort_14116522_2 | SOURCE | VENTILATION | ETA 17
InPort_14116524_1 | SINK | VENTILATION | ETA 17
OutPort_14116520_1 | SOURCE | VENTILATION | ETA 17
InPort_14116536_2 | SINK | VENTILATION | ETA 17
OutPort_14116528_0 | SOURCE | VENTILATION | ETA 17
InPort_14116528_1 | SINK | VENTILATION | ETA 17
OutPort_14116538_2 | SOURCE | VENTILATION | ETA 17
InPort_14116608_2 | SINK | VENTILATION | ETA 17
OutPort_14116593_0 | SOURCE | VENTILATION | ETA 17
InPort_14116604_2 | SINK | VENTILATION | ETA 17
OutPort_14116602_0 | SOURCE | VENTILATION | ETA 17
InPort_14116602_1 | SINK | VENTILATION | ETA 17
OutPort_14116608_1 | SOURCE | VENTILATION | ETA 17
InPort_14117549_2 | SINK | VENTILATION | SUP 12
OutPort_14116782_1 | SOURCE | VENTILATION | SUP 12
InPort_14116783_1 | SINK | VENTILATION | SUP 5
OutPort_14117168_2 | SOURCE | VENTILATION | SUP 5
InPort_14116899_0 | SINK | VENTILATION | SUP 5
OutPort_14116901_2 | SOURCE | VENTILATION | SUP 5
InPort_14116903_1 | SINK | VENTILATION | SUP 5
OutPort_14116899_1 | SOURCE | VENTILATION | SUP 5
InPort_14116923_0 | SINK | VENTILATION | SUP 5
OutPort_14116903_2 | SOURCE | VENTILATION | SUP 5
InPort_14117166_2 | SINK | VENTILATION | SUP 5
OutPort_14116923_1 | SOURCE | VENTILATION | SUP 5
InPort_14117048_0 | SINK | VENTILATION | SUP 5
OutPort_14117166_1 | SOURCE | VENTILATION | SUP 5
InPort_14117168_1 | SINK | VENTILATION | SUP 5
OutPort_14117048_1 | SOURCE | VENTILATION | SUP 5
InPort_14117548_0 | SINK | VENTILATION | SUP 12
OutPort_14117244_0 | SOURCE | VENTILATION | SUP 12
InPort_14117244_1 | SINK | VENTILATION | SUP 12
OutPort_14117549_1 | SOURCE | VENTILATION | SUP 12
InPort_14117546_2 | SINK | VENTILATION | SUP 12
OutPort_14117548_1 | SOURCE | VENTILATION | SUP 12
InPort_14117707_2 | SINK | VENTILATION | ETA 17
OutPort_14117692_0 | SOURCE | VENTILATION | ETA 17
InPort_14117692_1 | SINK | VENTILATION | ETA 17
OutPort_14117736_1 | SOURCE | VENTILATION | ETA 17
InPort_14117703_2 | SINK | VENTILATION | ETA 17
OutPort_14117701_0 | SOURCE | VENTILATION | ETA 17
InPort_14117701_1 | SINK | VENTILATION | ETA 17
OutPort_14117707_1 | SOURCE | VENTILATION | ETA 17
InPort_14183831_2 | SINK | VENTILATION | SUP 11
OutPort_14118227_0 | SOURCE | VENTILATION | SUP 11
InPort_14118227_1 | SINK | VENTILATION | SUP 11
OutPort_14183832_1 | SOURCE | VENTILATION | SUP 11
InPort_14170267_0 | SINK | VENTILATION | SUP 11
OutPort_14118227_2 | SOURCE | VENTILATION | SUP 11
InPort_14170428_0 | SINK | VENTILATION | SUP 11
OutPort_14118227_3 | SOURCE | VENTILATION | SUP 11
Port_14119668_1 | SOURCEANDSINK | EXHAUST | EHA 19
Port_14119668_2 | SOURCEANDSINK | EXHAUST | EHA 19
Port_14119824_1 | SOURCEANDSINK | EXHAUST | EHA 19
Port_14119824_2 | SOURCEANDSINK | EXHAUST | EHA 19
Port_14120108_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14120109_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14120309_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14120577_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14120309_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14120634_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14120581_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14120634_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14120581_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14120638_2 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_14120730_0 | SINK | VENTILATION | SUP 5
OutPort_14120745_2 | SOURCE | VENTILATION | SUP 5
InPort_14120747_2 | SINK | VENTILATION | SUP 5
OutPort_14120730_1 | SOURCE | VENTILATION | SUP 5
InPort_14120745_1 | SINK | VENTILATION | SUP 5
OutPort_14186834_3 | SOURCE | VENTILATION | SUP 5
Port_14120922_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14121089_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14121029_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14121039_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14121029_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14121050_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14121044_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14121050_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14121044_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14121085_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14121071_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14121085_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14121071_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14121089_2 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_14121622_1 | SINK | VENTILATION | ODA 18
Port_14121850_2 | SOURCEANDSINK | VENTILATION | SUP 5
Port_14122039_0 | SOURCEANDSINK | VENTILATION | SUP 5
Port_14121922_0 | SOURCEANDSINK | VENTILATION | SUP 5
Port_14121947_2 | SOURCEANDSINK | VENTILATION | SUP 5
Port_14121922_1 | SOURCEANDSINK | VENTILATION | SUP 5
Port_14121952_2 | SOURCEANDSINK | VENTILATION | SUP 5
Port_14121939_0 | SOURCEANDSINK | VENTILATION | SUP 5
Port_14121941_2 | SOURCEANDSINK | VENTILATION | SUP 5
Port_14121939_1 | SOURCEANDSINK | VENTILATION | SUP 5
Port_14121947_1 | SOURCEANDSINK | VENTILATION | SUP 5
Port_14122039_1 | SOURCEANDSINK | VENTILATION | SUP 5
Port_14122086_1 | SOURCEANDSINK | VENTILATION | SUP 5
Port_14122398_2 | SOURCEANDSINK | VENTILATION | ETA 1
Port_14122399_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_14122721_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_14122737_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_14122721_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_14122739_1 | SOURCEANDSINK | VENTILATION | ETA 1
InPort_14123350_2 | SINK | VENTILATION | SUP 24
OutPort_14123093_0 | SOURCE | VENTILATION | SUP 24
InPort_14123093_1 | SINK | VENTILATION | SUP 24
OutPort_14123354_1 | SOURCE | VENTILATION | SUP 24
Port_14123339_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_14123354_0 | SINK | VENTILATION | SUP 24
Port_14123795_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14123797_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_14124010_0 | SINK | VENTILATION | SUP 24
OutPort_14123799_2 | SOURCE | VENTILATION | SUP 24
InPort_14123975_2 | SINK | VENTILATION | SUP 24
OutPort_14123977_1 | SOURCE | VENTILATION | SUP 24
InPort_14124009_2 | SINK | VENTILATION | SUP 24
OutPort_14124010_1 | SOURCE | VENTILATION | SUP 24
InPort_14124017_0 | SINK | VENTILATION | SUP 24
OutPort_14124009_3 | SOURCE | VENTILATION | SUP 24
InPort_14124621_2 | SINK | VENTILATION | ETA 11
OutPort_14177474_0 | SOURCE | VENTILATION | ETA 11
Port_14124647_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14124649_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_14183776_1 | SINK | VENTILATION | SUP 11
OutPort_14125321_1 | SOURCE | VENTILATION | SUP 11
InPort_14132088_1 | SINK | VENTILATION | SUP 11
OutPort_14169149_1 | SOURCE | VENTILATION | SUP 11
InPort_14132098_1 | SINK | VENTILATION | SUP 11
OutPort_14171117_1 | SOURCE | VENTILATION | SUP 11
InPort_14171117_0 | SINK | VENTILATION | SUP 11
OutPort_14132247_0 | SOURCE | VENTILATION | SUP 11
InPort_14132247_1 | SINK | VENTILATION | SUP 11
OutPort_14171119_1 | SOURCE | VENTILATION | SUP 11
InPort_14169149_0 | SINK | VENTILATION | SUP 11
OutPort_14132276_0 | SOURCE | VENTILATION | SUP 11
InPort_14132276_1 | SINK | VENTILATION | SUP 11
OutPort_14169151_1 | SOURCE | VENTILATION | SUP 11
InPort_14170845_0 | SINK | VENTILATION | SUP 11
OutPort_14132306_0 | SOURCE | VENTILATION | SUP 11
InPort_14132306_1 | SINK | VENTILATION | SUP 11
OutPort_14170847_1 | SOURCE | VENTILATION | SUP 11
InPort_14170728_0 | SINK | VENTILATION | SUP 11
OutPort_14132337_0 | SOURCE | VENTILATION | SUP 11
InPort_14132337_1 | SINK | VENTILATION | SUP 11
OutPort_14170730_1 | SOURCE | VENTILATION | SUP 11
InPort_14170622_0 | SINK | VENTILATION | SUP 11
OutPort_14132363_0 | SOURCE | VENTILATION | SUP 11
InPort_14132363_1 | SINK | VENTILATION | SUP 11
OutPort_14170624_1 | SOURCE | VENTILATION | SUP 11
InPort_14170426_0 | SINK | VENTILATION | SUP 11
OutPort_14132431_0 | SOURCE | VENTILATION | SUP 11
InPort_14132431_1 | SINK | VENTILATION | SUP 11
OutPort_14170428_1 | SOURCE | VENTILATION | SUP 11
InPort_14170265_0 | SINK | VENTILATION | SUP 11
OutPort_14132455_0 | SOURCE | VENTILATION | SUP 11
InPort_14132455_1 | SINK | VENTILATION | SUP 11
OutPort_14170267_1 | SOURCE | VENTILATION | SUP 11
InPort_14132490_1 | SINK | VENTILATION | SUP 11
OutPort_14169988_1 | SOURCE | VENTILATION | SUP 11
InPort_14132498_1 | SINK | VENTILATION | SUP 11
OutPort_14168515_1 | SOURCE | VENTILATION | SUP 11
InPort_14169988_0 | SINK | VENTILATION | SUP 11
OutPort_14132512_0 | SOURCE | VENTILATION | SUP 11
InPort_14132512_1 | SINK | VENTILATION | SUP 11
OutPort_14169990_1 | SOURCE | VENTILATION | SUP 11
InPort_14168515_0 | SINK | VENTILATION | SUP 11
OutPort_14132598_0 | SOURCE | VENTILATION | SUP 11
InPort_14132598_1 | SINK | VENTILATION | SUP 11
OutPort_14168517_1 | SOURCE | VENTILATION | SUP 11
Port_14135897_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14135907_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14135897_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14135925_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14135912_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14135925_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14135912_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14136186_2 | SOURCEANDSINK | VENTILATION | ETA 17
InPort_14135972_0 | SINK | VENTILATION | SUP 5
OutPort_14135982_2 | SOURCE | VENTILATION | SUP 5
InPort_14136036_1 | SINK | VENTILATION | SUP 5
OutPort_14135972_1 | SOURCE | VENTILATION | SUP 5
Port_14136178_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14136186_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14136178_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14136200_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14136189_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14136200_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14136189_1 | SOURCEANDSINK | VENTILATION | ETA 17
InPort_14136189_2 | SINK | VENTILATION | ETA 17
OutPort_14136278_1 | SOURCE | VENTILATION | ETA 17
InPort_14136380_1 | SINK | VENTILATION | SUP 5
OutPort_14136386_0 | SOURCE | VENTILATION | SUP 5
InPort_14136703_1 | SINK | VENTILATION | ETA 27
OutPort_14137439_1 | SOURCE | VENTILATION | ETA 27
InPort_14136703_3 | SINK | VENTILATION | ETA 27
OutPort_14137160_1 | SOURCE | VENTILATION | ETA 27
InPort_14136703_4 | SINK | VENTILATION | ETA 27
OutPort_14137351_1 | SOURCE | VENTILATION | ETA 27
InPort_14137761_0 | SINK | VENTILATION | ETA 27
OutPort_14137775_2 | SOURCE | VENTILATION | ETA 27
InPort_14137900_3 | SINK | VENTILATION | ETA 27
OutPort_14137761_1 | SOURCE | VENTILATION | ETA 27
InPort_14137901_1 | SINK | VENTILATION | ETA 27
OutPort_14137900_1 | SOURCE | VENTILATION | ETA 27
InPort_14137981_1 | SINK | VENTILATION | ETA 15
OutPort_14137981_2 | SOURCE | VENTILATION | ETA 15
Port_14137983_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14137985_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14137985_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14137987_2 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_14138160_0 | SINK | VENTILATION | SUP 24
OutPort_14138062_1 | SOURCE | VENTILATION | SUP 24
InPort_14138343_2 | SINK | VENTILATION | SUP 24
OutPort_14138160_1 | SOURCE | VENTILATION | SUP 24
InPort_14138184_0 | SINK | VENTILATION | SUP 24
OutPort_14138338_0 | SOURCE | VENTILATION | SUP 24
Port_14138184_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_14138416_1 | SINK | VENTILATION | SUP 24
OutPort_14138184_2 | SOURCE | VENTILATION | SUP 24
InPort_14138309_1 | SINK | VENTILATION | SUP 24
OutPort_14138342_1 | SOURCE | VENTILATION | SUP 24
InPort_14138338_1 | SINK | VENTILATION | SUP 24
OutPort_14138309_2 | SOURCE | VENTILATION | SUP 24
InPort_14138342_0 | SINK | VENTILATION | SUP 24
OutPort_14138311_0 | SOURCE | VENTILATION | SUP 24
InPort_14138311_1 | SINK | VENTILATION | SUP 24
OutPort_14138343_1 | SOURCE | VENTILATION | SUP 24
InPort_14138973_1 | SINK | VENTILATION | ETA 1
OutPort_14138529_0 | SOURCE | VENTILATION | ETA 1
InPort_14138529_1 | SINK | VENTILATION | ETA 1
OutPort_14138694_1 | SOURCE | VENTILATION | ETA 1
InPort_14138933_0 | SINK | VENTILATION | ETA 1
OutPort_14138685_0 | SOURCE | VENTILATION | ETA 1
Port_14138685_1 | SOURCEANDSINK | VENTILATION | ETA 1
InPort_14138685_2 | SINK | VENTILATION | ETA 1
OutPort_14139103_1 | SOURCE | VENTILATION | ETA 1
InPort_14138694_2 | SINK | VENTILATION | ETA 1
OutPort_14138906_0 | SOURCE | VENTILATION | ETA 1
InPort_14138904_1 | SINK | VENTILATION | ETA 1
OutPort_14138933_1 | SOURCE | VENTILATION | ETA 1
InPort_14138974_1 | SINK | VENTILATION | ETA 1
OutPort_14138904_2 | SOURCE | VENTILATION | ETA 1
InPort_14138906_1 | SINK | VENTILATION | ETA 1
OutPort_14138974_0 | SOURCE | VENTILATION | ETA 1
InPort_14139188_0 | SINK | VENTILATION | ETA 7
OutPort_14139186_2 | SOURCE | VENTILATION | ETA 7
InPort_14189973_2 | SINK | VENTILATION | ETA 7
OutPort_14139188_1 | SOURCE | VENTILATION | ETA 7
InPort_14145808_2 | SINK | VENTILATION | ODA 6
OutPort_14145827_0 | SOURCE | VENTILATION | ODA 6
InPort_14145827_1 | SINK | VENTILATION | ODA 6
OutPort_14145825_1 | SOURCE | VENTILATION | ODA 6
InPort_14145900_1 | SINK | VENTILATION | ODA 14
OutPort_14145874_1 | SOURCE | VENTILATION | ODA 14
InPort_14146225_2 | SINK | VENTILATION | ODA 7
OutPort_14146247_0 | SOURCE | VENTILATION | ODA 7
InPort_14146247_1 | SINK | VENTILATION | ODA 7
OutPort_14146245_1 | SOURCE | VENTILATION | ODA 7
InPort_14146295_2 | SINK | VENTILATION | ODA 3
OutPort_14146431_0 | SOURCE | VENTILATION | ODA 3
InPort_14146431_1 | SINK | VENTILATION | ODA 3
OutPort_14146429_1 | SOURCE | VENTILATION | ODA 3
Port_14146900_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_14147088_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_14147074_0 | SOURCEANDSINK | VENTILATION | SUP 4
Port_14147088_2 | SOURCEANDSINK | VENTILATION | SUP 4
Port_14147074_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_14147099_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_14147093_0 | SOURCEANDSINK | VENTILATION | SUP 4
Port_14147099_2 | SOURCEANDSINK | VENTILATION | SUP 4
Port_14147093_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_14147161_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_14147104_0 | SOURCEANDSINK | VENTILATION | SUP 4
Port_14147161_2 | SOURCEANDSINK | VENTILATION | SUP 4
Port_14147104_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_14147165_2 | SOURCEANDSINK | VENTILATION | SUP 4
InPort_14149682_0 | SINK | VENTILATION | ETA 3
OutPort_14149874_1 | SOURCE | VENTILATION | ETA 3
InPort_14149806_1 | SINK | VENTILATION | ETA 3
OutPort_14149682_1 | SOURCE | VENTILATION | ETA 3
InPort_14149805_1 | SINK | VENTILATION | ETA 3
OutPort_14149714_0 | SOURCE | VENTILATION | ETA 3
InPort_14149714_1 | SINK | VENTILATION | ETA 3
OutPort_14149806_2 | SOURCE | VENTILATION | ETA 3
InPort_14150045_3 | SINK | VENTILATION | ETA 3
OutPort_14150119_1 | SOURCE | VENTILATION | ETA 3
InPort_14156186_1 | SINK | VENTILATION | ODA 25
OutPort_14152109_0 | SOURCE | VENTILATION | ODA 25
InPort_14152521_0 | SINK | VENTILATION | SUP 17
OutPort_14152535_3 | SOURCE | VENTILATION | SUP 17
InPort_14152818_1 | SINK | VENTILATION | SUP 17
OutPort_14152521_1 | SOURCE | VENTILATION | SUP 17
InPort_14152733_1 | SINK | VENTILATION | SUP 17
OutPort_14152521_2 | SOURCE | VENTILATION | SUP 17
InPort_14152535_1 | SINK | VENTILATION | SUP 17
OutPort_14152536_1 | SOURCE | VENTILATION | SUP 17
Port_14154909_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14154950_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14154930_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14154950_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14154930_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14154952_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14155566_1 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14155750_1 | SOURCEANDSINK | VENTILATION | ETA 97
InPort_14155816_2 | SINK | VENTILATION | ODA 25
OutPort_14155817_1 | SOURCE | VENTILATION | ODA 25
InPort_14156178_0 | SINK | VENTILATION | ODA 25
OutPort_14156186_2 | SOURCE | VENTILATION | ODA 25
InPort_14156187_2 | SINK | VENTILATION | ODA 25
OutPort_14156178_1 | SOURCE | VENTILATION | ODA 25
InPort_14156649_0 | SINK | VENTILATION | ODA 12
OutPort_14158500_2 | SOURCE | VENTILATION | ODA 12
InPort_14159533_1 | SINK | VENTILATION | ODA 12
OutPort_14156649_1 | SOURCE | VENTILATION | ODA 12
InPort_14158500_1 | SINK | VENTILATION | ODA 12
OutPort_14157737_1 | SOURCE | VENTILATION | ODA 12
InPort_14158271_1 | SINK | VENTILATION | ODA 12
OutPort_14157967_1 | SOURCE | VENTILATION | ODA 12
InPort_14158681_1 | SINK | VENTILATION | ODA 12
OutPort_14157971_0 | SOURCE | VENTILATION | ODA 12
InPort_14157971_1 | SINK | VENTILATION | ODA 12
OutPort_14159389_1 | SOURCE | VENTILATION | ODA 12
InPort_14158617_1 | SINK | VENTILATION | ODA 12
OutPort_14158871_1 | SOURCE | VENTILATION | ODA 12
InPort_14159389_2 | SINK | VENTILATION | ODA 12
OutPort_14158702_0 | SOURCE | VENTILATION | ODA 12
InPort_14158702_1 | SINK | VENTILATION | ODA 12
OutPort_14159390_1 | SOURCE | VENTILATION | ODA 12
InPort_14158871_2 | SINK | VENTILATION | ODA 12
OutPort_14158864_0 | SOURCE | VENTILATION | ODA 12
InPort_14158864_1 | SINK | VENTILATION | ODA 12
OutPort_14159531_1 | SOURCE | VENTILATION | ODA 12
InPort_14159531_2 | SINK | VENTILATION | ODA 12
OutPort_14159060_0 | SOURCE | VENTILATION | ODA 12
InPort_14159060_1 | SINK | VENTILATION | ODA 12
OutPort_14159533_2 | SOURCE | VENTILATION | ODA 12
Port_14159894_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14159895_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14164890_0 | SOURCEANDSINK | VENTILATION | ETA 5
Port_14164890_1 | SOURCEANDSINK | VENTILATION | ETA 5
InPort_14165726_1 | SINK | VENTILATION | ETA 11
OutPort_14165648_0 | SOURCE | VENTILATION | ETA 11
InPort_14165648_1 | SINK | VENTILATION | ETA 11
OutPort_14165918_2 | SOURCE | VENTILATION | ETA 11
InPort_14165918_1 | SINK | VENTILATION | ETA 11
OutPort_14165846_0 | SOURCE | VENTILATION | ETA 11
InPort_14165846_1 | SINK | VENTILATION | ETA 11
OutPort_14165931_1 | SOURCE | VENTILATION | ETA 11
InPort_14165931_2 | SINK | VENTILATION | ETA 11
OutPort_14165921_1 | SOURCE | VENTILATION | ETA 11
InPort_14171146_1 | SINK | VENTILATION | SUP 11
OutPort_14166803_0 | SOURCE | VENTILATION | SUP 11
InPort_14166803_1 | SINK | VENTILATION | SUP 11
OutPort_14183831_1 | SOURCE | VENTILATION | SUP 11
InPort_14168517_0 | SINK | VENTILATION | SUP 11
OutPort_14166803_2 | SOURCE | VENTILATION | SUP 11
InPort_14169990_0 | SINK | VENTILATION | SUP 11
OutPort_14166803_3 | SOURCE | VENTILATION | SUP 11
InPort_14183809_2 | SINK | VENTILATION | SUP 11
OutPort_14166989_0 | SOURCE | VENTILATION | SUP 11
InPort_14166989_1 | SINK | VENTILATION | SUP 11
OutPort_14183810_1 | SOURCE | VENTILATION | SUP 11
InPort_14170508_0 | SINK | VENTILATION | SUP 11
OutPort_14166989_2 | SOURCE | VENTILATION | SUP 11
InPort_14170624_0 | SINK | VENTILATION | SUP 11
OutPort_14166989_3 | SOURCE | VENTILATION | SUP 11
InPort_14181461_2 | SINK | VENTILATION | SUP 11
OutPort_14167138_0 | SOURCE | VENTILATION | SUP 11
InPort_14167138_1 | SINK | VENTILATION | SUP 11
OutPort_14183809_1 | SOURCE | VENTILATION | SUP 11
InPort_14170730_0 | SINK | VENTILATION | SUP 11
OutPort_14167138_2 | SOURCE | VENTILATION | SUP 11
InPort_14170847_0 | SINK | VENTILATION | SUP 11
OutPort_14167138_3 | SOURCE | VENTILATION | SUP 11
InPort_14183810_2 | SINK | VENTILATION | SUP 11
OutPort_14167710_0 | SOURCE | VENTILATION | SUP 11
InPort_14183832_2 | SINK | VENTILATION | SUP 11
OutPort_14167710_1 | SOURCE | VENTILATION | SUP 11
InPort_14167710_3 | SINK | VENTILATION | SUP 11
OutPort_14183776_0 | SOURCE | VENTILATION | SUP 11
InPort_14169151_0 | SINK | VENTILATION | SUP 11
OutPort_14169233_2 | SOURCE | VENTILATION | SUP 11
InPort_14169233_0 | SINK | VENTILATION | SUP 11
OutPort_14181461_1 | SOURCE | VENTILATION | SUP 11
InPort_14171134_1 | SINK | VENTILATION | SUP 11
OutPort_14169233_1 | SOURCE | VENTILATION | SUP 11
InPort_14171119_0 | SINK | VENTILATION | SUP 11
OutPort_14169233_3 | SOURCE | VENTILATION | SUP 11
InPort_14170506_0 | SINK | VENTILATION | SUP 11
OutPort_14169773_0 | SOURCE | VENTILATION | SUP 11
InPort_14169773_1 | SINK | VENTILATION | SUP 11
OutPort_14170508_1 | SOURCE | VENTILATION | SUP 11
InPort_14171801_2 | SINK | VENTILATION | ETA 7
OutPort_14171786_0 | SOURCE | VENTILATION | ETA 7
InPort_14171786_1 | SINK | VENTILATION | ETA 7
OutPort_14171805_2 | SOURCE | VENTILATION | ETA 7
InPort_14172815_2 | SINK | VENTILATION | ETA 7
OutPort_14172813_1 | SOURCE | VENTILATION | ETA 7
InPort_14172933_2 | SINK | VENTILATION | ETA 7
OutPort_14172923_0 | SOURCE | VENTILATION | ETA 7
InPort_14172923_1 | SINK | VENTILATION | ETA 7
OutPort_14173003_2 | SOURCE | VENTILATION | ETA 7
InPort_14173003_1 | SINK | VENTILATION | ETA 7
OutPort_14172970_0 | SOURCE | VENTILATION | ETA 7
InPort_14172970_1 | SINK | VENTILATION | ETA 7
OutPort_14173005_1 | SOURCE | VENTILATION | ETA 7
Port_14173213_1 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14173288_1 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14173279_0 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14173288_2 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14173279_1 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14173301_1 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14173292_0 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14173301_2 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14173292_1 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14173315_1 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14173304_0 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14173315_2 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14173304_1 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14173339_1 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14174116_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14176744_0 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_14174883_1 | SINK | VENTILATION | ETA 7
OutPort_14174483_1 | SOURCE | VENTILATION | ETA 7
InPort_14174528_0 | SINK | VENTILATION | ETA 7
OutPort_14174883_2 | SOURCE | VENTILATION | ETA 7
InPort_14174911_1 | SINK | VENTILATION | ETA 7
OutPort_14174528_1 | SOURCE | VENTILATION | ETA 7
InPort_14174818_0 | SINK | VENTILATION | ETA 7
OutPort_14174911_2 | SOURCE | VENTILATION | ETA 7
InPort_14174963_1 | SINK | VENTILATION | ETA 7
OutPort_14174818_1 | SOURCE | VENTILATION | ETA 7
InPort_14174954_0 | SINK | VENTILATION | ETA 7
OutPort_14174963_2 | SOURCE | VENTILATION | ETA 7
InPort_14174972_1 | SINK | VENTILATION | ETA 7
OutPort_14174954_1 | SOURCE | VENTILATION | ETA 7
InPort_14174967_0 | SINK | VENTILATION | ETA 7
OutPort_14174972_2 | SOURCE | VENTILATION | ETA 7
InPort_14175117_0 | SINK | VENTILATION | ETA 7
OutPort_14174967_1 | SOURCE | VENTILATION | ETA 7
InPort_14175103_0 | SINK | VENTILATION | ETA 7
OutPort_14175117_1 | SOURCE | VENTILATION | ETA 7
Port_14176154_0 | SOURCEANDSINK | VENTILATION | SUP 12
Port_14176154_1 | SOURCEANDSINK | VENTILATION | SUP 12
Port_14176250_1 | SOURCEANDSINK | VENTILATION | SUP 12
Port_14176234_0 | SOURCEANDSINK | VENTILATION | SUP 12
Port_14176250_2 | SOURCEANDSINK | VENTILATION | SUP 12
Port_14176234_1 | SOURCEANDSINK | VENTILATION | SUP 12
Port_14176254_2 | SOURCEANDSINK | VENTILATION | SUP 12
Port_14176553_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14176829_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14176553_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14176987_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14176744_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14176746_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14176745_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14176746_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14176745_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14176829_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14176987_2 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_14177460_0 | SINK | VENTILATION | ETA 11
OutPort_14177471_2 | SOURCE | VENTILATION | ETA 11
InPort_14177487_1 | SINK | VENTILATION | ETA 11
OutPort_14177460_1 | SOURCE | VENTILATION | ETA 11
InPort_14177474_1 | SINK | VENTILATION | ETA 11
OutPort_14177487_2 | SOURCE | VENTILATION | ETA 11
InPort_14178194_0 | SINK | VENTILATION | ETA 27
OutPort_14178208_2 | SOURCE | VENTILATION | ETA 27
InPort_14178398_1 | SINK | VENTILATION | ETA 27
OutPort_14178194_1 | SOURCE | VENTILATION | ETA 27
InPort_14178388_0 | SINK | VENTILATION | ETA 27
OutPort_14178398_2 | SOURCE | VENTILATION | ETA 27
InPort_14178436_1 | SINK | VENTILATION | ETA 27
OutPort_14178388_1 | SOURCE | VENTILATION | ETA 27
InPort_14178728_2 | SINK | VENTILATION | ETA 14
OutPort_14178713_0 | SOURCE | VENTILATION | ETA 14
InPort_14178713_1 | SINK | VENTILATION | ETA 14
OutPort_14178766_1 | SOURCE | VENTILATION | ETA 14
Port_14179203_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196280_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14179561_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196114_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14179900_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14180237_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_14180040_1 | SINK | VENTILATION | SUP 24
OutPort_14180332_1 | SOURCE | VENTILATION | SUP 24
Port_14180152_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14180237_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14180152_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14180243_2 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_14180272_0 | SINK | VENTILATION | SUP 24
OutPort_14180328_2 | SOURCE | VENTILATION | SUP 24
InPort_14180332_2 | SINK | VENTILATION | SUP 24
OutPort_14180272_1 | SOURCE | VENTILATION | SUP 24
InPort_14181120_1 | SINK | VENTILATION | ETA 7
OutPort_14181105_0 | SOURCE | VENTILATION | ETA 7
InPort_14181105_1 | SINK | VENTILATION | ETA 7
OutPort_14181185_2 | SOURCE | VENTILATION | ETA 7
InPort_14181185_1 | SINK | VENTILATION | ETA 7
OutPort_14181187_1 | SOURCE | VENTILATION | ETA 7
InPort_14181635_1 | SINK | VENTILATION | SUP 15
OutPort_14181647_1 | SOURCE | VENTILATION | SUP 15
InPort_14181636_1 | SINK | VENTILATION | SUP 15
OutPort_14181649_1 | SOURCE | VENTILATION | SUP 15
InPort_14181637_1 | SINK | VENTILATION | SUP 15
OutPort_14181644_1 | SOURCE | VENTILATION | SUP 15
InPort_14181638_1 | SINK | VENTILATION | SUP 15
OutPort_14181651_1 | SOURCE | VENTILATION | SUP 15
InPort_14181651_0 | SINK | VENTILATION | SUP 15
OutPort_14181639_0 | SOURCE | VENTILATION | SUP 15
InPort_14181639_1 | SINK | VENTILATION | SUP 15
OutPort_14181652_1 | SOURCE | VENTILATION | SUP 15
InPort_14181644_0 | SINK | VENTILATION | SUP 15
OutPort_14181640_0 | SOURCE | VENTILATION | SUP 15
InPort_14181640_1 | SINK | VENTILATION | SUP 15
OutPort_14181645_1 | SOURCE | VENTILATION | SUP 15
InPort_14181649_0 | SINK | VENTILATION | SUP 15
OutPort_14181641_0 | SOURCE | VENTILATION | SUP 15
InPort_14181641_1 | SINK | VENTILATION | SUP 15
OutPort_14181650_1 | SOURCE | VENTILATION | SUP 15
InPort_14181647_0 | SINK | VENTILATION | SUP 15
OutPort_14181642_0 | SOURCE | VENTILATION | SUP 15
InPort_14181642_1 | SINK | VENTILATION | SUP 15
OutPort_14181648_1 | SOURCE | VENTILATION | SUP 15
InPort_14181654_2 | SINK | VENTILATION | SUP 15
OutPort_14181643_0 | SOURCE | VENTILATION | SUP 15
InPort_14181643_1 | SINK | VENTILATION | SUP 15
OutPort_14181685_2 | SOURCE | VENTILATION | SUP 15
InPort_14181648_0 | SINK | VENTILATION | SUP 15
OutPort_14181643_2 | SOURCE | VENTILATION | SUP 15
InPort_14181650_0 | SINK | VENTILATION | SUP 15
OutPort_14181643_3 | SOURCE | VENTILATION | SUP 15
InPort_14181645_0 | SINK | VENTILATION | SUP 15
OutPort_14181646_2 | SOURCE | VENTILATION | SUP 15
InPort_14181646_0 | SINK | VENTILATION | SUP 15
OutPort_14181654_1 | SOURCE | VENTILATION | SUP 15
InPort_14181653_1 | SINK | VENTILATION | SUP 15
OutPort_14181646_1 | SOURCE | VENTILATION | SUP 15
InPort_14181652_0 | SINK | VENTILATION | SUP 15
OutPort_14181646_3 | SOURCE | VENTILATION | SUP 15
InPort_14181685_1 | SINK | VENTILATION | SUP 15
OutPort_14181678_0 | SOURCE | VENTILATION | SUP 15
InPort_14181678_1 | SINK | VENTILATION | SUP 15
OutPort_14183409_1 | SOURCE | VENTILATION | SUP 15
InPort_14183062_2 | SINK | VENTILATION | SUP 15
OutPort_14181760_0 | SOURCE | VENTILATION | SUP 15
Port_14181760_1 | SOURCEANDSINK | VENTILATION | SUP 15
Port_14182999_2 | SOURCEANDSINK | VENTILATION | SUP 15
InPort_14183411_0 | SINK | VENTILATION | SUP 15
OutPort_14181760_2 | SOURCE | VENTILATION | SUP 15
Port_14181760_3 | SOURCEANDSINK | VENTILATION | SUP 15
Port_14183445_0 | SOURCEANDSINK | VENTILATION | SUP 15
InPort_14181807_1 | SINK | VENTILATION | SUP 15
OutPort_14183103_1 | SOURCE | VENTILATION | SUP 15
InPort_14181808_1 | SINK | VENTILATION | SUP 15
OutPort_14181814_1 | SOURCE | VENTILATION | SUP 15
InPort_14181809_1 | SINK | VENTILATION | SUP 15
OutPort_14181819_1 | SOURCE | VENTILATION | SUP 15
InPort_14181819_0 | SINK | VENTILATION | SUP 15
OutPort_14181810_0 | SOURCE | VENTILATION | SUP 15
InPort_14181810_1 | SINK | VENTILATION | SUP 15
OutPort_14181820_1 | SOURCE | VENTILATION | SUP 15
InPort_14181814_0 | SINK | VENTILATION | SUP 15
OutPort_14181811_0 | SOURCE | VENTILATION | SUP 15
InPort_14181811_1 | SINK | VENTILATION | SUP 15
OutPort_14181815_1 | SOURCE | VENTILATION | SUP 15
InPort_14182054_2 | SINK | VENTILATION | SUP 15
OutPort_14181813_0 | SOURCE | VENTILATION | SUP 15
InPort_14181813_1 | SINK | VENTILATION | SUP 15
OutPort_14183061_1 | SOURCE | VENTILATION | SUP 15
InPort_14181818_0 | SINK | VENTILATION | SUP 15
OutPort_14181813_3 | SOURCE | VENTILATION | SUP 15
InPort_14181815_0 | SINK | VENTILATION | SUP 15
OutPort_14181816_2 | SOURCE | VENTILATION | SUP 15
InPort_14181816_0 | SINK | VENTILATION | SUP 15
OutPort_14182054_1 | SOURCE | VENTILATION | SUP 15
InPort_14181821_1 | SINK | VENTILATION | SUP 15
OutPort_14181816_1 | SOURCE | VENTILATION | SUP 15
InPort_14181820_0 | SINK | VENTILATION | SUP 15
OutPort_14181816_3 | SOURCE | VENTILATION | SUP 15
InPort_14183088_0 | SINK | VENTILATION | SUP 15
OutPort_14181818_1 | SOURCE | VENTILATION | SUP 15
Port_14182359_0 | SOURCEANDSINK | VENTILATION | SUP 15
Port_14182375_2 | SOURCEANDSINK | VENTILATION | SUP 15
Port_14182359_1 | SOURCEANDSINK | VENTILATION | SUP 15
Port_14183443_2 | SOURCEANDSINK | VENTILATION | SUP 15
InPort_14182360_1 | SINK | VENTILATION | SUP 26
OutPort_14182369_1 | SOURCE | VENTILATION | SUP 26
InPort_14182361_1 | SINK | VENTILATION | SUP 15
OutPort_14182366_1 | SOURCE | VENTILATION | SUP 15
InPort_14182362_1 | SINK | VENTILATION | SUP 15
OutPort_14182371_1 | SOURCE | VENTILATION | SUP 15
InPort_14182371_0 | SINK | VENTILATION | SUP 15
OutPort_14182363_0 | SOURCE | VENTILATION | SUP 15
InPort_14182363_1 | SINK | VENTILATION | SUP 15
OutPort_14182372_1 | SOURCE | VENTILATION | SUP 15
InPort_14182366_0 | SINK | VENTILATION | SUP 15
OutPort_14182364_0 | SOURCE | VENTILATION | SUP 15
InPort_14182364_1 | SINK | VENTILATION | SUP 15
OutPort_14182367_1 | SOURCE | VENTILATION | SUP 15
InPort_14182374_2 | SINK | VENTILATION | SUP 15
OutPort_14182365_0 | SOURCE | VENTILATION | SUP 15
Port_14182365_1 | SOURCEANDSINK | VENTILATION | SUP 15
Port_14182375_1 | SOURCEANDSINK | VENTILATION | SUP 15
Port_14182365_3 | SOURCEANDSINK | VENTILATION | SUP 15
Port_14182370_0 | SOURCEANDSINK | VENTILATION | SUP 15
InPort_14182367_0 | SINK | VENTILATION | SUP 15
OutPort_14182368_2 | SOURCE | VENTILATION | SUP 15
InPort_14182368_0 | SINK | VENTILATION | SUP 15
OutPort_14182374_1 | SOURCE | VENTILATION | SUP 15
InPort_14182373_1 | SINK | VENTILATION | SUP 15
OutPort_14182368_1 | SOURCE | VENTILATION | SUP 15
InPort_14182372_0 | SINK | VENTILATION | SUP 15
OutPort_14182368_3 | SOURCE | VENTILATION | SUP 15
InPort_14182369_0 | SINK | VENTILATION | SUP 26
Port_14182370_1 | SOURCEANDSINK | VENTILATION | SUP 15
Port_14182436_0 | SOURCEANDSINK | VENTILATION | SUP 15
Port_14183443_1 | SOURCEANDSINK | VENTILATION | SUP 15
Port_14182436_1 | SOURCEANDSINK | VENTILATION | SUP 15
Port_14183445_1 | SOURCEANDSINK | VENTILATION | SUP 15
InPort_14183409_2 | SINK | VENTILATION | SUP 15
OutPort_14182515_0 | SOURCE | VENTILATION | SUP 15
InPort_14182515_1 | SINK | VENTILATION | SUP 15
OutPort_14183411_1 | SOURCE | VENTILATION | SUP 15
InPort_14183103_0 | SINK | VENTILATION | SUP 15
OutPort_14183088_1 | SOURCE | VENTILATION | SUP 15
InPort_14184105_0 | SINK | EXHAUST | EHA 10
OutPort_14184116_1 | SOURCE | EXHAUST | EHA 10
InPort_14184278_1 | SINK | EXHAUST | EHA 10
OutPort_14184105_1 | SOURCE | EXHAUST | EHA 10
InPort_14184277_0 | SINK | EXHAUST | EHA 10
OutPort_14184278_2 | SOURCE | EXHAUST | EHA 10
InPort_14184285_1 | SINK | EXHAUST | EHA 10
OutPort_14184277_1 | SOURCE | EXHAUST | EHA 10
InPort_14186819_0 | SINK | VENTILATION | SUP 5
OutPort_14186831_2 | SOURCE | VENTILATION | SUP 5
InPort_14186842_2 | SINK | VENTILATION | SUP 5
OutPort_14186819_1 | SOURCE | VENTILATION | SUP 5
InPort_14186834_1 | SINK | VENTILATION | SUP 5
OutPort_14186842_1 | SOURCE | VENTILATION | SUP 5
InPort_14186850_2 | SINK | VENTILATION | ETA 17
OutPort_14186870_0 | SOURCE | VENTILATION | ETA 17
InPort_14186870_1 | SINK | VENTILATION | ETA 17
OutPort_14187167_1 | SOURCE | VENTILATION | ETA 17
InPort_14187167_0 | SINK | VENTILATION | ETA 17
OutPort_14187160_1 | SOURCE | VENTILATION | ETA 17
InPort_14188787_2 | SINK | EXHAUST | EHA 1
OutPort_14188788_1 | SOURCE | EXHAUST | EHA 1
InPort_14189440_1 | SINK | VENTILATION | ETA 27
OutPort_14188902_1 | SOURCE | VENTILATION | ETA 27
InPort_14189408_1 | SINK | VENTILATION | ETA 27
OutPort_14189241_0 | SOURCE | VENTILATION | ETA 27
InPort_14189241_1 | SINK | VENTILATION | ETA 27
OutPort_14189444_1 | SOURCE | VENTILATION | ETA 27
InPort_14189404_2 | SINK | VENTILATION | ETA 27
OutPort_14189387_0 | SOURCE | VENTILATION | ETA 27
InPort_14189387_1 | SINK | VENTILATION | ETA 27
OutPort_14189408_2 | SOURCE | VENTILATION | ETA 27
InPort_14189428_0 | SINK | VENTILATION | ETA 27
OutPort_14189440_2 | SOURCE | VENTILATION | ETA 27
InPort_14189444_2 | SINK | VENTILATION | ETA 27
OutPort_14189428_1 | SOURCE | VENTILATION | ETA 27
InPort_14189704_0 | SINK | VENTILATION | ETA 7
OutPort_14191505_2 | SOURCE | VENTILATION | ETA 7
InPort_14190816_2 | SINK | VENTILATION | ETA 7
OutPort_14189704_1 | SOURCE | VENTILATION | ETA 7
InPort_14189913_1 | SINK | VENTILATION | ETA 7
OutPort_14189923_0 | SOURCE | VENTILATION | ETA 7
InPort_14189923_1 | SINK | VENTILATION | ETA 7
OutPort_14189965_1 | SOURCE | VENTILATION | ETA 7
InPort_14189965_2 | SINK | VENTILATION | ETA 7
OutPort_14189963_0 | SOURCE | VENTILATION | ETA 7
InPort_14189963_1 | SINK | VENTILATION | ETA 7
OutPort_14189973_1 | SOURCE | VENTILATION | ETA 7
InPort_14190038_2 | SINK | VENTILATION | ETA 7
OutPort_14191557_0 | SOURCE | VENTILATION | ETA 7
InPort_14191557_1 | SINK | VENTILATION | ETA 7
OutPort_14190816_1 | SOURCE | VENTILATION | ETA 7
InPort_14192711_0 | SINK | EXHAUST | EHA 1
OutPort_14193502_2 | SOURCE | EXHAUST | EHA 1
InPort_14193587_1 | SINK | EXHAUST | EHA 1
OutPort_14192711_1 | SOURCE | EXHAUST | EHA 1
InPort_14193578_0 | SINK | EXHAUST | EHA 1
OutPort_14193587_2 | SOURCE | EXHAUST | EHA 1
InPort_14193598_1 | SINK | EXHAUST | EHA 1
OutPort_14193578_1 | SOURCE | EXHAUST | EHA 1
InPort_14193591_1 | SINK | EXHAUST | EHA 1
OutPort_14193598_2 | SOURCE | EXHAUST | EHA 1
Port_14194373_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196743_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14194373_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196703_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14194493_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196687_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14194493_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196706_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14194681_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196439_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14194681_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196298_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14194769_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196280_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14194769_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196298_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14194973_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14194984_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14194973_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14195856_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14194974_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14194975_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14194974_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14195687_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14194975_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14194976_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14195706_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14194976_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14195687_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14194979_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14195856_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14194979_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196115_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14194981_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196114_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14194981_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196115_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14194984_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196439_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196745_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196489_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196703_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196489_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196706_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196743_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196745_1 | SOURCEANDSINK | VENTILATION | SUP 13

# IfcDistributionSystem: Odváděný (82)
PredefinedType: VENTILATION
Name
ETA 12
ETA 14
ETA 11
ETA 34
ETA 7
ETA 1
ETA 17
ETA 27
ETA 18
ETA 8
ETA 21
ETA 3
ETA 97
ETA 39
ETA 38
ETA 40
ETA 41
ETA 42
ETA 44
ETA 46
ETA 48
ETA 43
ETA 45
ETA 47
ETA 49
ETA 50
ETA 51
ETA 64
ETA 53
ETA 54
ETA 55
ETA 56
ETA 57
ETA 58
ETA 59
ETA 60
ETA 61
ETA 62
ETA 63
ETA 90
ETA 65
ETA 66
ETA 67
ETA 69
ETA 70
ETA 71
ETA 72
ETA 73
ETA 74
ETA 75
ETA 76
ETA 78
ETA 79
ETA 80
ETA 81
ETA 82
ETA 83
ETA 84
ETA 85
ETA 29
ETA 91
ETA 92
ETA 93
ETA 94
ETA 95
ETA 4
ETA 6
ETA 68
ETA 9
ETA 10
ETA 23
ETA 13
ETA 16
ETA 33
ETA 89
ETA 101
ETA 98
ETA 99
ETA 2
ETA 22
ETA 15
ETA 5

# IfcDistributionSystem: Přívodní (47)
PredefinedType: VENTILATION
Name
SUP 17
SUP 9
SUP 15
SUP 13
SUP 24
SUP 2
SUP 35
SUP 59
SUP 55
SUP 57
SUP 39
SUP 1
SUP 12
SUP 50
SUP 22
SUP 18
SUP 21
SUP 40
SUP 45
SUP 4
SUP 7
SUP 11
SUP 48
SUP 5
SUP 20
SUP 3
SUP 16
SUP 10
SUP 36
SUP 38
SUP 41
SUP 42
SUP 49
SUP 46
SUP 47
SUP 56
SUP 58
SUP 60
SUP 63
SUP 14
SUP 8
SUP 25
SUP 27
SUP 28
SUP 23
SUP 64
SUP 26

# IfcDistributionSystem: Znehodnocený (15)
PredefinedType: EXHAUST
Name
EHA 5
EHA 10
EHA 8
EHA 9
EHA 2
EHA 1
EHA 17
EHA 11
EHA 7
EHA 12
EHA 15
EHA 16
EHA 3
EHA 13
EHA 19

# IfcDistributionSystem: Čerstvý (17)
PredefinedType: VENTILATION
Name
ODA 7
ODA 3
ODA 6
ODA 1
ODA 2
ODA 21
ODA 12
ODA 25
ODA 13
ODA 8
ODA 17
ODA 19
ODA 10
ODA 4
ODA 23
ODA 14
ODA 18

# IfcDuctFitting: Hranaté zakončení:Standardní (5)
In: 1.NP_SO-102
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - ID kategorie: Z; Kód sestavy: TA00; Název typu: Standardní; Označení typu: 15; Popis: Zakončení; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: Hranaté zakončení
Classification: TA00 Uniformat (Uniformat)
Qto_DuctFittingBaseQuantities - Length: 250 mm; GrossCrossSectionArea: 0.0945 m2; NetCrossSectionArea: 0.0945 m2; OuterSurfaceArea: 0.39 m2
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 630 mm × 250 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 630 mm × 250 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Vazby - Podlaží: 1.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes
Kóty - x: 0 mm; a: 250 mm; b: 630 mm; Objem: 0.023625 m3; Velikost: 630 × 250
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 1154122; Rodina: Hranaté zakončení; Rodina a typ: Hranaté zakončení: Standardní; Max ab: 630 mm; x1: 150 mm; x2: 150 mm
Name (Hranaté zakončení:Standardní:...) | Výška od podlaží (mm) | Název systému = Group | Kód prvku | Označení
14171134 | 3294.94 | SUP 11 | TA00.15.1415 | 1415
14171146 | 3294.94 | SUP 11 | TA00.15.1416 | 1416
14181653 | 3282.5 | SUP 15 | TA00.15.1471 | 1471
14181821 | 3350 | SUP 15 | TA00.15.1479 | 1479
14182373 | 3282.5 | SUP 15 | TA00.15.1487 | 1487

# IfcDuctFitting: Hranaté zakončení:Standardní (2)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - ID kategorie: Z; Kód sestavy: TA00; Název typu: Standardní; Označení typu: 15; Popis: Zakončení; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: Hranaté zakončení
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes
Kóty - x: 0 mm
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 1154122; Rodina: Hranaté zakončení; Rodina a typ: Hranaté zakončení: Standardní; x1: 150 mm; x2: 150 mm
Name (Hranaté zakončení:Standardní:...) | In | Length (mm) = a (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Název systému = Group | b (mm) = Max ab (mm) | Objem (m3) | Velikost | Kód prvku | Označení
14112603 | 1.NP_SO-102 | 400 | 0.15 | 0.92 | 1000 mm × 400 mm | 1.NP_SO-102 | 3050 | ETA 11 | 1000 | 0.06 | 1000 × 400 | TA00.15.1205 | 1205
14120011 | -1.PP_SO-102 | 160 | 0.04725 | 0.1488 | 315 mm × 160 mm | -1.PP_SO-102 | 2580 | ETA 97 | 315 | 0.00756 | 315 × 160 | TA00.15.1254 | 1254

# IfcDuctFitting: Kulaté koleno, rovné, dilatační spoj:1.5 a (4)
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - z: 1.5
Type - Identifikační data - Kód sestavy: TA01; Název typu: 1.5 a; Označení typu: 14; Popis sestavy: Koleno
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: Kulaté koleno, rovné, dilatační spoj
Classification: TA01 Uniformat (Uniformat); Group: ETA 17
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 160 mm-160 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 160 mm-160 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 2
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 17; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes
Kóty - d1: 160 mm; r1: 80 mm; rm: 240 mm; Velikost: 160-160
Jiné - Páteřní trasa: no; Id typu: 1181584; Rodina: Kulaté koleno, rovné, dilatační spoj; Rodina a typ: Kulaté koleno, rovné, dilatační spoj: 1.5 a; Typ: 1.5 a
Name (Kulaté koleno, rovné, dilatační spoj:1.5 a:...) | Výška od podlaží (mm) | alfa (deg) | Objem (m3) | Kód prvku | Označení | Délka 1 (mm)
14007247 | 3070 | 45 | 0.00378977 | TA01.14.0946 | 0946 | 99.4113
14007249 | 2600 | 45 | 0.00378977 | TA01.14.0947 | 0947 | 99.4113
14007258 | 2600 | 90 | 0.00757963 | TA01.14.0948 | 0948 | 240
14116565 | 2600 | 90 | 0.00757963 | TA01.14.1237 | 1237 | 240

# IfcDuctFitting: M_Hranaté odbočení:Standardní (27)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA04; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 12; Popis sestavy: Odbočka
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Hranaté odbočení
Classification: TA04 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes
Kóty - Délka Násobitel: 0.25
Jiné - Typ: Standardní; Id typu: 1559781; Rodina: M_Hranaté odbočení; Rodina a typ: M_Hranaté odbočení: Standardní
Name (M_Hranaté odbočení:Standardní:...) | In | Length (mm) = Výška potrubí 1 (mm) = Výška potrubí 2 (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Délka odbočení | Objem (m3) | Pevná délka odbočení | Projekce délky odbočení | Šířka potrubí 1 (mm) = Šířka potrubí 2 (mm) | Velikost | Kód prvku | Označení | Páteřní trasa
14037530 | 2.NP_SO-102 | 500 | 0.0242316 | 0.332696 | 225 mm × 500 mm-225 mm × 500 mm | 2.NP_SO-102 | 2880 | Fáze 1 | SUP 9 | 101.6 | 0.0121158 | 101.6 | 6.096 | 225 | 225 × 500-225 × 500 | TA04.12.1010 | 1010 | yes
14039401 | 1.NP_SO-102 | 160 | 0.043876 | 0.136161 | 250 mm × 160 mm-250 mm × 160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | SUP 14 | 101.6 | 0.00702016 | 101.6 | 73.904 | 250 | 250 × 160-250 × 160 | TA04.12.1022 | 1022 | yes
14039436 | 1.NP_SO-102 | 160 | 0.043876 | 0.136161 | 250 mm × 160 mm-250 mm × 160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | SUP 14 | 101.6 | 0.00702016 | 101.6 | 73.904 | 250 | 250 × 160-250 × 160 | TA04.12.1023 | 1023 | yes
14147727 | 2.NP_SO-102 | 400 | 0.0430784 | 0.406157 | 400 mm × 400 mm-400 mm × 400 mm | 2.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 101.6 | 0.0172314 | 101.6 | 6.096 | 400 | 400 × 400-400 × 400 | TA04.12.1347 | 1347 | yes
14168517 | 1.NP_SO-102 | 315 | 0.0339242 | 0.266298 | 315 mm × 315 mm-315 mm × 315 mm | 1.NP_SO-102 | 3169.94 | Fáze 1 | SUP 11 | 101.6 | 0.0106861 | 101.6 | 6.096 | 315 | 315 × 315-315 × 315 | TA04.12.1396 | 1396 | yes
14169151 | 1.NP_SO-102 | 315 | 0.0339242 | 0.266298 | 315 mm × 315 mm-315 mm × 315 mm | 1.NP_SO-102 | 3169.94 | Fáze 1 | SUP 11 | 101.6 | 0.0106861 | 101.6 | 6.096 | 315 | 315 × 315-315 × 315 | TA04.12.1398 | 1398 | yes
14169990 | 1.NP_SO-102 | 315 | 0.0339242 | 0.266298 | 315 mm × 315 mm-315 mm × 315 mm | 1.NP_SO-102 | 3169.94 | Fáze 1 | SUP 11 | 101.6 | 0.0106861 | 101.6 | 6.096 | 315 | 315 × 315-315 × 315 | TA04.12.1400 | 1400 | yes
14170267 | 1.NP_SO-102 | 315 | 0.0339242 | 0.266298 | 315 mm × 315 mm-315 mm × 315 mm | 1.NP_SO-102 | 3104.94 | Fáze 1 | SUP 11 | 101.6 | 0.0106861 | 101.6 | 6.096 | 315 | 315 × 315-315 × 315 | TA04.12.1402 | 1402 | yes
14170428 | 1.NP_SO-102 | 315 | 0.0339242 | 0.266298 | 315 mm × 315 mm-315 mm × 315 mm | 1.NP_SO-102 | 3104.94 | Fáze 1 | SUP 11 | 101.6 | 0.0106861 | 101.6 | 6.096 | 315 | 315 × 315-315 × 315 | TA04.12.1404 | 1404 | yes
14170508 | 1.NP_SO-102 | 315 | 0.0339242 | 0.266298 | 315 mm × 315 mm-315 mm × 315 mm | 1.NP_SO-102 | 3064.94 | Fáze 1 | SUP 11 | 101.6 | 0.0106861 | 101.6 | 6.096 | 315 | 315 × 315-315 × 315 | TA04.12.1406 | 1406 | yes
14170624 | 1.NP_SO-102 | 315 | 0.0339242 | 0.266298 | 315 mm × 315 mm-315 mm × 315 mm | 1.NP_SO-102 | 3064.94 | Fáze 1 | SUP 11 | 101.6 | 0.0106861 | 101.6 | 6.096 | 315 | 315 × 315-315 × 315 | TA04.12.1408 | 1408 | yes
14170730 | 1.NP_SO-102 | 315 | 0.0339242 | 0.266298 | 315 mm × 315 mm-315 mm × 315 mm | 1.NP_SO-102 | 3104.94 | Fáze 1 | SUP 11 | 101.6 | 0.0106861 | 101.6 | 6.096 | 315 | 315 × 315-315 × 315 | TA04.12.1410 | 1410 | yes
14170847 | 1.NP_SO-102 | 315 | 0.0339242 | 0.266298 | 315 mm × 315 mm-315 mm × 315 mm | 1.NP_SO-102 | 3104.94 | Fáze 1 | SUP 11 | 101.6 | 0.0106861 | 101.6 | 6.096 | 315 | 315 × 315-315 × 315 | TA04.12.1412 | 1412 | yes
14171119 | 1.NP_SO-102 | 315 | 0.0339242 | 0.266298 | 315 mm × 315 mm-315 mm × 315 mm | 1.NP_SO-102 | 3169.94 | Fáze 1 | SUP 11 | 101.6 | 0.0106861 | 101.6 | 6.096 | 315 | 315 × 315-315 × 315 | TA04.12.1414 | 1414 | yes
14181645 | 1.NP_SO-102 | 315 | 0.0339242 | 0.266298 | 315 mm × 315 mm-315 mm × 315 mm | 1.NP_SO-102 | 3157.5 | Fáze 1 | SUP 15 | 101.6 | 0.0106861 | 101.6 | 6.096 | 315 | 315 × 315-315 × 315 | TA04.12.1464 | 1464 | yes
14181648 | 1.NP_SO-102 | 315 | 0.0339242 | 0.266298 | 315 mm × 315 mm-315 mm × 315 mm | 1.NP_SO-102 | 3092.5 | Fáze 1 | SUP 15 | 101.6 | 0.0106861 | 101.6 | 6.096 | 315 | 315 × 315-315 × 315 | TA04.12.1466 | 1466 | yes
14181650 | 1.NP_SO-102 | 315 | 0.0339242 | 0.266298 | 315 mm × 315 mm-315 mm × 315 mm | 1.NP_SO-102 | 3092.5 | Fáze 1 | SUP 15 | 101.6 | 0.0106861 | 101.6 | 6.096 | 315 | 315 × 315-315 × 315 | TA04.12.1468 | 1468 | yes
14181652 | 1.NP_SO-102 | 315 | 0.0339242 | 0.266298 | 315 mm × 315 mm-315 mm × 315 mm | 1.NP_SO-102 | 3157.5 | Fáze 1 | SUP 15 | 101.6 | 0.0106861 | 101.6 | 6.096 | 315 | 315 × 315-315 × 315 | TA04.12.1470 | 1470 | yes
14181815 | 1.NP_SO-102 | 315 | 0.0339242 | 0.266298 | 315 mm × 315 mm-315 mm × 315 mm | 1.NP_SO-102 | 3225 | Fáze 1 | SUP 15 | 101.6 | 0.0106861 | 101.6 | 6.096 | 315 | 315 × 315-315 × 315 | TA04.12.1475 | 1475 | yes
14181818 | 1.NP_SO-102 | 315 | 0.0339242 | 0.266298 | 315 mm × 315 mm-315 mm × 315 mm | 1.NP_SO-102 | 3160 | Fáze 1 | SUP 15 | 101.6 | 0.0106861 | 101.6 | 6.096 | 315 | 315 × 315-315 × 315 | TA04.12.1476 | 1476 | yes
14181820 | 1.NP_SO-102 | 315 | 0.0339242 | 0.266298 | 315 mm × 315 mm-315 mm × 315 mm | 1.NP_SO-102 | 3225 | Fáze 1 | SUP 15 | 101.6 | 0.0106861 | 101.6 | 6.096 | 315 | 315 × 315-315 × 315 | TA04.12.1478 | 1478 | yes
14182367 | 1.NP_SO-102 | 315 | 0.0339242 | 0.266298 | 315 mm × 315 mm-315 mm × 315 mm | 1.NP_SO-102 | 3157.5 | Fáze 1 | SUP 15 | 101.6 | 0.0106861 | 101.6 | 6.096 | 315 | 315 × 315-315 × 315 | TA04.12.1482 | 1482 | yes
14182370 | 1.NP_SO-102 | 315 | 0.0339242 | 0.266298 | 315 mm × 315 mm-315 mm × 315 mm | 1.NP_SO-102 | 3092.5 | Fáze 1 | SUP 15 | 101.6 | 0.0106861 | 101.6 | 6.096 | 315 | 315 × 315-315 × 315 | TA04.12.1484 | 1484 | yes
14182372 | 1.NP_SO-102 | 315 | 0.0339242 | 0.266298 | 315 mm × 315 mm-315 mm × 315 mm | 1.NP_SO-102 | 3157.5 | Fáze 1 | SUP 15 | 101.6 | 0.0106861 | 101.6 | 6.096 | 315 | 315 × 315-315 × 315 | TA04.12.1486 | 1486 | yes
14183411 | 1.NP_SO-102 | 315 | 0.421395 | 0.821214 | 710 mm × 315 mm-710 mm × 315 mm | 1.NP_SO-102 | 3250 | Fáze 1 | SUP 15 | 382.459 | 0.13274 | 177.5 | 211.055 | 710 | 710 × 315-710 × 315 | TA04.12.1495 | 1495
14183445 | 1.NP_SO-102 | 315 | 0.421395 | 0.821214 | 710 mm × 315 mm-710 mm × 315 mm | 1.NP_SO-102 | 3250 | Fáze 1 | SUP 15 | 382.459 | 0.13274 | 177.5 | 211.055 | 710 | 710 × 315-710 × 315 | TA04.12.1497 | 1497
14183776 | 2.NP_SO-102 | 400 | 0.256096 | 1.00488 | 1000 mm × 400 mm-1000 mm × 400 mm | 2.NP_SO-102 | -580.057 | Fáze 1 | SUP 11 | 250 | 0.102438 | 250 | 6.096 | 1000 | 1000 × 400-1000 × 400 | TA04.12.1498 | 1498

# IfcDuctFitting: M_Hranaté odbočení:Standardní (7)
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA04; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 12; Popis sestavy: Odbočka
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Hranaté odbočení
Classification: TA04 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 15 mm; Typ izolace: Protipožární
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
