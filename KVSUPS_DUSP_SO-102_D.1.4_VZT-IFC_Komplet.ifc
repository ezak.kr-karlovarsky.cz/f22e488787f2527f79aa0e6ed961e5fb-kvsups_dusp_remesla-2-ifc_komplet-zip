Properties of the parts of a building model (IFC4), part 12 of 45

# IfcSpace: Učebna pro skláře B122:13713738, B122
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0.125 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0207255 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 3420 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 182.971 m3; Plocha: 53.5002 m2
Identifikační data - Číslo: B122; Číslo místnosti: Neobsazené; ID systému: 18; Název: Učebna pro skláře; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Učebna výpočetní techniky IKT 01 B329:13559560, B329
In: 3.NP_SO-102
LongName: Učebna výpočetní techniky IKT 01; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3000 mm; GrossVolume: 142.493 m3; NetVolume: 142.493 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Počet dospělých: 1; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Dávka dospělý: 0.0138889 m3/s; Dávka žák: 0.00555556 m3/s; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 1.66241; Počet žáků: 22; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 511.259 W; Specifikované výkonové zatížení: 664.636 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0.136111 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0184001 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 3.NP_SO-102; Horní odsazení: 3000 mm; Podlaží: 3.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3000 mm; Objem: 142.493 m3; Plocha: 47.4975 m2
Identifikační data - Číslo: B329; Číslo místnosti: Neobsazené; ID systému: 19; Název: Učebna výpočetní techniky IKT 01; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Učebna výpočetní techniky IKT 02 B328:13559557, B328
In: 3.NP_SO-102
LongName: Učebna výpočetní techniky IKT 02; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3000 mm; GrossVolume: 140.568 m3; NetVolume: 140.568 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Počet dospělých: 1; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Dávka dospělý: 0.0138889 m3/s; Dávka žák: 0.00555556 m3/s; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 1.63996; Počet žáků: 16; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 504.353 W; Specifikované výkonové zatížení: 655.659 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0.102778 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0181516 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 3.NP_SO-102; Horní odsazení: 3000 mm; Podlaží: 3.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3000 mm; Objem: 140.568 m3; Plocha: 46.8559 m2
Identifikační data - Číslo: B328; Číslo místnosti: Neobsazené; ID systému: 19; Název: Učebna výpočetní techniky IKT 02; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Vodoměrná místnost B0140:13560472, B0140
In: -1.PP_SO-102
LongName: Vodoměrná místnost; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; NetVolume: 25.9869 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.339676; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 104.464 W; Specifikované výkonové zatížení: 135.803 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.00555556 m3/s; Tok venkovního vzduchu: 0.00375964 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3420 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 25.9869 m3; Plocha: 9.70502 m2
Identifikační data - Číslo: B0140; Číslo místnosti: Neobsazené; ID systému: 23; Název: Vodoměrná místnost; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Vstup B0142:13560518, B0142
In: -1.PP_SO-102
LongName: Vstup; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 40.6972 m3; NetVolume: 40.698 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.416492; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 128.088 W; Specifikované výkonové zatížení: 166.514 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00460986 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3420 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 40.698 m3; Plocha: 11.8998 m2
Identifikační data - Číslo: B0142; Číslo místnosti: Neobsazené; Název: Vstup; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Vstup B107:13548371, B107
In: 1.NP_SO-102
LongName: Vstup; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3000 mm; GrossVolume: 17.7588 m3; NetVolume: 17.7588 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.207186; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 63.7182 W; Specifikované výkonové zatížení: 82.8336 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0022932 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 3000 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3000 mm; Objem: 17.7588 m3; Plocha: 5.91961 m2
Identifikační data - Číslo: B107; Číslo místnosti: Neobsazené; Název: Vstup; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Vstup B132:13548380, B132
In: 1.NP_SO-102
LongName: Vstup; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3000 mm; GrossVolume: 118.214 m3; NetVolume: 118.214 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 1.37917; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 424.15 W; Specifikované výkonové zatížení: 551.394 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0.0277778 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.015265 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 3000 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3000 mm; Objem: 118.214 m3; Plocha: 39.4048 m2
Identifikační data - Číslo: B132; Číslo místnosti: Neobsazené; ID systému: 25; Název: Vstup; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Vstupní hala B101.2:13548374, B101.2
In: 1.NP_SO-102
LongName: Vstupní hala; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3000 mm; GrossVolume: 437.731 m3; NetVolume: 437.729 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Dávka žák: 0.00555556 m3/s; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 5.10687; Počet žáků: 10; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 1570.57 W; Specifikované výkonové zatížení: 2041.74 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0.0666667 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0565244 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 3000 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3000 mm; Objem: 437.729 m3; Plocha: 145.91 m2
Identifikační data - Číslo: B101.2; Číslo místnosti: Neobsazené; ID systému: 19; Název: Vstupní hala; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Výdejna, doplňkový prodej B236:13559794, B236
In: 2.NP_SO-102
LongName: Výdejna, doplňkový prodej; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 147.427 m3; NetVolume: 147.427 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Počet dospělých: 3; Celkový přírůstek tepla na osobu: 131.882 W; Dávka dospělý: 0.0138889 m3/s; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 1.50875; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 464.002 W; Specifikované výkonové zatížení: 603.203 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0.0416667 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0416667 m3/s; Tok venkovního vzduchu: 0.0166993 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 3420 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 147.427 m3; Plocha: 43.1072 m2
Identifikační data - Číslo: B236; Číslo místnosti: Neobsazené; ID systému: 24; Název: Výdejna, doplňkový prodej; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Výstava aktualních sbírek B435:13559508, B435
In: 4.NP_SO-102
LongName: Výstava aktualních sbírek; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 784.579 m3; NetVolume: 784.579 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Dávka dospělý: 0.0138889 m3/s; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet dospělých: 16; Počet osob: 8.02931; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 2469.34 W; Specifikované výkonové zatížení: 3210.14 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0.222222 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.222222 m3/s; Tok venkovního vzduchu: 0.0888709 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 4.NP_SO-102; Horní odsazení: 3420 mm; Podlaží: 4.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 784.579 m3; Plocha: 229.409 m2
Identifikační data - Číslo: B435; Číslo místnosti: Neobsazené; ID systému: 25; Název: Výstava aktualních sbírek; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Výtah B0149:13628298, B0149
In: -1.PP_SO-102
LongName: Výtah; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 8.31744 m3; NetVolume: 8.31744 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.08512; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 26.1778 W; Specifikované výkonové zatížení: 34.0312 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.000942134 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3420 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 8.31744 m3; Plocha: 2.432 m2
Identifikační data - Číslo: B0149; Číslo místnosti: Neobsazené; Název: Výtah; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Výtah gastro-1 B0110-1:13548434, B0110-1
In: 1.NP_SO-102
LongName: Výtah gastro-1; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3000 mm; GrossVolume: 8.20786 m3; NetVolume: 8.20786 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.0957584; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 29.4496 W; Specifikované výkonové zatížení: 38.2844 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00105988 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 3000 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3000 mm; Objem: 8.20786 m3; Plocha: 2.73595 m2
Identifikační data - Číslo: B0110-1; Číslo místnosti: Neobsazené; Název: Výtah gastro-1; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Výtah gastro-2 B0110-2:13559478, B0110-2
In: 4.NP_SO-102
LongName: Výtah gastro-2; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3000 mm; GrossVolume: 8.20791 m3; NetVolume: 8.20791 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.0957589; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 29.4497 W; Specifikované výkonové zatížení: 38.2847 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00105989 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 4.NP_SO-102; Horní odsazení: 3000 mm; Podlaží: 4.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3000 mm; Objem: 8.20791 m3; Plocha: 2.73597 m2
Identifikační data - Číslo: B0110-2; Číslo místnosti: Neobsazené; Název: Výtah gastro-2; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Výtah gastro-3 B0110-3:13559644, B0110-3
In: 3.NP_SO-102
LongName: Výtah gastro-3; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3000 mm; GrossVolume: 8.20796 m3; NetVolume: 8.20796 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.0957595; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 29.4499 W; Specifikované výkonové zatížení: 38.2849 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.0010599 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 3.NP_SO-102; Horní odsazení: 3000 mm; Podlaží: 3.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3000 mm; Objem: 8.20796 m3; Plocha: 2.73599 m2
Identifikační data - Číslo: B0110-3; Číslo místnosti: Neobsazené; Název: Výtah gastro-3; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Výtah gastro-4 B0110-4:13559753, B0110-4
In: 2.NP_SO-102
LongName: Výtah gastro-4; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3000 mm; GrossVolume: 8.20786 m3; NetVolume: 8.20786 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.0957584; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 29.4496 W; Specifikované výkonové zatížení: 38.2844 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00105988 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 3000 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3000 mm; Objem: 8.20786 m3; Plocha: 2.73595 m2
Identifikační data - Číslo: B0110-4; Číslo místnosti: Neobsazené; Název: Výtah gastro-4; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Výtah gastro-5 B0110-5:13560391, B0110-5
In: -1.PP_SO-102
LongName: Výtah gastro-5; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3000 mm; GrossVolume: 7.98163 m3; NetVolume: 7.98163 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.093119; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 28.6379 W; Specifikované výkonové zatížení: 37.2292 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00103067 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3000 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3000 mm; Objem: 7.98163 m3; Plocha: 2.66054 m2
Identifikační data - Číslo: B0110-5; Číslo místnosti: Neobsazené; Název: Výtah gastro-5; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Výtah nákl.-1 B0109-1:13548431, B0109-1
In: 1.NP_SO-102
LongName: Výtah nákl.-1; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3000 mm; GrossVolume: 8.74785 m3; NetVolume: 8.74785 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.102058; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 31.387 W; Specifikované výkonové zatížení: 40.8032 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00112961 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 3000 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3000 mm; Objem: 8.74785 m3; Plocha: 2.91595 m2
Identifikační data - Číslo: B0109-1; Číslo místnosti: Neobsazené; Název: Výtah nákl.-1; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Výtah nákl.-2 B0109-2:13560388, B0109-2
In: -1.PP_SO-102
LongName: Výtah nákl.-2; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3000 mm; GrossVolume: 8.50674 m3; NetVolume: 8.50674 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.0992453; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 30.5219 W; Specifikované výkonové zatížení: 39.6785 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00109848 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3000 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3000 mm; Objem: 8.50674 m3; Plocha: 2.83558 m2
Identifikační data - Číslo: B0109-2; Číslo místnosti: Neobsazené; Název: Výtah nákl.-2; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC - Muži B0137.2:13560484, B0137.2
In: -1.PP_SO-102
LongName: WC - Muži; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 5.61735 m3; NetVolume: 5.61735 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.0574875; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 17.6797 W; Specifikované výkonové zatížení: 22.9836 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0138889 m3/s; Tok venkovního vzduchu: 0.000636289 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3420 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 5.61735 m3; Plocha: 1.6425 m2
Identifikační data - Číslo: B0137.2; Číslo místnosti: Neobsazené; ID systému: 23; Název: WC - Muži; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC - Muži B109.1:13548347, B109.1
In: 1.NP_SO-102
LongName: WC - Muži; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 17.7378 m3; NetVolume: 17.7378 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.181528; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 55.827 W; Specifikované výkonové zatížení: 72.5751 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.025 m3/s; Tok venkovního vzduchu: 0.0020092 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 3420 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 17.7378 m3; Plocha: 5.1865 m2
Identifikační data - Číslo: B109.1; Číslo místnosti: Neobsazené; ID systému: 18; Název: WC - Muži; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC - Muži B109.2:13548350, B109.2
In: 1.NP_SO-102
LongName: WC - Muži; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 39.1248 m3; NetVolume: 39.1248 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.4004; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 123.139 W; Specifikované výkonové zatížení: 160.081 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0486111 m3/s; Tok venkovního vzduchu: 0.00443175 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 1.NP_SO-102; Horní odsazení: 3420 mm; Podlaží: 1.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 39.1248 m3; Plocha: 11.44 m2
Identifikační data - Číslo: B109.2; Číslo místnosti: Neobsazené; ID systému: 18; Název: WC - Muži; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC - Muži B209.1:13559690, B209.1
In: 2.NP_SO-102
LongName: WC - Muži; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 18.6031 m3; NetVolume: 18.6031 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.190383; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 58.5503 W; Specifikované výkonové zatížení: 76.1154 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.025 m3/s; Tok venkovního vzduchu: 0.00210721 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 3420 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 18.6031 m3; Plocha: 5.4395 m2
Identifikační data - Číslo: B209.1; Číslo místnosti: Neobsazené; ID systému: 18; Název: WC - Muži; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC - Muži B209.2:13559687, B209.2
In: 2.NP_SO-102
LongName: WC - Muži; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 40.5475 m3; NetVolume: 40.5475 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.41496; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 127.617 W; Specifikované výkonové zatížení: 165.902 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0486111 m3/s; Tok venkovního vzduchu: 0.00459291 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 3420 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 40.5475 m3; Plocha: 11.856 m2
Identifikační data - Číslo: B209.2; Číslo místnosti: Neobsazené; ID systému: 18; Název: WC - Muži; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC - Muži B247.1:13559821, B247.1
In: 2.NP_SO-102
LongName: WC - Muži; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 11.5434 m3; NetVolume: 11.5434 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.12705; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 39.073 W; Specifikované výkonové zatížení: 50.7949 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0166667 m3/s; Tok venkovního vzduchu: 0.00140623 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 3420 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 11.5434 m3; Plocha: 3.63 m2
Identifikační data - Číslo: B247.1; Číslo místnosti: Neobsazené; ID systému: 25; Název: WC - Muži; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: WC - Muži B247.2:13559824, B247.2
In: 2.NP_SO-102
LongName: WC - Muži; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 11.5434 m3; NetVolume: 11.5434 m3
