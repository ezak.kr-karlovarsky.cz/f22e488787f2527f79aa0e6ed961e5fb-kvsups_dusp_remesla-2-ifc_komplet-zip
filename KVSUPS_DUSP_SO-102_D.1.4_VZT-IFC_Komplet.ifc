Properties of the parts of a building model (IFC4), part 45 of 45

# IfcDuctSegment: Kulaté potrubí:SPIRO POZINK/T spoj (978)
Name (Kulaté potrubí:SPIRO POZINK/T spoj:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Volná velikost | Celková velikost | Tloušťka izolace (mm) | Dynamický tlak (Pa) | Průtok (m3/s) | Reynoldsovo číslo | Rychlost (m/s) | Tlaková ztráta (Pa) | Tření (kg/m2/s2) | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Sklon | Spodní výška (mm) | Fáze vytvoření | Ekvivaletní průměr (mm) = Hydraulický průměr (mm) = Průměr (mm) = Velikost | Klasifikace systému | Koeficient ztrát | Název systému | Řez | Typ systému | Zkratka systému | Kód prvku | Označení | Páteřní trasa | Group
14080669 | -1.PP_SO-102 | 162.312 | 0.125636 | 0.203968 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 2880 | 2880 | -1.PP_SO-102 | 0 | 2680 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 7 | 30 | Přívodní | SUP | PO02.01.1445 | 1445 | yes | SUP 7
14080757 | -1.PP_SO-102 | 296.28 | 0.0989649 | 0.330431 | 355 mm | 385 mm | 15 | 0 | 0 | 0 | 0 | 0 | 0 | 3254.64 | 3077.14 | 3077.14 | -1.PP_SO-102 | 0 | 2899.64 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 4 | 63 | Přívodní | SUP | PO02.01.1446 | 1446 | yes | SUP 4 | Izolace - Typ izolace: Protipožární
14080993 | 4.NP_SO-102 | 304.8 | 0.0201032 | 0.153209 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3380 | 3300 | 3300 | 4.NP_SO-102 | 0 | 3220 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 2 | 2 | Odváděný | ETA | PO02.01.1448 | 1448 | no | ETA 2
14081136 | 4.NP_SO-102 | 463.206 | 0.0201032 | 0.232833 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3380 | 3300 | 3300 | 4.NP_SO-102 | 0 | 3220 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 2 | 3 | Odváděný | ETA | PO02.01.1449 | 1449 | no | ETA 2
14081208 | 4.NP_SO-102 | 60 | 0.0201032 | 0.0301593 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3140 | 3080 | 3140 | 4.NP_SO-102 |  | 3080 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 2 | 3 | Odváděný | ETA | PO02.01.1450 | 1450 | yes | ETA 2
14081409 | 4.NP_SO-102 | 103.602 | 0.0201032 | 0.0520762 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3380 | 3300 | 3300 | 4.NP_SO-102 | 0 | 3220 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 2 | 2 | Odváděný | ETA | PO02.01.1451 | 1451 | no | ETA 2
14081764 | 4.NP_SO-102 | 1916.79 | 0.0201032 | 0.963486 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3380 | 3300 | 3300 | 4.NP_SO-102 | 0 | 3220 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 2 | 5 | Odváděný | ETA | PO02.01.1452 | 1452 | no | ETA 2
14081773 | 4.NP_SO-102 | 11457.4 | 0.0201032 | 5.75911 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3380 | 3300 | 3300 | 4.NP_SO-102 | 0 | 3220 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 2 | 3 | Odváděný | ETA | PO02.01.1453 | 1453 | no | ETA 2
14081779 | 4.NP_SO-102 | 1780 | 0.0201032 | 0.894726 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3380 | 3300 | 3300 | 4.NP_SO-102 | 0 | 3220 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 2 | 5 | Odváděný | ETA | PO02.01.1454 | 1454 | no | ETA 2
14081788 | 4.NP_SO-102 | 55.1385 | 0.0201032 | 0.0277156 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3380 | 3300 | 3300 | 4.NP_SO-102 | 0 | 3220 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 2 | 5 | Odváděný | ETA | PO02.01.1455 | 1455 | no | ETA 2
14081912 | 3.NP_SO-102 | 34.9941 | 0.0201032 | 0.0175899 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3380 | 3300 | 3300 | 3.NP_SO-102 | 0 | 3220 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 376 | Odváděný | ETA | PO02.01.1456 | 1456 | no | ETA 7
14081974 | 3.NP_SO-102 | 9580 | 0.0201032 | 4.81543 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3380 | 3300 | 3300 | 3.NP_SO-102 | 0 | 3220 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 376 | Odváděný | ETA | PO02.01.1457 | 1457 | no | ETA 7
14082072 | 3.NP_SO-102 | 4025.97 | 0.0201032 | 2.02367 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3380 | 3300 | 3300 | 3.NP_SO-102 | 0 | 3220 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 376 | Odváděný | ETA | PO02.01.1458 | 1458 | no | ETA 7
14082083 | 3.NP_SO-102 | 9.98904 | 0.0201032 | 0.00502104 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3380 | 3300 | 3300 | 3.NP_SO-102 | 0 | 3220 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 376 | Odváděný | ETA | PO02.01.1459 | 1459 | no | ETA 7
14082310 | 3.NP_SO-102 | 150.294 | 0.0201032 | 0.0755462 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3309.71 | 3146.86 | 3253.14 | 3.NP_SO-102 | 100 | 3090.29 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 376 | Odváděný | ETA | PO02.01.1460 | 1460 | no | ETA 7
14082344 | 3.NP_SO-102 | 43.1537 | 0.0201032 | 0.0216914 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 3.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 376 | Odváděný | ETA | PO02.01.1461 | 1461 | no | ETA 7
14105798 | 1.NP_SO-102 | 1213.52 | 0.196306 | 1.90619 | 500 mm | 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3345.01 | 3095.01 | 3095 | 1.NP_SO-102 | 0 | 2845 | Fáze 1 | 500 | Přívod vzduchu | 0 | SUP 24 | 450 | Přívodní | SUP | PO02.01.1464 | 1464 | yes | SUP 24
14108756 | -1.PP_SO-102 | 406.733 | 0.0779194 | 0.402504 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3237.5 | 3080 | 3080 | -1.PP_SO-102 | 0 | 2922.5 | Fáze 1 | 315 | Zpětný vzduch | 0 | ETA 7 | 434 | Odváděný | ETA | PO02.01.1466 | 1466 | yes | ETA 7
14109036 | -1.PP_SO-102 | 54.5227 | 0.0779194 | 0.0539558 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3257.5 | 3100 | 3100 | -1.PP_SO-102 | 0 | 2942.5 | Fáze 1 | 315 | Zpětný vzduch | 0 | ETA 7 | 283 | Odváděný | ETA | PO02.01.1467 | 1467 | yes | ETA 7
14110116 | -1.PP_SO-102 | 567.447 | 0.0254431 | 0.320884 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3240 | 3150 | 3150 | -1.PP_SO-102 | 0 | 3060 | Fáze 2 | 180 | Zpětný vzduch | 0 | ETA 7 | 393 | Odváděný | ETA | PO02.01.1469 | 1469 | no | ETA 7 | Identifikační data - Komentáře: PŘIPOJENÍ ODVODNÍHO POTRUBÍ V II.ETAPĚ VÝSTAVBY
14110703 | 1.NP_SO-102 | 113.32 | 0.0201032 | 0.0569609 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | ODA 19 | 4 | Čerstvý | ODA | PO02.01.1472 | 1472 | yes | ODA 19
14110719 | 1.NP_SO-102 | 434.708 | 0.0201032 | 0.218508 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | ODA 19 | 4 | Čerstvý | ODA | PO02.01.1473 | 1473 | yes | ODA 19
14113524 | -1.PP_SO-102 | 594.751 | 0.0201032 | 0.298954 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2680 | 2600 | 2600 | -1.PP_SO-102 | 0 | 2520 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 439 | Odváděný | ETA | PO02.01.1475 | 1475 | no | ETA 7
14113879 | -1.PP_SO-102 | 137.751 | 0.0201032 | 0.0692413 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2680 | 2600 | 2600 | -1.PP_SO-102 | 0 | 2520 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 361 | Odváděný | ETA | PO02.01.1476 | 1476 | no | ETA 7
14114530 | 2.NP_SO-102 | 65.04 | 0.0254431 | 0.0367792 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2862.35 | 2798.71 | 2752.72 | 2.NP_SO-102 | 100 | 2689.08 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 12 | 29 | Odváděný | ETA | PO02.01.1478 | 1478 | no | ETA 12
14120109 | 1.NP_SO-102 | 2381.81 | 0.0779194 | 2.35704 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3252.5 | 3095 | 3095 | 1.NP_SO-102 | 0 | 2937.5 | Fáze 1 | 315 | Přívod vzduchu | 0 | SUP 24 | 415 | Přívodní | SUP | PO02.01.1503 | 1503 | yes | SUP 24
14120309 | 2.NP_SO-102 | 86.4466 | 0.04908 | 0.067895 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3035 | 2910 | 2910 | 2.NP_SO-102 | 0 | 2785 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 14 | 494 | Odváděný | ETA | PO02.01.1504 | 1504 | yes | ETA 14
14120581 | 2.NP_SO-102 | 203.015 | 0.04908 | 0.159448 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2925.17 | 2693.22 | 2836.78 | 2.NP_SO-102 | 100 | 2604.83 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 14 | 494 | Odváděný | ETA | PO02.01.1505 | 1505 | yes | ETA 14
14120922 | 2.NP_SO-102 | 1668.73 | 0.0989649 | 1.86108 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3087.5 | 2910 | 2910 | 2.NP_SO-102 | 0 | 2732.5 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 14 | 293 | Odváděný | ETA | PO02.01.1507 | 1507 | yes | ETA 14
14121029 | 2.NP_SO-102 | 305.908 | 0.0989649 | 0.341169 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2941.53 | 2599.71 | 2816.02 | 2.NP_SO-102 | 100 | 2474.2 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 14 | 293 | Odváděný | ETA | PO02.01.1508 | 1508 | yes | ETA 14
14121044 | 2.NP_SO-102 | 1103.67 | 0.0989649 | 1.23089 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2673.24 | 2495.74 | 2495.74 | 2.NP_SO-102 | 0 | 2318.24 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 14 | 293 | Odváděný | ETA | PO02.01.1509 | 1509 | yes | ETA 14
14121071 | 2.NP_SO-102 | 291.766 | 0.0989649 | 0.325397 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2931.53 | 2806.02 | 2599.71 | 2.NP_SO-102 | 100 | 2474.2 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 14 | 293 | Odváděný | ETA | PO02.01.1510 | 1510 | yes | ETA 14
14123093 | -1.PP_SO-102 | 222.074 | 0.0201032 | 0.111627 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3150 | 3070 | 3070 | -1.PP_SO-102 | 0 | 2990 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 437 | Přívodní | SUP | PO02.01.1516 | 1516 | no | SUP 24
14124649 | 1.NP_SO-102 | 235.425 | 0.0779194 | 0.232977 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3307.5 | 3150 | 3150 | 1.NP_SO-102 | 0 | 2992.5 | Fáze 1 | 315 | Přívod vzduchu | 0 | SUP 13 | 77 | Přívodní | SUP | PO02.01.1518 | 1518 | yes | SUP 13 | Identifikační data - Komentáře: VZT19
14136703 | -1.PP_SO-102 | 3660 | 0.0201032 | 1.83972 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2430 | 2350 | 2350 | -1.PP_SO-102 | 0 | 2270 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 27 | 54 | Odváděný | ETA | PO02.01.1534 | 1534 | no | ETA 27
14137761 | -1.PP_SO-102 | 51.5795 | 0.04908 | 0.0405104 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2998.08 | 2909.7 | 2873.22 | -1.PP_SO-102 | 100 | 2784.83 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 27 | 174 | Odváděný | ETA | PO02.01.1535 | 1535 | yes | ETA 27
14137901 | -1.PP_SO-102 | 2338.29 | 0.0989649 | 2.60781 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3249.28 | 3070.65 | 3071.78 | -1.PP_SO-102 | 0.0486157 | 2893.15 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 27 | 172 | Odváděný | ETA | PO02.01.1536 | 1536 | yes | ETA 27
14137983 | -1.PP_SO-102 | 291.383 | 0.0254431 | 0.164773 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3140 | 3050 | 3050 | -1.PP_SO-102 | 0 | 2960 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 7 | 161 | Odváděný | ETA | PO02.01.1537 | 1537 | no | ETA 7 | Identifikační data - Komentáře: VZT18
14139188 | -1.PP_SO-102 | 182.608 | 0.0201032 | 0.0917886 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2630 | 2550 | 2550 | -1.PP_SO-102 | 0 | 2470 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 437 | Odváděný | ETA | PO02.01.1544 | 1544 | no | ETA 7
14146900 | -1.PP_SO-102 | 2433.8 | 0.04908 | 1.9115 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2825 | 2700 | 2700 | -1.PP_SO-102 | 0 | 2575 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 4 | 11 | Přívodní | SUP | PO02.01.1549 | 1549 | no | SUP 4
14147074 | -1.PP_SO-102 | 358.579 | 0.04908 | 0.281627 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2715.17 | 2373.22 | 2626.78 | -1.PP_SO-102 | 100 | 2284.83 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 4 | 66 | Přívodní | SUP | PO02.01.1550 | 1550 | no | SUP 4
14147093 | -1.PP_SO-102 | 845.492 | 0.04908 | 0.664048 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2425 | 2300 | 2300 | -1.PP_SO-102 | 0 | 2175 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 4 | 66 | Přívodní | SUP | PO02.01.1551 | 1551 | no | SUP 4
14147104 | -1.PP_SO-102 | 358.579 | 0.04908 | 0.281627 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2715.17 | 2626.78 | 2373.22 | -1.PP_SO-102 | 100 | 2284.83 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 4 | 66 | Přívodní | SUP | PO02.01.1552 | 1552 | no | SUP 4
14152521 | 2.NP_SO-102 | 1520 | 0.0201032 | 0.764035 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2980 | 2900 | 2900 | 2.NP_SO-102 | 0 | 2820 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 17 | 156 | Přívodní | SUP | PO02.01.1569 | 1569 | no | SUP 17
14152536 | 2.NP_SO-102 | 3030.75 | 0.0201032 | 1.52342 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2980 | 2900 | 2900 | 2.NP_SO-102 | 0 | 2820 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 17 | 133 | Přívodní | SUP | PO02.01.1570 | 1570 | no | SUP 17
14154930 | 2.NP_SO-102 | 895.754 | 0.04908 | 0.703523 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3065 | 2940 | 2940 | 2.NP_SO-102 | 0 | 2815 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 9 | 493 | Přívodní | SUP | PO02.01.1571 | 1571 | no | SUP 9
14171786 | -1.PP_SO-102 | 234.21 | 0.0779194 | 0.231774 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3237.5 | 3080 | 3080 | -1.PP_SO-102 | 0 | 2922.5 | Fáze 1 | 315 | Zpětný vzduch | 0 | ETA 7 | 62 | Odváděný | ETA | PO02.01.1591 | 1591 |  | ETA 7
14172923 | 1.NP_SO-102 | 80.1187 | 0.0201032 | 0.040272 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2843.77 | 2763.77 | 2763.77 | 1.NP_SO-102 | 0 | 2683.77 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 426 | Odváděný | ETA | PO02.01.1592 | 1592 |  | ETA 7
14172970 | 1.NP_SO-102 | 95.5133 | 0.0201032 | 0.0480102 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2843.77 | 2763.77 | 2763.77 | 1.NP_SO-102 | 0 | 2683.77 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 426 | Odváděný | ETA | PO02.01.1593 | 1593 |  | ETA 7
14175103 | -1.PP_SO-102 | 18.6962 | 0.04908 | 0.014684 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3025 | 2900 | 2900 | -1.PP_SO-102 | 0 | 2775 | Fáze 2 | 250 | Zpětný vzduch | 0 | ETA 7 | 286 | Odváděný | ETA | PO02.01.1603 | 1603 | yes | ETA 7
14176154 | 1.NP_SO-102 | 7140 | 0.0201032 | 3.58896 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2780 | 2700 | 2700 | 1.NP_SO-102 | 0 | 2620 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 12 | 241 | Přívodní | SUP | PO02.01.1604 | 1604 | no | SUP 12
14176234 | 1.NP_SO-102 | 80 | 0.0201032 | 0.0402124 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2940 | 2940 | 2860 | 1.NP_SO-102 |  | 2860 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 12 | 172 | Přívodní | SUP | PO02.01.1605 | 1605 |  | SUP 12
14178194 | -1.PP_SO-102 | 436.447 | 0.04908 | 0.342784 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2475 | 2350 | 2350 | -1.PP_SO-102 | 0 | 2225 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 27 | 174 | Odváděný | ETA | PO02.01.1611 | 1611 |  | ETA 27
14178388 | -1.PP_SO-102 | 429.283 | 0.04908 | 0.337158 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2815.17 | 2726.78 | 2423.23 | -1.PP_SO-102 | 100 | 2334.84 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 27 | 174 | Odváděný | ETA | PO02.01.1612 | 1612 |  | ETA 27
14178713 | 2.NP_SO-102 | 322.721 | 0.0397548 | 0.228118 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3023.65 | 2944.1 | 2715.9 | 2.NP_SO-102 | 100 | 2636.35 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 14 | 333 | Odváděný | ETA | PO02.01.1613 | 1613 |  | ETA 14
14179203 | 2.NP_SO-102 | 1464.01 | 0.125636 | 1.83972 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3295 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2895 | Fáze 2 | 400 | Přívod vzduchu | 0 | SUP 13 | 330 | Přívodní | SUP | PO02.01.1614 | 1614 | yes | SUP 13 | Identifikační data - Komentáře: PŘIPOJENÍ PŘÍVODNÍHO POTRUBÍ V II.ETAPĚ VÝSTAVBY
14179561 | 3.NP_SO-102 | 1090.34 | 0.125636 | 1.37016 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3295 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2895 | Fáze 2 | 400 | Přívod vzduchu | 0 | SUP 13 | 93 | Přívodní | SUP | PO02.01.1615 | 1615 | yes | SUP 13 | Identifikační data - Komentáře: PŘIPOJENÍ PŘÍVODNÍHO POTRUBÍ V II.ETAPĚ VÝSTAVBY
14179900 | 1.NP_SO-102 | 1766.95 | 0.0779194 | 1.74858 | 315 mm | 345 mm | 15 | 0 | 0 | 0 | 0 | 0 | 0 | 3252.5 | 3095 | 3095 | 1.NP_SO-102 | 0 | 2937.5 | Fáze 1 | 315 | Přívod vzduchu | 0 | SUP 24 | 559 | Přívodní | SUP | PO02.01.1616 | 1616 | yes | SUP 24 | Identifikační data - Komentáře: ZASLEPENÁ ODBOČKA PŘÍPRAVA PRO NAPOJENÍ MÍSTNOSTÍ VE II.ETAPĚ VÝSTAVBY; Izolace - Typ izolace: Protipožární
14180040 | 1.NP_SO-102 | 2540.07 | 0.04908 | 1.99497 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3220 | 3095 | 3095 | 1.NP_SO-102 | 0 | 2970 | Fáze 2 | 250 | Přívod vzduchu | 0 | SUP 24 | 85 | Přívodní | SUP | PO02.01.1617 | 1617 | yes | SUP 24 | Identifikační data - Komentáře: PŘIPOJENÍ PŘÍVODNÍHO POTRUBÍ V II.ETAPĚ VÝSTAVBY
14180152 | 1.NP_SO-102 | 368.37 | 0.0779194 | 0.36454 | 315 mm | 345 mm | 15 | 0 | 0 | 0 | 0 | 0 | 0 | 3114.11 | 2742.26 | 3002.74 | 1.NP_SO-102 | 100 | 2630.89 | Fáze 1 | 315 | Přívod vzduchu | 0 | SUP 24 | 559 | Přívodní | SUP | PO02.01.1618 | 1618 |  | SUP 24 | Izolace - Typ izolace: Protipožární
14180272 | 1.NP_SO-102 | 422.218 | 0.04908 | 0.331609 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3110.17 | 3021.78 | 2723.22 | 1.NP_SO-102 | 100 | 2634.83 | Fáze 2 | 250 | Přívod vzduchu | 0 | SUP 24 | 85 | Přívodní | SUP | PO02.01.1619 | 1619 |  | SUP 24
14181105 | -1.PP_SO-102 | 327.109 | 0.0779194 | 0.323707 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3257.5 | 3100 | 3100 | -1.PP_SO-102 | 0 | 2942.5 | Fáze 1 | 315 | Zpětný vzduch | 0 | ETA 7 | 283 | Odváděný | ETA | PO02.01.1620 | 1620 |  | ETA 7
14188902 | -1.PP_SO-102 | 900 | 0.0314112 | 0.565487 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2450 | 2350 | 2350 | -1.PP_SO-102 | 0 | 2250 | Fáze 1 | 200 | Zpětný vzduch | 0 | ETA 27 | 175 | Odváděný | ETA | PO02.01.1646 | 1646 | no | ETA 27
14189241 | -1.PP_SO-102 | 7958.98 | 0.0314112 | 5.00077 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2877.23 | 2777.23 | 2777.23 | -1.PP_SO-102 | 0 | 2677.23 | Fáze 1 | 200 | Zpětný vzduch | 0 | ETA 27 | 147 | Odváděný | ETA | PO02.01.1647 | 1647 | no | ETA 27
14189387 | -1.PP_SO-102 | 27.2296 | 0.0314112 | 0.0171089 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2577.23 | 2577.23 | 2550 | -1.PP_SO-102 |  | 2550 | Fáze 1 | 200 | Zpětný vzduch | 0 | ETA 27 | 147 | Odváděný | ETA | PO02.01.1648 | 1648 |  | ETA 27
14189428 | -1.PP_SO-102 | 27.2296 | 0.0314112 | 0.0171089 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2577.23 | 2577.23 | 2550 | -1.PP_SO-102 |  | 2550 | Fáze 1 | 200 | Zpětný vzduch | 0 | ETA 27 | 175 | Odváděný | ETA | PO02.01.1649 | 1649 |  | ETA 27
14189704 | -1.PP_SO-102 | 124.966 | 0.0201032 | 0.0628145 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3962.77 | 3837.81 | 3962.77 | -1.PP_SO-102 |  | 3837.81 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 437 | Odváděný | ETA | PO02.01.1650 | 1650 |  | ETA 7
14189923 | -1.PP_SO-102 | 1104.14 | 0.0201032 | 0.555002 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3330 | 3250 | 3250 | -1.PP_SO-102 | 0 | 3170 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 437 | Odváděný | ETA | PO02.01.1651 | 1651 |  | ETA 7
14189963 | -1.PP_SO-102 | 380 | 0.0201032 | 0.191009 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3090 | 2710 | 3090 | -1.PP_SO-102 |  | 2710 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 437 | Odváděný | ETA | PO02.01.1652 | 1652 |  | ETA 7
14191557 | -1.PP_SO-102 | 27.8073 | 0.0201032 | 0.0139775 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2737.81 | 2737.81 | 2710 | -1.PP_SO-102 |  | 2710 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 437 | Odváděný | ETA | PO02.01.1653 | 1653 |  | ETA 7

# IfcDuctSegment: Kulaté potrubí:SPIRO POZINK/vývod (72)
Type - Material: 0-0-255
Type - Požární ochrana - Požární odolnost: A1
Type - Materiály a povrchové úpravy - Materiál: Kov, pozink
Type - Stavba - Drsnost: 0.2 mm
Type - Identifikační data - ID kategorie: PO; Kód sestavy: PO02; Komentáře k typům: SPIRO; Název typu: SPIRO POZINK/vývod; Označení typu: 04; Popis: Potrubí spiro pozink; Popis sestavy: Pozinkované
Type - Jiné - Kategorie: Potrubí; MJ: m; Název rodiny: Kulaté potrubí
Classification: PO02 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Mechanické – tok - Reynoldsovo číslo: 0; Doplňkový průtok: 0 m3/s; Dynamický tlak: 0 Pa; Průtok: 0 m3/s; Rychlost: 0 m/s; Tlaková ztráta: 0 Pa; Tření: 0 kg/m2/s2
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Mechanické - Koeficient ztrát: 0; Uzamknutí velikosti: no
Jiné - Rodina: Kulaté potrubí; Id typu: 9070558; Rodina a typ: Kulaté potrubí: SPIRO POZINK/vývod; Typ: SPIRO POZINK/vývod
Name (Kulaté potrubí:SPIRO POZINK/vývod:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Referenční podlaží | Sklon | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Typ systému | Ekvivaletní průměr (mm) = Hydraulický průměr (mm) = Průměr (mm) = Velikost | Klasifikace systému | Název systému = Group | Řez | Zkratka systému | Kód prvku | Označení | Páteřní trasa
13151517 | 2.NP_SO-102 | 6707.75 | 0.0989649 | 7.48092 | 355 mm | 0 | 355 mm | 2.NP_SO-102 | 0 | 3117.5 | 2940 | 2940 | 2762.5 | Fáze 1 | Přívodní | 355 | Přívod vzduchu | SUP 9 | 300 | SUP | PO02.04.0064 | 0064 | no
13635760 | 3.NP_SO-102 | 3384.33 | 0.196306 | 5.31609 | 500 mm | 0 | 500 mm | 3.NP_SO-102 |  | 1920 | 1920 | -1464.33 | -1464.33 | Fáze 1 | Čerstvý | 500 | Přívod vzduchu | ODA 13 | 118 | ODA | PO02.04.0320 | 0320 | yes | Identifikační data - Komentáře: VZT31
13742634 | -1.PP_SO-102 | 169.691 | 0.0314112 | 0.10662 | 200 mm | 0 | 200 mm | -1.PP_SO-102 | 0 | 3340 | 3240 | 3240 | 3140 | Fáze 2 | Přívodní | 200 | Přívod vzduchu | SUP 5 | 9 | SUP | PO02.04.0434 | 0434 | no
13806542 | -1.PP_SO-102 | 1643.34 | 0.0201032 | 0.826034 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | -799.056 | -879.056 | -879.056 | -959.056 | Fáze 1 | Odváděný | 160 | Zpětný vzduch | ETA 7 | 140 | ETA | PO02.04.0585 | 0585 | no | Identifikační data - Komentáře: VZT18
13806681 | -1.PP_SO-102 | 4739.97 | 0.0201032 | 2.38257 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | -799.056 | -879.056 | -879.056 | -959.056 | Fáze 1 | Odváděný | 160 | Zpětný vzduch | ETA 7 | 140 | ETA | PO02.04.0586 | 0586 | no
13806699 | -1.PP_SO-102 | 181.174 | 0.0201032 | 0.0910681 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | -799.056 | -879.056 | -879.056 | -959.056 | Fáze 1 | Odváděný | 160 | Zpětný vzduch | ETA 7 | 138 | ETA | PO02.04.0587 | 0587 | no
13807310 | 3.NP_SO-102 | 3845.64 | 0.159008 | 5.43665 | 450 mm | 0 | 450 mm | 3.NP_SO-102 |  | -1524.68 | -1524.68 | -5370.33 | -5370.33 | Fáze 1 | Čerstvý | 450 | Přívod vzduchu | ODA 13 | 123 | ODA | PO02.04.0588 | 0588 | yes | Identifikační data - Komentáře: VZT31
13807534 | 3.NP_SO-102 | 920 | 0.196306 | 1.44513 | 500 mm | 0 | 500 mm | 3.NP_SO-102 | 0 | 3285.67 | 3035.67 | 3035.67 | 2785.67 | Fáze 1 | Čerstvý | 500 | Přívod vzduchu | ODA 10 | 131 | ODA | PO02.04.0589 | 0589 | yes
13807780 | 4.NP_SO-102 | 4784.3 | 0.196306 | 7.51515 | 500 mm | 0 | 500 mm | 4.NP_SO-102 |  | 4319.97 | 4319.97 | -464.326 | -464.326 | Fáze 1 | Čerstvý | 500 | Přívod vzduchu | ODA 10 | 131 | ODA | PO02.04.0590 | 0590 | yes | Identifikační data - Komentáře: VZT31
13807840 | 4.NP_SO-102 | 5404.3 | 0.196306 | 8.48905 | 500 mm | 0 | 500 mm | 4.NP_SO-102 |  | 4319.97 | 4319.97 | -1084.33 | -1084.33 | Fáze 1 | Čerstvý | 500 | Přívod vzduchu | ODA 10 | 132 | ODA | PO02.04.0592 | 0592 | yes | Identifikační data - Komentáře: VZT31
13865427 | -1.PP_SO-102 | 606.813 | 0.0314112 | 0.381272 | 200 mm | 0 | 200 mm | -1.PP_SO-102 | 0 | 2700 | 2600 | 2600 | 2500 | Fáze 2 | Odváděný | 200 | Zpětný vzduch | ETA 17 | 30 | ETA | PO02.04.0787 | 0787 | no
13865498 | -1.PP_SO-102 | 2873.73 | 0.0201032 | 1.44449 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 3380 | 3300 | 3300 | 3220 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 156 | ETA | PO02.04.0788 | 0788 | no
13865530 | -1.PP_SO-102 | 520 | 0.0314112 | 0.326726 | 200 mm | 0 | 200 mm | -1.PP_SO-102 | 0 | 2700 | 2600 | 2600 | 2500 | Fáze 2 | Odváděný | 200 | Zpětný vzduch | ETA 17 | 166 | ETA | PO02.04.0789 | 0789 | no
13901342 | -1.PP_SO-102 | 15667.5 | 0.0201032 | 7.87532 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 3180 | 3100 | 3100 | 3020 | Fáze 2 | Přívodní | 160 | Přívod vzduchu | SUP 5 | 44 | SUP | PO02.04.0932 | 0932 | no
13901527 | -1.PP_SO-102 | 5365.61 | 0.0201032 | 2.69705 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 3320 | 3240 | 3240 | 3160 | Fáze 2 | Přívodní | 160 | Přívod vzduchu | SUP 5 | 44 | SUP | PO02.04.0933 | 0933 | no
13901674 | -1.PP_SO-102 | 6540.94 | 0.0201032 | 3.28784 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 2680 | 2600 | 2600 | 2520 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 119 | ETA | PO02.04.0934 | 0934 | no
13901814 | -1.PP_SO-102 | 3140 | 0.0201032 | 1.57834 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 2680 | 2600 | 2600 | 2520 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 37 | ETA | PO02.04.0935 | 0935 | no
13901823 | -1.PP_SO-102 | 2546.61 | 0.0201032 | 1.28006 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 2680 | 2600 | 2600 | 2520 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 173 | ETA | PO02.04.0936 | 0936 | no
13901866 | -1.PP_SO-102 | 3975.26 | 0.0201032 | 1.99818 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 2680 | 2600 | 2600 | 2520 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 29 | ETA | PO02.04.0937 | 0937 | no
13902154 | -1.PP_SO-102 | 11106.2 | 0.0201032 | 5.58259 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 3380 | 3300 | 3300 | 3220 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 156 | ETA | PO02.04.0938 | 0938 | no
13902181 | -1.PP_SO-102 | 185.949 | 0.0201032 | 0.0934683 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 3350 | 3270 | 3270 | 3190 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 42 | ETA | PO02.04.0939 | 0939 | no
13903321 | -1.PP_SO-102 | 8300.59 | 0.0201032 | 4.17233 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 3150 | 3070 | 3070 | 2990 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 134 | ETA | PO02.04.0941 | 0941 | no
13923338 | 1.NP_SO-102 | 1580 | 0.0779194 | 1.56357 | 315 mm | 0 | 315 mm | 1.NP_SO-102 |  | 2466.71 | 886.715 | 2466.71 | 886.715 | Fáze 1 | Čerstvý | 315 | Přívod vzduchu | ODA 13 | 121 | ODA | PO02.04.1001 | 1001 | yes | Identifikační data - Komentáře: VZT31
13960045 | -1.PP_SO-102 | 168.955 | 0.0314112 | 0.106158 | 200 mm | 0 | 200 mm | -1.PP_SO-102 | 0 | 2700 | 2600 | 2600 | 2500 | Fáze 2 | Odváděný | 200 | Zpětný vzduch | ETA 17 | 30 | ETA | PO02.04.1105 | 1105 | no
13960153 | -1.PP_SO-102 | 168.955 | 0.0314112 | 0.106158 | 200 mm | 0 | 200 mm | -1.PP_SO-102 | 0 | 3340 | 3240 | 3240 | 3140 | Fáze 2 | Přívodní | 200 | Přívod vzduchu | SUP 5 | 9 | SUP | PO02.04.1106 | 1106 | no
13960179 | -1.PP_SO-102 | 558.649 | 0.0314112 | 0.351009 | 200 mm | 0 | 200 mm | -1.PP_SO-102 | 0 | 3340 | 3240 | 3240 | 3140 | Fáze 2 | Přívodní | 200 | Přívod vzduchu | SUP 5 | 58 | SUP | PO02.04.1107 | 1107 | no
14001799 | -1.PP_SO-102 | 5532.13 | 0.0201032 | 2.78075 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 3150 | 3070 | 3070 | 2990 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 170 | ETA | PO02.04.1221 | 1221 | no
14003615 | -1.PP_SO-102 | 8617.49 | 0.0201032 | 4.33162 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 3217.04 | 3137.04 | 3137.04 | 3057.04 | Fáze 2 | Přívodní | 160 | Přívod vzduchu | SUP 5 | 28 | SUP | PO02.04.1223 | 1223 | no
14004377 | -1.PP_SO-102 | 267.452 | 0.0201032 | 0.134436 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 3060 | 2980 | 2980 | 2900 | Fáze 2 | Přívodní | 160 | Přívod vzduchu | SUP 5 | 72 | SUP | PO02.04.1224 | 1224 | no
14004712 | -1.PP_SO-102 | 6216.88 | 0.0201032 | 3.12494 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 3060 | 2980 | 2980 | 2900 | Fáze 2 | Přívodní | 160 | Přívod vzduchu | SUP 5 | 30 | SUP | PO02.04.1225 | 1225 | no
14004723 | -1.PP_SO-102 | 387.346 | 0.0201032 | 0.194701 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 3060 | 2980 | 2980 | 2900 | Fáze 2 | Přívodní | 160 | Přívod vzduchu | SUP 5 | 30 | SUP | PO02.04.1226 | 1226 | no
14004898 | -1.PP_SO-102 | 3.59796 | 0.0201032 | 0.00180853 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 2680 | 2600 | 2600 | 2520 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 120 | ETA | PO02.04.1227 | 1227 | no
14005085 | -1.PP_SO-102 | 25.198 | 0.0201032 | 0.0126659 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 2680 | 2600 | 2600 | 2520 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 105 | ETA | PO02.04.1228 | 1228 | no
14006291 | -1.PP_SO-102 | 26 | 0.0314112 | 0.0163363 | 200 mm | 0 | 200 mm | -1.PP_SO-102 | 0 | 3340 | 3240 | 3240 | 3140 | Fáze 2 | Přívodní | 200 | Přívod vzduchu | SUP 5 | 58 | SUP | PO02.04.1229 | 1229 | no
14006398 | -1.PP_SO-102 | 2021.13 | 0.0314112 | 1.26991 | 200 mm | 15 | 230 mm | -1.PP_SO-102 | 0 | 3350 | 3250 | 3250 | 3150 | Fáze 2 | Přívodní | 200 | Přívod vzduchu | SUP 5 | 61 | SUP | PO02.04.1230 | 1230 | no | Izolace - Typ izolace: Protipožární
14006745 | -1.PP_SO-102 | 679.189 | 0.0314112 | 0.426747 | 200 mm | 0 | 200 mm | -1.PP_SO-102 | 0 | 2800 | 2700 | 2700 | 2600 | Fáze 2 | Přívodní | 200 | Přívod vzduchu | SUP 5 | 61 | SUP | PO02.04.1231 | 1231 | no
14007234 | -1.PP_SO-102 | 216.932 | 0.0201032 | 0.109042 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 2680 | 2600 | 2600 | 2520 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 134 | ETA | PO02.04.1232 | 1232 | no
14007246 | -1.PP_SO-102 | 465.858 | 0.0201032 | 0.234166 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 100 | 3056.27 | 2670.29 | 2999.71 | 2613.73 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 134 | ETA | PO02.04.1233 | 1233 | no
14007253 | -1.PP_SO-102 | 4301.31 | 0.0201032 | 2.16207 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 2680 | 2600 | 2600 | 2520 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 134 | ETA | PO02.04.1234 | 1234 | no
14007378 | -1.PP_SO-102 | 1190.24 | 0.0201032 | 0.598279 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 2680 | 2600 | 2600 | 2520 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 134 | ETA | PO02.04.1235 | 1235 | no
14054914 | -1.PP_SO-102 | 1494.02 | 0.0201032 | 0.750976 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 2480 | 2400 | 2400 | 2320 | Fáze 2 | Přívodní | 160 | Přívod vzduchu | SUP 5 | 47 | SUP | PO02.04.1350 | 1350 | no
14114612 | 2.NP_SO-102 | 401.697 | 0.0254431 | 0.227154 | 180 mm | 0 | 180 mm | 2.NP_SO-102 | 0 | 2941.43 | 2851.43 | 2851.43 | 2761.43 | Fáze 1 | Odváděný | 180 | Zpětný vzduch | ETA 12 | 29 | ETA | PO02.04.1479 | 1479 | no
14115432 | -1.PP_SO-102 | 415.035 | 0.0314112 | 0.260774 | 200 mm | 0 | 200 mm | -1.PP_SO-102 | 0 | 3170 | 3070 | 3070 | 2970 | Fáze 2 | Odváděný | 200 | Zpětný vzduch | ETA 17 | 160 | ETA | PO02.04.1480 | 1480 | no
14115607 | -1.PP_SO-102 | 567.452 | 0.0201032 | 0.285232 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 3380 | 3300 | 3300 | 3220 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 156 | ETA | PO02.04.1481 | 1481 | no
14115617 | -1.PP_SO-102 | 2310.31 | 0.0201032 | 1.16129 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 3380 | 3300 | 3300 | 3220 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 156 | ETA | PO02.04.1482 | 1482 | no
14115629 | -1.PP_SO-102 | 338.4 | 0.0201032 | 0.170098 | 160 mm | 0 | 160 mm | -1.PP_SO-102 |  | 3140 | 3140 | 2801.6 | 2801.6 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 156 | ETA | PO02.04.1483 | 1483 | no
14115741 | -1.PP_SO-102 | 2517.72 | 0.0314112 | 1.58193 | 200 mm | 0 | 200 mm | -1.PP_SO-102 | 0 | 2700 | 2600 | 2600 | 2500 | Fáze 2 | Odváděný | 200 | Zpětný vzduch | ETA 17 | 157 | ETA | PO02.04.1484 | 1484 | no
14116215 | -1.PP_SO-102 | 235.147 | 0.0201032 | 0.118198 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 100 | 3249.71 | 3193.14 | 3026.86 | 2970.29 | Fáze 2 | Přívodní | 160 | Přívod vzduchu | SUP 5 | 72 | SUP | PO02.04.1487 | 1487 | no
14116228 | -1.PP_SO-102 | 1494.43 | 0.0201032 | 0.751182 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 3320 | 3240 | 3240 | 3160 | Fáze 2 | Přívodní | 160 | Přívod vzduchu | SUP 5 | 72 | SUP | PO02.04.1488 | 1488 | no
14116511 | -1.PP_SO-102 | 360 | 0.0314112 | 0.226195 | 200 mm | 0 | 200 mm | -1.PP_SO-102 | 0 | 3170 | 3070 | 3070 | 2970 | Fáze 2 | Odváděný | 200 | Zpětný vzduch | ETA 17 | 30 | ETA | PO02.04.1489 | 1489 | no
14116520 | -1.PP_SO-102 | 70 | 0.0314112 | 0.0439823 | 200 mm | 0 | 200 mm | -1.PP_SO-102 |  | 2870 | 2870 | 2800 | 2800 | Fáze 2 | Odváděný | 200 | Zpětný vzduch | ETA 17 | 30 | ETA | PO02.04.1490 | 1490 | no
14116528 | -1.PP_SO-102 | 887.797 | 0.0314112 | 0.55782 | 200 mm | 0 | 200 mm | -1.PP_SO-102 | 0 | 3170 | 3070 | 3070 | 2970 | Fáze 2 | Odváděný | 200 | Zpětný vzduch | ETA 17 | 30 | ETA | PO02.04.1491 | 1491 | no
14116593 | -1.PP_SO-102 | 405.253 | 0.0314112 | 0.254628 | 200 mm | 0 | 200 mm | -1.PP_SO-102 | 0 | 3170 | 3070 | 3070 | 2970 | Fáze 2 | Odváděný | 200 | Zpětný vzduch | ETA 17 | 160 | ETA | PO02.04.1492 | 1492 | no
14116602 | -1.PP_SO-102 | 70 | 0.0314112 | 0.0439823 | 200 mm | 0 | 200 mm | -1.PP_SO-102 |  | 2870 | 2870 | 2800 | 2800 | Fáze 2 | Odváděný | 200 | Zpětný vzduch | ETA 17 | 160 | ETA | PO02.04.1493 | 1493 | no
14116783 | -1.PP_SO-102 | 2908.83 | 0.0314112 | 1.82767 | 200 mm | 0 | 200 mm | -1.PP_SO-102 | 0 | 2800 | 2700 | 2700 | 2600 | Fáze 2 | Přívodní | 200 | Přívod vzduchu | SUP 5 | 61 | SUP | PO02.04.1495 | 1495 | no
14116899 | -1.PP_SO-102 | 138.4 | 0.0314112 | 0.0869593 | 200 mm | 0 | 200 mm | -1.PP_SO-102 |  | 3038.4 | 2900 | 3038.4 | 2900 | Fáze 2 | Přívodní | 200 | Přívod vzduchu | SUP 5 | 60 | SUP | PO02.04.1496 | 1496 | no
14116923 | -1.PP_SO-102 | 1496.59 | 0.0314112 | 0.940334 | 200 mm | 0 | 200 mm | -1.PP_SO-102 | 0 | 2800 | 2700 | 2700 | 2600 | Fáze 2 | Přívodní | 200 | Přívod vzduchu | SUP 5 | 60 | SUP | PO02.04.1497 | 1497 | no
14117048 | -1.PP_SO-102 | 917.322 | 0.0314112 | 0.576371 | 200 mm | 0 | 200 mm | -1.PP_SO-102 | 0 | 2800 | 2700 | 2700 | 2600 | Fáze 2 | Přívodní | 200 | Přívod vzduchu | SUP 5 | 60 | SUP | PO02.04.1498 | 1498 | no
14117692 | -1.PP_SO-102 | 2752.78 | 0.0314112 | 1.72962 | 200 mm | 0 | 200 mm | -1.PP_SO-102 | 0 | 2700 | 2600 | 2600 | 2500 | Fáze 2 | Odváděný | 200 | Zpětný vzduch | ETA 17 | 160 | ETA | PO02.04.1500 | 1500 | no
14117701 | -1.PP_SO-102 | 498.995 | 0.0314112 | 0.313528 | 200 mm | 0 | 200 mm | -1.PP_SO-102 | 100 | 3082.13 | 2658.58 | 3011.42 | 2587.87 | Fáze 2 | Odváděný | 200 | Zpětný vzduch | ETA 17 | 160 | ETA | PO02.04.1501 | 1501 | no
14120730 | -1.PP_SO-102 | 238.4 | 0.0201032 | 0.119833 | 160 mm | 0 | 160 mm | -1.PP_SO-102 |  | 2798.4 | 2560 | 2798.4 | 2560 | Fáze 2 | Přívodní | 160 | Přívod vzduchu | SUP 5 | 47 | SUP | PO02.04.1506 | 1506 | no
14121922 | -1.PP_SO-102 | 1000 | 0.0201032 | 0.502655 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 3320 | 3240 | 3240 | 3160 | Fáze 2 | Přívodní | 160 | Přívod vzduchu | SUP 5 | 44 | SUP | PO02.04.1512 | 1512 | no
14121939 | -1.PP_SO-102 | 65.4413 | 0.0201032 | 0.0328944 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 100 | 3249.71 | 3193.14 | 3146.86 | 3090.29 | Fáze 2 | Přívodní | 160 | Přívod vzduchu | SUP 5 | 44 | SUP | PO02.04.1513 | 1513 | no
14122039 | -1.PP_SO-102 | 800 | 0.0254431 | 0.452389 | 180 mm | 0 | 180 mm | -1.PP_SO-102 | 0 | 3330 | 3240 | 3240 | 3150 | Fáze 2 | Přívodní | 180 | Přívod vzduchu | SUP 5 | 51 | SUP | PO02.04.1514 | 1514 | no
14135897 | -1.PP_SO-102 | 122.01 | 0.0201032 | 0.061329 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 100 | 3259.71 | 3203.14 | 3116.86 | 3060.29 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 170 | ETA | PO02.04.1529 | 1529 | no
14135912 | -1.PP_SO-102 | 2247.45 | 0.0201032 | 1.12969 | 160 mm | 15 | 190 mm | -1.PP_SO-102 | 0 | 3330 | 3250 | 3250 | 3170 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 170 | ETA | PO02.04.1530 | 1530 | no | Izolace - Typ izolace: Protipožární
14135972 | -1.PP_SO-102 | 150 | 0.0314112 | 0.0942478 | 200 mm | 0 | 200 mm | -1.PP_SO-102 |  | 3050 | 3050 | 2900 | 2900 | Fáze 2 | Přívodní | 200 | Přívod vzduchu | SUP 5 | 61 | SUP | PO02.04.1531 | 1531 | no
14136178 | -1.PP_SO-102 | 260.915 | 0.0201032 | 0.13115 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 3330 | 3250 | 3250 | 3170 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 170 | ETA | PO02.04.1532 | 1532 | no
14136189 | -1.PP_SO-102 | 4293.73 | 0.0201032 | 2.15826 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 3330 | 3250 | 3250 | 3170 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 170 | ETA | PO02.04.1533 | 1533 | no
14186819 | -1.PP_SO-102 | 253.238 | 0.0201032 | 0.127291 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 3060 | 2980 | 2980 | 2900 | Fáze 2 | Přívodní | 160 | Přívod vzduchu | SUP 5 | 72 | SUP | PO02.04.1643 | 1643
14186834 | -1.PP_SO-102 | 6400.93 | 0.0201032 | 3.21746 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 3060 | 2980 | 2980 | 2900 | Fáze 2 | Přívodní | 160 | Přívod vzduchu | SUP 5 | 30 | SUP | PO02.04.1644 | 1644
14186870 | -1.PP_SO-102 | 77.1683 | 0.0201032 | 0.038789 | 160 mm | 0 | 160 mm | -1.PP_SO-102 | 0 | 2680 | 2600 | 2600 | 2520 | Fáze 2 | Odváděný | 160 | Zpětný vzduch | ETA 17 | 174 | ETA | PO02.04.1645 | 1645

# IfcZone, Výchozí:102462
Energetická analýza - Možnost pro prostor s venkovním vzduchem: Z typu prostoru; Nastavená hodnota chlazení: 23.3333 C; Nastavená hodnota odvlhčování: 0; Nastavená hodnota topení: 21.1111 C; Nastavená hodnota zvlhčování: 0; Obtokový součinitel: 0; Použít nastavenou hodnotu odvlhčování: no; Použít nastavenou hodnotu zvlhčování: no; Použít vnější vzduch na osobu: no; Použít vnější vzduch na plochu: no; Použít výměnu vzduchu na hodinu: no; Proudění venkovního vzduchu / výměna vzduchu na hodinu: 0; Teplota chladicího vzduchu: 12.2222 C; Teplota vzduchu topení: 32.2222 C; Typ služby: <Budova>; Venkovní vzduch na osobu: 0 m3/s; Venkovní vzduch na plochu: 0
Kóty - Hrubá plocha: 12775.1 m2; Hrubý objem: 43846.5 m3; Obsazená plocha: 12775.1 m2; Obsazený objem: 43846.5 m3
Identifikační data - Název: Výchozí
Jiné - Kategorie: Zóny VZT
