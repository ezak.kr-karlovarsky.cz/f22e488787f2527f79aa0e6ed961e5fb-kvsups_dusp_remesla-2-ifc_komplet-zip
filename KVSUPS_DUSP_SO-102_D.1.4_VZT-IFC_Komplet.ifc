Properties of the parts of a building model (IFC4), part 32 of 45

# IfcDuctFitting: M_Kulaté koleno:1 D (432)
Name (M_Kulaté koleno:1 D:...) | In | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Úhel (deg) | Délka1 (mm) | Objem (m3) | Poloměr potrubí (mm) | Střední poloměr (mm) | Velikost | Kód prvku | Označení | Páteřní trasa
14135907 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | -1.PP_SO-102 | 3070 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.1312 | 1312 | no
14135925 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | -1.PP_SO-102 | 3250 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.1313 | 1313 | no
14135982 | -1.PP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm | 0 | -1.PP_SO-102 | 2700 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.1314 | 1314 | no
14136036 | -1.PP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm | 0 | -1.PP_SO-102 | 3250 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.1315 | 1315 | no
14136186 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | -1.PP_SO-102 | 3250 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.1316 | 1316 | no
14136200 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | -1.PP_SO-102 | 3250 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.1317 | 1317 | no
14137512 | -1.PP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm |  | -1.PP_SO-102 | 2350 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.1321 | 1321 | no
14137775 | -1.PP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm | 0 | -1.PP_SO-102 | 2800 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 45 | 103.553 | 0.00963785 | 125 | 250 | 250-250 | TA00.04.1322 | 1322 | yes
14147088 | -1.PP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | -1.PP_SO-102 | 2700 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 45 | 103.553 | 0.00963785 | 125 | 250 | 250-250 | TA00.04.1342 | 1342 | no
14147099 | -1.PP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | -1.PP_SO-102 | 2300 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 45 | 103.553 | 0.00963785 | 125 | 250 | 250-250 | TA00.04.1343 | 1343 | no
14147161 | -1.PP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | -1.PP_SO-102 | 2300 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 45 | 103.553 | 0.00963785 | 125 | 250 | 250-250 | TA00.04.1344 | 1344 | no
14147165 | -1.PP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | -1.PP_SO-102 | 2700 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 45 | 103.553 | 0.00963785 | 125 | 250 | 250-250 | TA00.04.1345 | 1345 | no
14147910 | 3.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm | 0 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.1349 | 1349 | no
14147992 | 4.NP_SO-102 | 450 mm-450 mm | 0 | 450 mm-450 mm |  | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 450 | 0.112416 | 225 | 450 | 450-450 | TA00.04.1350 | 1350 | yes
14150848 | 2.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm | 0 | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.1358 | 1358 | yes
14154952 | 2.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | 2.NP_SO-102 | 2940 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.1371 | 1371 | no
14171801 | 1.NP_SO-102 | 315 mm-315 mm | 0 | 315 mm-315 mm | 0 | 1.NP_SO-102 | -920 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 315 | 0.0385592 | 157.5 | 315 | 315-315 | TA00.04.1418 | 1418
14171805 | -1.PP_SO-102 | 315 mm-315 mm | 0 | 315 mm-315 mm | 0 | -1.PP_SO-102 | 3080 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 315 | 0.0385592 | 157.5 | 315 | 315-315 | TA00.04.1419 | 1419
14172563 | 1.NP_SO-102 | 315 mm-315 mm | 0 | 315 mm-315 mm | 0 | 1.NP_SO-102 | -1100 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 315 | 0.0385592 | 157.5 | 315 | 315-315 | TA00.04.1421 | 1421 | yes
14172813 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 2763.77 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1422 | 1422
14172933 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 2763.77 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1424 | 1424
14173003 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 2763.77 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1425 | 1425
14176250 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 1.NP_SO-102 | 2700 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1439 | 1439
14176254 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1440 | 1440
14178398 | -1.PP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm | 0 | -1.PP_SO-102 | 2350 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 45 | 103.553 | 0.00963785 | 125 | 250 | 250-250 | TA00.04.1447 | 1447
14178436 | -1.PP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm | 0 | -1.PP_SO-102 | 2800 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 45 | 103.553 | 0.00963785 | 125 | 250 | 250-250 | TA00.04.1448 | 1448
14178728 | 2.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 2.NP_SO-102 | 2650 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 45 | 93.1981 | 0.00702599 | 112.5 | 225 | 225-225 | TA00.04.1449 | 1449
14178764 | 2.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 2.NP_SO-102 | 3010 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.1450 | 1450
14178766 | 2.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 2.NP_SO-102 | 3010 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 45 | 93.1981 | 0.00702599 | 112.5 | 225 | 225-225 | TA00.04.1451 | 1451
14180237 | 1.NP_SO-102 | 315 mm-315 mm | 15 | 345 mm-345 mm |  | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 45 | 130.477 | 0.0192793 | 157.5 | 315 | 315-315 | TA00.04.1452 | 1452 | Izolace - Typ izolace: Protipožární
14180243 | 1.NP_SO-102 | 315 mm-315 mm | 15 | 345 mm-345 mm |  | 1.NP_SO-102 | 2650 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 45 | 130.477 | 0.0192793 | 157.5 | 315 | 315-315 | TA00.04.1453 | 1453 | Izolace - Typ izolace: Protipožární
14180328 | 1.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm | 0 | 1.NP_SO-102 | 2650 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 45 | 103.553 | 0.00963785 | 125 | 250 | 250-250 | TA00.04.1454 | 1454
14180332 | 1.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 45 | 103.553 | 0.00963785 | 125 | 250 | 250-250 | TA00.04.1455 | 1455
14181086 | 1.NP_SO-102 | 315 mm-315 mm | 0 | 315 mm-315 mm | 0 | 1.NP_SO-102 | -900 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 315 | 0.0385592 | 157.5 | 315 | 315-315 | TA00.04.1458 | 1458
14181120 | -1.PP_SO-102 | 315 mm-315 mm | 0 | 315 mm-315 mm | 0 | -1.PP_SO-102 | 3100 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 45 | 130.477 | 0.0192793 | 157.5 | 315 | 315-315 | TA00.04.1459 | 1459
14181185 | -1.PP_SO-102 | 315 mm-315 mm | 0 | 315 mm-315 mm | 0 | -1.PP_SO-102 | 3100 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 45 | 130.477 | 0.0192793 | 157.5 | 315 | 315-315 | TA00.04.1460 | 1460
14186831 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 2980 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.1508 | 1508
14186842 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 2980 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.1509 | 1509
14189404 | -1.PP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm | 0 | -1.PP_SO-102 | 2350 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.1515 | 1515
14189408 | -1.PP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm | 0 | -1.PP_SO-102 | 2777.23 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.1516 | 1516
14189440 | -1.PP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm | 0 | -1.PP_SO-102 | 2350 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.1517 | 1517
14189444 | -1.PP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm | 0 | -1.PP_SO-102 | 2777.23 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.1518 | 1518
14189965 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 3250 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1520 | 1520
14189973 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 2550 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1521 | 1521
14190038 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 2550 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1522 | 1522
14191505 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 4122.77 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1523 | 1523

# IfcDuctFitting: M_Kulaté křížení:Standardní (2)
In: 2.NP_SO-102
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA04; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 09; Popis sestavy: Odbočka
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulaté křížení
Classification: TA04 Uniformat (Uniformat); Group: SUP 9
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 450 mm-450 mm-225 mm-225 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 450 mm-450 mm-225 mm-225 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Výška od podlaží: 2937.5 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 9; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes
Kóty - Délka potrubí 1: 187.5 mm; Délka potrubí 3: 300 mm; Objem: 0.0661777 m3; Poloměr potrubí 1: 225 mm; Poloměr potrubí 3: 112.5 mm; Poloměr potrubí 4: 112.5 mm; Průměr potrubí 1: 450 mm; Průměr potrubí 3: 225 mm; Průměr potrubí 4: 225 mm; Rameno: 75 mm; Velikost: 450-450-225-225
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 1451166; Rodina: M_Kulaté křížení; Rodina a typ: M_Kulaté křížení: Standardní
Name (M_Kulaté křížení:Standardní:...) | Kód prvku | Označení
13717467 | TA04.09.0219 | 0219
13717477 | TA04.09.0221 | 0221

# IfcDuctFitting: M_Kulaté odbočení:Standardní (4)
In: -1.PP_SO-102
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA04; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 13; Popis sestavy: Odbočka
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulaté odbočení
Classification: TA04 Uniformat (Uniformat); Group: SUP 5
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 2
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 5; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes
Kóty - Délka odbočení: 101.6; Pevná délka odbočení: 101.6
Jiné - Páteřní trasa: no; Typ: Standardní; Id typu: 1449384; Rodina: M_Kulaté odbočení; Rodina a typ: M_Kulaté odbočení: Standardní
Name (M_Kulaté odbočení:Standardní:...) | Volná velikost = Celková velikost | Výška od podlaží (mm) | Objem (m3) | Poloměr potrubí (mm) | Projekce délky odbočení | Průměr vedení (mm) | Velikost | Kód prvku | Označení
14065154 | 160 mm-160 mm | 3137.04 | 0.00223395 | 80 | 9.51332 | 160 | 160-160 | TA04.13.1118 | 1118
14116309 | 160 mm-160 mm | 3240 | 0.00314576 | 80 | 54.8649 | 160 | 160-160 | TA04.13.1231 | 1231
14116901 | 200 mm-200 mm | 3140 | 0.00614163 | 100 | 93.904 | 200 | 200-200 | TA04.13.1241 | 1241
14120745 | 160 mm-160 mm | 2900 | 0.00352854 | 80 | 73.904 | 160 | 160-160 | TA04.13.1262 | 1262

# IfcDuctFitting: M_Kulaté odbočení:Standardní (7)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA04; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 13; Popis sestavy: Odbočka
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulaté odbočení
Classification: TA04 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes
Kóty - Délka odbočení: 101.6; Pevná délka odbočení: 101.6
Jiné - Typ: Standardní; Id typu: 1449384; Rodina: M_Kulaté odbočení; Rodina a typ: M_Kulaté odbočení: Standardní
Name (M_Kulaté odbočení:Standardní:...) | In | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Objem (m3) | Poloměr potrubí (mm) | Projekce délky odbočení | Průměr vedení (mm) | Velikost | Kód prvku | Označení | Páteřní trasa
13902222 | -1.PP_SO-102 | 160 mm-160 mm | -1.PP_SO-102 | 3270 | Fáze 2 | ETA 17 | 0.00240072 | 80 | 17.808 | 160 | 160-160 | TA04.13.0640 | 0640 | no
14004907 | -1.PP_SO-102 | 160 mm-160 mm | -1.PP_SO-102 | 2600 | Fáze 2 | ETA 17 | 0.00352854 | 80 | 73.904 | 160 | 160-160 | TA04.13.0937 | 0937 | no
14114713 | 2.NP_SO-102 | 180 mm-180 mm | 2.NP_SO-102 | 2851.43 | Fáze 1 | ETA 12 | 0.00321837 | 90 | 24.8801 | 180 | 180-180 | TA04.13.1216 | 1216 | yes
14115779 | -1.PP_SO-102 | 160 mm-160 mm | -1.PP_SO-102 | 2700 | Fáze 2 | ETA 17 | 0.00296946 | 80 | 46.096 | 160 | 160-160 | TA04.13.1223 | 1223 | no
14116536 | -1.PP_SO-102 | 200 mm-200 mm | -1.PP_SO-102 | 3070 | Fáze 2 | ETA 17 | 0.0033832 | 100 | 6.096 | 200 | 200-200 | TA04.13.1235 | 1235 | no
14116569 | -1.PP_SO-102 | 160 mm-160 mm | -1.PP_SO-102 | 2600 | Fáze 2 | ETA 17 | 0.00296946 | 80 | 46.096 | 160 | 160-160 | TA04.13.1238 | 1238 | no
14135894 | -1.PP_SO-102 | 160 mm-160 mm | -1.PP_SO-102 | 3070 | Fáze 2 | ETA 17 | 0.00352854 | 80 | 73.904 | 160 | 160-160 | TA04.13.1311 | 1311 | no

# IfcDuctFitting: M_Kulaté spojení:Standardní (4)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA06; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 10; Popis sestavy: Spojka
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulaté spojení
Classification: TA06 Uniformat (Uniformat)
Qto_DuctFittingBaseQuantities - Length: 6 mm
Výstelka - Tloušťka výstelky: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - Délka potrubí: 6 mm
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 1448456; Rodina: M_Kulaté spojení; Rodina a typ: M_Kulaté spojení: Standardní
Name (M_Kulaté spojení:Standardní:...) | In | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Objem (m3) | Poloměr potrubí (mm) | Velikost | Kód prvku | Označení | Tlaková ztráta (Pa)
13797159 | 1.NP_SO-102 | 0.0779207 | 0.00593761 | 315 mm-315 mm | 0 | 315 mm-315 mm | 1.NP_SO-102 | 3095 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.000467565 | 157.5 | 315-315 | TA06.10.0337 | 0337
13850308 | -1.PP_SO-102 | 0.0989666 | 0.00669159 | 355 mm-355 mm | 0 | 355 mm-355 mm | -1.PP_SO-102 | 3077.14 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 0.000593851 | 177.5 | 355-355 | TA06.10.0433 | 0433 | 0
13850334 | -1.PP_SO-102 | 0.0989666 | 0.00669159 | 355 mm-355 mm | 0 | 355 mm-355 mm | -1.PP_SO-102 | 3071.78 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 0.000593851 | 177.5 | 355-355 | TA06.10.0434 | 0434 | 0
13963098 | -1.PP_SO-102 | 0.0989666 | 0.00669159 | 355 mm-355 mm | 15 | 385 mm-385 mm | -1.PP_SO-102 | 3077.14 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 0.000593851 | 177.5 | 355-355 | TA06.10.0827 | 0827 | 0 | Izolace - Typ izolace: Protipožární

# IfcDuctFitting: M_Kulaté zakončení:Standardní (5)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka potrubí: 25 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 16; Popis sestavy: Tvarovka potrubí (VZT)
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulaté zakončení
Classification: TA Uniformat (Uniformat)
Qto_DuctFittingBaseQuantities - Length: 25 mm; GrossCrossSectionArea: 0.0201032 m2; NetCrossSectionArea: 0.0201032 m2; OuterSurfaceArea: 0.0125664 m2
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 160 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 160 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - Objem: 0.00050263 m3; Poloměr potrubí: 80 mm; Velikost: 160
Jiné - Typ: Standardní; Id typu: 1447762; Rodina: M_Kulaté zakončení; Rodina a typ: M_Kulaté zakončení: Standardní
Name (M_Kulaté zakončení:Standardní:...) | In | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení | Páteřní trasa
14137439 | -1.PP_SO-102 | -1.PP_SO-102 | 2350 | Odváděný | Zpětný vzduch | ETA 27 | ETA | TA.16.1319 | 1319 | no
14137462 | -1.PP_SO-102 | -1.PP_SO-102 | 2350 | Odváděný | Zpětný vzduch | ETA 27 | ETA | TA.16.1320 | 1320 | no
14152818 | 2.NP_SO-102 | 2.NP_SO-102 | 2900 | Přívodní | Přívod vzduchu | SUP 17 | SUP | TA.16.1367 | 1367 | no
14152838 | 2.NP_SO-102 | 2.NP_SO-102 | 2900 | Přívodní | Přívod vzduchu | SUP 17 | SUP | TA.16.1368 | 1368 | no
14191867 | 2.NP_SO-102 | 2.NP_SO-102 | 2700 | Odváděný | Zpětný vzduch | ETA 12 | ETA | TA.16.1524 | 1524

# IfcDuctFitting: M_Kulatý přechod, úhel:45 stupňů (209)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA03; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 01; Popis sestavy: Přechod
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulatý přechod, úhel
Classification: TA03 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Grafika - Použít měřítko poznámky: yes
Kóty - Odsazení šířky od základny: 3048 mm
Jiné - Číslo 4: 1; Délka 3: 0 mm; Id typu: 1446832; Rodina: M_Kulatý přechod, úhel; Rodina a typ: M_Kulatý přechod, úhel: 45 stupňů; Typ: 45 stupňů
Name (M_Kulatý přechod, úhel:45 stupňů:...) | In | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Dočas. šířka odsazení | Dočas. výška odsazení | Objem (m3) | Odsazení výšky od základny (mm) | Odskok – šířka = Poloměr potrubí 1 (mm) | Odskok – výška | Plocha (m2) | Poloměr potrubí 2 (mm) | Rozdíl odsazení (mm) | Rozdíl poloměrů (mm) = Délka 1 (mm) = Délka 2 (mm) | Velikost | Vypočítaná délka (mm) | Kód prvku | Označení | Páteřní trasa | Číslo 1 = Číslo 2 | Číslo 3 | Číslo 5 | Tlaková ztráta (Pa)
12891014 | 2.NP_SO-102 | 280 mm-200 mm | 0 | 280 mm-200 mm | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 0.0388889 | 0.0388889 | 0.004409 | 3048 | 140 | 140 | 0.0778625 | 100 | 0 | 40 | 280-200 | 96.5685 | TA03.01.0001 | 0001 | yes | 1.6 | 3.2 | 3.86274
13096056 | 2.NP_SO-102 | 315 mm-280 mm | 0 | 315 mm-280 mm | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 0.04375 | 0.04375 | 0.00294005 | 3048 | 157.5 | 157.5 | 0.0705798 | 140 | 0 | 17.5 | 315-280 | 42.2487 | TA03.01.0006 | 0006 | yes | 0.7 | 1.4 | 1.68995
13096242 | 2.NP_SO-102 | 315 mm-280 mm | 0 | 315 mm-280 mm | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 0.04375 | 0.04375 | 0.00294005 | 3048 | 157.5 | 157.5 | 0.0705798 | 140 | 0 | 17.5 | 315-280 | 42.2487 | TA03.01.0008 | 0008 | yes | 0.7 | 1.4 | 1.68995
13103805 | 1.NP_SO-102 | 250 mm-180 mm | 0 | 250 mm-180 mm | 1.NP_SO-102 | 3200.1 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 0.0347222 | 0.0347222 | 0.00309445 | 3048 | 125 | 125 | 0.0615557 | 90 | 0 | 35 | 250-180 | 84.4975 | TA03.01.0020 | 0020 | no | 1.4 | 2.8 | 3.3799
13149505 | 2.NP_SO-102 | 280 mm-200 mm | 0 | 280 mm-200 mm | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 0.0388889 | 0.0388889 | 0.004409 | 3048 | 140 | 140 | 0.0778625 | 100 | 0 | 40 | 280-200 | 96.5685 | TA03.01.0031 | 0031 | yes | 1.6 | 3.2 | 3.86274
13155917 | 2.NP_SO-102 | 560 mm-500 mm | 0 | 560 mm-500 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0777778 | 0.0777778 | 0.0159953 | 3048 | 280 | 280 | 0.220835 | 250 | 0 | 30 | 560-500 | 72.4264 | TA03.01.0038 | 0038 | yes | 1.2 | 2.4 | 2.89706
13156071 | 2.NP_SO-102 | 400 mm-315 mm | 0 | 400 mm-315 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.04375 | 0.04375 | 0.0103474 | 3048 | 157.5 | 157.5 | 0.14119 | 200 | 0 | 42.5 | 400-315 | 102.604 | TA03.01.0039 | 0039 | yes | 1.7 | 3.4 | 4.10416 | 0
13156320 | 2.NP_SO-102 | 450 mm-400 mm | 0 | 450 mm-400 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0625 | 0.0625 | 0.00857183 | 3048 | 225 | 225 | 0.14404 | 200 | 0 | 25 | 450-400 | 60.3553 | TA03.01.0044 | 0044 | yes | 1 | 2 | 2.41421 | 0
13156922 | 4.NP_SO-102 | 450 mm-355 mm | 0 | 450 mm-355 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0625 | 0.0625 | 0.0146585 | 3048 | 225 | 225 | 0.178248 | 177.5 | 0 | 47.5 | 450-355 | 114.675 | TA03.01.0045 | 0045 | yes | 1.9 | 3.8 | 4.58701
13157294 | 3.NP_SO-102 | 560 mm-500 mm | 0 | 560 mm-500 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0777778 | 0.0777778 | 0.0159953 | 3048 | 280 | 280 | 0.220835 | 250 | 0 | 30 | 560-500 | 72.4264 | TA03.01.0049 | 0049 | yes | 1.2 | 2.4 | 2.89706
13157315 | 3.NP_SO-102 | 500 mm-450 mm | 0 | 500 mm-450 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0694444 | 0.0694444 | 0.0107049 | 3048 | 250 | 250 | 0.172825 | 225 | 0 | 25 | 500-450 | 60.3553 | TA03.01.0050 | 0050 | yes | 1 | 2 | 2.41421
13157338 | 3.NP_SO-102 | 450 mm-400 mm | 0 | 450 mm-400 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 0.0625 | 0.0625 | 0.00857183 | 3048 | 225 | 225 | 0.14404 | 200 | 0 | 25 | 450-400 | 60.3553 | TA03.01.0051 | 0051 | yes | 1 | 2 | 2.41421
13157382 | 3.NP_SO-102 | 400 mm-355 mm | 0 | 400 mm-355 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 0.0493056 | 0.0493056 | 0.00608664 | 3048 | 177.5 | 177.5 | 0.114207 | 200 | 0 | 22.5 | 400-355 | 54.3198 | TA03.01.0052 | 0052 | yes | 0.9 | 1.8 | 2.17279 | 0
13168458 | 1.NP_SO-102 | 315 mm-280 mm | 0 | 315 mm-280 mm | 1.NP_SO-102 | 3380 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 34 | ETA | 0.04375 | 0.04375 | 0.00294005 | 3048 | 157.5 | 157.5 | 0.0705798 | 140 | 0 | 17.5 | 315-280 | 42.2487 | TA03.01.0065 | 0065 | yes | 0.7 | 1.4 | 1.68995
13169497 | 1.NP_SO-102 | 200 mm-160 mm | 0 | 200 mm-160 mm | 1.NP_SO-102 | 3150 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.0277778 | 0.0277778 | 0.00123356 | 3048 | 100 | 100 | 0.0344984 | 80 | 0 | 20 | 200-160 | 48.2843 | TA03.01.0079 | 0079 | no | 0.8 | 1.6 | 1.93137
13169504 | 1.NP_SO-102 | 315 mm-250 mm | 0 | 315 mm-250 mm | 1.NP_SO-102 | 3150 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.04375 | 0.04375 | 0.00493938 | 3048 | 157.5 | 157.5 | 0.0865885 | 125 | 0 | 32.5 | 315-250 | 78.4619 | TA03.01.0080 | 0080 | yes | 1.3 | 2.6 | 3.13848
13199363 | 3.NP_SO-102 | 160 mm-125 mm | 0 | 160 mm-125 mm | 3.NP_SO-102 | 3099.91 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.0222222 | 0.0222222 | 0.000677011 | 3048 | 80 | 80 | 0.0228432 | 62.5 | 0 | 17.5 | 160-125 | 42.2487 | TA03.01.0096 | 0096 | no | 0.7 | 1.4 | 1.68995 | 0
13226156 | 1.NP_SO-102 | 315 mm-280 mm | 0 | 315 mm-280 mm | 1.NP_SO-102 | 3862.5 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 0.04375 | 0.04375 | 0.00294005 | 3048 | 157.5 | 157.5 | 0.0705798 | 140 | 0 | 17.5 | 315-280 | 42.2487 | TA03.01.0103 | 0103 | yes | 0.7 | 1.4 | 1.68995
13430013 | 1.NP_SO-102 | 400 mm-355 mm | 0 | 400 mm-355 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0493056 | 0.0493056 | 0.00608664 | 3048 | 177.5 | 177.5 | 0.114207 | 200 | 0 | 22.5 | 400-355 | 54.3198 | TA03.01.0117 | 0117 | yes | 0.9 | 1.8 | 2.17279
13430037 | 1.NP_SO-102 | 450 mm-400 mm | 0 | 450 mm-400 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0625 | 0.0625 | 0.00857183 | 3048 | 225 | 225 | 0.14404 | 200 | 0 | 25 | 450-400 | 60.3553 | TA03.01.0118 | 0118 | yes | 1 | 2 | 2.41421
13430045 | 1.NP_SO-102 | 500 mm-450 mm | 0 | 500 mm-450 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0694444 | 0.0694444 | 0.0107049 | 3048 | 250 | 250 | 0.172825 | 225 | 0 | 25 | 500-450 | 60.3553 | TA03.01.0119 | 0119 | yes | 1 | 2 | 2.41421
13713259 | 2.NP_SO-102 | 560 mm-160 mm | 0 | 560 mm-160 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0222222 | 0.0222222 | 0.0542017 | 3048 | 80 | 80 | 0.446768 | 280 | 0 | 200 | 560-160 | 482.843 | TA03.01.0201 | 0201 | yes | 8 | 16 | 19.3137 | 0
13714810 | 4.NP_SO-102 | 225 mm-160 mm | 0 | 225 mm-160 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.03125 | 0.03125 | 0.002305 | 3048 | 112.5 | 112.5 | 0.0505085 | 80 | 0 | 32.5 | 225-160 | 78.4619 | TA03.01.0213 | 0213 | yes | 1.3 | 2.6 | 3.13848 | 0
13717471 | 2.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 2.NP_SO-102 | 2937.5 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 0.03125 | 0.0354167 | 0.00223637 | 3033 | 112.5 | 127.5 | 0.0510673 | 112.5 | 15 | 0 | 225-225 | 56.25 | TA03.01.0220 | 0220 | yes | 0 | 0 | 0
13717562 | 2.NP_SO-102 | 450 mm-355 mm | 0 | 450 mm-355 mm | 2.NP_SO-102 | 2937.5 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 0.0625 | 0.0625 | 0.0146585 | 3048 | 225 | 225 | 0.178248 | 177.5 | 0 | 47.5 | 450-355 | 114.675 | TA03.01.0222 | 0222 | yes | 1.9 | 3.8 | 4.58701
13717564 | 2.NP_SO-102 | 450 mm-355 mm | 0 | 450 mm-355 mm | 2.NP_SO-102 | 2937.5 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 0.0625 | 0.0625 | 0.0146585 | 3048 | 225 | 225 | 0.178248 | 177.5 | 0 | 47.5 | 450-355 | 114.675 | TA03.01.0223 | 0223 | yes | 1.9 | 3.8 | 4.58701
13717572 | 2.NP_SO-102 | 450 mm-250 mm | 0 | 450 mm-250 mm | 2.NP_SO-102 | 2937.5 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 0.0625 | 0.0625 | 0.0238587 | 3048 | 225 | 225 | 0.242207 | 125 | 0 | 100 | 450-250 | 241.421 | TA03.01.0224 | 0224 | yes | 4 | 8 | 9.65685
13817713 | 1.NP_SO-102 | 250 mm-180 mm | 0 | 250 mm-180 mm | 1.NP_SO-102 | 3150 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.0347222 | 0.0347222 | 0.00309445 | 3048 | 125 | 125 | 0.0615557 | 90 | 0 | 35 | 250-180 | 84.4975 | TA03.01.0384 | 0384 | yes | 1.4 | 2.8 | 3.3799 | 0
13847383 | 2.NP_SO-102 | 560 mm-450 mm | 0 | 560 mm-450 mm | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.0625 | 0.0625 | 0.0267004 | 3048 | 225 | 225 | 0.268659 | 280 | 0 | 55 | 560-450 | 132.782 | TA03.01.0422 | 0422 | yes | 2.2 | 4.4 | 5.31127
13848426 | 3.NP_SO-102 | 400 mm-250 mm | 0 | 400 mm-250 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.0555556 | 0.0555556 | 0.0152867 | 3048 | 200 | 200 | 0.178166 | 125 | 0 | 75 | 400-250 | 181.066 | TA03.01.0424 | 0424 | yes | 3 | 6 | 7.24264 | 0
13848568 | 3.NP_SO-102 | 450 mm-400 mm | 0 | 450 mm-400 mm | 3.NP_SO-102 | 3099.91 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.0555556 | 0.0555556 | 0.00857177 | 3048 | 200 | 200 | 0.14404 | 225 | 0 | 25 | 450-400 | 60.3553 | TA03.01.0427 | 0427 | yes | 1 | 2 | 2.41421
13848629 | 3.NP_SO-102 | 355 mm-225 mm | 0 | 355 mm-225 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 0.0493056 | 0.0493056 | 0.010538 | 3048 | 177.5 | 177.5 | 0.138928 | 112.5 | 0 | 65 | 355-225 | 156.924 | TA03.01.0428 | 0428 | yes | 2.6 | 5.2 | 6.27696 | 0
13848800 | 4.NP_SO-102 | 500 mm-400 mm | 0 | 500 mm-400 mm | 4.NP_SO-102 | 2595 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.0694444 | 0.06901 | 0.0192767 | 3049.56 | 250 | 248.436 | 0.215754 | 200 | 0 | 50 | 500-400 | 120.711 | TA03.01.0429 | 0429 | yes | 2 | 4 | 4.82843
13849950 | 2.NP_SO-102 | 400 mm-225 mm | 0 | 400 mm-225 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.0555556 | 0.0555556 | 0.0166247 | 3048 | 200 | 200 | 0.190123 | 112.5 | 0 | 87.5 | 400-225 | 211.244 | TA03.01.0431 | 0431 | yes | 3.5 | 7 | 8.44975
13850089 | 2.NP_SO-102 | 560 mm-450 mm | 0 | 560 mm-450 mm | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.0625 | 0.0625 | 0.0267004 | 3048 | 225 | 225 | 0.268659 | 280 | 0 | 55 | 560-450 | 132.782 | TA03.01.0432 | 0432 | yes | 2.2 | 4.4 | 5.31127
13864850 | 2.NP_SO-102 | 355 mm-250 mm | 0 | 355 mm-250 mm | 2.NP_SO-102 | 2940 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 0.0347222 | 0.0347222 | 0.00920006 | 3048 | 125 | 125 | 0.126972 | 177.5 | 0 | 52.5 | 355-250 | 126.746 | TA03.01.0453 | 0453 | no | 2.1 | 4.2 | 5.06985
13866787 | 4.NP_SO-102 | 180 mm-160 mm | 0 | 180 mm-160 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 80 | 80 | 0.0230465 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.01.0457 | 0457 | no | 0.4 | 0.8 | 0.965685 | 0
13866943 | 4.NP_SO-102 | 355 mm-280 mm | 0 | 355 mm-280 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 0.0388889 | 0.0388889 | 0.007201 | 3048 | 140 | 140 | 0.110963 | 177.5 | 0 | 37.5 | 355-280 | 90.533 | TA03.01.0459 | 0459 | yes | 1.5 | 3 | 3.62132 | 0
13866987 | 4.NP_SO-102 | 200 mm-180 mm | 0 | 200 mm-180 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 0.0277778 | 0.0277778 | 0.000685038 | 3048 | 100 | 100 | 0.0276519 | 90 | 0 | 10 | 200-180 | 24.1421 | TA03.01.0460 | 0460 | yes | 0.4 | 0.8 | 0.965685 | 0
13867250 | 4.NP_SO-102 | 180 mm-160 mm | 0 | 180 mm-160 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 80 | 80 | 0.0230465 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.01.0462 | 0462 | no | 0.4 | 0.8 | 0.965685 | 0
13867392 | 4.NP_SO-102 | 250 mm-200 mm | 0 | 250 mm-200 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 0.0277778 | 0.0277778 | 0.00240942 | 3048 | 100 | 100 | 0.0539038 | 125 | 0 | 25 | 250-200 | 60.3553 | TA03.01.0466 | 0466 | no | 1 | 2 | 2.41421 | 0
13867504 | 4.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0470 | 0470 | no | 0.5 | 1 | 1.20711 | 0
13867506 | 4.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0471 | 0471 | no | 0.5 | 1 | 1.20711 | 0
13867716 | 4.NP_SO-102 | 180 mm-160 mm | 0 | 180 mm-160 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 80 | 80 | 0.0230465 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.01.0473 | 0473 | no | 0.4 | 0.8 | 0.965685 | 0
13867718 | 4.NP_SO-102 | 180 mm-160 mm | 0 | 180 mm-160 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 80 | 80 | 0.0230465 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.01.0474 | 0474 | no | 0.4 | 0.8 | 0.965685 | 0
13868044 | 4.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0477 | 0477 | yes | 0.5 | 1 | 1.20711 | 0
13868046 | 4.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0478 | 0478 | yes | 0.5 | 1 | 1.20711 | 0
13868194 | 4.NP_SO-102 | 200 mm-180 mm | 0 | 200 mm-180 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 16 | SUP | 0.0277778 | 0.0277778 | 0.000685038 | 3048 | 100 | 100 | 0.0276519 | 90 | 0 | 10 | 200-180 | 24.1421 | TA03.01.0479 | 0479 | no | 0.4 | 0.8 | 0.965685
13868196 | 4.NP_SO-102 | 200 mm-180 mm | 0 | 200 mm-180 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 10 | SUP | 0.0277778 | 0.0277778 | 0.000685038 | 3048 | 100 | 100 | 0.0276519 | 90 | 0 | 10 | 200-180 | 24.1421 | TA03.01.0480 | 0480 | yes | 0.4 | 0.8 | 0.965685
13868423 | 4.NP_SO-102 | 225 mm-180 mm | 0 | 225 mm-180 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.03125 | 0.03125 | 0.00175646 | 3048 | 112.5 | 112.5 | 0.0436621 | 90 | 0 | 22.5 | 225-180 | 54.3198 | TA03.01.0481 | 0481 | no | 0.9 | 1.8 | 2.17279
13868425 | 4.NP_SO-102 | 225 mm-180 mm | 0 | 225 mm-180 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 21 | SUP | 0.03125 | 0.03125 | 0.00175646 | 3048 | 112.5 | 112.5 | 0.0436621 | 90 | 0 | 22.5 | 225-180 | 54.3198 | TA03.01.0482 | 0482 | no | 0.9 | 1.8 | 2.17279
13868626 | 4.NP_SO-102 | 200 mm-180 mm | 0 | 200 mm-180 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0277778 | 0.0277778 | 0.000685038 | 3048 | 100 | 100 | 0.0276519 | 90 | 0 | 10 | 200-180 | 24.1421 | TA03.01.0483 | 0483 | no | 0.4 | 0.8 | 0.965685
13868628 | 4.NP_SO-102 | 200 mm-180 mm | 0 | 200 mm-180 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0277778 | 0.0277778 | 0.000685038 | 3048 | 100 | 100 | 0.0276519 | 90 | 0 | 10 | 200-180 | 24.1421 | TA03.01.0484 | 0484 | no | 0.4 | 0.8 | 0.965685
13868760 | 4.NP_SO-102 | 355 mm-280 mm | 0 | 355 mm-280 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0388889 | 0.0388889 | 0.007201 | 3048 | 140 | 140 | 0.110963 | 177.5 | 0 | 37.5 | 355-280 | 90.533 | TA03.01.0488 | 0488 | yes | 1.5 | 3 | 3.62132
13868791 | 4.NP_SO-102 | 225 mm-180 mm | 0 | 225 mm-180 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 39 | SUP | 0.03125 | 0.03125 | 0.00175646 | 3048 | 112.5 | 112.5 | 0.0436621 | 90 | 0 | 22.5 | 225-180 | 54.3198 | TA03.01.0489 | 0489 | no | 0.9 | 1.8 | 2.17279
13868793 | 4.NP_SO-102 | 225 mm-180 mm | 0 | 225 mm-180 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.03125 | 0.03125 | 0.00175646 | 3048 | 112.5 | 112.5 | 0.0436621 | 90 | 0 | 22.5 | 225-180 | 54.3198 | TA03.01.0490 | 0490 | no | 0.9 | 1.8 | 2.17279
13868919 | 4.NP_SO-102 | 225 mm-180 mm | 0 | 225 mm-180 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.03125 | 0.03125 | 0.00175646 | 3048 | 112.5 | 112.5 | 0.0436621 | 90 | 0 | 22.5 | 225-180 | 54.3198 | TA03.01.0491 | 0491 | no | 0.9 | 1.8 | 2.17279 | 0
13868921 | 4.NP_SO-102 | 225 mm-180 mm | 0 | 225 mm-180 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.03125 | 0.03125 | 0.00175646 | 3048 | 112.5 | 112.5 | 0.0436621 | 90 | 0 | 22.5 | 225-180 | 54.3198 | TA03.01.0492 | 0492 | no | 0.9 | 1.8 | 2.17279 | 0
13869243 | 4.NP_SO-102 | 500 mm-355 mm | 0 | 500 mm-355 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.0694444 | 0.0694444 | 0.0253634 | 3048 | 250 | 250 | 0.249822 | 177.5 | 0 | 72.5 | 500-355 | 175.03 | TA03.01.0494 | 0494 | yes | 2.9 | 5.8 | 7.00122
13870817 | 3.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0499 | 0499 | no | 0.5 | 1 | 1.20711 | 0
13870819 | 3.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0500 | 0500 | no | 0.5 | 1 | 1.20711 | 0
13871226 | 3.NP_SO-102 | 250 mm-225 mm | 0 | 250 mm-225 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.0347222 | 0.0347222 | 0.00133803 | 3048 | 125 | 125 | 0.0432062 | 112.5 | 0 | 12.5 | 250-225 | 30.1777 | TA03.01.0502 | 0502 | yes | 0.5 | 1 | 1.20711 | 0
13871228 | 3.NP_SO-102 | 250 mm-225 mm | 0 | 250 mm-225 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.0347222 | 0.0347222 | 0.00133803 | 3048 | 125 | 125 | 0.0432062 | 112.5 | 0 | 12.5 | 250-225 | 30.1777 | TA03.01.0503 | 0503 | yes | 0.5 | 1 | 1.20711 | 0
13871588 | 3.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0508 | 0508 | no | 0.5 | 1 | 1.20711 | 0
13871590 | 3.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0509 | 0509 | no | 0.5 | 1 | 1.20711 | 0
13875484 | 2.NP_SO-102 | 400 mm-280 mm | 0 | 400 mm-280 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0555556 | 0.0555556 | 0.0132874 | 3048 | 200 | 200 | 0.162158 | 140 | 0 | 60 | 400-280 | 144.853 | TA03.01.0513 | 0513 | yes | 2.4 | 4.8 | 5.79411 | 0
13875488 | 2.NP_SO-102 | 280 mm-250 mm | 0 | 280 mm-250 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0347222 | 0.0347222 | 0.00199932 | 3048 | 125 | 125 | 0.0552087 | 140 | 0 | 15 | 280-250 | 36.2132 | TA03.01.0514 | 0514 | no | 0.6 | 1.2 | 1.44853 | 0
13875505 | 2.NP_SO-102 | 315 mm-280 mm | 0 | 315 mm-280 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0388889 | 0.0388889 | 0.00294016 | 3048 | 140 | 140 | 0.0705798 | 157.5 | 0 | 17.5 | 315-280 | 42.2487 | TA03.01.0515 | 0515 | no | 0.7 | 1.4 | 1.68995 | 0
13875507 | 2.NP_SO-102 | 280 mm-250 mm | 0 | 280 mm-250 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0347222 | 0.0347222 | 0.00199932 | 3048 | 125 | 125 | 0.0552087 | 140 | 0 | 15 | 280-250 | 36.2132 | TA03.01.0516 | 0516 | no | 0.6 | 1.2 | 1.44853 | 0
13875509 | 2.NP_SO-102 | 280 mm-250 mm | 0 | 280 mm-250 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0347222 | 0.0347222 | 0.00199932 | 3048 | 125 | 125 | 0.0552087 | 140 | 0 | 15 | 280-250 | 36.2132 | TA03.01.0517 | 0517 | no | 0.6 | 1.2 | 1.44853 | 0
13875548 | 2.NP_SO-102 | 400 mm-280 mm | 0 | 400 mm-280 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0555556 | 0.0555556 | 0.0132874 | 3048 | 200 | 200 | 0.162158 | 140 | 0 | 60 | 400-280 | 144.853 | TA03.01.0518 | 0518 | yes | 2.4 | 4.8 | 5.79411
13876227 | 2.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 50 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0527 | 0527 | yes | 0.5 | 1 | 1.20711
13876229 | 2.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0528 | 0528 | yes | 0.5 | 1 | 1.20711
13876231 | 2.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 45 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0529 | 0529 | no | 0.5 | 1 | 1.20711
13876233 | 2.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0530 | 0530 | no | 0.5 | 1 | 1.20711
13876235 | 2.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 48 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0531 | 0531 | no | 0.5 | 1 | 1.20711
13876237 | 2.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0532 | 0532 | no | 0.5 | 1 | 1.20711
13876812 | 2.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0536 | 0536 | no | 0.5 | 1 | 1.20711 | 0
13876814 | 2.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0537 | 0537 | no | 0.5 | 1 | 1.20711 | 0
13878431 | 2.NP_SO-102 | 250 mm-225 mm | 0 | 250 mm-225 mm | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.0347222 | 0.0347222 | 0.00133803 | 3048 | 125 | 125 | 0.0432062 | 112.5 | 0 | 12.5 | 250-225 | 30.1777 | TA03.01.0563 | 0563 | no | 0.5 | 1 | 1.20711 | 0
13879616 | 4.NP_SO-102 | 280 mm-200 mm | 0 | 280 mm-200 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 0.0388889 | 0.0388889 | 0.004409 | 3048 | 140 | 140 | 0.0778625 | 100 | 0 | 40 | 280-200 | 96.5685 | TA03.01.0565 | 0565 | yes | 1.6 | 3.2 | 3.86274 | 0
13879740 | 4.NP_SO-102 | 250 mm-225 mm | 0 | 250 mm-225 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 0.0347222 | 0.0347222 | 0.00133803 | 3048 | 125 | 125 | 0.0432062 | 112.5 | 0 | 12.5 | 250-225 | 30.1777 | TA03.01.0567 | 0567 | no | 0.5 | 1 | 1.20711 | 0
13879742 | 4.NP_SO-102 | 250 mm-225 mm | 0 | 250 mm-225 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 0.0347222 | 0.0347222 | 0.00133803 | 3048 | 125 | 125 | 0.0432062 | 112.5 | 0 | 12.5 | 250-225 | 30.1777 | TA03.01.0568 | 0568 | no | 0.5 | 1 | 1.20711 | 0
13879943 | 4.NP_SO-102 | 250 mm-200 mm | 0 | 250 mm-200 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 0.0277778 | 0.0277778 | 0.00240942 | 3048 | 100 | 100 | 0.0539038 | 125 | 0 | 25 | 250-200 | 60.3553 | TA03.01.0572 | 0572 | no | 1 | 2 | 2.41421 | 0
13880035 | 4.NP_SO-102 | 250 mm-225 mm | 0 | 250 mm-225 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.0347222 | 0.0347222 | 0.00133803 | 3048 | 125 | 125 | 0.0432062 | 112.5 | 0 | 12.5 | 250-225 | 30.1777 | TA03.01.0574 | 0574 | no | 0.5 | 1 | 1.20711 | 0
13882276 | 4.NP_SO-102 | 180 mm-160 mm | 0 | 180 mm-160 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 80 | 80 | 0.0230465 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.01.0575 | 0575 | no | 0.4 | 0.8 | 0.965685 | 0
13884374 | 3.NP_SO-102 | 315 mm-280 mm | 0 | 315 mm-280 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.04375 | 0.04375 | 0.00294005 | 3048 | 157.5 | 157.5 | 0.0705798 | 140 | 0 | 17.5 | 315-280 | 42.2487 | TA03.01.0578 | 0578 | yes | 0.7 | 1.4 | 1.68995 | 0
13884376 | 3.NP_SO-102 | 280 mm-250 mm | 0 | 280 mm-250 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0347222 | 0.0347222 | 0.00199932 | 3048 | 125 | 125 | 0.0552087 | 140 | 0 | 15 | 280-250 | 36.2132 | TA03.01.0579 | 0579 | yes | 0.6 | 1.2 | 1.44853 | 0
13884378 | 3.NP_SO-102 | 280 mm-250 mm | 0 | 280 mm-250 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0347222 | 0.0347222 | 0.00199932 | 3048 | 125 | 125 | 0.0552087 | 140 | 0 | 15 | 280-250 | 36.2132 | TA03.01.0580 | 0580 | yes | 0.6 | 1.2 | 1.44853 | 0
13884458 | 3.NP_SO-102 | 315 mm-280 mm | 0 | 315 mm-280 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.04375 | 0.04375 | 0.00294005 | 3048 | 157.5 | 157.5 | 0.0705798 | 140 | 0 | 17.5 | 315-280 | 42.2487 | TA03.01.0585 | 0585 | yes | 0.7 | 1.4 | 1.68995 | 0
13884460 | 3.NP_SO-102 | 280 mm-250 mm | 0 | 280 mm-250 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0347222 | 0.0347222 | 0.00199932 | 3048 | 125 | 125 | 0.0552087 | 140 | 0 | 15 | 280-250 | 36.2132 | TA03.01.0586 | 0586 | yes | 0.6 | 1.2 | 1.44853 | 0
13884462 | 3.NP_SO-102 | 280 mm-250 mm | 0 | 280 mm-250 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0347222 | 0.0347222 | 0.00199932 | 3048 | 125 | 125 | 0.0552087 | 140 | 0 | 15 | 280-250 | 36.2132 | TA03.01.0587 | 0587 | yes | 0.6 | 1.2 | 1.44853 | 0
13884912 | 3.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0593 | 0593 | yes | 0.5 | 1 | 1.20711 | 0
13884914 | 3.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0594 | 0594 | yes | 0.5 | 1 | 1.20711 | 0
13884949 | 3.NP_SO-102 | 225 mm-180 mm | 0 | 225 mm-180 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 0.03125 | 0.03125 | 0.00175646 | 3048 | 112.5 | 112.5 | 0.0436621 | 90 | 0 | 22.5 | 225-180 | 54.3198 | TA03.01.0595 | 0595 | no | 0.9 | 1.8 | 2.17279 | 0
13884951 | 3.NP_SO-102 | 225 mm-180 mm | 0 | 225 mm-180 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 0.03125 | 0.03125 | 0.00175646 | 3048 | 112.5 | 112.5 | 0.0436621 | 90 | 0 | 22.5 | 225-180 | 54.3198 | TA03.01.0596 | 0596 | no | 0.9 | 1.8 | 2.17279 | 0
13885176 | 3.NP_SO-102 | 250 mm-225 mm | 0 | 250 mm-225 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 0.0347222 | 0.0347222 | 0.00133803 | 3048 | 125 | 125 | 0.0432062 | 112.5 | 0 | 12.5 | 250-225 | 30.1777 | TA03.01.0601 | 0601 | no | 0.5 | 1 | 1.20711 | 0
13885407 | 3.NP_SO-102 | 250 mm-225 mm | 0 | 250 mm-225 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 0.0347222 | 0.0347222 | 0.00133803 | 3048 | 125 | 125 | 0.0432062 | 112.5 | 0 | 12.5 | 250-225 | 30.1777 | TA03.01.0605 | 0605 | no | 0.5 | 1 | 1.20711 | 0
13885409 | 3.NP_SO-102 | 250 mm-225 mm | 0 | 250 mm-225 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 0.0347222 | 0.0347222 | 0.00133803 | 3048 | 125 | 125 | 0.0432062 | 112.5 | 0 | 12.5 | 250-225 | 30.1777 | TA03.01.0606 | 0606 | no | 0.5 | 1 | 1.20711 | 0
13885575 | 3.NP_SO-102 | 280 mm-250 mm | 0 | 280 mm-250 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 0.0347222 | 0.0347222 | 0.00199932 | 3048 | 125 | 125 | 0.0552087 | 140 | 0 | 15 | 280-250 | 36.2132 | TA03.01.0609 | 0609 | no | 0.6 | 1.2 | 1.44853 | 0
13885577 | 3.NP_SO-102 | 280 mm-250 mm | 0 | 280 mm-250 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 0.0347222 | 0.0347222 | 0.00199932 | 3048 | 125 | 125 | 0.0552087 | 140 | 0 | 15 | 280-250 | 36.2132 | TA03.01.0610 | 0610 | no | 0.6 | 1.2 | 1.44853 | 0
13885619 | 3.NP_SO-102 | 250 mm-225 mm | 0 | 250 mm-225 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 0.0347222 | 0.0347222 | 0.00133803 | 3048 | 125 | 125 | 0.0432062 | 112.5 | 0 | 12.5 | 250-225 | 30.1777 | TA03.01.0611 | 0611 | no | 0.5 | 1 | 1.20711 | 0
13885621 | 3.NP_SO-102 | 250 mm-225 mm | 0 | 250 mm-225 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 0.0347222 | 0.0347222 | 0.00133803 | 3048 | 125 | 125 | 0.0432062 | 112.5 | 0 | 12.5 | 250-225 | 30.1777 | TA03.01.0612 | 0612 | no | 0.5 | 1 | 1.20711 | 0
13886721 | 3.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0619 | 0619 | no | 0.5 | 1 | 1.20711 | 0
13886723 | 3.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.03125 | 0.03125 | 0.00107141 | 3048 | 112.5 | 112.5 | 0.0360101 | 100 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0620 | 0620 | no | 0.5 | 1 | 1.20711 | 0
13887690 | 3.NP_SO-102 | 280 mm-250 mm | 0 | 280 mm-250 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0347222 | 0.0347222 | 0.00199932 | 3048 | 125 | 125 | 0.0552087 | 140 | 0 | 15 | 280-250 | 36.2132 | TA03.01.0621 | 0621 | no | 0.6 | 1.2 | 1.44853 | 0
13908110 | 1.NP_SO-102 | 280 mm-250 mm | 0 | 280 mm-250 mm | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 0.0347222 | 0.0347222 | 0.00199932 | 3048 | 125 | 125 | 0.0552087 | 140 | 0 | 15 | 280-250 | 36.2132 | TA03.01.0646 | 0646 | no | 0.6 | 1.2 | 1.44853
13908144 | 1.NP_SO-102 | 250 mm-160 mm | 0 | 250 mm-160 mm | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 0.0222222 | 0.0222222 | 0.00364293 | 3048 | 80 | 80 | 0.0684022 | 125 | 0 | 45 | 250-160 | 108.64 | TA03.01.0647 | 0647 | no | 1.8 | 3.6 | 4.34558
13908938 | 1.NP_SO-102 | 355 mm-315 mm | 0 | 355 mm-315 mm | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 0.0493056 | 0.0493056 | 0.00426067 | 3048 | 177.5 | 177.5 | 0.0899957 | 157.5 | 0 | 20 | 355-315 | 48.2843 | TA03.01.0652 | 0652 | no | 0.8 | 1.6 | 1.93137 | 0
13909352 | 1.NP_SO-102 | 355 mm-315 mm | 0 | 355 mm-315 mm | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 0.04375 | 0.04375 | 0.00426072 | 3048 | 157.5 | 157.5 | 0.0899957 | 177.5 | 0 | 20 | 355-315 | 48.2843 | TA03.01.0654 | 0654 | no | 0.8 | 1.6 | 1.93137 | 0
13909354 | 1.NP_SO-102 | 355 mm-315 mm | 0 | 355 mm-315 mm | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 0.04375 | 0.04375 | 0.00426072 | 3048 | 157.5 | 157.5 | 0.0899957 | 177.5 | 0 | 20 | 355-315 | 48.2843 | TA03.01.0655 | 0655 | no | 0.8 | 1.6 | 1.93137 | 0
13909557 | 1.NP_SO-102 | 315 mm-250 mm | 0 | 315 mm-250 mm | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 0.04375 | 0.04375 | 0.00493938 | 3048 | 157.5 | 157.5 | 0.0865885 | 125 | 0 | 32.5 | 315-250 | 78.4619 | TA03.01.0656 | 0656 | no | 1.3 | 2.6 | 3.13848
13909622 | 1.NP_SO-102 | 250 mm-180 mm | 0 | 250 mm-180 mm | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 0.0347222 | 0.0347222 | 0.00309445 | 3048 | 125 | 125 | 0.0615557 | 90 | 0 | 35 | 250-180 | 84.4975 | TA03.01.0657 | 0657 | no | 1.4 | 2.8 | 3.3799
13911016 | 1.NP_SO-102 | 180 mm-160 mm | 0 | 180 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 80 | 80 | 0.0230465 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.01.0658 | 0658 | no | 0.4 | 0.8 | 0.965685 | 0
13911018 | 1.NP_SO-102 | 180 mm-160 mm | 0 | 180 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0222222 | 0.0222222 | 0.000548507 | 3048 | 80 | 80 | 0.0230465 | 90 | 0 | 10 | 180-160 | 24.1421 | TA03.01.0659 | 0659 | no | 0.4 | 0.8 | 0.965685 | 0
13911211 | 1.NP_SO-102 | 160 mm-125 mm | 0 | 160 mm-125 mm | 1.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0173611 | 0.0173611 | 0.000677006 | 3048 | 62.5 | 62.5 | 0.0228432 | 80 | 0 | 17.5 | 160-125 | 42.2487 | TA03.01.0661 | 0661 | yes | 0.7 | 1.4 | 1.68995 | 0
13911213 | 1.NP_SO-102 | 160 mm-125 mm | 0 | 160 mm-125 mm | 1.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 0.0173611 | 0.0173611 | 0.000677006 | 3048 | 62.5 | 62.5 | 0.0228432 | 80 | 0 | 17.5 | 160-125 | 42.2487 | TA03.01.0662 | 0662 | yes | 0.7 | 1.4 | 1.68995 | 0
13911795 | 1.NP_SO-102 | 450 mm-355 mm | 0 | 450 mm-355 mm | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 0.0625 | 0.0625 | 0.0146585 | 3048 | 225 | 225 | 0.178248 | 177.5 | 0 | 47.5 | 450-355 | 114.675 | TA03.01.0665 | 0665 | yes | 1.9 | 3.8 | 4.58701 | 0
13911938 | -1.PP_SO-102 | 500 mm-450 mm | 0 | 500 mm-450 mm | -1.PP_SO-102 | 3570 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 0.0694444 | 0.0694444 | 0.0107049 | 3048 | 250 | 250 | 0.172825 | 225 | 0 | 25 | 500-450 | 60.3553 | TA03.01.0667 | 0667 | yes | 1 | 2 | 2.41421
13911942 | 1.NP_SO-102 | 450 mm-355 mm | 0 | 450 mm-355 mm | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 0.0625 | 0.0625 | 0.0146585 | 3048 | 225 | 225 | 0.178248 | 177.5 | 0 | 47.5 | 450-355 | 114.675 | TA03.01.0668 | 0668 | yes | 1.9 | 3.8 | 4.58701 | 0
13912084 | 1.NP_SO-102 | 450 mm-355 mm | 0 | 450 mm-355 mm | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 0.0625 | 0.0625 | 0.0146585 | 3048 | 225 | 225 | 0.178248 | 177.5 | 0 | 47.5 | 450-355 | 114.675 | TA03.01.0670 | 0670 | yes | 1.9 | 3.8 | 4.58701
13914082 | 1.NP_SO-102 | 280 mm-160 mm | 0 | 280 mm-160 mm | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 0.0388889 | 0.0388889 | 0.00564269 | 3048 | 140 | 140 | 0.0923609 | 80 | 0 | 60 | 280-160 | 144.853 | TA03.01.0681 | 0681 | no | 2.4 | 4.8 | 5.79411
13914107 | 1.NP_SO-102 | 315 mm-280 mm | 0 | 315 mm-280 mm | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 0.0388889 | 0.0388889 | 0.00294016 | 3048 | 140 | 140 | 0.0705798 | 157.5 | 0 | 17.5 | 315-280 | 42.2487 | TA03.01.0682 | 0682 | yes | 0.7 | 1.4 | 1.68995 | 0
13914109 | 1.NP_SO-102 | 315 mm-280 mm | 0 | 315 mm-280 mm | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 0.0388889 | 0.0388889 | 0.00294016 | 3048 | 140 | 140 | 0.0705798 | 157.5 | 0 | 17.5 | 315-280 | 42.2487 | TA03.01.0683 | 0683 | no | 0.7 | 1.4 | 1.68995 | 0
13914137 | 1.NP_SO-102 | 355 mm-280 mm | 0 | 355 mm-280 mm | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 0.0388889 | 0.0388889 | 0.007201 | 3048 | 140 | 140 | 0.110963 | 177.5 | 0 | 37.5 | 355-280 | 90.533 | TA03.01.0684 | 0684 | no | 1.5 | 3 | 3.62132 | 0
13914139 | 1.NP_SO-102 | 355 mm-280 mm | 0 | 355 mm-280 mm | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 0.0388889 | 0.0388889 | 0.007201 | 3048 | 140 | 140 | 0.110963 | 177.5 | 0 | 37.5 | 355-280 | 90.533 | TA03.01.0685 | 0685 | no | 1.5 | 3 | 3.62132 | 0
13915147 | 2.NP_SO-102 | 200 mm-180 mm | 0 | 200 mm-180 mm | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 0.0277778 | 0.0277778 | 0.000685038 | 3048 | 100 | 100 | 0.0276519 | 90 | 0 | 10 | 200-180 | 24.1421 | TA03.01.0695 | 0695 | no | 0.4 | 0.8 | 0.965685
13928642 | 1.NP_SO-102 | 200 mm-160 mm | 0 | 200 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 0.0277778 | 0.0277778 | 0.00123356 | 3048 | 100 | 100 | 0.0344984 | 80 | 0 | 20 | 200-160 | 48.2843 | TA03.01.0720 | 0720 | no | 0.8 | 1.6 | 1.93137
13928644 | 1.NP_SO-102 | 200 mm-160 mm | 0 | 200 mm-160 mm | 1.NP_SO-102 | 3150 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.0277778 | 0.0277778 | 0.00123356 | 3048 | 100 | 100 | 0.0344984 | 80 | 0 | 20 | 200-160 | 48.2843 | TA03.01.0721 | 0721 | no | 0.8 | 1.6 | 1.93137
13928870 | 1.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 0.0277778 | 0.0277778 | 0.00107139 | 3048 | 100 | 100 | 0.0360101 | 112.5 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0722 | 0722 | no | 0.5 | 1 | 1.20711
13928872 | 1.NP_SO-102 | 225 mm-200 mm | 0 | 225 mm-200 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 0.0277778 | 0.0277778 | 0.00107139 | 3048 | 100 | 100 | 0.0360101 | 112.5 | 0 | 12.5 | 225-200 | 30.1777 | TA03.01.0723 | 0723 | no | 0.5 | 1 | 1.20711
13928967 | 1.NP_SO-102 | 225 mm-180 mm | 0 | 225 mm-180 mm | 1.NP_SO-102 | 3150 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.025 | 0.025 | 0.00175647 | 3048 | 90 | 90 | 0.0436621 | 112.5 | 0 | 22.5 | 225-180 | 54.3198 | TA03.01.0724 | 0724 | no | 0.9 | 1.8 | 2.17279 | 0
13928970 | 1.NP_SO-102 | 225 mm-180 mm | 0 | 225 mm-180 mm | 1.NP_SO-102 | 3150 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 0.025 | 0.025 | 0.00175647 | 3048 | 90 | 90 | 0.0436621 | 112.5 | 0 | 22.5 | 225-180 | 54.3198 | TA03.01.0725 | 0725 | no | 0.9 | 1.8 | 2.17279 | 0
13935720 | 2.NP_SO-102 | 400 mm-355 mm | 0 | 400 mm-355 mm | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 0.0555556 | 0.0555556 | 0.00608666 | 3048 | 200 | 200 | 0.114207 | 177.5 | 0 | 22.5 | 400-355 | 54.3198 | TA03.01.0733 | 0733 | yes | 0.9 | 1.8 | 2.17279 | 0
13935722 | 2.NP_SO-102 | 400 mm-355 mm | 0 | 400 mm-355 mm | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 0.0555556 | 0.0555556 | 0.00608666 | 3048 | 200 | 200 | 0.114207 | 177.5 | 0 | 22.5 | 400-355 | 54.3198 | TA03.01.0734 | 0734 | yes | 0.9 | 1.8 | 2.17279 | 0
13935805 | 2.NP_SO-102 | 400 mm-355 mm | 0 | 400 mm-355 mm | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 0.0555556 | 0.0555556 | 0.00608666 | 3048 | 200 | 200 | 0.114207 | 177.5 | 0 | 22.5 | 400-355 | 54.3198 | TA03.01.0735 | 0735 | yes | 0.9 | 1.8 | 2.17279 | 0
13935807 | 2.NP_SO-102 | 400 mm-355 mm | 0 | 400 mm-355 mm | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 0.0555556 | 0.0555556 | 0.00608666 | 3048 | 200 | 200 | 0.114207 | 177.5 | 0 | 22.5 | 400-355 | 54.3198 | TA03.01.0736 | 0736 | yes | 0.9 | 1.8 | 2.17279 | 0
