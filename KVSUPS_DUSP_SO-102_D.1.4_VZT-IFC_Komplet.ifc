Properties of the parts of a building model (IFC4), part 10 of 45

# IfcSpace: Sklad B239:13559738, B239
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.295575; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 90.9012 W; Specifikované výkonové zatížení: 118.172 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.00833333 m3/s; Tok venkovního vzduchu: 0.00327152 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 3420 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 28.8819 m3; Plocha: 8.445 m2
Identifikační data - Číslo: B239; Číslo místnosti: Neobsazené; ID systému: 24; Název: Sklad; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Sklad B335:13559650, B335
In: 3.NP_SO-102
LongName: Sklad; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3000 mm; GrossVolume: 42.761 m3; NetVolume: 42.761 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.498878; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 153.425 W; Specifikované výkonové zatížení: 199.453 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.00694444 m3/s; Tok venkovního vzduchu: 0.00552174 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 3.NP_SO-102; Horní odsazení: 3000 mm; Podlaží: 3.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3000 mm; Objem: 42.761 m3; Plocha: 14.2537 m2
Identifikační data - Číslo: B335; Číslo místnosti: Neobsazené; ID systému: 19; Název: Sklad; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Sklad IT B330.2:13559566, B330.2
In: 3.NP_SO-102
LongName: Sklad IT; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3000 mm; GrossVolume: 23.421 m3; NetVolume: 23.421 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.273245; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 84.0338 W; Specifikované výkonové zatížení: 109.244 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.00694444 m3/s; Tok venkovního vzduchu: 0.00302436 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 3.NP_SO-102; Horní odsazení: 3000 mm; Podlaží: 3.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3000 mm; Objem: 23.421 m3; Plocha: 7.807 m2
Identifikační data - Číslo: B330.2; Číslo místnosti: Neobsazené; ID systému: 18; Název: Sklad IT; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Sklad Rezerva B0124:13628268, B0124
In: -1.PP_SO-102
LongName: Sklad Rezerva; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; NetVolume: 105.912 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 1.77211; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 544.997 W; Specifikované výkonové zatížení: 708.496 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0.0319444 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0319444 m3/s; Tok venkovního vzduchu: 0.0196143 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3420 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 105.912 m3; Plocha: 50.6318 m2
Identifikační data - Číslo: B0124; Číslo místnosti: Neobsazené; ID systému: 20; Název: Sklad Rezerva; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Sklad TV B0145:13560443, B0145
In: -1.PP_SO-102
LongName: Sklad TV; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 55.6201 m3; NetVolume: 55.6201 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.569211; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 175.055 W; Specifikované výkonové zatížení: 227.572 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0277778 m3/s; Tok venkovního vzduchu: 0.0063002 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3420 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 55.6201 m3; Plocha: 16.2632 m2
Identifikační data - Číslo: B0145; Číslo místnosti: Neobsazené; ID systému: 22; Název: Sklad TV; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Sklad bar B252:13559866, B252
In: 2.NP_SO-102
LongName: Sklad bar; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 39.7973 m3; NetVolume: 39.7973 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.438021; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 134.709 W; Specifikované výkonové zatížení: 175.122 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0138889 m3/s; Tok venkovního vzduchu: 0.00484815 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 3420 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 39.7973 m3; Plocha: 12.5149 m2
Identifikační data - Číslo: B252; Číslo místnosti: Neobsazené; ID systému: 25; Název: Sklad bar; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Sklad brusiva B0121:13628283, B0121
In: -1.PP_SO-102
LongName: Sklad brusiva; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 70.5834 m3; NetVolume: 70.5834 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.722345; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 222.15 W; Specifikované výkonové zatížení: 288.795 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0.0194444 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0194444 m3/s; Tok venkovního vzduchu: 0.00799513 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3420 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 70.5834 m3; Plocha: 20.6384 m2
Identifikační data - Číslo: B0121; Číslo místnosti: Neobsazené; ID systému: 20; Název: Sklad brusiva; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Sklad foto-1 B0118.2-1:13560370, B0118.2-1
In: -1.PP_SO-102
LongName: Sklad foto-1; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 24.7469 m3; NetVolume: 24.7469 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.253257; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 77.8868 W; Specifikované výkonové zatížení: 101.253 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.00833333 m3/s; Tok venkovního vzduchu: 0.00280313 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3420 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 24.7469 m3; Plocha: 7.23592 m2
Identifikační data - Číslo: B0118.2-1; Číslo místnosti: Neobsazené; ID systému: 18; Název: Sklad foto-1; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Sklad foto-2 B0118.2-2:13628340, B0118.2-2
In: -1.PP_SO-102
LongName: Sklad foto-2; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 24.7469 m3; NetVolume: 24.7469 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.253257; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 77.8868 W; Specifikované výkonové zatížení: 101.253 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.00833333 m3/s; Tok venkovního vzduchu: 0.00280313 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3420 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 24.7469 m3; Plocha: 7.23592 m2
Identifikační data - Číslo: B0118.2-2; Číslo místnosti: Neobsazené; Název: Sklad foto-2; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Sklad grafických prací - G 02 B0130:13628325, B0130
In: -1.PP_SO-102
LongName: Sklad grafických prací - G 02; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 46.5548 m3; NetVolume: 46.5548 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.476438; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 146.524 W; Specifikované výkonové zatížení: 190.481 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0.00694444 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.00694444 m3/s; Tok venkovního vzduchu: 0.00527336 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3420 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 46.5548 m3; Plocha: 13.6125 m2
Identifikační data - Číslo: B0130; Číslo místnosti: Neobsazené; ID systému: 20; Název: Sklad grafických prací - G 02; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Sklad keramiky 3/I B0126.1:13628271, B0126.1
In: -1.PP_SO-102
LongName: Sklad keramiky 3/I; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 40.3132 m3; NetVolume: 40.3132 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.412562; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 126.88 W; Specifikované výkonové zatížení: 164.943 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0.0416667 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.00833333 m3/s; Tok venkovního vzduchu: 0.00456637 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3420 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 40.3132 m3; Plocha: 11.7875 m2
Identifikační data - Číslo: B0126.1; Číslo místnosti: Neobsazené; ID systému: 20; Název: Sklad keramiky 3/I; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Sklad keramiky 4 B0128:13628261, B0128
In: -1.PP_SO-102
LongName: Sklad keramiky 4; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 392.992 m3; NetVolume: 392.992 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 4.02185; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 1236.88 W; Specifikované výkonové zatížení: 1607.95 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0.0555556 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0555556 m3/s; Tok venkovního vzduchu: 0.0445151 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3420 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 392.992 m3; Plocha: 114.91 m2
Identifikační data - Číslo: B0128; Číslo místnosti: Neobsazené; ID systému: 20; Název: Sklad keramiky 4; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Sklad na mobiliář B232:13559771, B232
In: 2.NP_SO-102
LongName: Sklad na mobiliář; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 30.5534 m3; NetVolume: 30.5534 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.336279; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 103.419 W; Specifikované výkonové zatížení: 134.445 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.00555556 m3/s; Tok venkovního vzduchu: 0.00372204 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 2.NP_SO-102; Horní odsazení: 3420 mm; Podlaží: 2.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 30.5534 m3; Plocha: 9.60797 m2
Identifikační data - Číslo: B232; Číslo místnosti: Neobsazené; ID systému: 19; Název: Sklad na mobiliář; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Sklad obalů kavárna B0113.2:13627888, B0113.2
In: -1.PP_SO-102
LongName: Sklad obalů kavárna; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 2.48976 m3; NetVolume: 2.48976 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.02548; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 7.83613 W; Specifikované výkonové zatížení: 10.187 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.00555556 m3/s; Tok venkovního vzduchu: 0.000282021 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3420 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 2.48976 m3; Plocha: 0.728 m2
Identifikační data - Číslo: B0113.2; Číslo místnosti: Neobsazené; ID systému: 28; Název: Sklad obalů kavárna; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Sklad obalů výdej B0112.2:13627885, B0112.2
In: -1.PP_SO-102
LongName: Sklad obalů výdej; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 2.48976 m3; NetVolume: 2.48976 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.02548; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 7.83612 W; Specifikované výkonové zatížení: 10.187 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.00555556 m3/s; Tok venkovního vzduchu: 0.00028202 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3420 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 2.48976 m3; Plocha: 0.727999 m2
Identifikační data - Číslo: B0112.2; Číslo místnosti: Neobsazené; ID systému: 28; Název: Sklad obalů výdej; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Sklad odpadu výdej B0112.1:13560355, B0112.1
In: -1.PP_SO-102
LongName: Sklad odpadu výdej; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 19.901 m3; NetVolume: 19.901 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.203665; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 62.6352 W; Specifikované výkonové zatížení: 81.4258 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0194444 m3/s; Tok venkovního vzduchu: 0.00225423 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3420 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 19.901 m3; Plocha: 5.819 m2
Identifikační data - Číslo: B0112.1; Číslo místnosti: Neobsazené; ID systému: 28; Název: Sklad odpadu výdej; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Sklad pytlované sádry B0123:13628274, B0123
In: -1.PP_SO-102
LongName: Sklad pytlované sádry; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 46.7154 m3; NetVolume: 46.7154 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.590267; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 181.531 W; Specifikované výkonové zatížení: 235.99 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0.00833333 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.00833333 m3/s; Tok venkovního vzduchu: 0.00653326 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3420 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 46.7154 m3; Plocha: 16.8648 m2
Identifikační data - Číslo: B0123; Číslo místnosti: Neobsazené; ID systému: 20; Název: Sklad pytlované sádry; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Sklad přírodověda B345:13864545, B345
In: 3.NP_SO-102
LongName: Sklad přírodověda; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3300 mm; GrossVolume: 21.0499 m3; NetVolume: 21.0499 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.223256; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 68.6603 W; Specifikované výkonové zatížení: 89.2584 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.00694444 m3/s; Tok venkovního vzduchu: 0.00247107 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 3.NP_SO-102; Horní odsazení: 3300 mm; Podlaží: 3.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3300 mm; Objem: 21.0499 m3; Plocha: 6.37875 m2
Identifikační data - Číslo: B345; Číslo místnosti: Neobsazené; ID systému: 18; Název: Sklad přírodověda; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Sklad skla B0120:13628310, B0120
In: -1.PP_SO-102
LongName: Sklad skla; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; NetVolume: 167.243 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 1.71703; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 528.055 W; Specifikované výkonové zatížení: 686.472 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0.0236111 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0236111 m3/s; Tok venkovního vzduchu: 0.0190046 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3420 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 167.243 m3; Plocha: 49.0579 m2
Identifikační data - Číslo: B0120; Číslo místnosti: Neobsazené; ID systému: 20; Název: Sklad skla; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Sklad venk. mob. B332:13559632, B332
In: 3.NP_SO-102
LongName: Sklad venk. mob.; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3000 mm; GrossVolume: 38.5009 m3; NetVolume: 38.5009 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.449177; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 138.14 W; Specifikované výkonové zatížení: 179.582 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.00694444 m3/s; Tok venkovního vzduchu: 0.00497164 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: 3.NP_SO-102; Horní odsazení: 3000 mm; Podlaží: 3.NP_SO-102
Fázování - Fáze: Fáze 1
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3000 mm; Objem: 38.5009 m3; Plocha: 12.8336 m2
Identifikační data - Číslo: B332; Číslo místnosti: Neobsazené; ID systému: 19; Název: Sklad venk. mob.; Název místnosti: Neobsazené
Jiné - Id fáze: 86961; Kategorie: Prostory

# IfcSpace: Sklad úklidu B0126.1:13628295, B0126.1
In: -1.PP_SO-102
LongName: Sklad úklidu; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 10.708 m3; NetVolume: 10.708 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.109585; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 33.7018 W; Specifikované výkonové zatížení: 43.8123 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.00555556 m3/s; Tok venkovního vzduchu: 0.00121292 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3420 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 10.708 m3; Plocha: 3.131 m2
Identifikační data - Číslo: B0126.1; Číslo místnosti: Neobsazené; ID systému: 20; Název: Sklad úklidu; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Sklad úklidu B0126.4:13628286, B0126.4
In: -1.PP_SO-102
LongName: Sklad úklidu; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 15.5913 m3; NetVolume: 15.5913 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.15956; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 49.0712 W; Specifikované výkonové zatížení: 63.7926 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0.0277778 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0 m3/s; Tok venkovního vzduchu: 0.00176606 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3420 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 15.5913 m3; Plocha: 4.55886 m2
Identifikační data - Číslo: B0126.4; Číslo místnosti: Neobsazené; ID systému: 20; Název: Sklad úklidu; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Sklad školníka B0122.1:13628280, B0122.1
In: -1.PP_SO-102
LongName: Sklad školníka; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; NetVolume: 42.5288 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.438382; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 134.82 W; Specifikované výkonové zatížení: 175.266 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.0138889 m3/s; Tok venkovního vzduchu: 0.00485214 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
Vazby - Dolní odsazení: 0 mm; Horní limit: -1.PP_SO-102; Horní odsazení: 3420 mm; Podlaží: -1.PP_SO-102
Fázování - Fáze: Fáze 2
Kóty - Obvod: 0 mm; Výpočtová výška: 0 mm; Neohraničená výška: 3420 mm; Objem: 42.5288 m3; Plocha: 12.5252 m2
Identifikační data - Číslo: B0122.1; Číslo místnosti: Neobsazené; ID systému: 20; Název: Sklad školníka; Název místnosti: Neobsazené
Jiné - Kategorie: Prostory; Id fáze: 12731853

# IfcSpace: Sklad/tisk-1 B118.2-1:13703015, B118.2-1
In: 1.NP_SO-102
LongName: Sklad/tisk-1; PredefinedType: SPACE; Group: Výchozí:102462
Qto_SpaceBaseQuantities - Height: 3420 mm; GrossVolume: 53.9099 m3; NetVolume: 53.9099 m3
Energetická analýza - Hodnoty tepelného zatížení: Podle typu místa; Jednotka obsazení: Podle typu místa; Jednotky světelného zatížení: Výkonová hustota; Jednotky výkonového zatížení: Výkonová hustota; Metoda toku venkovního vzduchu: podle osob a podle plochy; Obsaditelné: yes; Skutečné světelné zatížení na plochu: 0; Skutečné výkonové zatížení na plochu: 0; Typ podmínky: Vytápěno a chlazeno; Volný prostor: no; Výměna vzduchu za hodinu: 0.5; Základní proudové zatížení zapnuto: Podle typu místa; Základní světelné zatížení zapnuto: Podle typu místa; Celkový přírůstek tepla na osobu: 131.882 W; Návrhové zatížení chlazení: 0 W; Návrhové zatížení vytápění: 0 W; Plánované proudové zatížení na plochu: 13.9931; Plánované světelné zatížení na plochu: 10.7639; Plocha na osobu: 28.5714 m2; Počet osob: 0.551709; Přírůstek citelného tepla na osobu: 73.2678 W; Přírůstek latentního tepla na osobu: 58.6142 W; Příspěvek k osvětlení volného prostoru: 20; Skutečné světelné zatížení: 0 W; Skutečné výkonové zatížení: 0 W; Specifikované světelné zatížení: 169.673 W; Specifikované výkonové zatížení: 220.575 W; Údaje o venkovním vzduchu: Z typu prostoru; Venkovní vzduch na osobu: 0.00235974 m3/s; Venkovní vzduch na plochu: 0.3048; Zóna: Výchozí
Mechanické – tok - Zpětný tok vzduchu: Stanovený; Skutečný přívod vzduchu: 0 m3/s; Skutečný tok odváděného vzduchu: 0 m3/s; Skutečný zpětný tok vzduchu: 0 m3/s; Specifikovaný přívod vzduchu: 0 m3/s; Specifikovaný tok odváděného vzduchu: 0 m3/s; Specifikovaný zpětný tok vzduchu: 0.00694444 m3/s; Tok venkovního vzduchu: 0.00610649 m3/s
Elektroinstalace – zatížení - Jiné zatížení návrhu na plochu: 0; Zatížení VZT návrhu na plochu: 0
Elektroinstalace – osvětlení - Poměr rezonance místnosti: 0; Pracovní rovina výpočtu osvětlení: 762 mm; Odrazivost podlahy: 20; Odrazivost stěny: 50; Odrazivost stropu: 75; Průměrné odhadované osvětlení: 0 lx
