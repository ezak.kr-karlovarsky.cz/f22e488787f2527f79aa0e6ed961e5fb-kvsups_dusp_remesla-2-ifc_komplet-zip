Properties of the parts of a building model (IFC4), part 29 of 45

# IfcDuctFitting: M_Hranaté odbočení:Standardní (7)
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes
Kóty - Délka Násobitel: 0.25; Délka odbočení: 101.6; Pevná délka odbočení: 101.6; Projekce délky odbočení: 6.096
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 1559781; Rodina: M_Hranaté odbočení; Rodina a typ: M_Hranaté odbočení: Standardní
Name (M_Hranaté odbočení:Standardní:...) | In | Length (mm) = Výška potrubí 1 (mm) = Výška potrubí 2 (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Objem (m3) | Šířka potrubí 1 (mm) = Šířka potrubí 2 (mm) | Velikost | Kód prvku | Označení
13912711 | 4.NP_SO-102 | 560 | 0.0430784 | 0.56862 | 400 mm × 560 mm-400 mm × 560 mm | 430 mm × 590 mm-430 mm × 590 mm | 4.NP_SO-102 | 3100 | Fáze 2 | ODA 21 | 0.0241239 | 400 | 400 × 560-400 × 560 | TA04.12.0675 | 0675
13912996 | 3.NP_SO-102 | 560 | 0.0430784 | 0.56862 | 400 mm × 560 mm-400 mm × 560 mm | 430 mm × 590 mm-430 mm × 590 mm | 3.NP_SO-102 | 3095 | Fáze 2 | ODA 21 | 0.0241239 | 400 | 400 × 560-400 × 560 | TA04.12.0677 | 0677
13913206 | 2.NP_SO-102 | 560 | 0.0430784 | 0.56862 | 400 mm × 560 mm-400 mm × 560 mm | 430 mm × 590 mm-430 mm × 590 mm | 2.NP_SO-102 | 2775 | Fáze 2 | ODA 21 | 0.0241239 | 400 | 400 × 560-400 × 560 | TA04.12.0679 | 0679
13918393 | 1.NP_SO-102 | 560 | 0.0430784 | 0.56862 | 400 mm × 560 mm-400 mm × 560 mm | 430 mm × 590 mm-430 mm × 590 mm | 1.NP_SO-102 | 3120 | Fáze 2 | ODA 21 | 0.0241239 | 400 | 400 × 560-400 × 560 | TA04.12.0701 | 0701
14121171 | 1.NP_SO-102 | 450 | 0.0301549 | 0.348926 | 280 mm × 450 mm-280 mm × 450 mm | 310 mm × 480 mm-310 mm × 480 mm | 1.NP_SO-102 | 3096.2 | Fáze 1 | ODA 12 | 0.0135697 | 280 | 280 × 450-280 × 450 | TA04.12.1269 | 1269
14151034 | 3.NP_SO-102 | 630 | 0.0301549 | 0.488497 | 280 mm × 630 mm-280 mm × 630 mm | 310 mm × 660 mm-310 mm × 660 mm | 3.NP_SO-102 | 3096.2 | Fáze 1 | ODA 12 | 0.0189976 | 280 | 280 × 630-280 × 630 | TA04.12.1362 | 1362
14151945 | 4.NP_SO-102 | 450 | 0.0430784 | 0.456926 | 400 mm × 450 mm-400 mm × 450 mm | 430 mm × 480 mm-430 mm × 480 mm | 4.NP_SO-102 | 3096.2 | Fáze 1 | ODA 25 | 0.0193853 | 400 | 400 × 450-400 × 450 | TA04.12.1365 | 1365

# IfcDuctFitting: M_Hranaté odbočení:Standardní (18)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA04; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 12; Popis sestavy: Odbočka
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Hranaté odbočení
Classification: TA04 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - Délka Násobitel: 0.25
Jiné - Typ: Standardní; Id typu: 1559781; Rodina: M_Hranaté odbočení; Rodina a typ: M_Hranaté odbočení: Standardní
Name (M_Hranaté odbočení:Standardní:...) | In | Length (mm) = Výška potrubí 1 (mm) = Výška potrubí 2 (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Délka odbočení | Objem (m3) | Pevná délka odbočení | Projekce délky odbočení | Šířka potrubí 1 (mm) = Šířka potrubí 2 (mm) | Velikost | Kód prvku | Označení | Páteřní trasa
13901084 | -1.PP_SO-102 | 200 | 0.0215392 | 0.123078 | 200 mm × 200 mm-200 mm × 200 mm | -1.PP_SO-102 | 2830 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 101.6 | 0.00430784 | 101.6 | 6.096 | 200 | 200 × 200-200 × 200 | TA04.12.0637 | 0637 | no
13937736 | 2.NP_SO-102 | 180 | 0.0610784 | 0.198971 | 400 mm × 180 mm-400 mm × 180 mm | 2.NP_SO-102 | 2850 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 101.6 | 0.0109941 | 101.6 | 51.096 | 400 | 400 × 180-400 × 180 | TA04.12.0748 | 0748 | yes
13937763 | 2.NP_SO-102 | 180 | 0.0777804 | 0.214002 | 400 mm × 180 mm-400 mm × 180 mm | 2.NP_SO-102 | 2902.86 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 106.296 | 0.0140005 | 101.6 | 88.155 | 400 | 400 × 180-400 × 180 | TA04.12.0749 | 0749 | yes
13937786 | 2.NP_SO-102 | 180 | 0.0450673 | 0.184561 | 400 mm × 180 mm-400 mm × 180 mm | 2.NP_SO-102 | 2901.43 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 106.572 | 0.00811212 | 101.6 | 6.096 | 400 | 400 × 180-400 × 180 | TA04.12.0750 | 0750 | yes
13937943 | 2.NP_SO-102 | 180 | 0.0430784 | 0.182771 | 400 mm × 180 mm-400 mm × 180 mm | 2.NP_SO-102 | 2850 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 101.6 | 0.00775411 | 101.6 | 6.096 | 400 | 400 × 180-400 × 180 | TA04.12.0751 | 0751 | yes
13937979 | 2.NP_SO-102 | 180 | 0.0656428 | 0.203079 | 400 mm × 180 mm-400 mm × 180 mm | 2.NP_SO-102 | 2850 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 101.6 | 0.0118157 | 101.6 | 62.507 | 400 | 400 × 180-400 × 180 | TA04.12.0754 | 0754 | yes
13971572 | 3.NP_SO-102 | 300 | 0.164877 | 0.603658 | 800 mm × 300 mm-800 mm × 300 mm | 3.NP_SO-102 | 3200 | Odváděný | Zpětný vzduch | ETA 53 | ETA | 200 | 0.049463 | 200 | 6.096 | 800 | 800 × 300-800 × 300 | TA04.12.0857 | 0857 | no
13978671 | 4.NP_SO-102 | 500 | 0.0172314 | 0.267696 | 160 mm × 500 mm-160 mm × 500 mm | 4.NP_SO-102 | 2827.52 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 101.6 | 0.00861568 | 101.6 | 6.096 | 160 | 160 × 500-160 × 500 | TA04.12.0861 | 0861 | no
14010946 | 2.NP_SO-102 | 450 | 0.256096 | 1.13049 | 1000 mm × 450 mm-1000 mm × 450 mm | 2.NP_SO-102 | 2159 | Odváděný | Zpětný vzduch | ETA 11 | ETA | 250 | 0.115243 | 250 | 6.096 | 1000 | 1000 × 450-1000 × 450 | TA04.12.0956 | 0956 | yes
14035399 | 3.NP_SO-102 | 225 | 0.026924 | 0.160963 | 250 mm × 225 mm-250 mm × 225 mm | 3.NP_SO-102 | 3100 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 101.6 | 0.0060579 | 101.6 | 6.096 | 250 | 250 × 225-250 × 225 | TA04.12.1002 | 1002 | no
14040367 | 1.NP_SO-102 | 300 | 0.065548 | 0.378658 | 500 mm × 300 mm-500 mm × 300 mm | 1.NP_SO-102 | 3200 | Odváděný | Zpětný vzduch | ETA 98 | ETA | 125 | 0.0196644 | 125 | 6.096 | 500 | 500 × 300-500 × 300 | TA04.12.1025 | 1025 | no
14076596 | 2.NP_SO-102 | 225 | 0.065548 | 0.283993 | 500 mm × 225 mm-500 mm × 225 mm | 2.NP_SO-102 | 2925 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 125 | 0.0147483 | 125 | 6.096 | 500 | 500 × 225-500 × 225 | TA04.12.1135 | 1135 | yes
14122737 | -1.PP_SO-102 | 400 | 0.164877 | 0.804877 | 800 mm × 400 mm-800 mm × 400 mm | -1.PP_SO-102 | 2400 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 200 | 0.0659507 | 200 | 6.096 | 800 | 800 × 400-800 × 400 | TA04.12.1280 | 1280 | yes
14123339 | -1.PP_SO-102 | 500 | 0.0172314 | 0.267696 | 160 mm × 500 mm-160 mm × 500 mm | -1.PP_SO-102 | 3090 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 101.6 | 0.00861568 | 101.6 | 6.096 | 160 | 160 × 500-160 × 500 | TA04.12.1283 | 1283 | no
14138973 | -1.PP_SO-102 | 400 | 0.0215392 | 0.246157 | 200 mm × 400 mm-200 mm × 400 mm | -1.PP_SO-102 | 2404.86 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 101.6 | 0.00861568 | 101.6 | 6.09604 | 200 | 200 × 400-200 × 400 | TA04.12.1333 | 1333 | yes
14149805 | 2.NP_SO-102 | 630 | 0.0533682 | 0.716431 | 450 mm × 630 mm-450 mm × 630 mm | 2.NP_SO-102 | 1349.64 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 112.5 | 0.033622 | 112.5 | 6.096 | 450 | 450 × 630-450 × 630 | TA04.12.1352 | 1352 | yes
14173338 | -1.PP_SO-102 | 160 | 0.0339242 | 0.135263 | 315 mm × 160 mm-315 mm × 160 mm | -1.PP_SO-102 | 2580 | Odváděný | Zpětný vzduch | ETA 97 | ETA | 101.6 | 0.00542788 | 101.6 | 6.096 | 315 | 315 × 160-315 × 160 | TA04.12.1430 | 1430
14181001 | -1.PP_SO-102 | 315 | 0.065548 | 0.39759 | 500 mm × 315 mm-500 mm × 315 mm | -1.PP_SO-102 | 3080 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 125 | 0.0206476 | 125 | 6.096 | 500 | 500 × 315-500 × 315 | TA04.12.1457 | 1457

# IfcDuctFitting: M_Hranaté spojení:Standardní (2)
In: -1.PP_SO-102
Type - Material: 128-64-0
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; ID kategorie: S; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 11; Popis: Spojení; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Hranaté spojení
Classification: TA00 Uniformat (Uniformat)
Qto_DuctFittingBaseQuantities - Length: 355 mm; GrossCrossSectionArea: 0.0048 m2; NetCrossSectionArea: 0.0048 m2; OuterSurfaceArea: 0.57226 m2
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 800 mm × 355 mm-800 mm × 355 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 2
Grafika - Použít měřítko poznámky: yes
Kóty - Délka potrubí: 6 mm; Objem: 0.001704 m3; Šířka potrubí: 800 mm; Velikost: 800 × 355-800 × 355; Výška potrubí: 355 mm
Jiné - Typ: Standardní; Id typu: 1559790; Rodina: M_Hranaté spojení; Rodina a typ: M_Hranaté spojení: Standardní
Name (M_Hranaté spojení:Standardní:...) | Celková velikost | Tloušťka izolace (mm) | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
14116147 | 830 mm × 385 mm-830 mm × 385 mm | 15 | 2930 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | TA00.11.1228 | 1228 | Izolace - Typ izolace: Protipožární; Mechanické – tok - Tlaková ztráta: 0 Pa; Jiné - Páteřní trasa: yes
14159895 | 800 mm × 355 mm-800 mm × 355 mm | 0 | 2550 | Odváděný | Zpětný vzduch | ETA 7 | ETA | TA00.11.1390 | 1390

# IfcDuctFitting: M_Hranaté spojení:Standardní (2)
In: -1.PP_SO-102
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; ID kategorie: S; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 11; Popis: Spojení; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Hranaté spojení
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes
Kóty - Délka potrubí: 6 mm
Jiné - Páteřní trasa: yes; Typ: Standardní; Id typu: 1559790; Rodina: M_Hranaté spojení; Rodina a typ: M_Hranaté spojení: Standardní
Name (M_Hranaté spojení:Standardní:...) | Length (mm) = Výška potrubí (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Výška od podlaží (mm) | Název systému = Group | Objem (m3) | Šířka potrubí (mm) | Velikost | Kód prvku | Označení
13898591 | 160 | 0.00189 | 0.10272 | 315 mm × 160 mm-315 mm × 160 mm | 2580 | ETA 97 | 0.0003024 | 315 | 315 × 160-315 × 160 | TA00.11.0632 | 0632
13968226 | 1100 | 0.0144 | 5.2932 | 2400 mm × 1100 mm-2400 mm × 1100 mm | 850 | ETA 1 | 0.01584 | 2400 | 2400 × 1100-2400 × 1100 | TA00.11.0853 | 0853

# IfcDuctFitting: M_Hranatý přechod, úhel:45 stupňů (37)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Cena: 100; Číslo OmniClass: 23.75.70.14; ID kategorie: R; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 06; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; MJ: ks; Název rodiny: M_Hranatý přechod, úhel
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes
Jiné - Typ: 45 stupňů; Id typu: 1559788; Rodina: M_Hranatý přechod, úhel; Rodina a typ: M_Hranatý přechod, úhel: 45 stupňů
Name (M_Hranatý přechod, úhel:45 stupňů:...) | In | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Délka potrubí (mm) = Max. rozdíl (mm) = Vypočítaná délka (mm) | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Poloviční šířka 1 (mm) | Poloviční šířka 2 (mm) | Poloviční výška 1 (mm) | Poloviční výška 2 (mm) | Rozdíl šířek (mm) | Rozdíl výšek (mm) | Šířka potrubí 1 (mm) | Šířka potrubí 2 (mm) | Šířkové odsazení (mm) | Velikost | Výška potrubí 1 (mm) | Výška potrubí 2 (mm) | Výškové odsazení (mm) | Kód prvku | Označení | Páteřní trasa | Čís.1 | Čís.2 | Čís.3 | Čís.4 | Čís.5 | Čís.6 | Čís.7 | Čís.8 | Délka 1 (mm) | Délka 2 (mm) | Delta 1 (mm) | Delta 2 (mm)
13097293 | 2.NP_SO-102 | 450 mm × 1100 mm-450 mm × 500 mm | 0 | 450 mm × 1100 mm-450 mm × 500 mm | 0 | 2.NP_SO-102 | 1917.21 | Fáze 1 | SUP 17 | 600 | 0.216 | 225 | 550 | 0.761853 | 225 | 225 | 250 | 550 | 0 | 600 | 450 | 450 | 3048 | 450 × 1100-450 × 500 | 500 | 1100 | 3348 | TA00.06.0012 | 0012 | yes | 1 | 1 | 1 | 1 | 24 | 0 | 144 | 12 | 600 | 60.3553 | 0 | 300 | Qto_DuctFittingBaseQuantities - Length: 450 mm; GrossCrossSectionArea: 0.48 m2; NetCrossSectionArea: 0.48 m2; OuterSurfaceArea: 1.37184 m2
13107194 | 2.NP_SO-102 | 1250 mm × 400 mm-1250 mm × 315 mm | 0 | 1250 mm × 400 mm-1250 mm × 315 mm |  | 2.NP_SO-102 | 2880 | Fáze 1 | SUP 9 | 102.604 | 0.0458512 | 625 | 200 | 0.375317 | 625 | 625 | 200 | 157.5 | 0 | 85 | 1250 | 1250 | 3048 | 1250 × 400-1250 × 315 | 400 | 315 | 3048 | TA00.06.0026 | 0026 | yes | 1 | 1 | 1 | 1 | 1.7 | 1.7 | 2.89 | 1.7 | 102.604 | 60.3553 | 0 | 0 | Qto_DuctFittingBaseQuantities - Length: 1250 mm; GrossCrossSectionArea: 0.036681 m2; NetCrossSectionArea: 0.036681 m2; OuterSurfaceArea: 1.17139 m2
13792559 | -1.PP_SO-102 | 1250 mm × 630 mm-1250 mm × 500 mm | 15 | 1280 mm × 660 mm-1280 mm × 530 mm |  | -1.PP_SO-102 | 3090 | Fáze 1 | SUP 24 | 156.924 | 0.110827 | 625 | 250 | 0.601692 | 625 | 625 | 250 | 315 | 0 | 130 | 1250 | 1250 | 3048 | 1250 × 630-1250 × 500 | 500 | 630 | 3048 | TA00.06.0313 | 0313 | yes | 1 | 1 | 1 | 1 | 2.6 | 2.6 | 6.76 | 2.6 | 156.924 | 60.3553 | 0 | 0 | Qto_DuctFittingBaseQuantities - Length: 1250 mm; GrossCrossSectionArea: 0.088662 m2; NetCrossSectionArea: 0.088662 m2; OuterSurfaceArea: 1.83713 m2; Izolace - Typ izolace: Protipožární
13794143 | 2.NP_SO-102 | 1250 mm × 500 mm-710 mm × 500 mm | 0 | 1250 mm × 500 mm-710 mm × 500 mm |  | 2.NP_SO-102 | 3922.97 | Fáze 1 | SUP 24 | 651.838 | 0.3194 | 624.978 | 237.847 | 1.0603 | 625 | 355 | 250 | 250 | 540 | 0 | 1250 | 710 | 3047.98 | 1250 × 500-710 × 500 | 500 | 500 | 3035.85 | TA00.06.0322 | 0322 | yes | 10.8009 | 10.7991 | 116.64 | 10.8 | 1 | 1 | 1 | 1 | 60.3553 | 651.838 | 0.0216996 | 12.1527
13798279 | -1.PP_SO-102 | 800 mm × 800 mm-800 mm × 500 mm | 0 | 800 mm × 800 mm-800 mm × 500 mm | 0 | -1.PP_SO-102 | 814 | Fáze 2 | SUP 12 | 362.132 | 0.188309 | 400 | 400 | 0.679333 | 400 | 400 | 400 | 250 | 0 | 300 | 800 | 800 | 3048 | 800 × 800-800 × 500 | 800 | 500 | 3048 | TA00.06.0340 | 0340 | yes | 1 | 1 | 1 | 1 | 6 | 6 | 36 | 6 | 362.132 | 60.3553 | 0 | 0 | Qto_DuctFittingBaseQuantities - Length: 800 mm; GrossCrossSectionArea: 0.235386 m2; NetCrossSectionArea: 0.235386 m2; OuterSurfaceArea: 1.66715 m2
13809404 | -1.PP_SO-102 | 1600 mm × 500 mm-1250 mm × 500 mm | 0 | 1600 mm × 500 mm-1250 mm × 500 mm |  | -1.PP_SO-102 | 3090 | Fáze 1 | SUP 24 | 422.487 | 0.301022 | 625 | 250 | 1.07262 | 625 | 800 | 250 | 250 | 350 | 0 | 1250 | 1600 | 3048 | 1600 × 500-1250 × 500 | 500 | 500 | 3048 | TA00.06.0369 | 0369 | yes | 7 | 7 | 49 | 7 | 1 | 1 | 1 | 1 | 60.3553 | 422.487 | 0 | 0 | Qto_DuctFittingBaseQuantities - Length: 500 mm; GrossCrossSectionArea: 0.602045 m2; NetCrossSectionArea: 0.602045 m2; OuterSurfaceArea: 1.8823 m2
13846526 | 2.NP_SO-102 | 1800 mm × 560 mm-1250 mm × 560 mm | 0 | 1800 mm × 560 mm-1250 mm × 560 mm | 0 | 2.NP_SO-102 | 1219 | Fáze 1 | SUP 13 | 663.66 | 0.566765 | 913.92 | 280 | 1.64026 | 900 | 625 | 280 | 280 | 550 | 0 | 1800 | 1250 | 3061.92 | 1800 × 560-1250 × 560 | 560 | 560 | 3048 | TA00.06.0415 | 0415 | yes | 11.5568 | 10.4432 | 121 | 11 | 1 | 1 | 1 | 1 | 60.3553 | 663.66 | 13.9202 | 0 | Qto_DuctFittingBaseQuantities - Length: 560 mm; GrossCrossSectionArea: 1.01208 m2; NetCrossSectionArea: 1.01208 m2; OuterSurfaceArea: 2.51271 m2
13853055 | -1.PP_SO-102 | 2400 mm × 1100 mm-1250 mm × 1250 mm | 0 | 2400 mm × 1100 mm-1250 mm × 1250 mm | 0 | -1.PP_SO-102 | 234 | Fáze 1 | SUP 24 | 1388.17 | 2.95681 | 1200 | 550 | 4.46863 | 1200 | 625 | 550 | 625 | 1150 | 150 | 2400 | 1250 | 3048 | 2400 × 1100-1250 × 1250 | 1100 | 1250 | 3048 | TA00.06.0438 | 0438 | yes | 23 | 23 | 529 | 23 | 3 | 3 | 9 | 3 | 181.066 | 1388.17 | 0 | 0
13863625 | 2.NP_SO-102 | 2000 mm × 900 mm-1800 mm × 710 mm | 0 | 2000 mm × 900 mm-1800 mm × 710 mm | 0 | 2.NP_SO-102 | 709 | Fáze 1 | SUP 13 | 240.995 | 0.369364 | 989.021 | 450 | 1.34963 | 1000 | 900 | 450 | 355 | 200 | 190 | 2000 | 1800 | 3037.02 | 2000 × 900-1800 × 710 | 900 | 710 | 3048 | TA00.06.0449 | 0449 | yes | 4.43918 | 3.56082 | 16 | 4 | 3.8 | 3.8 | 14.44 | 3.8 | 229.35 | 240.995 | 10.9794 | 0
13934451 | 2.NP_SO-102 | 1250 mm × 315 mm-1120 mm × 315 mm | 0 | 1250 mm × 315 mm-1120 mm × 315 mm | 0 | 2.NP_SO-102 | 2880 | Fáze 1 | SUP 9 | 156.924 | 0.0585758 | 625 | 157.5 | 0.399344 | 625 | 560 | 157.5 | 157.5 | 130 | 0 | 1250 | 1120 | 3048 | 1250 × 315-1120 × 315 | 315 | 315 | 3048 | TA00.06.0726 | 0726 | yes | 2.6 | 2.6 | 6.76 | 2.6 | 1 | 1 | 1 | 1 | 60.3553 | 156.924 | 0 | 0 | Qto_DuctFittingBaseQuantities - Length: 315 mm; GrossCrossSectionArea: 0.185955 m2; NetCrossSectionArea: 0.185955 m2; OuterSurfaceArea: 0.853558 m2
13934453 | 2.NP_SO-102 | 1250 mm × 315 mm-1120 mm × 315 mm | 0 | 1250 mm × 315 mm-1120 mm × 315 mm | 0 | 2.NP_SO-102 | 2880 | Fáze 1 | SUP 9 | 156.924 | 0.0585758 | 625 | 157.5 | 0.399344 | 625 | 560 | 157.5 | 157.5 | 130 | 0 | 1250 | 1120 | 3048 | 1250 × 315-1120 × 315 | 315 | 315 | 3048 | TA00.06.0727 | 0727 | yes | 2.6 | 2.6 | 6.76 | 2.6 | 1 | 1 | 1 | 1 | 60.3553 | 156.924 | 0 | 0 | Qto_DuctFittingBaseQuantities - Length: 315 mm; GrossCrossSectionArea: 0.185955 m2; NetCrossSectionArea: 0.185955 m2; OuterSurfaceArea: 0.853558 m2
13934875 | 2.NP_SO-102 | 1250 mm × 500 mm-1250 mm × 315 mm | 0 | 1250 mm × 500 mm-1250 mm × 315 mm | 0 | 2.NP_SO-102 | 2880 | Fáze 1 | SUP 9 | 223.315 | 0.113751 | 625 | 157.5 | 0.590831 | 625 | 625 | 157.5 | 250 | 0 | 185 | 1250 | 1250 | 3048 | 1250 × 500-1250 × 315 | 315 | 500 | 3048 | TA00.06.0728 | 0728 | yes | 1 | 1 | 1 | 1 | 3.7 | 3.7 | 13.69 | 3.7 | 223.315 | 60.3553 | 0 | 0 | Qto_DuctFittingBaseQuantities - Length: 1250 mm; GrossCrossSectionArea: 0.0910008 m2; NetCrossSectionArea: 0.0910008 m2; OuterSurfaceArea: 1.62304 m2
13934877 | 2.NP_SO-102 | 1250 mm × 500 mm-1250 mm × 315 mm | 0 | 1250 mm × 500 mm-1250 mm × 315 mm | 0 | 2.NP_SO-102 | 2880 | Fáze 1 | SUP 9 | 223.315 | 0.113751 | 625 | 157.5 | 0.590831 | 625 | 625 | 157.5 | 250 | 0 | 185 | 1250 | 1250 | 3048 | 1250 × 500-1250 × 315 | 315 | 500 | 3048 | TA00.06.0729 | 0729 | yes | 1 | 1 | 1 | 1 | 3.7 | 3.7 | 13.69 | 3.7 | 223.315 | 60.3553 | 0 | 0 | Qto_DuctFittingBaseQuantities - Length: 1250 mm; GrossCrossSectionArea: 0.0910008 m2; NetCrossSectionArea: 0.0910008 m2; OuterSurfaceArea: 1.62304 m2
14013227 | 2.NP_SO-102 | 2400 mm × 1100 mm-1250 mm × 800 mm | 0 | 2400 mm × 1100 mm-1250 mm × 800 mm | 0 | 2.NP_SO-102 | 809 | Fáze 1 | SUP 11 | 1152.24 | 2.03082 | 1772.76 | 550 | 3.68162 | 1200 | 625 | 550 | 400 | 1150 | 300 | 2400 | 1250 | 3620.76 | 2400 × 1100-1250 × 800 | 1100 | 800 | 3048 | TA00.06.0958 | 0958 | yes | 45.9102 | 0.0897983 | 529 | 23 | 6 | 6 | 36 | 6 | 362.132 | 1152.24 | 572.755 | 0
14032941 | 2.NP_SO-102 | 1000 mm × 800 mm-1000 mm × 400 mm | 0 | 1000 mm × 800 mm-1000 mm × 400 mm | 0 | 2.NP_SO-102 | 809 | Fáze 1 | SUP 11 | 482.843 | 0.289706 | 500 | 400 | 0.947587 | 500 | 500 | 400 | 200 | 0 | 400 | 1000 | 1000 | 3048 | 1000 × 800-1000 × 400 | 800 | 400 | 3048 | TA00.06.0989 | 0989 | yes | 1 | 1 | 1 | 1 | 8 | 8 | 64 | 8 | 482.843 | 60.3553 | 0 | 0 | Qto_DuctFittingBaseQuantities - Length: 1000 mm; GrossCrossSectionArea: 0.289706 m2; NetCrossSectionArea: 0.289706 m2; OuterSurfaceArea: 2.24525 m2
14036863 | 2.NP_SO-102 | 500 mm × 315 mm-500 mm × 225 mm | 0 | 500 mm × 315 mm-500 mm × 225 mm | 0 | 2.NP_SO-102 | 2880 | Fáze 1 | SUP 9 | 108.64 | 0.0146663 | 250 | 157.5 | 0.138724 | 250 | 250 | 157.5 | 112.5 | 0 | 90 | 500 | 500 | 3048 | 500 × 315-500 × 225 | 315 | 225 | 3048 | TA00.06.1006 | 1006 | yes | 1 | 1 | 1 | 1 | 1.8 | 1.8 | 3.24 | 1.8 | 108.64 | 60.3553 | 0 | 0 | Qto_DuctFittingBaseQuantities - Length: 500 mm; GrossCrossSectionArea: 0.0293327 m2; NetCrossSectionArea: 0.0293327 m2; OuterSurfaceArea: 0.387591 m2
14037061 | 2.NP_SO-102 | 600 mm × 300 mm-500 mm × 225 mm | 0 | 600 mm × 300 mm-500 mm × 225 mm | 0 | 2.NP_SO-102 | 2880 | Fáze 1 | SUP 9 | 120.711 | 0.017503 | 250 | 112.5 | 0.158229 | 250 | 300 | 112.5 | 150 | 100 | 75 | 500 | 600 | 3048 | 600 × 300-500 × 225 | 225 | 300 | 3048 | TA00.06.1007 | 1007 | yes | 2 | 2 | 4 | 2 | 1.5 | 1.5 | 2.25 | 1.5 | 90.533 | 120.711 | 0 | 0
14037063 | 2.NP_SO-102 | 600 mm × 300 mm-500 mm × 225 mm | 0 | 600 mm × 300 mm-500 mm × 225 mm | 0 | 2.NP_SO-102 | 2880 | Fáze 1 | SUP 9 | 120.711 | 0.017503 | 250 | 112.5 | 0.158229 | 250 | 300 | 112.5 | 150 | 100 | 75 | 500 | 600 | 3048 | 600 × 300-500 × 225 | 225 | 300 | 3048 | TA00.06.1008 | 1008 | yes | 2 | 2 | 4 | 2 | 1.5 | 1.5 | 2.25 | 1.5 | 90.533 | 120.711 | 0 | 0
14050644 | 2.NP_SO-102 | 1250 mm × 315 mm-1250 mm × 225 mm | 0 | 1250 mm × 315 mm-1250 mm × 225 mm | 0 | 2.NP_SO-102 | 2880 | Fáze 1 | SUP 9 | 108.64 | 0.0366659 | 625 | 112.5 | 0.32481 | 625 | 625 | 112.5 | 157.5 | 0 | 90 | 1250 | 1250 | 3048 | 1250 × 315-1250 × 225 | 225 | 315 | 3048 | TA00.06.1040 | 1040 | yes | 1 | 1 | 1 | 1 | 1.8 | 1.8 | 3.24 | 1.8 | 108.64 | 60.3553 | 0 | 0 | Qto_DuctFittingBaseQuantities - Length: 1250 mm; GrossCrossSectionArea: 0.0293327 m2; NetCrossSectionArea: 0.0293327 m2; OuterSurfaceArea: 0.968977 m2
14078256 | 2.NP_SO-102 | 1250 mm × 1250 mm-500 mm × 1250 mm | 0 | 1250 mm × 1250 mm-500 mm × 1250 mm | 0 | 2.NP_SO-102 | 964 | Fáze 1 | SUP 9 | 905.33 | 0.990205 | 625 | 625 | 1.95149 | 625 | 250 | 625 | 625 | 750 | 0 | 1250 | 500 | 3048 | 1250 × 1250-500 × 1250 | 1250 | 1250 | 3048 | TA00.06.1145 | 1145 | yes | 15 | 15 | 225 | 15 | 1 | 1 | 1 | 1 | 60.3553 | 905.33 | 0 | 0 | Qto_DuctFittingBaseQuantities - Length: 1250 mm; GrossCrossSectionArea: 0.792164 m2; NetCrossSectionArea: 0.792164 m2; OuterSurfaceArea: 4.63731 m2
14078296 | 2.NP_SO-102 | 1500 mm × 600 mm-1250 mm × 500 mm | 0 | 1500 mm × 600 mm-1250 mm × 500 mm | 0 | 2.NP_SO-102 | 559 | Fáze 1 | SUP 9 | 301.777 | 0.228847 | 625 | 250 | 0.888848 | 625 | 750 | 250 | 300 | 250 | 100 | 1250 | 1500 | 3048 | 1500 × 600-1250 × 500 | 500 | 600 | 3048 | TA00.06.1146 | 1146 | yes | 5 | 5 | 25 | 5 | 2 | 2 | 4 | 2 | 120.711 | 301.777 | 0 | 0
14117549 | -1.PP_SO-102 | 800 mm × 500 mm-560 mm × 630 mm | 0 | 800 mm × 500 mm-560 mm × 630 mm | 0 | -1.PP_SO-102 | 3070 | Fáze 2 | SUP 12 | 240 | 0.091584 | 400 | 315 | 0.436182 | 280 | 400 | 315 | 250 | 240 | 130 | 560 | 800 | 3168 | 800 × 500-560 × 630 | 630 | 500 | 3048 | TA00.06.1247 | 1247 | yes | 9.6 | 0 | 23.04 | 4.8 | 2.6 | 2.6 | 6.76 | 2.6 | 156.924 | 240 | 120 | 0
14123797 | -1.PP_SO-102 | 800 mm × 400 mm-400 mm × 800 mm | 0 | 800 mm × 400 mm-400 mm × 800 mm |  | -1.PP_SO-102 | 3485 | Fáze 2 | SUP 24 | 482.843 | 0.167385 | 399.962 | 200 | 0.618428 | 400 | 200 | 200 | 400 | 400 | 400 | 800 | 400 | 3047.96 | 800 × 400-400 × 800 | 400 | 800 | 3048 | TA00.06.1289 | 1289 | yes | 8.00153 | 7.99847 | 64 | 8 | 8 | 8 | 64 | 8 | 482.843 | 482.843 | 0.0381765 | 0
14123799 | 2.NP_SO-102 | 400 mm × 800 mm-280 mm × 630 mm | 0 | 400 mm × 800 mm-280 mm × 630 mm | 0 | 2.NP_SO-102 | 3649.79 | Fáze 2 | SUP 24 | 205.208 | 0.050235 | 199.829 | 400 | 0.273179 | 200 | 140 | 400 | 315 | 120 | 170 | 400 | 280 | 3047.83 | 400 × 800-280 × 630 | 800 | 630 | 3048 | TA00.06.1290 | 1290 | yes | 2.40684 | 2.39316 | 5.76 | 2.4 | 3.4 | 3.4 | 11.56 | 3.4 | 205.208 | 144.853 | 0.171037 | 0
14127343 | 1.NP_SO-102 | 250 mm × 160 mm-225 mm × 125 mm | 0 | 250 mm × 160 mm-225 mm × 125 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | SUP 14 | 42.2487 | 0.00143294 | 112.5 | 62.5 | 0.0306179 | 112.5 | 125 | 62.5 | 80 | 25 | 35 | 225 | 250 | 3048 | 250 × 160-225 × 125 | 125 | 160 | 3048 | TA00.06.1301 | 1301 | yes | 0.5 | 0.5 | 0.25 | 0.5 | 0.7 | 0.7 | 0.49 | 0.7 | 42.2487 | 30.1777 | 0 | 0
14127344 | 1.NP_SO-102 | 250 mm × 160 mm-225 mm × 125 mm | 0 | 250 mm × 160 mm-225 mm × 125 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | SUP 14 | 42.2487 | 0.00143294 | 112.5 | 62.5 | 0.0306179 | 112.5 | 125 | 62.5 | 80 | 25 | 35 | 225 | 250 | 3048 | 250 × 160-225 × 125 | 125 | 160 | 3048 | TA00.06.1302 | 1302 | yes | 0.5 | 0.5 | 0.25 | 0.5 | 0.7 | 0.7 | 0.49 | 0.7 | 42.2487 | 30.1777 | 0 | 0
14138343 | -1.PP_SO-102 | 1250 mm × 315 mm-315 mm × 315 mm | 0 | 1250 mm × 315 mm-315 mm × 315 mm | 0 | -1.PP_SO-102 | 2747.5 | Fáze 1 | SUP 24 | 1128.64 | 0.278197 | 157.5 | 157.5 | 1.19882 | 157.5 | 625 | 157.5 | 157.5 | 935 | 0 | 315 | 1250 | 3048 | 1250 × 315-315 × 315 | 315 | 315 | 3048 | TA00.06.1330 | 1330 | yes | 18.7 | 18.7 | 349.69 | 18.7 | 1 | 1 | 1 | 1 | 60.3553 | 1128.64 | 0 | 0 | Qto_DuctFittingBaseQuantities - Length: 315 mm; GrossCrossSectionArea: 0.883165 m2; NetCrossSectionArea: 0.883165 m2; OuterSurfaceArea: 1.26261 m2
14148090 | 2.NP_SO-102 | 1800 mm × 800 mm-1500 mm × 600 mm | 0 | 1800 mm × 800 mm-1500 mm × 600 mm | 0 | 2.NP_SO-102 | 559 | Fáze 1 | SUP 9 | 362.132 | 0.420073 | 900 | 400 | 1.33089 | 900 | 750 | 400 | 300 | 300 | 200 | 1800 | 1500 | 3048 | 1800 × 800-1500 × 600 | 800 | 600 | 3048 | TA00.06.1351 | 1351 | yes | 6 | 6 | 36 | 6 | 4 | 4 | 16 | 4 | 241.421 | 362.132 | 0 | 0
14181461 | 1.NP_SO-102 | 710 mm × 315 mm-630 mm × 250 mm | 0 | 710 mm × 315 mm-630 mm × 250 mm | 0 | 1.NP_SO-102 | 3294.94 | Fáze 1 | SUP 11 | 96.5685 | 0.0183199 | 315 | 92.5 | 0.176536 | 315 | 355 | 125 | 157.5 | 80 | 65 | 630 | 710 | 3048 | 710 × 315-630 × 250 | 250 | 315 | 3015.5 | TA00.06.1462 | 1462 |  | 1.6 | 1.6 | 2.56 | 1.6 | 2.6 | 0 | 1.69 | 1.3 | 65 | 96.5685 | 0 | 32.5
14181654 | 1.NP_SO-102 | 710 mm × 315 mm-630 mm × 250 mm | 0 | 710 mm × 315 mm-630 mm × 250 mm | 0 | 1.NP_SO-102 | 3282.5 | Fáze 1 | SUP 15 | 96.5685 | 0.0183199 | 315 | 92.5 | 0.176536 | 315 | 355 | 125 | 157.5 | 80 | 65 | 630 | 710 | 3048 | 710 × 315-630 × 250 | 250 | 315 | 3015.5 | TA00.06.1472 | 1472 |  | 1.6 | 1.6 | 2.56 | 1.6 | 2.6 | 0 | 1.69 | 1.3 | 65 | 96.5685 | 0 | 32.5
14182054 | 1.NP_SO-102 | 710 mm × 315 mm-630 mm × 250 mm | 0 | 710 mm × 315 mm-630 mm × 250 mm | 0 | 1.NP_SO-102 | 3350 | Fáze 1 | SUP 15 | 96.5685 | 0.0183199 | 315 | 92.5 | 0.176536 | 315 | 355 | 125 | 157.5 | 80 | 65 | 630 | 710 | 3048 | 710 × 315-630 × 250 | 250 | 315 | 3015.5 | TA00.06.1480 | 1480 |  | 1.6 | 1.6 | 2.56 | 1.6 | 2.6 | 0 | 1.69 | 1.3 | 65 | 96.5685 | 0 | 32.5
14182374 | 1.NP_SO-102 | 710 mm × 315 mm-630 mm × 250 mm | 0 | 710 mm × 315 mm-630 mm × 250 mm | 0 | 1.NP_SO-102 | 3282.5 | Fáze 1 | SUP 15 | 96.5685 | 0.0183199 | 315 | 92.5 | 0.176536 | 315 | 355 | 125 | 157.5 | 80 | 65 | 630 | 710 | 3048 | 710 × 315-630 × 250 | 250 | 315 | 3015.5 | TA00.06.1488 | 1488 |  | 1.6 | 1.6 | 2.56 | 1.6 | 2.6 | 0 | 1.69 | 1.3 | 65 | 96.5685 | 0 | 32.5
14183062 | 1.NP_SO-102 | 1000 mm × 450 mm-710 mm × 315 mm | 0 | 1000 mm × 450 mm-710 mm × 315 mm | 0 | 1.NP_SO-102 | 3317.5 | Fáze 1 | SUP 15 | 290 | 0.095787 | 500 | 90 | 0.486626 | 355 | 500 | 157.5 | 225 | 290 | 135 | 710 | 1000 | 3193 | 1000 × 450-710 × 315 | 315 | 450 | 2980.5 | TA00.06.1492 | 1492 |  | 11.6 | 0 | 33.64 | 5.8 | 5.4 | 0 | 7.29 | 2.7 | 135 | 290 | 145 | 67.5
14183809 | 1.NP_SO-102 | 1120 mm × 355 mm-710 mm × 315 mm | 0 | 1120 mm × 355 mm-710 mm × 315 mm | 0 | 1.NP_SO-102 | 3262.44 | Fáze 1 | SUP 11 | 410 | 0.126236 | 560 | 137.5 | 0.613584 | 355 | 560 | 157.5 | 177.5 | 410 | 40 | 710 | 1120 | 3253 | 1120 × 355-710 × 315 | 315 | 355 | 3028 | TA00.06.1499 | 1499 |  | 16.4 | 0 | 67.24 | 8.2 | 1.6 | 0 | 0.64 | 0.8 | 40 | 410 | 205 | 20
14183810 | 1.NP_SO-102 | 1250 mm × 400 mm-1120 mm × 355 mm | 0 | 1250 mm × 400 mm-1120 mm × 355 mm | 0 | 1.NP_SO-102 | 3242.44 | Fáze 1 | SUP 11 | 130 | 0.0582173 | 625 | 155 | 0.409215 | 560 | 625 | 177.5 | 200 | 130 | 45 | 1120 | 1250 | 3113 | 1250 × 400-1120 × 355 | 355 | 400 | 3025.5 | TA00.06.1500 | 1500 |  | 5.2 | 0 | 6.76 | 2.6 | 1.8 | 0 | 0.81 | 0.9 | 45 | 130 | 65 | 22.5
14183831 | 1.NP_SO-102 | 900 mm × 315 mm-630 mm × 250 mm | 0 | 900 mm × 315 mm-630 mm × 250 mm | 0 | 1.NP_SO-102 | 3294.94 | Fáze 1 | SUP 11 | 270 | 0.0587453 | 180 | 92.5 | 0.363582 | 315 | 450 | 125 | 157.5 | 270 | 65 | 630 | 900 | 2913 | 900 × 315-630 × 250 | 250 | 315 | 3015.5 | TA00.06.1501 | 1501 |  | 10.8 | 0 | 29.16 | 5.4 | 2.6 | 0 | 1.69 | 1.3 | 65 | 270 | 135 | 32.5
14183832 | 1.NP_SO-102 | 1250 mm × 400 mm-900 mm × 315 mm | 0 | 1250 mm × 400 mm-900 mm × 315 mm | 0 | 1.NP_SO-102 | 3262.44 | Fáze 1 | SUP 11 | 350 | 0.135377 | 275 | 115 | 0.649026 | 450 | 625 | 157.5 | 200 | 350 | 85 | 900 | 1250 | 2873 | 1250 × 400-900 × 315 | 315 | 400 | 3005.5 | TA00.06.1502 | 1502 |  | 14 | 0 | 49 | 7 | 3.4 | 0 | 2.89 | 1.7 | 85 | 350 | 175 | 42.5

# IfcDuctFitting: M_Hranatý přechod, úhel:45 stupňů (40)
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Cena: 100; Číslo OmniClass: 23.75.70.14; ID kategorie: R; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 06; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; MJ: ks; Název rodiny: M_Hranatý přechod, úhel
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes
Jiné - Typ: 45 stupňů; Id typu: 1559788; Rodina: M_Hranatý přechod, úhel; Rodina a typ: M_Hranatý přechod, úhel: 45 stupňů
Name (M_Hranatý přechod, úhel:45 stupňů:...) | In | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Šířkové odsazení (mm) | Výškové odsazení (mm) | Délka potrubí (mm) = Max. rozdíl (mm) = Vypočítaná délka (mm) | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Poloviční šířka 1 (mm) | Poloviční šířka 2 (mm) | Poloviční výška 1 (mm) | Poloviční výška 2 (mm) | Rozdíl šířek (mm) | Rozdíl výšek (mm) | Šířka potrubí 1 (mm) | Šířka potrubí 2 (mm) | Velikost | Výška potrubí 1 (mm) | Výška potrubí 2 (mm) | Kód prvku | Označení | Páteřní trasa | Delta 2 (mm) | Delta 1 (mm) | Čís.1 | Čís.2 | Čís.3 | Čís.4 | Čís.5 | Čís.6 | Čís.7 | Čís.8 | Délka 1 (mm) | Délka 2 (mm)
13746986 | 2.NP_SO-102 | 2400 mm × 1100 mm-1120 mm × 630 mm | 0 | 2400 mm × 1100 mm-1120 mm × 630 mm | 13.9 | 2.NP_SO-102 | 809 | Fáze 1 | ODA 6 | 3048 | 3048 | 1545.1 | 2.42972 | 1200 | 550 | 4.29472 | 1200 | 560 | 550 | 315 | 1280 | 470 | 2400 | 1120 | 2400 × 1100-1120 × 630 | 1100 | 630 | TA00.06.0241 | 0241 | yes | 0 | 0 | 25.6 | 25.6 | 655.36 | 25.6 | 9.4 | 9.4 | 88.36 | 9.4 | 567.34 | 1545.1
13757108 | 2.NP_SO-102 | 1500 mm × 900 mm-1120 mm × 630 mm | 0 | 1500 mm × 900 mm-1120 mm × 630 mm | 27.6778 | 2.NP_SO-102 | 2543.58 | Fáze 1 | ODA 6 | 3048 | 3048 | 458.701 | 0.463609 | 560 | 315 | 1.31745 | 560 | 750 | 315 | 450 | 380 | 270 | 1120 | 1500 | 1500 × 900-1120 × 630 | 630 | 900 | TA00.06.0254 | 0254 | yes | 0 | 0 | 7.6 | 7.6 | 57.76 | 7.6 | 5.4 | 5.4 | 29.16 | 5.4 | 325.919 | 458.701
13801710 | 4.NP_SO-102 | 710 mm × 630 mm-630 mm × 630 mm | 0 | 710 mm × 630 mm-630 mm × 630 mm | 0 | STŘECHA_SO-102 | 1475.5 | Fáze 2 | ODA 21 | 3048 | 3048 | 96.5685 | 0.0407616 | 315 | 315 | 0.308676 | 315 | 355 | 315 | 315 | 80 | 0 | 630 | 710 | 710 × 630-630 × 630 | 630 | 630 | TA00.06.0341 | 0341 | yes | 0 | 0 | 1.6 | 1.6 | 2.56 | 1.6 | 1 | 1 | 1 | 1 | 60.3553 | 96.5685 | Qto_DuctFittingBaseQuantities - Length: 630 mm; GrossCrossSectionArea: 0.0647009 m2; NetCrossSectionArea: 0.0647009 m2; OuterSurfaceArea: 0.975902 m2
13801713 | 4.NP_SO-102 | 800 mm × 800 mm-500 mm × 450 mm | 0 | 800 mm × 800 mm-500 mm × 450 mm | 0 | STŘECHA_SO-102 | 1475.5 | Fáze 2 | ODA 21 | 3048 | 3048 | 422.487 | 0.175332 | 400 | 400 | 0.642282 | 400 | 250 | 400 | 225 | 300 | 350 | 800 | 500 | 800 × 800-500 × 450 | 800 | 450 | TA00.06.0342 | 0342 | yes | 0 | 0 | 6 | 6 | 36 | 6 | 7 | 7 | 49 | 7 | 422.487 | 362.132
13802166 | 4.NP_SO-102 | 560 mm × 450 mm-500 mm × 450 mm | 0 | 560 mm × 450 mm-500 mm × 450 mm | 0 | STŘECHA_SO-102 | 1475.5 | Fáze 2 | ODA 21 | 3048 | 3048 | 72.4264 | 0.0172737 | 280 | 225 | 0.175275 | 280 | 250 | 225 | 225 | 60 | 0 | 560 | 500 | 560 × 450-500 × 450 | 450 | 450 | TA00.06.0345 | 0345 | yes | 0 | 0 | 1.2 | 1.2 | 1.44 | 1.2 | 1 | 1 | 1 | 1 | 60.3553 | 72.4264 | Qto_DuctFittingBaseQuantities - Length: 450 mm; GrossCrossSectionArea: 0.038386 m2; NetCrossSectionArea: 0.038386 m2; OuterSurfaceArea: 0.547554 m2
13802205 | 4.NP_SO-102 | 710 mm × 630 mm-630 mm × 630 mm | 0 | 710 mm × 630 mm-630 mm × 630 mm | 0 | STŘECHA_SO-102 | 1000 | Fáze 1 | ODA 4 | 3048 | 3048 | 96.5685 | 0.0407616 | 315 | 315 | 0.308676 | 315 | 355 | 315 | 315 | 80 | 0 | 630 | 710 | 710 × 630-630 × 630 | 630 | 630 | TA00.06.0346 | 0346 | yes | 0 | 0 | 1.6 | 1.6 | 2.56 | 1.6 | 1 | 1 | 1 | 1 | 60.3553 | 96.5685 | Qto_DuctFittingBaseQuantities - Length: 630 mm; GrossCrossSectionArea: 0.0647009 m2; NetCrossSectionArea: 0.0647009 m2; OuterSurfaceArea: 0.975902 m2
13817254 | -1.PP_SO-102 | 630 mm × 500 mm-630 mm × 280 mm | 0 | 630 mm × 500 mm-630 mm × 280 mm | 0 | -1.PP_SO-102 | 3000 | Fáze 2 | ODA 17 | 3048 | 3048 | 265.563 | 0.0652489 | 315 | 250 | 0.348832 | 315 | 315 | 250 | 140 | 0 | 220 | 630 | 630 | 630 × 500-630 × 280 | 500 | 280 | TA00.06.0382 | 0382 | yes | 0 | 0 | 1 | 1 | 1 | 1 | 4.4 | 4.4 | 19.36 | 4.4 | 265.563 | 60.3553 | Qto_DuctFittingBaseQuantities - Length: 630 mm; GrossCrossSectionArea: 0.10357 m2; NetCrossSectionArea: 0.10357 m2; OuterSurfaceArea: 0.853579 m2
13817255 | -1.PP_SO-102 | 800 mm × 500 mm-630 mm × 280 mm | 0 | 800 mm × 500 mm-630 mm × 280 mm | 0 | -1.PP_SO-102 | 3000 | Fáze 2 | ODA 17 | 3048 | 3048 | 265.563 | 0.0748801 | 400 | 250 | 0.396173 | 400 | 315 | 250 | 140 | 170 | 220 | 800 | 630 | 800 × 500-630 × 280 | 500 | 280 | TA00.06.0383 | 0383 | yes | 0 | 0 | 3.4 | 3.4 | 11.56 | 3.4 | 4.4 | 4.4 | 19.36 | 4.4 | 265.563 | 205.208
13853630 | -1.PP_SO-102 | 1500 mm × 710 mm-1500 mm × 560 mm | 0 | 1500 mm × 710 mm-1500 mm × 560 mm | 0 | -1.PP_SO-102 | 2400 | Fáze 1 | ODA 8 | 3048 | 3048 | 181.066 | 0.172465 | 750 | 280 | 0.816526 | 750 | 750 | 280 | 355 | 0 | 150 | 1500 | 1500 | 1500 × 710-1500 × 560 | 560 | 710 | TA00.06.0440 | 0440 | yes | 0 | 0 | 1 | 1 | 1 | 1 | 3 | 3 | 9 | 3 | 181.066 | 60.3553 | Qto_DuctFittingBaseQuantities - Length: 1500 mm; GrossCrossSectionArea: 0.114977 m2; NetCrossSectionArea: 0.114977 m2; OuterSurfaceArea: 2.49295 m2
13853631 | -1.PP_SO-102 | 1200 mm × 900 mm-1250 mm × 560 mm | 0 | 1200 mm × 900 mm-1250 mm × 560 mm | 0 | -1.PP_SO-102 | 2400 | Fáze 1 | ODA 8 | 3048 | 3048 | 410.416 | 0.366433 | 600 | 450 | 1.11855 | 600 | 625 | 450 | 280 | 50 | 340 | 1200 | 1250 | 1200 × 900-1250 × 560 | 900 | 560 | TA00.06.0441 | 0441 | yes | 0 | 0 | 1 | 1 | 1 | 1 | 6.8 | 6.8 | 46.24 | 6.8 | 410.416 | 60.3553
13853632 | -1.PP_SO-102 | 1200 mm × 900 mm-1250 mm × 560 mm | 0 | 1200 mm × 900 mm-1250 mm × 560 mm | 0 | -1.PP_SO-102 | 2400 | Fáze 1 | ODA 8 | 3048 | 3048 | 410.416 | 0.366433 | 600 | 450 | 1.11855 | 600 | 625 | 450 | 280 | 50 | 340 | 1200 | 1250 | 1200 × 900-1250 × 560 | 900 | 560 | TA00.06.0442 | 0442 | yes | 0 | 0 | 1 | 1 | 1 | 1 | 6.8 | 6.8 | 46.24 | 6.8 | 410.416 | 60.3553
13863136 | 2.NP_SO-102 | 2000 mm × 900 mm-1800 mm × 800 mm | 0 | 2000 mm × 900 mm-1800 mm × 800 mm | 14.9316 | 2.NP_SO-102 | 1809 | Fáze 1 | ODA 14 | 3048 | 3048 | 241.421 | 0.390298 | 900 | 400 | 1.38463 | 900 | 1000 | 400 | 450 | 200 | 100 | 1800 | 2000 | 2000 × 900-1800 × 800 | 800 | 900 | TA00.06.0448 | 0448 | yes | 0 | 0 | 4 | 4 | 16 | 4 | 2 | 2 | 4 | 2 | 120.711 | 241.421
13896743 | 2.NP_SO-102 | 1120 mm × 630 mm-560 mm × 315 mm | 0 | 1120 mm × 630 mm-560 mm × 315 mm | 10.594 | 2.NP_SO-102 | 2775 | Fáze 1 | ODA 7 | 3048 | 3048 | 675.98 | 0.278233 | 280 | 157.5 | 0.968786 | 280 | 560 | 157.5 | 315 | 560 | 315 | 560 | 1120 | 1120 × 630-560 × 315 | 315 | 630 | TA00.06.0627 | 0627 | yes | 0 | 0 | 11.2 | 11.2 | 125.44 | 11.2 | 6.3 | 6.3 | 39.69 | 6.3 | 380.239 | 675.98
13896867 | 2.NP_SO-102 | 1120 mm × 630 mm-1120 mm × 450 mm | 0 | 1120 mm × 630 mm-1120 mm × 450 mm | 21.4802 | 2.NP_SO-102 | 2775 | Fáze 1 | ODA 7 | 3048 | 3048 | 217.279 | 0.13141 | 560 | 225 | 0.614443 | 560 | 560 | 225 | 315 | 0 | 180 | 1120 | 1120 | 1120 × 630-1120 × 450 | 450 | 630 | TA00.06.0628 | 0628 | yes | 0 | 0 | 1 | 1 | 1 | 1 | 3.6 | 3.6 | 12.96 | 3.6 | 217.279 | 60.3553 | Qto_DuctFittingBaseQuantities - Length: 1120 mm; GrossCrossSectionArea: 0.117331 m2; NetCrossSectionArea: 0.117331 m2; OuterSurfaceArea: 1.73641 m2
13912340 | 1.NP_SO-102 | 500 mm × 400 mm-450 mm × 280 mm | 15 | 530 mm × 430 mm-480 mm × 310 mm | 0 | 1.NP_SO-102 | 2990.01 | Fáze 1 | ODA 25 | 3048 | 3048 | 144.853 | 0.0234662 | 250 | 200 | 0.178129 | 250 | 225 | 200 | 140 | 50 | 120 | 500 | 450 | 500 × 400-450 × 280 | 400 | 280 | TA00.06.0672 | 0672 | yes | 0 | 0 | 1 | 1 | 1 | 1 | 2.4 | 2.4 | 5.76 | 2.4 | 144.853 | 60.3553 | Izolace - Typ izolace: Protipožární; Fázování - Bouráno ve FÁZI 2: yes
13912448 | 2.NP_SO-102 | 500 mm × 400 mm-450 mm × 280 mm | 15 | 530 mm × 430 mm-480 mm × 310 mm | 0 | 2.NP_SO-102 | 3096.2 | Fáze 1 | ODA 25 | 3048 | 3048 | 144.853 | 0.0234662 | 250 | 200 | 0.178129 | 250 | 225 | 200 | 140 | 50 | 120 | 500 | 450 | 500 × 400-450 × 280 | 400 | 280 | TA00.06.0673 | 0673 | yes | 0 | 0 | 1 | 1 | 1 | 1 | 2.4 | 2.4 | 5.76 | 2.4 | 144.853 | 60.3553 | Izolace - Typ izolace: Protipožární; Fázování - Bouráno ve FÁZI 2: yes
13912512 | 3.NP_SO-102 | 500 mm × 400 mm-450 mm × 280 mm | 15 | 530 mm × 430 mm-480 mm × 310 mm | 0 | 3.NP_SO-102 | 3196.2 | Fáze 1 | ODA 25 | 3048 | 3048 | 144.853 | 0.0234662 | 250 | 200 | 0.178129 | 250 | 225 | 200 | 140 | 50 | 120 | 500 | 450 | 500 × 400-450 × 280 | 400 | 280 | TA00.06.0674 | 0674 | yes | 0 | 0 | 1 | 1 | 1 | 1 | 2.4 | 2.4 | 5.76 | 2.4 | 144.853 | 60.3553 | Izolace - Typ izolace: Protipožární; Fázování - Bouráno ve FÁZI 2: yes
13912785 | 4.NP_SO-102 | 575 mm × 425 mm-560 mm × 400 mm | 15 | 605 mm × 455 mm-590 mm × 430 mm | 0 | 4.NP_SO-102 | 3100 | Fáze 2 | ODA 21 | 3048 | 3048 | 30.1777 | 0.00706535 | 287.5 | 212.5 | 0.141339 | 287.5 | 280 | 212.5 | 200 | 15 | 25 | 575 | 560 | 575 × 425-560 × 400 | 425 | 400 | TA00.06.0676 | 0676 | yes | 0 | 0 | 0.3 | 0.3 | 0.09 | 0.3 | 0.5 | 0.5 | 0.25 | 0.5 | 30.1777 | 18.1066 | Izolace - Typ izolace: Protipožární
13912999 | 3.NP_SO-102 | 575 mm × 425 mm-560 mm × 400 mm | 15 | 605 mm × 455 mm-590 mm × 430 mm | 0 | 3.NP_SO-102 | 3095 | Fáze 2 | ODA 21 | 3048 | 3048 | 30.1777 | 0.00706535 | 287.5 | 212.5 | 0.141339 | 287.5 | 280 | 212.5 | 200 | 15 | 25 | 575 | 560 | 575 × 425-560 × 400 | 425 | 400 | TA00.06.0678 | 0678 | yes | 0 | 0 | 0.3 | 0.3 | 0.09 | 0.3 | 0.5 | 0.5 | 0.25 | 0.5 | 30.1777 | 18.1066 | Izolace - Typ izolace: Protipožární
13913209 | 2.NP_SO-102 | 575 mm × 425 mm-560 mm × 400 mm | 15 | 605 mm × 455 mm-590 mm × 430 mm | 0 | 2.NP_SO-102 | 2775 | Fáze 2 | ODA 21 | 3048 | 3048 | 30.1777 | 0.00706535 | 287.5 | 212.5 | 0.141339 | 287.5 | 280 | 212.5 | 200 | 15 | 25 | 575 | 560 | 575 × 425-560 × 400 | 425 | 400 | TA00.06.0680 | 0680 | yes | 0 | 0 | 0.3 | 0.3 | 0.09 | 0.3 | 0.5 | 0.5 | 0.25 | 0.5 | 30.1777 | 18.1066 | Izolace - Typ izolace: Protipožární
13917256 | -1.PP_SO-102 | 400 mm × 400 mm-250 mm × 400 mm | 0 | 400 mm × 400 mm-250 mm × 400 mm | 0 | -1.PP_SO-102 | -715.801 | Fáze 1 | ODA 12 | 3048 | 3048 | 181.066 | 0.0235386 | 125 | 200 | 0.163043 | 125 | 200 | 200 | 200 | 150 | 0 | 250 | 400 | 400 × 400-250 × 400 | 400 | 400 | TA00.06.0699 | 0699 | yes | 0 | 0 | 3 | 3 | 9 | 3 | 1 | 1 | 1 | 1 | 60.3553 | 181.066 | Qto_DuctFittingBaseQuantities - Length: 400 mm; GrossCrossSectionArea: 0.0588465 m2; NetCrossSectionArea: 0.0588465 m2; OuterSurfaceArea: 0.416788 m2
13918531 | 2.NP_SO-102 | 710 mm × 560 mm-315 mm × 560 mm | 15 | 740 mm × 590 mm-345 mm × 590 mm | 0 | 2.NP_SO-102 | 1919.76 | Fáze 2 | ODA 21 | 3048 | 3048 | 476.807 | 0.136844 | 157.5 | 280 | 0.53237 | 157.5 | 355 | 280 | 280 | 395 | 0 | 315 | 710 | 710 × 560-315 × 560 | 560 | 560 | TA00.06.0703 | 0703 | yes | 0 | 0 | 7.9 | 7.9 | 62.41 | 7.9 | 1 | 1 | 1 | 1 | 60.3553 | 476.807 | Qto_DuctFittingBaseQuantities - Length: 560 mm; GrossCrossSectionArea: 0.244364 m2; NetCrossSectionArea: 0.244364 m2; OuterSurfaceArea: 1.15202 m2; Izolace - Typ izolace: Protipožární
13968543 | -1.PP_SO-102 | 2400 mm × 1100 mm-1600 mm × 560 mm | 0 | 2400 mm × 1100 mm-1600 mm × 560 mm | 0 | -1.PP_SO-102 | 829 | Fáze 1 | ODA 8 | 3048 | 2778 | 965.685 | 1.6378 | 1200 | 280 | 3.42691 | 1200 | 800 | 550 | 280 | 800 | 540 | 2400 | 1600 | 2400 × 1100-1600 × 560 | 1100 | 560 | TA00.06.0854 | 0854 | yes | 270 | 0 | 16 | 16 | 256 | 16 | 21.6 | 0 | 116.64 | 10.8 | 540 | 965.685
13992395 | 4.NP_SO-102 | 800 mm × 800 mm-500 mm × 450 mm | 0 | 800 mm × 800 mm-500 mm × 450 mm | 0 | STŘECHA_SO-102 | 1000 | Fáze 1 | ODA 10 | 3048 | 3048 | 422.487 | 0.175332 | 400 | 400 | 0.642282 | 400 | 250 | 400 | 225 | 300 | 350 | 800 | 500 | 800 × 800-500 × 450 | 800 | 450 | TA00.06.0907 | 0907 | yes | 0 | 0 | 6 | 6 | 36 | 6 | 7 | 7 | 49 | 7 | 422.487 | 362.132
14066239 | -1.PP_SO-102 | 280 mm × 400 mm-250 mm × 400 mm | 15 | 310 mm × 430 mm-280 mm × 430 mm | 0 | -1.PP_SO-102 | 2208.79 | Fáze 1 | ODA 12 | 3048 | 3048 | 36.2132 | 0.0038386 | 125 | 200 | 0.0704359 | 125 | 140 | 200 | 200 | 30 | 0 | 250 | 280 | 280 × 400-250 × 400 | 400 | 400 | TA00.06.1125 | 1125 | yes | 0 | 0 | 0.6 | 0.6 | 0.36 | 0.6 | 1 | 1 | 1 | 1 | 60.3553 | 36.2132 | Qto_DuctFittingBaseQuantities - Length: 400 mm; GrossCrossSectionArea: 0.0095965 m2; NetCrossSectionArea: 0.0095965 m2; OuterSurfaceArea: 0.243358 m2; Izolace - Typ izolace: Protipožární
14067628 | 4.NP_SO-102 | 1000 mm × 500 mm-710 mm × 630 mm | 15 | 1030 mm × 530 mm-740 mm × 660 mm | 0 | 4.NP_SO-102 | -1398.09 | Fáze 1 | ODA 12 | 3048 | 3048 | 350.061 | 0.168006 | 355 | 315 | 0.645725 | 355 | 500 | 315 | 250 | 290 | 130 | 710 | 1000 | 1000 × 500-710 × 630 | 630 | 500 | TA00.06.1127 | 1127 | yes | 0 | 0 | 5.8 | 5.8 | 33.64 | 5.8 | 2.6 | 2.6 | 6.76 | 2.6 | 156.924 | 350.061 | Izolace - Typ izolace: Protipožární
14067814 | -1.PP_SO-102 | 710 mm × 450 mm-710 mm × 400 mm | 15 | 740 mm × 480 mm-740 mm × 430 mm | 0 | -1.PP_SO-102 | 2955 | Fáze 1 | ODA 12 | 3048 | 3058.03 | 58.9026 | 0.0177738 | 355 | 235.031 | 0.206178 | 355 | 355 | 225 | 200 | 0 | 50 | 710 | 710 | 710 × 450-710 × 400 | 450 | 400 | TA00.06.1129 | 1129 | yes | 10.0308 | 0 | 1 | 1 | 1 | 1 | 1.40123 | 0.598769 | 1 | 1 | 58.9026 | 60.3553 | Qto_DuctFittingBaseQuantities - Length: 710 mm; GrossCrossSectionArea: 0.0250336 m2; NetCrossSectionArea: 0.0250336 m2; OuterSurfaceArea: 0.695308 m2; Izolace - Typ izolace: Protipožární
14121218 | 1.NP_SO-102 | 800 mm × 450 mm-710 mm × 400 mm | 15 | 830 mm × 480 mm-740 mm × 430 mm | 0 | 1.NP_SO-102 | 2246.64 | Fáze 1 | ODA 12 | 3048 | 3048 | 108.64 | 0.0349005 | 355 | 200 | 0.269083 | 355 | 400 | 200 | 225 | 90 | 50 | 710 | 800 | 800 × 450-710 × 400 | 400 | 450 | TA00.06.1270 | 1270 | yes | 0 | 0 | 1.8 | 1.8 | 3.24 | 1.8 | 1 | 1 | 1 | 1 | 60.3553 | 108.64 | Izolace - Typ izolace: Protipožární
14121221 | 2.NP_SO-102 | 1000 mm × 500 mm-800 mm × 450 mm | 15 | 1030 mm × 530 mm-830 mm × 480 mm | 0 | 2.NP_SO-102 | 2379.35 | Fáze 1 | ODA 12 | 2948 | 3048 | 200 | 0.0856667 | 300 | 225 | 0.453038 | 400 | 500 | 225 | 250 | 200 | 50 | 800 | 1000 | 1000 × 500-800 × 450 | 450 | 500 | TA00.06.1271 | 1271 | yes | 0 | 100 | 8 | 0 | 16 | 4 | 1 | 1 | 1 | 1 | 60.3553 | 200 | Izolace - Typ izolace: Protipožární
14127339 | 1.NP_SO-102 | 575 mm × 425 mm-560 mm × 400 mm | 15 | 605 mm × 455 mm-590 mm × 430 mm | 0 | 1.NP_SO-102 | 3120 | Fáze 2 | ODA 21 | 3048 | 3048 | 30.1777 | 0.00706535 | 287.5 | 212.5 | 0.141339 | 287.5 | 280 | 212.5 | 200 | 15 | 25 | 575 | 560 | 575 × 425-560 × 400 | 425 | 400 | TA00.06.1299 | 1299 | yes | 0 | 0 | 0.3 | 0.3 | 0.09 | 0.3 | 0.5 | 0.5 | 0.25 | 0.5 | 30.1777 | 18.1066 | Izolace - Typ izolace: Protipožární
14127341 | -1.PP_SO-102 | 575 mm × 425 mm-560 mm × 400 mm | 15 | 605 mm × 455 mm-590 mm × 430 mm | 0 | -1.PP_SO-102 | 3120 | Fáze 2 | ODA 21 | 3048 | 3048 | 30.1777 | 0.00706535 | 287.5 | 212.5 | 0.141339 | 287.5 | 280 | 212.5 | 200 | 15 | 25 | 575 | 560 | 575 × 425-560 × 400 | 425 | 400 | TA00.06.1300 | 1300 | yes | 0 | 0 | 0.3 | 0.3 | 0.09 | 0.3 | 0.5 | 0.5 | 0.25 | 0.5 | 30.1777 | 18.1066 | Izolace - Typ izolace: Protipožární
14145808 | 2.NP_SO-102 | 1500 mm × 900 mm-1600 mm × 400 mm | 0 | 1500 mm × 900 mm-1600 mm × 400 mm | 53.1564 | 2.NP_SO-102 | 2543.58 | Fáze 1 | ODA 6 | 3048 | 3048 | 603.553 | 0.605565 | 750 | 450 | 1.66837 | 750 | 800 | 450 | 200 | 100 | 500 | 1500 | 1600 | 1500 × 900-1600 × 400 | 900 | 400 | TA00.06.1336 | 1336 | yes | 0 | 0 | 2 | 2 | 4 | 2 | 10 | 10 | 100 | 10 | 603.553 | 120.711
14146295 | 2.NP_SO-102 | 1800 mm × 800 mm-900 mm × 400 mm | 0 | 1800 mm × 800 mm-900 mm × 400 mm | 11.2921 | 2.NP_SO-102 | 1559 | Fáze 1 | ODA 3 | 3048 | 3248 | 1086.4 | 0.912573 | 900 | 600 | 2.28173 | 900 | 450 | 400 | 200 | 900 | 400 | 1800 | 900 | 1800 × 800-900 × 400 | 800 | 400 | TA00.06.1340 | 1340 | yes | 200 | 0 | 18 | 18 | 324 | 18 | 16 | 0 | 64 | 8 | 400 | 1086.4
14155817 | 4.NP_SO-102 | 450 mm × 500 mm-500 mm × 450 mm | 0 | 450 mm × 500 mm-500 mm × 450 mm | 0 | 4.NP_SO-102 | 5090 | Fáze 1 | ODA 25 | 3048 | 3048 | 60.3553 | 0.0136051 | 225 | 250 | 0.157865 | 225 | 250 | 250 | 225 | 50 | 50 | 450 | 500 | 450 × 500-500 × 450 | 500 | 450 | TA00.06.1375 | 1375 |  | 0 | 0 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 1 | 60.3553 | 60.3553 | Fázování - Bouráno ve FÁZI 2: yes
14156070 | 4.NP_SO-102 | 710 mm × 630 mm-630 mm × 630 mm | 0 | 710 mm × 630 mm-630 mm × 630 mm | 0 | STŘECHA_SO-102 | 1240 | Fáze 1 | ODA 25 | 3048 | 3048 | 96.5685 | 0.0407616 | 315 | 315 | 0.308676 | 315 | 355 | 315 | 315 | 80 | 0 | 630 | 710 | 710 × 630-630 × 630 | 630 | 630 | TA00.06.1377 | 1377 | yes | 0 | 0 | 1.6 | 1.6 | 2.56 | 1.6 | 1 | 1 | 1 | 1 | 60.3553 | 96.5685 | Qto_DuctFittingBaseQuantities - Length: 630 mm; GrossCrossSectionArea: 0.0647009 m2; NetCrossSectionArea: 0.0647009 m2; OuterSurfaceArea: 0.975902 m2
14156186 | 4.NP_SO-102 | 800 mm × 800 mm-500 mm × 450 mm | 0 | 800 mm × 800 mm-500 mm × 450 mm | 0 | STŘECHA_SO-102 | 1240 | Fáze 1 | ODA 25 | 3048 | 3048 | 422.487 | 0.175332 | 400 | 400 | 0.642282 | 400 | 250 | 400 | 225 | 300 | 350 | 800 | 500 | 800 × 800-500 × 450 | 800 | 450 | TA00.06.1378 | 1378 | yes | 0 | 0 | 6 | 6 | 36 | 6 | 7 | 7 | 49 | 7 | 422.487 | 362.132 | Fázování - Bouráno ve FÁZI 2: yes
14158267 | 4.NP_SO-102 | 1000 mm × 560 mm-630 mm × 710 mm | 15 | 1030 mm × 590 mm-660 mm × 740 mm | 0 | 4.NP_SO-102 | 1174.3 | Fáze 1 | ODA 12 | 3048 | 2893 | 362.132 | 0.185738 | 500 | 125 | 0.692581 | 500 | 315 | 280 | 355 | 370 | 150 | 1000 | 630 | 1000 × 560-630 × 710 | 560 | 710 | TA00.06.1381 | 1381 | yes | 155 | 0 | 7.4 | 7.4 | 54.76 | 7.4 | 9.2 | -3.2 | 9 | 3 | 362.132 | 362.132 | Izolace - Typ izolace: Protipožární
14158271 | 4.NP_SO-102 | 1000 mm × 560 mm-1000 mm × 400 mm | 15 | 1030 mm × 590 mm-1030 mm × 430 mm | 0 | 4.NP_SO-102 | 4385 | Fáze 1 | ODA 12 | 3048 | 3048 | 193.137 | 0.0927058 | 500 | 200 | 0.487446 | 500 | 500 | 200 | 280 | 0 | 160 | 1000 | 1000 | 1000 × 560-1000 × 400 | 400 | 560 | TA00.06.1382 | 1382 | yes | 0 | 0 | 1 | 1 | 1 | 1 | 3.2 | 3.2 | 10.24 | 3.2 | 193.137 | 60.3553 | Qto_DuctFittingBaseQuantities - Length: 1000 mm; GrossCrossSectionArea: 0.0927058 m2; NetCrossSectionArea: 0.0927058 m2; OuterSurfaceArea: 1.3781 m2; Izolace - Typ izolace: Protipožární
14158500 | 4.NP_SO-102 | 1120 mm × 630 mm-1000 mm × 630 mm | 0 | 1120 mm × 630 mm-1000 mm × 630 mm | 0 | 4.NP_SO-102 | 5650 | Fáze 1 | ODA 12 | 3048 | 3048 | 144.853 | 0.0967327 | 560 | 315 | 0.536832 | 560 | 500 | 315 | 315 | 120 | 0 | 1120 | 1000 | 1120 × 630-1000 × 630 | 630 | 630 | TA00.06.1383 | 1383 | yes | 0 | 0 | 2.4 | 2.4 | 5.76 | 2.4 | 1 | 1 | 1 | 1 | 60.3553 | 144.853 | Qto_DuctFittingBaseQuantities - Length: 630 mm; GrossCrossSectionArea: 0.153544 m2; NetCrossSectionArea: 0.153544 m2; OuterSurfaceArea: 1.53315 m2
14159390 | 4.NP_SO-102 | 800 mm × 800 mm-400 mm × 1120 mm | 0 | 800 mm × 800 mm-400 mm × 1120 mm | 0 | STŘECHA_SO-102 | 1250 | Fáze 1 | ODA 12 | 3048 | 3048 | 482.843 | 0.272967 | 200 | 560 | 0.820312 | 200 | 400 | 560 | 400 | 400 | 320 | 400 | 800 | 800 × 800-400 × 1120 | 1120 | 800 | TA00.06.1387 | 1387 | yes | 0 | 0 | 8 | 8 | 64 | 8 | 6.4 | 6.4 | 40.96 | 6.4 | 386.274 | 482.843

# IfcDuctFitting: M_Hranatý přechod, úhel:45 stupňů (18)
Type - Material: 128-64-0
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Cena: 100; Číslo OmniClass: 23.75.70.14; ID kategorie: R; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 06; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; MJ: ks; Název rodiny: M_Hranatý přechod, úhel
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Grafika - Použít měřítko poznámky: yes
Jiné - Typ: 45 stupňů; Id typu: 1559788; Rodina: M_Hranatý přechod, úhel; Rodina a typ: M_Hranatý přechod, úhel: 45 stupňů
Name (M_Hranatý přechod, úhel:45 stupňů:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Šířkové odsazení (mm) | Rozdíl výšek (mm) | Výškové odsazení (mm) | Délka potrubí (mm) = Max. rozdíl (mm) = Vypočítaná délka (mm) | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Poloviční šířka 1 (mm) | Poloviční šířka 2 (mm) | Poloviční výška 1 (mm) | Poloviční výška 2 (mm) | Rozdíl šířek (mm) | Šířka potrubí 1 (mm) | Šířka potrubí 2 (mm) | Velikost | Výška potrubí 1 (mm) | Výška potrubí 2 (mm) | Kód prvku | Označení | Páteřní trasa | Delta 2 (mm) | Delta 1 (mm) | Čís.5 | Čís.6 | Čís.7 | Čís.8 | Čís.1 | Čís.2 | Čís.3 | Čís.4 | Délka 1 (mm) | Délka 2 (mm)
13651152 | -1.PP_SO-102 | 500 | 0.146724 | 0.937116 | 800 mm × 500 mm-630 mm × 500 mm | 0 | 800 mm × 500 mm-630 mm × 500 mm | 0 | -1.PP_SO-102 | 2930 | Fáze 2 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | 3048 | 0 | 3048 | 205.208 | 0.0733619 | 400 | 250 | 0.381003 | 400 | 315 | 250 | 250 | 170 | 800 | 630 | 800 × 500-630 × 500 | 500 | 500 | TA00.06.0172 | 0172 | yes | 0 | 0 | 1 | 1 | 1 | 1 | 3.4 | 3.4 | 11.56 | 3.4 | 60.3553 | 205.208
13697844 | -1.PP_SO-102 | 500 | 0.482843 | 1.52263 | 1200 mm × 500 mm-800 mm × 500 mm | 0 | 1200 mm × 500 mm-800 mm × 500 mm | 0 | -1.PP_SO-102 | 1296.84 | Fáze 2 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | 3048 | 0 | 3048 | 482.843 | 0.241421 | 400 | 250 | 0.863499 | 400 | 600 | 250 | 250 | 400 | 800 | 1200 | 1200 × 500-800 × 500 | 500 | 500 | TA00.06.0176 | 0176 | yes | 0 | 0 | 1 | 1 | 1 | 1 | 8 | 8 | 64 | 8 | 60.3553 | 482.843
13697872 | -1.PP_SO-102 | 500 | 0.482843 | 1.52263 | 1200 mm × 500 mm-800 mm × 500 mm | 0 | 1200 mm × 500 mm-800 mm × 500 mm | 0 | -1.PP_SO-102 | 1996.84 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 17 | ODA | 3048 | 0 | 3048 | 482.843 | 0.241421 | 400 | 250 | 0.863499 | 400 | 600 | 250 | 250 | 400 | 800 | 1200 | 1200 × 500-800 × 500 | 500 | 500 | TA00.06.0178 | 0178 | yes | 0 | 0 | 1 | 1 | 1 | 1 | 8 | 8 | 64 | 8 | 60.3553 | 482.843
13787065 | -1.PP_SO-102 | 710 | 0.0267978 | 1.61331 | 710 mm × 1120 mm-710 mm × 1100 mm | 0 | 710 mm × 1120 mm-710 mm × 1100 mm | 0 | -1.PP_SO-102 | -471 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 11 | EHA | 3048 | 20 | 3048 | 24.1421 | 0.0190264 | 355 | 550 | 0.425296 | 355 | 355 | 550 | 560 | 0 | 710 | 710 | 710 × 1120-710 × 1100 | 1100 | 1120 | TA00.06.0295 | 0295 | yes | 0 | 0 | 0.4 | 0.4 | 0.16 | 0.4 | 1 | 1 | 1 | 1 | 24.1421 | 60.3553
13823015 | 2.NP_SO-102 | 1600 | 0.142982 | 2.60963 | 1600 mm × 630 mm-1600 mm × 400 mm | 0 | 1600 mm × 630 mm-1600 mm × 400 mm | 0 | 2.NP_SO-102 | 2650 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 8 | EHA | 3048 | 230 | 3048 | 277.635 | 0.228771 | 800 | 315 | 0.946006 | 800 | 800 | 315 | 200 | 0 | 1600 | 1600 | 1600 × 630-1600 × 400 | 630 | 400 | TA00.06.0394 | 0394 | yes | 0 | 0 | 4.6 | 4.6 | 21.16 | 4.6 | 1 | 1 | 1 | 1 | 277.635 | 60.3553
13855116 | 2.NP_SO-102 |  |  |  | 1500 mm × 900 mm-1600 mm × 400 mm | 0 | 1500 mm × 900 mm-1600 mm × 400 mm | 0 | 2.NP_SO-102 | 2650 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 8 | EHA | 3048 | 500 | 3048 | 603.553 | 0.605565 | 800 | 200 | 1.66837 | 800 | 750 | 200 | 450 | 100 | 1600 | 1500 | 1500 × 900-1600 × 400 | 400 | 900 | TA00.06.0445 | 0445 | yes | 0 | 0 | 10 | 10 | 100 | 10 | 2 | 2 | 4 | 2 | 603.553 | 120.711
13896990 | 2.NP_SO-102 | 450 | 0.0267978 | 1.02252 | 1120 mm × 450 mm-1100 mm × 450 mm | 0 | 1120 mm × 450 mm-1100 mm × 450 mm | 0 | 2.NP_SO-102 | 384 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 5 | EHA | 3048 | 0 | 3048 | 24.1421 | 0.012059 | 550 | 225 | 0.282427 | 550 | 560 | 225 | 225 | 20 | 1100 | 1120 | 1120 × 450-1100 × 450 | 450 | 450 | TA00.06.0629 | 0629 | yes | 0 | 0 | 1 | 1 | 1 | 1 | 0.4 | 0.4 | 0.16 | 0.4 | 60.3553 | 24.1421
13897143 | 2.NP_SO-102 | 600 | 0.15405 | 1.61031 | 1250 mm × 600 mm-1120 mm × 600 mm | 0 | 1250 mm × 600 mm-1120 mm × 600 mm | 0 | 2.NP_SO-102 | 2700 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 5 | EHA | 3113 | 0 | 3048 | 130 | 0.09243 | 690 | 300 | 0.556627 | 625 | 560 | 300 | 300 | 130 | 1250 | 1120 | 1250 × 600-1120 × 600 | 600 | 600 | TA00.06.0631 | 0631 | yes | 0 | 65 | 1 | 1 | 1 | 1 | 5.2 | 0 | 6.76 | 2.6 | 60.3553 | 130
13919410 | -1.PP_SO-102 |  |  |  | 630 mm × 500 mm-500 mm × 630 mm | 0 | 630 mm × 500 mm-500 mm × 630 mm | 0 | -1.PP_SO-102 | 3335 | Fáze 2 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | 3048 | 130 | 3048 | 156.924 | 0.049873 | 315 | 250 | 0.297798 | 315 | 250 | 250 | 315 | 130 | 630 | 500 | 630 × 500-500 × 630 | 500 | 630 | TA00.06.0707 | 0707 | yes | 0 | 0 | 2.6 | 2.6 | 6.76 | 2.6 | 2.6 | 2.6 | 6.76 | 2.6 | 156.924 | 156.924
13965779 | -1.PP_SO-102 |  |  |  | 1250 mm × 710 mm-1400 mm × 500 mm | 0 | 1250 mm × 710 mm-1400 mm × 500 mm |  | -1.PP_SO-102 | 2300 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 17 | EHA | 3048 | 210 | 3048 | 253.492 | 0.20254 | 700 | 250 | 0.826557 | 700 | 625 | 250 | 355 | 150 | 1400 | 1250 | 1250 × 710-1400 × 500 | 500 | 710 | TA00.06.0838 | 0838 | yes | 0 | 0 | 4.2 | 4.2 | 17.64 | 4.2 | 3 | 3 | 9 | 3 | 253.492 | 181.066
14009394 | 2.NP_SO-102 | 1800 | 0.0820229 | 3.14133 | 1800 mm × 800 mm-1800 mm × 710 mm | 0 | 1800 mm × 800 mm-1800 mm × 710 mm | 0 | 2.NP_SO-102 | 2650 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 13 | EHA | 3048 | 90 | 3048 | 108.64 | 0.147641 | 900 | 400 | 0.924119 | 900 | 900 | 400 | 355 | 0 | 1800 | 1800 | 1800 × 800-1800 × 710 | 800 | 710 | TA00.06.0951 | 0951 | yes | 0 | 0 | 1.8 | 1.8 | 3.24 | 1.8 | 1 | 1 | 1 | 1 | 108.64 | 60.3553
14115957 | -1.PP_SO-102 |  |  |  | 630 mm × 500 mm-800 mm × 355 mm | 15 | 660 mm × 530 mm-830 mm × 385 mm | 0 | -1.PP_SO-102 | 2930 | Fáze 2 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | 3048 | 145 | 3048 | 205.208 | 0.0623029 | 400 | 177.5 | 0.348395 | 400 | 315 | 177.5 | 250 | 170 | 800 | 630 | 630 × 500-800 × 355 | 355 | 500 | TA00.06.1224 | 1224 | yes | 0 | 0 | 2.9 | 2.9 | 8.41 | 2.9 | 3.4 | 3.4 | 11.56 | 3.4 | 175.03 | 205.208 | Izolace - Typ izolace: Protipožární
14119824 | 2.NP_SO-102 | 2400 | 0.490749 | 7.09961 | 2400 mm × 1100 mm-2400 mm × 630 mm | 0 | 2400 mm × 1100 mm-2400 mm × 630 mm |  | 2.NP_SO-102 | 2109 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 19 | EHA | 3048 | 470 | 3048 | 567.34 | 1.1778 | 1200 | 315 | 2.70108 | 1200 | 1200 | 315 | 550 | 0 | 2400 | 2400 | 2400 × 1100-2400 × 630 | 630 | 1100 | TA00.06.1253 | 1253 | yes | 0 | 0 | 9.4 | 9.4 | 88.36 | 9.4 | 1 | 1 | 1 | 1 | 567.34 | 60.3553
14155699 | 4.NP_SO-102 |  |  |  | 800 mm × 800 mm-710 mm × 630 mm | 0 | 800 mm × 800 mm-710 mm × 630 mm | 0 | 4.NP_SO-102 | 4900 | Fáze 1 | Znehodnocený | Přívod vzduchu | EHA 3 | EHA | 3048 | 170 | 3048 | 205.208 | 0.111038 | 355 | 315 | 0.508245 | 355 | 400 | 315 | 400 | 90 | 710 | 800 | 800 × 800-710 × 630 | 630 | 800 | TA00.06.1372 | 1372 | yes | 0 | 0 | 3.4 | 3.4 | 11.56 | 3.4 | 1.8 | 1.8 | 3.24 | 1.8 | 205.208 | 108.64
14184346 | 2.NP_SO-102 |  |  |  | 1250 mm × 600 mm-560 mm × 315 mm | 0 | 1250 mm × 600 mm-560 mm × 315 mm | 0 | 2.NP_SO-102 | 2700 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 5 | EHA | 2703 | 285 | 3048 | 690 | 0.296993 | 280 | 300 | 1.05317 | 625 | 280 | 300 | 157.5 | 690 | 1250 | 560 | 1250 × 600-560 × 315 | 600 | 315 | TA00.06.1506 | 1506 |  | 0 | 345 | 5.7 | 5.7 | 32.49 | 5.7 | 27.6 | 0 | 190.44 | 13.8 | 344.025 | 690
14188788 | 4.NP_SO-102 | 500 | 0.49875 | 1.84749 | 500 mm × 1600 mm-500 mm × 1250 mm | 0 | 500 mm × 1600 mm-500 mm × 1250 mm | 0 | 4.NP_SO-102 | 4174.33 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 1 | EHA | 3048 | 350 | 2873 | 350 | 0.249375 | 250 | 625 | 0.827197 | 250 | 250 | 800 | 625 | 0 | 500 | 500 | 500 × 1600-500 × 1250 | 1600 | 1250 | TA00.06.1514 | 1514 |  | 175 | 0 | 14 | 0 | 49 | 7 | 1 | 1 | 1 | 1 | 350 | 60.3553
14194075 | 2.NP_SO-102 |  |  |  | 1800 mm × 710 mm-1600 mm × 500 mm | 0 | 1800 mm × 710 mm-1600 mm × 500 mm | 0 | 2.NP_SO-102 | 2650 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 13 | EHA | 3048 | 210 | 3048 | 253.492 | 0.261604 | 900 | 355 | 1.05062 | 900 | 800 | 355 | 250 | 200 | 1800 | 1600 | 1800 × 710-1600 × 500 | 710 | 500 | TA00.06.1528 | 1528 |  | 0 | 0 | 4.2 | 4.2 | 17.64 | 4.2 | 4 | 4 | 16 | 4 | 253.492 | 241.421
14194087 | 2.NP_SO-102 |  |  |  | 1500 mm × 900 mm-1600 mm × 500 mm | 0 | 1500 mm × 900 mm-1600 mm × 500 mm | 0 | 2.NP_SO-102 | 2650 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 8 | EHA | 3048 | 400 | 3048 | 482.843 | 0.522275 | 750 | 450 | 1.48664 | 750 | 800 | 450 | 250 | 100 | 1500 | 1600 | 1500 × 900-1600 × 500 | 900 | 500 | TA00.06.1529 | 1529 |  | 0 | 0 | 8 | 8 | 64 | 8 | 2 | 2 | 4 | 2 | 482.843 | 120.711

# IfcDuctFitting: M_Hranatý přechod, úhel:45 stupňů (66)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Cena: 100; Číslo OmniClass: 23.75.70.14; ID kategorie: R; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 06; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; MJ: ks; Název rodiny: M_Hranatý přechod, úhel
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Grafika - Použít měřítko poznámky: yes
Jiné - Typ: 45 stupňů; Id typu: 1559788; Rodina: M_Hranatý přechod, úhel; Rodina a typ: M_Hranatý přechod, úhel: 45 stupňů
