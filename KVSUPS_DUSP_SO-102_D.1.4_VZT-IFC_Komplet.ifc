Properties of the parts of a building model (IFC4), part 21 of 45

# IfcBuildingElementProxy: Tlumič hluku kruhový.LH:Průměr × Délka (2)
Identifikační data - Komentáře: VZT 28
Jiné - Páteřní trasa: yes; Id typu: 13544592; Rodina: Tlumič hluku kruhový.LH; Rodina a typ: Tlumič hluku kruhový.LH: Průměr × Délka; Typ: Průměr × Délka
Name (Tlumič hluku kruhový.LH:Průměr × Délka:...) | Kód prvku | Označení
13629073 | TC02.02.0005 | 0005
13629092 | TC02.02.0006 | 0006

# IfcBuildingElementProxy: Uzavírací klapka hranatá.LH:1000x400, Uzavírací klapka hranatá.LH:1000x400:14145874
In: 2.NP_SO-102
Type - Material: 0-128-64
Type - Požární ochrana - Požární odolnost: A1
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 250 mm; Jmenovitá velikost vstupu: 1250 mm; Jmenovitá velikost vstupu - šířka: 1000 mm; Jmenovitá velikost vstupu - výška: 400 mm; Jmenovitá velikost výstupu: 560 mm; Jmenovitá velikost výstupu - šířka: 1000 mm; Jmenovitá velikost výstupu - výška: 400 mm; Šířka: 1000 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 400 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: UK; Kód sestavy: LV02; Nadpis OmniClass: Guide Vanes; Název typu: 1000x400; Označení typu: 70; Popis: Uzavírací klapka hranatá; Popis sestavy: Uzavírací
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Uzavírací klapka hranatá.LH
Classification: LV02 Uniformat (Uniformat); Group: ODA 14
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.42 m2; NetVolume: 0.104725 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1000 mm × 400 mm-1000 mm × 400 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1000 mm × 400 mm-1000 mm × 400 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 2.94444 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Připojení ELEKTRO: no; Připojení MaR: no; Výška od podlaží: 2750 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Název systému: ODA 14; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.104725 m3; Plocha: 1.8064 m2; Velikost: 1000 × 400-1000 × 400
Identifikační data - Kód prvku: LV02.70.0461; Označení: 0461
Jiné - Páteřní trasa: yes; Rodina: Uzavírací klapka hranatá.LH; Typ: 1000x400; Id typu: 14145567; Rodina a typ: Uzavírací klapka hranatá.LH: 1000x400

# IfcBuildingElementProxy: Uzavírací klapka hranatá.LH:1250x560, Uzavírací klapka hranatá.LH:1250x560:13854742
In: -1.PP_SO-102
Type - Material: 0-128-64
Type - Požární ochrana - Požární odolnost: A1
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 250 mm; Jmenovitá velikost vstupu: 1250 mm; Jmenovitá velikost vstupu - šířka: 1250 mm; Jmenovitá velikost vstupu - výška: 560 mm; Jmenovitá velikost výstupu: 560 mm; Jmenovitá velikost výstupu - šířka: 1250 mm; Jmenovitá velikost výstupu - výška: 560 mm; Šířka: 1250 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 560 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: UK; Kód sestavy: LV02; Nadpis OmniClass: Guide Vanes; Název typu: 1250x560; Označení typu: 36; Popis: Uzavírací klapka hranatá; Popis sestavy: Uzavírací
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Uzavírací klapka hranatá.LH
Classification: LV02 Uniformat (Uniformat); Group: ODA 8
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.5152 m2; NetVolume: 0.18293 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1250 mm × 560 mm-1250 mm × 560 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1250 mm × 560 mm-1250 mm × 560 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 4 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Připojení ELEKTRO: no; Připojení MaR: no; Výška od podlaží: 2400 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Název systému: ODA 8; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.18293 m3; Plocha: 2.874 m2; Velikost: 1250 × 560-1250 × 560
Identifikační data - Kód prvku: LV02.36.0128; Označení: 0128
Jiné - Páteřní trasa: yes; Rodina: Uzavírací klapka hranatá.LH; Typ: 1250x560; Id typu: 13854691; Rodina a typ: Uzavírací klapka hranatá.LH: 1250x560

# IfcBuildingElementProxy: Uzavírací klapka hranatá.LH:1600x400, Uzavírací klapka hranatá.LH:1600x400:14145825
In: 2.NP_SO-102
Type - Material: 0-128-64
Type - Požární ochrana - Požární odolnost: A1
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 250 mm; Jmenovitá velikost vstupu: 1250 mm; Jmenovitá velikost vstupu - šířka: 1600 mm; Jmenovitá velikost vstupu - výška: 400 mm; Jmenovitá velikost výstupu: 560 mm; Jmenovitá velikost výstupu - šířka: 1600 mm; Jmenovitá velikost výstupu - výška: 400 mm; Šířka: 1600 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 400 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: UK; Kód sestavy: LV02; Nadpis OmniClass: Guide Vanes; Název typu: 1600x400; Označení typu: 69; Popis: Uzavírací klapka hranatá; Popis sestavy: Uzavírací
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Uzavírací klapka hranatá.LH
Classification: LV02 Uniformat (Uniformat); Group: ODA 6
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.292 m2; NetVolume: 0.167425 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1600 mm × 400 mm-1600 mm × 400 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1600 mm × 400 mm-1600 mm × 400 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 4.16667 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Připojení ELEKTRO: no; Připojení MaR: no; Výška od podlaží: 2543.58 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Název systému: ODA 6; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.167425 m3; Plocha: 2.7904 m2; Velikost: 1600 × 400-1600 × 400
Identifikační data - Kód prvku: LV02.69.0460; Označení: 0460
Jiné - Páteřní trasa: yes; Rodina: Uzavírací klapka hranatá.LH; Id typu: 14145676; Rodina a typ: Uzavírací klapka hranatá.LH: 1600x400; Typ: 1600x400

# IfcBuildingElementProxy: Uzavírací klapka hranatá.LH:560x315, Uzavírací klapka hranatá.LH:560x315:14146245
In: 2.NP_SO-102
Type - Material: 0-128-64
Type - Požární ochrana - Požární odolnost: A1
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 250 mm; Jmenovitá velikost vstupu: 1250 mm; Jmenovitá velikost vstupu - šířka: 560 mm; Jmenovitá velikost vstupu - výška: 315 mm; Jmenovitá velikost výstupu: 560 mm; Jmenovitá velikost výstupu - šířka: 560 mm; Jmenovitá velikost výstupu - výška: 315 mm; Šířka: 560 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 315 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: UK; Kód sestavy: LV02; Nadpis OmniClass: Guide Vanes; Název typu: 560x315; Označení typu: 71; Popis: Uzavírací klapka hranatá; Popis sestavy: Uzavírací
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Uzavírací klapka hranatá.LH
Classification: LV02 Uniformat (Uniformat); Group: ODA 7
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.7004 m2; NetVolume: 0.0463265 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 560 mm × 315 mm-560 mm × 315 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 560 mm × 315 mm-560 mm × 315 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0.972222 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Připojení ELEKTRO: no; Připojení MaR: no; Výška od podlaží: 2775 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Název systému: ODA 7; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0463265 m3; Plocha: 0.9114 m2; Velikost: 560 × 315-560 × 315
Identifikační data - Kód prvku: LV02.71.0462; Označení: 0462
Jiné - Páteřní trasa: yes; Rodina: Uzavírací klapka hranatá.LH; Id typu: 14146165; Rodina a typ: Uzavírací klapka hranatá.LH: 560x315; Typ: 560x315

# IfcBuildingElementProxy: Uzavírací klapka hranatá.LH:900x400, Uzavírací klapka hranatá.LH:900x400:14146429
In: 2.NP_SO-102
Type - Material: 0-128-64
Type - Požární ochrana - Požární odolnost: A1
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 250 mm; Jmenovitá velikost vstupu: 1250 mm; Jmenovitá velikost vstupu - šířka: 900 mm; Jmenovitá velikost vstupu - výška: 400 mm; Jmenovitá velikost výstupu: 560 mm; Jmenovitá velikost výstupu - šířka: 900 mm; Jmenovitá velikost výstupu - výška: 400 mm; Šířka: 900 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 400 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: UK; Kód sestavy: LV02; Nadpis OmniClass: Guide Vanes; Název typu: 900x400; Označení typu: 72; Popis: Uzavírací klapka hranatá; Popis sestavy: Uzavírací
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Uzavírací klapka hranatá.LH
Classification: LV02 Uniformat (Uniformat); Group: ODA 3
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.108 m2; NetVolume: 0.094275 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 900 mm × 400 mm-900 mm × 400 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 900 mm × 400 mm-900 mm × 400 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 2.05556 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Připojení ELEKTRO: no; Připojení MaR: no; Výška od podlaží: 1759 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Název systému: ODA 3; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.094275 m3; Plocha: 1.6424 m2; Velikost: 900 × 400-900 × 400
Identifikační data - Kód prvku: LV02.72.0463; Označení: 0463
Jiné - Páteřní trasa: yes; Rodina: Uzavírací klapka hranatá.LH; Id typu: 14146333; Rodina a typ: Uzavírací klapka hranatá.LH: 900x400; Typ: 900x400

# IfcBuildingElementProxy: Uzavírací klapka hranatá.LH:Šířka × Výška × Délka, Uzavírací klapka hranatá.LH:Šířka × Výška × Délka:13817283
In: -1.PP_SO-102
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 250 mm; Jmenovitá velikost vstupu - šířka: 630 mm; Jmenovitá velikost vstupu - výška: 280 mm; Jmenovitá velikost výstupu - šířka: 630 mm; Jmenovitá velikost výstupu - výška: 280 mm; Šířka: 630 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 280 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: UK; Kód sestavy: LV02; Nadpis OmniClass: Guide Vanes; Název typu: Šířka × Výška × Délka; Označení typu: 22; Popis: Uzavírací klapka hranatá; Popis sestavy: Uzavírací
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Uzavírací klapka hranatá.LH
Classification: LV02 Uniformat (Uniformat); Group: ODA 17
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.7256 m2; NetVolume: 0.046344 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 630 mm × 280 mm-630 mm × 280 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 630 mm × 280 mm-630 mm × 280 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Připojení ELEKTRO: no; Připojení MaR: no; Výška od podlaží: 3000 mm
Fázování - Fáze vytvoření: Fáze 2
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Název systému: ODA 17; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.046344 m3; Plocha: 0.9296 m2; Velikost: 630 × 280-630 × 280
Identifikační data - Kód prvku: LV02.22.0043; Označení: 0043
Jiné - Páteřní trasa: yes; Id typu: 13817177; Rodina: Uzavírací klapka hranatá.LH; Rodina a typ: Uzavírací klapka hranatá.LH: Šířka × Výška × Délka; Typ: Šířka × Výška × Délka

# IfcBuildingElementProxy: Uzavírací klapka kruhová.LH:Průměr × Délka (2)
In: -1.PP_SO-102
Type - Material: 0-128-64
Type - Požární ochrana - Požární odolnost: A1
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 250 mm; Jmenovitá velikost vstupu: 355 mm; Jmenovitá velikost výstupu: 355 mm; Průměr: 355 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: UK; Kód sestavy: LV02; Nadpis OmniClass: Guide Vanes; Název typu: Průměr × Délka; Označení typu: 21; Popis: Uzavírací klapka kruhová; Popis sestavy: Uzavírací
Type - Jiné - Kategorie: Příslušenství potrubí; délka: 217.097 mm; Název rodiny: Uzavírací klapka kruhová.LH; úhel: 54.8458 deg
Classification: LV02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.476749 m2; NetVolume: 0.0247438 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 355 mm-355 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 355 mm-355 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Připojení ELEKTRO: no; Připojení MaR: no
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0247438 m3; Plocha: 0.283175 m2; Velikost: 355-355
Jiné - Páteřní trasa: yes; Typ: Průměr × Délka; Id typu: 13813939; Rodina: Uzavírací klapka kruhová.LH; Rodina a typ: Uzavírací klapka kruhová.LH: Průměr × Délka
Name (Uzavírací klapka kruhová.LH:Průměr × Délka:...) | Průtok vzduchu (m3/s) | Tlaková ztráta (Pa) | Výška od podlaží (mm) | Název systému = Group | Kód prvku | Označení
13814040 | 0.472222 | 3.2848 | 3078 | ODA 1 | LV02.21.0040 | 0040
13814054 | 0.611111 | 5.50118 | 3100 | ODA 2 | LV02.21.0041 | 0041

# IfcCovering: Izolace potrubí:Protipožární (93)
PredefinedType: INSULATION; Classification: IZ03 Uniformat (Uniformat)
Text - CCI Funkční systém: J; CCI Komponenta: FMH; CCI Technický systém: HF
Mechanické - Tloušťka izolace: 15 mm
Jiné - Id typu: 8918325; Kategorie: Izolace potrubí; Rodina: Izolace potrubí; Rodina a typ: Izolace potrubí: Protipožární; Typ: Protipožární
Požární ochrana(Type) - Požární odolnost: A1
Identifikační data(Type) - ID kategorie: IZP; Kód sestavy: IZ03; Název typu: Protipožární; Označení typu: 01; Popis: POŽÁRNÍ IZOLACE; Popis sestavy: Protipožární
Jiné(Type) - Kategorie: Izolace potrubí; MJ: m2; Název rodiny: Izolace potrubí
Name (Izolace potrubí:Protipožární:...) | In | Material | GrossArea (m2) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému | Zkratka systému | Velikost potrubí | Kód prvku | Označení
13797105 | 1.NP_SO-102 | 0-128-64 | 1.08631 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 25 | ODA | 450 × 280 | IZ03.01.0001 | 0001 | Qto_CoveringBaseQuantities - Width: 2263.15 mm; Mechanické - Objem: 0.0536366 m3; Plocha: 3.57577 m2; Kóty - Délka: 2263.15 mm
13797196 | 1.NP_SO-102 | 0-0-255 | 0.093468 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 315 | IZ03.01.0002 | 0002 | Mechanické - Objem: 0.0287267 m3; Plocha: 1.91511 m2; Kóty - Délka: 1766.95 mm
13803560 | 3.NP_SO-102 | 0-128-64 | 1.17271 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 25 | ODA | 450 × 280 | IZ03.01.0003 | 0003 | Qto_CoveringBaseQuantities - Width: 2443.15 mm; Mechanické - Objem: 0.0579026 m3; Plocha: 3.86017 m2; Kóty - Délka: 2443.15 mm
13817437 | -1.PP_SO-102 | 128-64-0 | 0.808767 | Fáze 2 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | 800 × 355 | IZ03.01.0004 | 0004 | Qto_CoveringBaseQuantities - Width: 974.419 mm; Mechanické - Objem: 0.0355176 m3; Plocha: 2.36784 m2; Kóty - Délka: 974.419 mm
13817573 | -1.PP_SO-102 | 0-0-255 | 5.76538 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 800 × 400 | IZ03.01.0005 | 0005 | Qto_CoveringBaseQuantities - Width: 6946.24 mm; Mechanické - Objem: 0.262568 m3; Plocha: 17.5045 m2; Kóty - Délka: 6946.24 mm
13817574 | -1.PP_SO-102 | 0-0-255 | 0.74317 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 800 × 400-800 × 400 | IZ03.01.0006 | 0006
13850363 | -1.PP_SO-102 | 0-0-255 | 0.11639 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 355 | IZ03.01.0007 | 0007 | Mechanické - Objem: 0.0768155 m3; Plocha: 5.12103 m2; Kóty - Délka: 4233.96 mm
13850364 | -1.PP_SO-102 | 255-0-0 | 0.11639 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 355 | IZ03.01.0008 | 0008 | Mechanické - Objem: 0.12727 m3; Plocha: 8.48469 m2; Kóty - Délka: 7014.96 mm
13907373 | 1.NP_SO-102 | 0-0-255 | 0.093468 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 315 | IZ03.01.0009 | 0009 | Mechanické - Objem: 0.000547986 m3; Plocha: 0.0365324 m2; Kóty - Délka: 33.7061 mm
13907376 | 1.NP_SO-102 | 0-0-255 | 0.093468 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 315-315 | IZ03.01.0010 | 0010
13912341 | 1.NP_SO-102 | 0-128-64 |  | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 25 | ODA | 500 × 400-450 × 280 | IZ03.01.0011 | 0011
13912513 | 3.NP_SO-102 | 0-128-64 |  | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 25 | ODA | 500 × 400-450 × 280 | IZ03.01.0012 | 0012
13963101 | -1.PP_SO-102 | 0-0-255 | 0.11639 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 355-355 | IZ03.01.0013 | 0013
13963199 | -1.PP_SO-102 | 0-0-255 | 0.11639 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 355 | IZ03.01.0014 | 0014 | Mechanické - Objem: 0.00537532 m3; Plocha: 0.358354 m2; Kóty - Délka: 296.28 mm
13963226 | -1.PP_SO-102 | 0-0-255 | 0.11639 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 355 | IZ03.01.0015 | 0015 | Mechanické - Objem: 0.00735224 m3; Plocha: 0.490149 m2; Kóty - Délka: 405.245 mm
13963227 | -1.PP_SO-102 | 0-0-255 |  | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 355-355 | IZ03.01.0016 | 0016
13963228 | -1.PP_SO-102 | 0-0-255 | 0.11639 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 355 | IZ03.01.0017 | 0017 | Mechanické - Objem: 0.00276582 m3; Plocha: 0.184388 m2; Kóty - Délka: 152.448 mm
13963229 | -1.PP_SO-102 | 0-0-255 |  | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 355-355 | IZ03.01.0018 | 0018
14006778 | -1.PP_SO-102 | 0-0-255 | 0.0415413 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 200 | IZ03.01.0019 | 0019 | Mechanické - Objem: 0.021906 m3; Plocha: 1.4604 m2; Kóty - Délka: 2021.13 mm
14065999 | -1.PP_SO-102 | 0-128-64 | 0.20355 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 315 × 560 | IZ03.01.0020 | 0020 | Qto_CoveringBaseQuantities - Width: 345 mm; Mechanické - Objem: 0.180776 m3; Plocha: 12.0517 m2; Kóty - Délka: 6444.76 mm
14066006 | 4.NP_SO-102 | 0-128-64 | 0.45904 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 710 × 560-450 × 560 | IZ03.01.0021 | 0021
14066008 | 4.NP_SO-102 | 0-128-64 | 0.0862712 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 560 × 400 | IZ03.01.0022 | 0022 | Qto_CoveringBaseQuantities - Width: 146.222 mm; Mechanické - Objem: 0.0044744 m3; Plocha: 0.298294 m2; Kóty - Délka: 146.222 mm
14066009 | 1.NP_SO-102 | 0-128-64 | 0.199846 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 560 × 400 | IZ03.01.0023 | 0023 | Qto_CoveringBaseQuantities - Width: 338.722 mm; Mechanické - Objem: 0.0103649 m3; Plocha: 0.690994 m2; Kóty - Délka: 338.722 mm
14066010 | 4.NP_SO-102 | 0-128-64 | 0.0723906 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 400 × 560-400 × 560 | IZ03.01.0024 | 0024 | Qto_CoveringBaseQuantities - Width: 590 mm
14066011 | 4.NP_SO-102 | 0-128-64 |  | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 575 × 425-560 × 400 | IZ03.01.0025 | 0025
14066012 | 3.NP_SO-102 | 0-128-64 | 0.0833212 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 560 × 400 | IZ03.01.0026 | 0026 | Qto_CoveringBaseQuantities - Width: 141.222 mm; Mechanické - Objem: 0.0043214 m3; Plocha: 0.288094 m2; Kóty - Délka: 141.222 mm
14066013 | 3.NP_SO-102 | 0-128-64 | 0.0723906 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 400 × 560-400 × 560 | IZ03.01.0027 | 0027 | Qto_CoveringBaseQuantities - Width: 590 mm
14066014 | 3.NP_SO-102 | 0-128-64 |  | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 575 × 425-560 × 400 | IZ03.01.0028 | 0028
14066015 | 2.NP_SO-102 | 0-128-64 | 0.0833212 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 560 × 400 | IZ03.01.0029 | 0029 | Qto_CoveringBaseQuantities - Width: 141.222 mm; Mechanické - Objem: 0.0043214 m3; Plocha: 0.288094 m2; Kóty - Délka: 141.222 mm
14066016 | 2.NP_SO-102 | 0-128-64 | 0.0723906 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 400 × 560-400 × 560 | IZ03.01.0030 | 0030 | Qto_CoveringBaseQuantities - Width: 590 mm
14066017 | 2.NP_SO-102 | 0-128-64 |  | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 575 × 425-560 × 400 | IZ03.01.0031 | 0031
14066018 | 2.NP_SO-102 | 0-128-64 | 0.4366 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 710 × 560 | IZ03.01.0032 | 0032 | Qto_CoveringBaseQuantities - Width: 740 mm; Mechanické - Objem: 0.420902 m3; Plocha: 28.0602 m2; Kóty - Délka: 10548.9 mm
14066019 | 1.NP_SO-102 | 0-128-64 | 0.0723906 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 400 × 560-400 × 560 | IZ03.01.0033 | 0033 | Qto_CoveringBaseQuantities - Width: 590 mm
14066020 | -1.PP_SO-102 | 0-128-64 | 0.16834 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 560 × 400 | IZ03.01.0034 | 0034 | Qto_CoveringBaseQuantities - Width: 285.322 mm; Mechanické - Objem: 0.00873086 m3; Plocha: 0.582058 m2; Kóty - Délka: 285.322 mm
14066021 | -1.PP_SO-102 | 0-128-64 | 0.218718 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 400 × 560-315 × 560 | IZ03.01.0035 | 0035
14066022 | 2.NP_SO-102 | 0-128-64 | 0.258668 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 710 × 560-315 × 560 | IZ03.01.0036 | 0036
14066808 | -1.PP_SO-102 | 0-128-64 | 0.3182 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 710 × 400 | IZ03.01.0037 | 0037 | Qto_CoveringBaseQuantities - Width: 740 mm; Mechanické - Objem: 0.113469 m3; Plocha: 7.5646 m2; Kóty - Délka: 3232.74 mm
14066809 | 1.NP_SO-102 | 0-128-64 | 0.3984 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 800 × 450 | IZ03.01.0038 | 0038 | Qto_CoveringBaseQuantities - Width: 480 mm; Mechanické - Objem: 0.158146 m3; Plocha: 10.5431 m2; Kóty - Délka: 4024.07 mm
14066810 | 2.NP_SO-102 | 0-128-64 | 0.5459 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 1000 × 500 | IZ03.01.0039 | 0039 | Qto_CoveringBaseQuantities - Width: 530 mm; Mechanické - Objem: 0.171873 m3; Plocha: 11.4582 m2; Kóty - Délka: 3672.5 mm
14066830 | -1.PP_SO-102 | 0-128-64 | 0.0715029 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 450 × 400 | IZ03.01.0040 | 0040 | Qto_CoveringBaseQuantities - Width: 148.964 mm; Mechanické - Objem: 0.00406672 m3; Plocha: 0.271115 m2; Kóty - Délka: 148.964 mm
14066831 | -2.PP_SO-102 | 0-128-64 | 0.1204 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 250 × 400 | IZ03.01.0041 | 0041 | Qto_CoveringBaseQuantities - Width: 280 mm; Mechanické - Objem: 0.0622937 m3; Plocha: 4.15291 m2; Kóty - Délka: 2924.59 mm
14066832 | -1.PP_SO-102 | 0-128-64 | 0.249929 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 400 × 280-400 × 280 | IZ03.01.0042 | 0042
14066833 | -1.PP_SO-102 | 0-128-64 | 0.0106829 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 280 × 400-250 × 400 | IZ03.01.0043 | 0043
14066834 | -1.PP_SO-102 | 0-128-64 | 0.1615 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 450 × 400-450 × 400-280 × 400 | IZ03.01.0044 | 0044
14066835 | -1.PP_SO-102 | 0-128-64 | 0.02544 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 450 × 400 | IZ03.01.0045 | 0045 | Qto_CoveringBaseQuantities - Width: 53 mm; Mechanické - Objem: 0.0014469 m3; Plocha: 0.09646 m2; Kóty - Délka: 53 mm
14066840 | 1.NP_SO-102 | 0-128-64 | 0.0191554 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 450 × 280 | IZ03.01.0046 | 0046 | Qto_CoveringBaseQuantities - Width: 39.9071 mm; Mechanické - Objem: 0.000945799 m3; Plocha: 0.0630533 m2; Kóty - Délka: 39.9071 mm
14067600 | 4.NP_SO-102 | 0-128-64 | 0.6077 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 1000 × 560 | IZ03.01.0047 | 0047 | Qto_CoveringBaseQuantities - Width: 590 mm; Mechanické - Objem: 0.146653 m3; Plocha: 9.77689 m2; Kóty - Délka: 3017.56 mm
14067601 | 4.NP_SO-102 | 0-128-64 | 0.1848 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 630 × 280 | IZ03.01.0048 | 0048 | Qto_CoveringBaseQuantities - Width: 280 mm; Mechanické - Objem: 0.008148 m3; Plocha: 0.5432 m2; Kóty - Délka: 280 mm
14067602 | 3.NP_SO-102 | 0-128-64 | 0.135514 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 630 × 280 | IZ03.01.0049 | 0049 | Qto_CoveringBaseQuantities - Width: 205.325 mm; Mechanické - Objem: 0.00597494 m3; Plocha: 0.39833 m2; Kóty - Délka: 205.325 mm
14067604 | 3.NP_SO-102 | 0-128-64 | 0.4884 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 710 × 630 | IZ03.01.0050 | 0050 | Qto_CoveringBaseQuantities - Width: 740 mm; Mechanické - Objem: 0.0928311 m3; Plocha: 6.18874 m2; Kóty - Délka: 2210.26 mm
14067629 | 3.NP_SO-102 | 0-128-64 |  | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 1000 × 500-710 × 630 | IZ03.01.0051 | 0051
14067815 | -1.PP_SO-102 | 0-128-64 | 0.0268007 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 710 × 450-710 × 400 | IZ03.01.0052 | 0052
14067816 | -1.PP_SO-102 | 0-128-64 | 0.426628 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 710 × 450-400 × 450 | IZ03.01.0053 | 0053
14080759 | -1.PP_SO-102 | 0-0-255 | 0.11639 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 355 | IZ03.01.0054 | 0054 | Mechanické - Objem: 0.0196686 m3; Plocha: 1.31124 m2; Kóty - Délka: 1084.11 mm
14080766 | -1.PP_SO-102 | 0-0-255 |  | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 355-315 | IZ03.01.0055 | 0055
14080767 | -1.PP_SO-102 | 0-0-255 | 0.093468 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 315-315 | IZ03.01.0056 | 0056
14080768 | -1.PP_SO-102 | 0-0-255 |  | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 355-315 | IZ03.01.0057 | 0057
14082662 | -2.PP_SO-102 | 0-128-64 | 0.118069 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 400 × 500 | IZ03.01.0058 | 0058 | Qto_CoveringBaseQuantities - Width: 274.578 mm; Mechanické - Objem: 0.00790786 m3; Plocha: 0.527191 m2; Kóty - Délka: 274.578 mm
14082663 | -2.PP_SO-102 | 0-128-64 | 0.306929 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 500 × 400-400 × 400 | IZ03.01.0059 | 0059
14115934 | -1.PP_SO-102 | 128-64-0 | 0.324192 | Fáze 2 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | 630 × 500 | IZ03.01.0060 | 0060 | Qto_CoveringBaseQuantities - Width: 491.201 mm; Mechanické - Objem: 0.0175359 m3; Plocha: 1.16906 m2; Kóty - Délka: 491.201 mm
14115958 | -1.PP_SO-102 | 128-64-0 |  | Fáze 2 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | 630 × 500-800 × 355 | IZ03.01.0061 | 0061
14116061 | -1.PP_SO-102 | 128-64-0 | 0.74317 | Fáze 2 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | 800 × 355-800 × 355 | IZ03.01.0062 | 0062
14116146 | -1.PP_SO-102 | 128-64-0 | 6.45899 | Fáze 2 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | 800 × 355 | IZ03.01.0063 | 0063 | Qto_CoveringBaseQuantities - Width: 7781.92 mm; Mechanické - Objem: 0.283651 m3; Plocha: 18.9101 m2; Kóty - Délka: 7781.92 mm
14116150 | -1.PP_SO-102 | 128-64-0 | 0.00498 | Fáze 2 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | 800 × 355-800 × 355 | IZ03.01.0064 | 0064 | Qto_CoveringBaseQuantities - Width: 830 mm
14121172 | 1.NP_SO-102 | 0-128-64 | 0.0588941 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 280 × 450-280 × 450 | IZ03.01.0065 | 0065 | Qto_CoveringBaseQuantities - Width: 480 mm
14121220 | 1.NP_SO-102 | 0-128-64 |  | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 800 × 450-710 × 400 | IZ03.01.0066 | 0066
14121223 | 2.NP_SO-102 | 0-128-64 |  | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 1000 × 500-800 × 450 | IZ03.01.0067 | 0067
14127340 | 1.NP_SO-102 | 0-128-64 |  | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 575 × 425-560 × 400 | IZ03.01.0068 | 0068
14127342 | -1.PP_SO-102 | 0-128-64 |  | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 575 × 425-560 × 400 | IZ03.01.0069 | 0069
14135924 | -1.PP_SO-102 | 255-0-0 | 0.0283486 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 160 | IZ03.01.0070 | 0070 | Mechanické - Objem: 0.0201226 m3; Plocha: 1.34151 m2; Kóty - Délka: 2247.45 mm
14151035 | 3.NP_SO-102 | 0-128-64 | 0.0809794 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 280 × 630-280 × 630 | IZ03.01.0071 | 0071 | Qto_CoveringBaseQuantities - Width: 660 mm
14151946 | 4.NP_SO-102 | 0-128-64 | 0.0588941 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 25 | ODA | 400 × 450-400 × 450 | IZ03.01.0072 | 0072 | Qto_CoveringBaseQuantities - Width: 480 mm
14151967 | 3.NP_SO-102 | 0-128-64 | 0.2544 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 25 | ODA | 450 × 500 | IZ03.01.0073 | 0073 | Qto_CoveringBaseQuantities - Width: 530 mm; Mechanické - Objem: 0.161311 m3; Plocha: 10.7541 m2; Kóty - Délka: 5323.8 mm
14151968 | 1.NP_SO-102 | 0-128-64 | 0.249962 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 25 | ODA | 500 × 450-280 × 450 | IZ03.01.0074 | 0074
14151969 | 3.NP_SO-102 | 0-128-64 | 0.178 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 25 | ODA | 500 × 450-500 × 450-280 × 450 | IZ03.01.0075 | 0075
14151970 | 2.NP_SO-102 | 0-128-64 | 0.2544 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 25 | ODA | 450 × 500 | IZ03.01.0076 | 0076 | Qto_CoveringBaseQuantities - Width: 530 mm; Mechanické - Objem: 0.114231 m3; Plocha: 7.6154 m2; Kóty - Délka: 3770 mm
14151971 | 2.NP_SO-102 | 0-128-64 | 0.0423106 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 25 | ODA | 450 × 280 | IZ03.01.0077 | 0077 | Qto_CoveringBaseQuantities - Width: 88.1472 mm; Mechanické - Objem: 0.00208909 m3; Plocha: 0.139273 m2; Kóty - Délka: 88.1472 mm
14151972 | 2.NP_SO-102 | 0-128-64 | 0.178 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 25 | ODA | 500 × 450-500 × 450-280 × 450 | IZ03.01.0078 | 0078
14151973 | 1.NP_SO-102 | 0-128-64 | 0.2544 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 25 | ODA | 450 × 500 | IZ03.01.0079 | 0079 | Qto_CoveringBaseQuantities - Width: 530 mm; Mechanické - Objem: 0.11048 m3; Plocha: 7.36531 m2; Kóty - Délka: 3646.19 mm
14151974 | 4.NP_SO-102 | 0-128-64 | 0.094272 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 25 | ODA | 450 × 400 | IZ03.01.0080 | 0080 | Qto_CoveringBaseQuantities - Width: 196.4 mm; Mechanické - Objem: 0.00536172 m3; Plocha: 0.357448 m2; Kóty - Délka: 196.4 mm
14151975 | 2.NP_SO-102 | 0-128-64 |  | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 25 | ODA | 500 × 400-450 × 280 | IZ03.01.0081 | 0081
14153708 | -1.PP_SO-102 | 0-0-255 | 0.618966 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 1250 × 630 | IZ03.01.0082 | 0082 | Qto_CoveringBaseQuantities - Width: 483.567 mm; Mechanické - Objem: 0.0281436 m3; Plocha: 1.87624 m2; Kóty - Délka: 483.567 mm
14153709 | -1.PP_SO-102 | 0-0-255 | 2.09567 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 1600 × 500-1250 × 500 | IZ03.01.0083 | 0083
14153710 | -1.PP_SO-102 | 0-0-255 | 0.0933697 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 1250 × 630-1250 × 500 | IZ03.01.0084 | 0084
14153711 | -1.PP_SO-102 | 0-0-255 | 0.687969 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 1250 × 630 | IZ03.01.0085 | 0085 | Qto_CoveringBaseQuantities - Width: 537.476 mm; Mechanické - Objem: 0.0312811 m3; Plocha: 2.08541 m2; Kóty - Délka: 537.476 mm
14153712 | -1.PP_SO-102 | 0-0-255 | 1.59864 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 1250 × 630-1250 × 630 | IZ03.01.0086 | 0086
14153713 | -1.PP_SO-102 | 0-0-255 | 14.3053 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 1600 × 500 | IZ03.01.0087 | 0087 | Qto_CoveringBaseQuantities - Width: 8776.25 mm; Mechanické - Objem: 0.568701 m3; Plocha: 37.9134 m2; Kóty - Délka: 8776.25 mm
14158268 | 4.NP_SO-102 | 0-128-64 |  | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 1000 × 560-630 × 710 | IZ03.01.0088 | 0088
14158272 | 4.NP_SO-102 | 0-128-64 | 0.0984999 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 1000 × 560-1000 × 400 | IZ03.01.0089 | 0089
14179902 | 1.NP_SO-102 | 0-0-255 | 0.093468 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 315 | IZ03.01.0090 | 0090 | Mechanické - Objem: 0.006298 m3; Plocha: 0.419867 m2; Kóty - Délka: 387.385 mm
14180241 | 1.NP_SO-102 | 0-0-255 |  | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 315-315 | IZ03.01.0091 | 0091
14180242 | 1.NP_SO-102 | 0-0-255 | 0.093468 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 315 | IZ03.01.0092 | 0092 | Mechanické - Objem: 0.00598887 m3; Plocha: 0.399258 m2; Kóty - Délka: 368.37 mm
14180247 | 1.NP_SO-102 | 0-0-255 |  | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 315-315 | IZ03.01.0093 | 0093

# IfcDistributionPort (8507)
Description: Flow; PredefinedType: DUCT
Name | FlowDirection | SystemType | Group
InPort_13095338_0 | SINK | VENTILATION | SUP 17
OutPort_12887694_1 | SOURCE | VENTILATION | SUP 17
InPort_12887694_2 | SINK | VENTILATION | ODA 7
OutPort_13113179_1 | SOURCE | VENTILATION | ODA 7
InPort_12887694_3 | SINK | VENTILATION | ETA 12
OutPort_13096663_0 | SOURCE | VENTILATION | ETA 12
InPort_13896990_1 | SINK | EXHAUST | EHA 5
OutPort_12887694_4 | SOURCE | EXHAUST | EHA 5
Port_12890935_0 | SOURCEANDSINK | VENTILATION | SUP 17
Port_12891014_1 | SOURCEANDSINK | VENTILATION | SUP 17
Port_12890935_1 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13096242_2 | SOURCEANDSINK | VENTILATION | SUP 17
InPort_13890817_1 | SINK | VENTILATION | SUP 17
OutPort_12890935_2 | SOURCE | VENTILATION | SUP 17
InPort_13890938_1 | SINK | VENTILATION | SUP 17
OutPort_12890935_3 | SOURCE | VENTILATION | SUP 17
InPort_13890974_1 | SINK | VENTILATION | SUP 17
OutPort_12890935_4 | SOURCE | VENTILATION | SUP 17
Port_12890992_0 | SOURCEANDSINK | VENTILATION | SUP 17
Port_12891014_2 | SOURCEANDSINK | VENTILATION | SUP 17
Port_12890992_1 | SOURCEANDSINK | VENTILATION | SUP 17
InPort_13890703_1 | SINK | VENTILATION | SUP 17
OutPort_12890992_2 | SOURCE | VENTILATION | SUP 17
InPort_13890743_1 | SINK | VENTILATION | SUP 17
OutPort_12890992_3 | SOURCE | VENTILATION | SUP 17
Port_12891539_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13936424_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_12891539_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_12891593_2 | SOURCEANDSINK | VENTILATION | ETA 12
InPort_12891539_2 | SINK | VENTILATION | ETA 12
OutPort_13892567_1 | SOURCE | VENTILATION | ETA 12
Port_12891553_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_12891593_3 | SOURCEANDSINK | VENTILATION | ETA 12
Port_12891553_1 | SOURCEANDSINK | VENTILATION | ETA 12
InPort_12891553_2 | SINK | VENTILATION | ETA 12
OutPort_13892182_1 | SOURCE | VENTILATION | ETA 12
InPort_12891553_3 | SINK | VENTILATION | ETA 12
OutPort_13892252_1 | SOURCE | VENTILATION | ETA 12
Port_12891593_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_12891605_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_12891605_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914394_2 | SOURCEANDSINK | VENTILATION | ETA 12
InPort_12891605_2 | SINK | VENTILATION | ETA 12
OutPort_13892359_1 | SOURCE | VENTILATION | ETA 12
Port_12891615_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914394_3 | SOURCEANDSINK | VENTILATION | ETA 12
Port_12891615_1 | SOURCEANDSINK | VENTILATION | ETA 12
InPort_12891615_2 | SINK | VENTILATION | ETA 12
OutPort_13892065_1 | SOURCE | VENTILATION | ETA 12
Port_12891726_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_12891726_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_14114542_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_12900268_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13957464_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_12900268_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13893094_1 | SINK | VENTILATION | SUP 9
OutPort_12900268_2 | SOURCE | VENTILATION | SUP 9
InPort_13893240_1 | SINK | VENTILATION | SUP 9
OutPort_12900268_3 | SOURCE | VENTILATION | SUP 9
InPort_13893278_1 | SINK | VENTILATION | SUP 9
OutPort_12900268_4 | SOURCE | VENTILATION | SUP 9
Port_12901855_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13999716_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_12901855_1 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_12901855_2 | SINK | VENTILATION | ETA 14
OutPort_13999865_1 | SOURCE | VENTILATION | ETA 14
Port_12901964_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13864850_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_12901964_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13891359_1 | SINK | VENTILATION | SUP 9
OutPort_12901964_2 | SOURCE | VENTILATION | SUP 9
Port_12903094_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14034587_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_12903094_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13996801_1 | SINK | VENTILATION | SUP 9
OutPort_12903094_2 | SOURCE | VENTILATION | SUP 9
Port_12904508_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13898827_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_12904508_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14034480_1 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_12904508_2 | SINK | VENTILATION | ETA 14
OutPort_13998288_1 | SOURCE | VENTILATION | ETA 14
Port_12904518_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13898827_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_12904518_1 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_12904518_2 | SINK | VENTILATION | ETA 14
OutPort_13998324_1 | SOURCE | VENTILATION | ETA 14
Port_12908056_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717477_3 | SOURCEANDSINK | VENTILATION | SUP 9
Port_12908056_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13915707_1 | SINK | VENTILATION | SUP 9
OutPort_12908056_2 | SOURCE | VENTILATION | SUP 9
InPort_13916061_1 | SINK | VENTILATION | SUP 9
OutPort_12908056_3 | SOURCE | VENTILATION | SUP 9
Port_12908099_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717444_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_12908099_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13915862_1 | SINK | VENTILATION | SUP 9
OutPort_12908099_2 | SOURCE | VENTILATION | SUP 9
InPort_13915892_1 | SINK | VENTILATION | SUP 9
OutPort_12908099_3 | SOURCE | VENTILATION | SUP 9
InPort_14183061_2 | SINK | VENTILATION | SUP 15
OutPort_12918689_0 | SOURCE | VENTILATION | SUP 15
InPort_12918689_1 | SINK | VENTILATION | SUP 15
OutPort_14183062_1 | SOURCE | VENTILATION | SUP 15
InPort_12918743_0 | SINK | VENTILATION | ETA 11
OutPort_14124621_1 | SOURCE | VENTILATION | ETA 11
InPort_12918743_1 | SINK | VENTILATION | ETA 11
OutPort_14112603_1 | SOURCE | VENTILATION | ETA 11
InPort_12918743_2 | SINK | VENTILATION | ETA 11
OutPort_13995423_1 | SOURCE | VENTILATION | ETA 11
InPort_12918743_3 | SINK | VENTILATION | ETA 11
OutPort_14048925_1 | SOURCE | VENTILATION | ETA 11
InPort_12918743_4 | SINK | VENTILATION | ETA 11
OutPort_14048933_1 | SOURCE | VENTILATION | ETA 11
InPort_14008926_1 | SINK | EXHAUST | EHA 10
OutPort_12928524_0 | SOURCE | EXHAUST | EHA 10
InPort_12928524_1 | SINK | EXHAUST | EHA 10
OutPort_14184285_2 | SOURCE | EXHAUST | EHA 10
InPort_13855526_3 | SINK | VENTILATION | ODA 3
OutPort_12928681_0 | SOURCE | VENTILATION | ODA 3
InPort_12928681_1 | SINK | VENTILATION | ODA 3
OutPort_14146295_1 | SOURCE | VENTILATION | ODA 3
Port_12930435_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13820645_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_12930435_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13106118_2 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_14078252_2 | SINK | VENTILATION | SUP 9
OutPort_12930744_0 | SOURCE | VENTILATION | SUP 9
InPort_12930744_1 | SINK | VENTILATION | SUP 9
OutPort_14078256_2 | SOURCE | VENTILATION | SUP 9
InPort_14146429_2 | SINK | VENTILATION | ODA 3
OutPort_12931474_0 | SOURCE | VENTILATION | ODA 3
InPort_12931474_1 | SINK | VENTILATION | ODA 3
OutPort_14146297_2 | SOURCE | VENTILATION | ODA 3
InPort_12931586_0 | SINK | VENTILATION | ETA 11
OutPort_14012769_2 | SOURCE | VENTILATION | ETA 11
InPort_14032232_1 | SINK | VENTILATION | ETA 11
OutPort_12931586_1 | SOURCE | VENTILATION | ETA 11
Port_12952477_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13169497_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_12952477_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13930245_1 | SINK | VENTILATION | SUP 13
OutPort_12952477_2 | SOURCE | VENTILATION | SUP 13
InPort_13930269_1 | SINK | VENTILATION | SUP 13
OutPort_12952477_3 | SOURCE | VENTILATION | SUP 13
InPort_13930293_1 | SINK | VENTILATION | SUP 13
OutPort_12952477_4 | SOURCE | VENTILATION | SUP 13
Port_12959017_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13718901_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_12959017_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14057421_3 | SOURCEANDSINK | VENTILATION | SUP 9
Port_12961485_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13998627_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_12961485_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14164774_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13088964_0 | SINK | VENTILATION | ETA 11
OutPort_13697215_3 | SOURCE | VENTILATION | ETA 11
InPort_14010723_1 | SINK | VENTILATION | ETA 11
OutPort_13088964_1 | SOURCE | VENTILATION | ETA 11
InPort_13746983_1 | SINK | VENTILATION | ODA 6
OutPort_13089207_0 | SOURCE | VENTILATION | ODA 6
InPort_13089207_1 | SINK | VENTILATION | ODA 6
OutPort_13089366_1 | SOURCE | VENTILATION | ODA 6
InPort_13089366_2 | SINK | VENTILATION | ODA 6
OutPort_13747012_0 | SOURCE | VENTILATION | ODA 6
InPort_14009229_1 | SINK | EXHAUST | EHA 8
OutPort_13094719_0 | SOURCE | EXHAUST | EHA 8
InPort_13094719_1 | SINK | EXHAUST | EHA 8
OutPort_14194087_2 | SOURCE | EXHAUST | EHA 8
InPort_13097172_1 | SINK | VENTILATION | SUP 17
OutPort_13095338_1 | SOURCE | VENTILATION | SUP 17
InPort_13095403_0 | SINK | VENTILATION | SUP 17
OutPort_13097172_2 | SOURCE | VENTILATION | SUP 17
InPort_13097293_2 | SINK | VENTILATION | SUP 17
OutPort_13095403_1 | SOURCE | VENTILATION | SUP 17
InPort_13095415_1 | SINK | VENTILATION | SUP 17
OutPort_13097284_0 | SOURCE | VENTILATION | SUP 17
InPort_13096317_0 | SINK | VENTILATION | SUP 17
OutPort_13095415_2 | SOURCE | VENTILATION | SUP 17
InPort_13095679_0 | SINK | VENTILATION | SUP 17
OutPort_13096318_1 | SOURCE | VENTILATION | SUP 17
InPort_13096137_1 | SINK | VENTILATION | SUP 17
OutPort_13095679_1 | SOURCE | VENTILATION | SUP 17
Port_13095866_1 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13096242_1 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13095866_2 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13096056_1 | SOURCEANDSINK | VENTILATION | SUP 17
InPort_13095966_1 | SINK | VENTILATION | SUP 17
OutPort_13095866_3 | SOURCE | VENTILATION | SUP 17
Port_13095900_0 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13096056_2 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13095900_1 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13149505_1 | SOURCEANDSINK | VENTILATION | SUP 17
InPort_13891057_1 | SINK | VENTILATION | SUP 17
OutPort_13095900_2 | SOURCE | VENTILATION | SUP 17
InPort_13891085_1 | SINK | VENTILATION | SUP 17
OutPort_13095900_3 | SOURCE | VENTILATION | SUP 17
InPort_13891186_1 | SINK | VENTILATION | SUP 17
OutPort_13095900_4 | SOURCE | VENTILATION | SUP 17
InPort_13935807_1 | SINK | VENTILATION | SUP 17
OutPort_13095966_0 | SOURCE | VENTILATION | SUP 17
InPort_13096060_0 | SINK | VENTILATION | SUP 17
OutPort_13939463_2 | SOURCE | VENTILATION | SUP 17
InPort_13939816_2 | SINK | VENTILATION | SUP 17
OutPort_13096060_1 | SOURCE | VENTILATION | SUP 17
InPort_14185152_1 | SINK | VENTILATION | SUP 17
OutPort_13096137_2 | SOURCE | VENTILATION | SUP 17
InPort_13096304_0 | SINK | VENTILATION | SUP 17
OutPort_13820810_1 | SOURCE | VENTILATION | SUP 17
InPort_13096318_2 | SINK | VENTILATION | SUP 17
OutPort_13096304_1 | SOURCE | VENTILATION | SUP 17
InPort_13820812_0 | SINK | VENTILATION | SUP 17
OutPort_13096317_1 | SOURCE | VENTILATION | SUP 17
InPort_13096388_0 | SINK | VENTILATION | SUP 17
OutPort_14185152_2 | SOURCE | VENTILATION | SUP 17
InPort_13803148_2 | SINK | VENTILATION | SUP 17
OutPort_13096388_1 | SOURCE | VENTILATION | SUP 17
InPort_13096663_1 | SINK | VENTILATION | ETA 12
OutPort_13097444_1 | SOURCE | VENTILATION | ETA 12
InPort_13097284_1 | SINK | VENTILATION | SUP 17
OutPort_13097293_1 | SOURCE | VENTILATION | SUP 17
InPort_13097444_2 | SINK | VENTILATION | ETA 12
OutPort_13097600_1 | SOURCE | VENTILATION | ETA 12
InPort_13097600_2 | SINK | VENTILATION | ETA 12
OutPort_13097632_0 | SOURCE | VENTILATION | ETA 12
InPort_13097632_1 | SINK | VENTILATION | ETA 12
OutPort_13097648_1 | SOURCE | VENTILATION | ETA 12
InPort_13097648_2 | SINK | VENTILATION | ETA 12
OutPort_13097672_0 | SOURCE | VENTILATION | ETA 12
InPort_13097672_1 | SINK | VENTILATION | ETA 12
OutPort_13097709_0 | SOURCE | VENTILATION | ETA 12
InPort_13820796_1 | SINK | VENTILATION | ETA 12
OutPort_13097687_0 | SOURCE | VENTILATION | ETA 12
InPort_13097687_1 | SINK | VENTILATION | ETA 12
OutPort_13097767_1 | SOURCE | VENTILATION | ETA 12
InPort_13097709_1 | SINK | VENTILATION | ETA 12
OutPort_13820798_0 | SOURCE | VENTILATION | ETA 12
InPort_13097767_2 | SINK | VENTILATION | ETA 12
Port_13097777_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13097777_2 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13936122_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13103740_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13103758_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13103740_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13817995_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13103750_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13864346_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13103750_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13103805_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13930449_1 | SINK | VENTILATION | SUP 9
OutPort_13103750_2 | SOURCE | VENTILATION | SUP 9
InPort_13930473_1 | SINK | VENTILATION | SUP 9
OutPort_13103750_3 | SOURCE | VENTILATION | SUP 9
Port_13103758_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13864347_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13103797_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13103805_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13103797_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13930393_1 | SINK | VENTILATION | SUP 9
OutPort_13103797_2 | SOURCE | VENTILATION | SUP 9
InPort_13930417_1 | SINK | VENTILATION | SUP 9
OutPort_13103797_3 | SOURCE | VENTILATION | SUP 9
Port_13103880_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717471_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13103880_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13915611_1 | SINK | VENTILATION | SUP 9
OutPort_13103880_3 | SOURCE | VENTILATION | SUP 9
InPort_13916091_1 | SINK | VENTILATION | SUP 9
OutPort_13103880_4 | SOURCE | VENTILATION | SUP 9
InPort_13104332_0 | SINK | VENTILATION | ETA 14
InPort_14076906_1 | SINK | VENTILATION | ETA 14
OutPort_13104332_1 | SOURCE | VENTILATION | ETA 14
Port_13105917_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14077672_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13105917_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14078017_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13106058_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14077672_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13106058_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13106118_1 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_13820449_0 | SINK | VENTILATION | ETA 14
OutPort_13106116_1 | SOURCE | VENTILATION | ETA 14
InPort_13106116_2 | SINK | VENTILATION | ETA 14
OutPort_13935322_0 | SOURCE | VENTILATION | ETA 14
InPort_13107171_0 | SINK | VENTILATION | SUP 9
OutPort_13107182_1 | SOURCE | VENTILATION | SUP 9
InPort_13107184_2 | SINK | VENTILATION | SUP 9
OutPort_13107171_1 | SOURCE | VENTILATION | SUP 9
Port_13107177_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13107194_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13107177_2 | SINK | VENTILATION | SUP 9
OutPort_13850147_1 | SOURCE | VENTILATION | SUP 9
InPort_13107182_0 | SINK | VENTILATION | SUP 9
OutPort_13107177_3 | SOURCE | VENTILATION | SUP 9
InPort_13930930_0 | SINK | VENTILATION | SUP 9
OutPort_13107184_1 | SOURCE | VENTILATION | SUP 9
Port_13107194_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14051670_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13107198_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14051669_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13107198_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14037805_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13934877_1 | SINK | VENTILATION | SUP 9
OutPort_13109700_0 | SOURCE | VENTILATION | SUP 9
InPort_13109700_1 | SINK | VENTILATION | SUP 9
OutPort_14036702_1 | SOURCE | VENTILATION | SUP 9
InPort_14036880_1 | SINK | VENTILATION | SUP 9
OutPort_13109732_0 | SOURCE | VENTILATION | SUP 9
InPort_13109732_1 | SINK | VENTILATION | SUP 9
OutPort_14036862_0 | SOURCE | VENTILATION | SUP 9
Port_13110419_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14037287_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13110419_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14016778_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_14053276_2 | SINK | VENTILATION | ETA 14
OutPort_13111254_0 | SOURCE | VENTILATION | ETA 14
InPort_13111254_1 | SINK | VENTILATION | ETA 14
OutPort_14053380_1 | SOURCE | VENTILATION | ETA 14
InPort_13111254_2 | SINK | VENTILATION | ETA 14
OutPort_14053858_1 | SOURCE | VENTILATION | ETA 14
InPort_13113179_2 | SINK | VENTILATION | ODA 7
OutPort_13113178_0 | SOURCE | VENTILATION | ODA 7
InPort_13113178_1 | SINK | VENTILATION | ODA 7
OutPort_13113350_1 | SOURCE | VENTILATION | ODA 7
InPort_13113350_2 | SINK | VENTILATION | ODA 7
OutPort_13113353_0 | SOURCE | VENTILATION | ODA 7
InPort_13113353_1 | SINK | VENTILATION | ODA 7
OutPort_13113389_2 | SOURCE | VENTILATION | ODA 7
InPort_13113389_1 | SINK | VENTILATION | ODA 7
OutPort_13896867_1 | SOURCE | VENTILATION | ODA 7
InPort_13113542_0 | SINK | EXHAUST | EHA 5
OutPort_13896990_2 | SOURCE | EXHAUST | EHA 5
InPort_13113594_1 | SINK | EXHAUST | EHA 5
OutPort_13113542_1 | SOURCE | EXHAUST | EHA 5
InPort_13113593_0 | SINK | EXHAUST | EHA 5
OutPort_13113594_2 | SOURCE | EXHAUST | EHA 5
InPort_13897141_1 | SINK | EXHAUST | EHA 5
OutPort_13113593_1 | SOURCE | EXHAUST | EHA 5
InPort_13759152_1 | SINK | EXHAUST | EHA 8
OutPort_13115087_0 | SOURCE | EXHAUST | EHA 8
InPort_13115087_1 | SINK | EXHAUST | EHA 8
Port_13149505_2 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13939464_0 | SOURCEANDSINK | VENTILATION | SUP 17
InPort_13151213_0 | SINK | VENTILATION | SUP 9
OutPort_14036733_2 | SOURCE | VENTILATION | SUP 9
InPort_14036862_1 | SINK | VENTILATION | SUP 9
OutPort_13151213_1 | SOURCE | VENTILATION | SUP 9
Port_13151376_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13935470_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13151376_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13151407_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13151388_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13935472_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13151388_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13999665_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13151391_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14076144_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13151391_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13151407_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13151517_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13864850_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13151517_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14154909_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13891381_1 | SINK | VENTILATION | SUP 9
OutPort_13151517_2 | SOURCE | VENTILATION | SUP 9
InPort_13891405_1 | SINK | VENTILATION | SUP 9
OutPort_13151517_3 | SOURCE | VENTILATION | SUP 9
Port_13151681_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14053265_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13151681_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14076144_3 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13152090_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13873057_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13152090_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14016778_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13152208_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14034587_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13152208_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13997247_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13996866_1 | SINK | VENTILATION | SUP 9
OutPort_13152208_4 | SOURCE | VENTILATION | SUP 9
InPort_13996910_1 | SINK | VENTILATION | SUP 9
OutPort_13152208_5 | SOURCE | VENTILATION | SUP 9
InPort_13152511_0 | SINK | VENTILATION | ETA 14
OutPort_13820447_1 | SOURCE | VENTILATION | ETA 14
InPort_14016684_2 | SINK | VENTILATION | ETA 14
OutPort_13152511_1 | SOURCE | VENTILATION | ETA 14
InPort_13154564_0 | SINK | VENTILATION | SUP 24
OutPort_13907368_1 | SOURCE | VENTILATION | SUP 24
InPort_14120170_1 | SINK | VENTILATION | SUP 24
OutPort_13154564_1 | SOURCE | VENTILATION | SUP 24
Port_13154670_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13227939_3 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13154670_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13154801_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13154814_3 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13154801_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13925588_1 | SINK | VENTILATION | SUP 24
OutPort_13154801_2 | SOURCE | VENTILATION | SUP 24
InPort_13925612_1 | SINK | VENTILATION | SUP 24
OutPort_13154801_3 | SOURCE | VENTILATION | SUP 24
Port_13154814_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13154859_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13154814_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13430013_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13154815_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13430013_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13154815_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13430037_2 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13926853_1 | SINK | VENTILATION | SUP 24
OutPort_13154830_0 | SOURCE | VENTILATION | SUP 24
InPort_13154830_1 | SINK | VENTILATION | SUP 24
OutPort_13927053_2 | SOURCE | VENTILATION | SUP 24
InPort_13154848_0 | SINK | VENTILATION | SUP 24
OutPort_13154858_3 | SOURCE | VENTILATION | SUP 24
InPort_13927055_2 | SINK | VENTILATION | SUP 24
OutPort_13154848_1 | SOURCE | VENTILATION | SUP 24
Port_13154858_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13154939_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13154858_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13154859_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13154924_0 | SINK | VENTILATION | SUP 24
OutPort_14078626_1 | SOURCE | VENTILATION | SUP 24
Port_13154924_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13925435_1 | SINK | VENTILATION | SUP 24
OutPort_13154924_2 | SOURCE | VENTILATION | SUP 24
Port_13154939_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14078576_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13155005_1 | SOURCEANDSINK | VENTILATION | SUP 2
Port_13926666_0 | SOURCEANDSINK | VENTILATION | SUP 2
Port_13155005_2 | SOURCEANDSINK | VENTILATION | SUP 2
InPort_13926765_2 | SINK | VENTILATION | SUP 35
OutPort_13155007_0 | SOURCE | VENTILATION | SUP 35
InPort_13155007_1 | SINK | VENTILATION | SUP 35
OutPort_13926767_1 | SOURCE | VENTILATION | SUP 35
InPort_13155011_0 | SINK | VENTILATION | SUP 35
OutPort_13926793_1 | SOURCE | VENTILATION | SUP 35
Port_13155011_1 | SOURCEANDSINK | VENTILATION | SUP 35
InPort_13925663_1 | SINK | VENTILATION | SUP 35
OutPort_13155011_2 | SOURCE | VENTILATION | SUP 35
InPort_13925687_1 | SINK | VENTILATION | SUP 35
OutPort_13155011_3 | SOURCE | VENTILATION | SUP 35
Port_13155646_0 | SOURCEANDSINK | VENTILATION | SUP 59
Port_13877925_1 | SOURCEANDSINK | VENTILATION | SUP 59
Port_13155646_1 | SOURCEANDSINK | VENTILATION | SUP 59
InPort_13889390_1 | SINK | VENTILATION | SUP 59
OutPort_13155646_2 | SOURCE | VENTILATION | SUP 59
InPort_13889414_1 | SINK | VENTILATION | SUP 59
OutPort_13155646_3 | SOURCE | VENTILATION | SUP 59
InPort_13889446_1 | SINK | VENTILATION | SUP 59
OutPort_13155646_4 | SOURCE | VENTILATION | SUP 59
Port_13155836_0 | SOURCEANDSINK | VENTILATION | SUP 59
Port_13877725_1 | SOURCEANDSINK | VENTILATION | SUP 59
Port_13155836_1 | SOURCEANDSINK | VENTILATION | SUP 59
Port_13713074_1 | SOURCEANDSINK | VENTILATION | SUP 59
Port_13155849_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13155859_3 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13155849_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13713072_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13155859_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13155917_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13155859_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13155860_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13155860_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13713179_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13155917_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877286_0 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13155972_0 | SINK | VENTILATION | SUP 24
OutPort_13156249_1 | SOURCE | VENTILATION | SUP 24
InPort_13156071_2 | SINK | VENTILATION | SUP 24
OutPort_13155972_1 | SOURCE | VENTILATION | SUP 24
InPort_13876779_0 | SINK | VENTILATION | SUP 24
OutPort_13156071_1 | SOURCE | VENTILATION | SUP 24
InPort_13156095_0 | SINK | VENTILATION | SUP 24
OutPort_13876401_1 | SOURCE | VENTILATION | SUP 24
Port_13156095_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13888790_1 | SINK | VENTILATION | SUP 24
OutPort_13156095_2 | SOURCE | VENTILATION | SUP 24
InPort_13888818_1 | SINK | VENTILATION | SUP 24
OutPort_13156095_3 | SOURCE | VENTILATION | SUP 24
InPort_13888842_1 | SINK | VENTILATION | SUP 24
OutPort_13156095_4 | SOURCE | VENTILATION | SUP 24
InPort_13156119_0 | SINK | VENTILATION | SUP 24
OutPort_13877820_1 | SOURCE | VENTILATION | SUP 24
Port_13156119_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13888903_1 | SINK | VENTILATION | SUP 24
OutPort_13156119_2 | SOURCE | VENTILATION | SUP 24
InPort_13888923_1 | SINK | VENTILATION | SUP 24
OutPort_13156119_3 | SOURCE | VENTILATION | SUP 24
InPort_13889022_1 | SINK | VENTILATION | SUP 24
OutPort_13156119_4 | SOURCE | VENTILATION | SUP 24
InPort_13156216_0 | SINK | VENTILATION | SUP 24
OutPort_13877824_1 | SOURCE | VENTILATION | SUP 24
Port_13156216_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13889058_1 | SINK | VENTILATION | SUP 24
OutPort_13156216_2 | SOURCE | VENTILATION | SUP 24
InPort_13889092_1 | SINK | VENTILATION | SUP 24
OutPort_13156216_3 | SOURCE | VENTILATION | SUP 24
