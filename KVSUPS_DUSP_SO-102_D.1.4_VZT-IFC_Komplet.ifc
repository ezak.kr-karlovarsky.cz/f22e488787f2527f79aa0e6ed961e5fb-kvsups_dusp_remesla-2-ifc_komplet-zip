Properties of the parts of a building model (IFC4), part 36 of 45

# IfcDuctFitting: Pravoúhlý přechod, koleno, poloměr, přírubový:Standardní (57)
Jiné - Typ: Standardní; Délka 17: 500 mm; e1: 50 mm; e2: 50 mm; f1: 50 mm; f2: 50 mm; Id typu: 1165284; r1: 100 mm; Rodina: Pravoúhlý přechod, koleno, poloměr, přírubový; Rodina a typ: Pravoúhlý přechod, koleno, poloměr, přírubový: Standardní; Šířka 2: 200 mm; Viditelnost 1: yes; Viditelnost 2: no
Name (Pravoúhlý přechod, koleno, poloměr, přírubový:Standardní:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | a (mm) = c (mm) = Výš. (mm) | alfa (deg) = alfa 2 (deg) = alfa 3 (deg) = alfa 4 (deg) | b (mm) | d (mm) | Objem (m3) | Příruba a (mm) = Příruba c (mm) | Příruba b (mm) | Příruba d (mm) | Velikost | Kód prvku | Označení | Páteřní trasa | alfa 1 (deg) | Délka 1 (mm) | Délka 10 (mm) | Délka 11 (mm) | Délka 12 (mm) | Délka 13 (mm) | Délka 14 (mm) | Délka 15 (mm) | Délka 16 (mm) | Délka 18 (mm) = Délka 19 (mm) | Délka 2 (mm) | Délka 20 (mm) = Délka 21 (mm) = Posouzení 2 (mm) | Délka 22 (mm) | Délka 23 (mm) = r2 (mm) = r3 (mm) | Délka 24 (mm) | Délka 25 (mm) | Délka 3 (mm) | Délka 4 (mm) | Délka 5 (mm) | Délka 6 (mm) | Délka 7 (mm) | Délka 8 (mm) | Délka 9 (mm) | Max ab (mm) | Max abcd (mm) | Max bd (mm) | Max cd (mm) | Polovina b (mm) | Posouzení 1 (mm) | r4 (mm) | Šířka 1 (mm)
13089366 | 2.NP_SO-102 | 1120 | 0.03465 | 1.5344 | 630 mm × 1120 mm-630 mm × 1120 mm | 0 | 630 mm × 1120 mm-630 mm × 1120 mm | 0 | 2.NP_SO-102 | 2543.58 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 6 | ODA | 1120 | 90 | 630 | 630 | 0.537585 | 1180 | 690 | 690 | 630 × 1120-630 × 1120 | TA00.03.0003 | 0003 | yes | 90 | 10415 | 0 | 50 | 0 | 5 | 780 | 780 | 1032.38 | 730 | 415 | 0 | 730 | 730 | 630 | 830 | 415 | 415 | 0 | 10000 | 0 | 415 | 465 | 1120 | 1120 | 630 | 1120 | 315 | 730 | 1230 | 1145
13113350 | 2.NP_SO-102 | 450 | 0.0605 | 1.0395 | 1100 mm × 450 mm-450 mm × 450 mm | 0 | 1100 mm × 450 mm-450 mm × 450 mm | 0 | 2.NP_SO-102 | 2775 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 7 | ODA | 450 | 90 | 1100 | 450 | 0.302616 | 510 | 1160 | 510 | 1100 × 450-450 × 450 | TA00.03.0028 | 0028 | yes | 90 | 10325 | 0 | 50 | 0 | 5 | 600 | 1250 | 1320.04 | 550 | 650 | 0 | 550 | 550 | 450 | 650 | 325 | 650 | 325 | 10000 | 0 | 650 | 375 | 1100 | 1100 | 1100 | 450 | 550 | 550 | 1050 | 1850
13113389 | 2.NP_SO-102 | 450 | 0.0616 | 1.0575 | 1120 mm × 450 mm-450 mm × 450 mm | 0 | 1120 mm × 450 mm-450 mm × 450 mm | -1386036 | 2.NP_SO-102 | 2775 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 7 | ODA | 450 | 90 | 1120 | 450 | 0.308061 | 510 | 1180 | 510 | 1120 × 450-450 × 450 | TA00.03.0029 | 0029 | yes | 90 | 10325 | 0 | 50 | 0 | 5 | 600 | 1270 | 1338.25 | 550 | 660 | 0 | 550 | 550 | 450 | 650 | 325 | 660 | 335 | 10000 | 0 | 660 | 375 | 1120 | 1120 | 1120 | 450 | 560 | 550 | 1050 | 1880
13641284 | -1.PP_SO-102 | 560 | 0.06875 | 1.4616 | 1250 mm × 560 mm-1250 mm × 560 mm | 0 | 1250 mm × 560 mm-1250 mm × 560 mm | 24.3469 | -1.PP_SO-102 | 2400 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 8 | ODA | 560 | 90 | 1250 | 1250 | 0.874222 | 620 | 1310 | 1310 | 1250 × 560-1250 × 560 | TA00.03.0161 | 0161 | yes | 90 | 10725 | 0 | 50 | 0 | 5 | 1400 | 1400 | 1909.19 | 1350 | 725 | 0 | 1350 | 1350 | 1250 | 1450 | 725 | 725 | 0 | 10000 | 0 | 725 | 775 | 1250 | 1250 | 1250 | 1250 | 625 | 1350 | 1850 | 2075
13641285 | -1.PP_SO-102 | 1250 | 0.0308 | 1.5375 | 560 mm × 1250 mm-560 mm × 1250 mm | 0 | 560 mm × 1250 mm-560 mm × 1250 mm | 0 | -1.PP_SO-102 | 2400 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 8 | ODA | 1250 | 30 | 560 | 560 | 0.216277 | 1310 | 620 | 620 | 560 × 1250-560 × 1250 | TA00.03.0162 | 0162 | yes | 150 | 10101.8 | 43.3013 | 25 | 4.33013 | 2.5 | 431.051 | 380 | 341.641 | 330 | 380 | 153.154 | 176.846 | 660 | 560 | 760 | 380 | 101.821 | 0 | 9911.82 | 329.09 | 101.821 | 151.821 | 1250 | 1250 | 560 | 1250 | 280 | 176.846 | 1160 | 1040
13641305 | -1.PP_SO-102 | 560 | 0.0825 | 1.7416 | 1500 mm × 560 mm-1250 mm × 560 mm | 0 | 1500 mm × 560 mm-1250 mm × 560 mm | 0 | -1.PP_SO-102 | 2400 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 8 | ODA | 560 | 90 | 1500 | 1250 | 1.07091 | 620 | 1560 | 1310 | 1500 × 560-1250 × 560 | TA00.03.0163 | 0163 | yes | 90 | 10725 | 0 | 50 | 0 | 5 | 1400 | 1650 | 2093.44 | 1350 | 850 | 0 | 1350 | 1350 | 1250 | 1450 | 725 | 850 | 125 | 10000 | 0 | 850 | 775 | 1500 | 1500 | 1500 | 1250 | 750 | 1350 | 1850 | 2450
13746983 | 2.NP_SO-102 | 1120 | 0.03465 | 1.5344 | 630 mm × 1120 mm-630 mm × 1120 mm | 0 | 630 mm × 1120 mm-630 mm × 1120 mm | 0 | 2.NP_SO-102 | 809 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 6 | ODA | 1120 | 90 | 630 | 630 | 0.537585 | 1180 | 690 | 690 | 630 × 1120-630 × 1120 | TA00.03.0240 | 0240 | yes | 90 | 10415 | 0 | 50 | 0 | 5 | 780 | 780 | 1032.38 | 730 | 415 | 0 | 730 | 730 | 630 | 830 | 415 | 415 | 0 | 10000 | 0 | 415 | 465 | 1120 | 1120 | 630 | 1120 | 315 | 730 | 1230 | 1145
13794486 | 1.NP_SO-102 | 450 | 0.0275 | 0.4995 | 500 mm × 450 mm-280 mm × 450 mm | 15 | 530 mm × 480 mm-310 mm × 480 mm | 0 | 1.NP_SO-102 | 2990.01 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 25 | ODA | 450 | 90 | 500 | 280 | 0.104426 | 510 | 560 | 340 | 500 × 450-280 × 450 | TA00.03.0326 | 0326 | yes | 90 | 10240 | 0 | 50 | 0 | 5 | 430 | 650 | 710.211 | 380 | 350 | 0 | 380 | 380 | 280 | 480 | 240 | 350 | 110 | 10000 | 0 | 350 | 290 | 500 | 500 | 500 | 450 | 250 | 380 | 880 | 950 | Izolace - Typ izolace: Protipožární; Fázování - Bouráno ve FÁZI 2: yes
13802164 | 4.NP_SO-102 | 450 | 0.0275 | 0.4995 | 500 mm × 450 mm-500 mm × 450 mm | 0 | 500 mm × 450 mm-500 mm × 450 mm | 0 | STŘECHA_SO-102 | 1475.5 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 450 | 90 | 500 | 500 | 0.148449 | 510 | 560 | 560 | 500 × 450-500 × 450 | TA00.03.0343 | 0343 | yes | 90 | 10350 | 0 | 50 | 0 | 5 | 650 | 650 | 848.528 | 600 | 350 | 0 | 600 | 600 | 500 | 700 | 350 | 350 | 0 | 10000 | 0 | 350 | 400 | 500 | 500 | 500 | 500 | 250 | 600 | 1100 | 950
13802165 | 4.NP_SO-102 | 560 | 0.03905 | 0.8568 | 710 mm × 560 mm-450 mm × 560 mm | 15 | 740 mm × 590 mm-480 mm × 590 mm | 0 | STŘECHA_SO-102 | 1475.5 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 560 | 90 | 710 | 450 | 0.244457 | 620 | 770 | 510 | 710 × 560-450 × 560 | TA00.03.0344 | 0344 | yes | 90 | 10325 | 0 | 50 | 0 | 5 | 600 | 860 | 979.081 | 550 | 455 | 0 | 550 | 550 | 450 | 650 | 325 | 455 | 130 | 10000 | 0 | 455 | 375 | 710 | 710 | 710 | 560 | 355 | 550 | 1050 | 1265 | Izolace - Typ izolace: Protipožární
13806182 | -1.PP_SO-102 | 500 | 0.044 | 0.855 | 800 mm × 500 mm-800 mm × 500 mm | 0 | 800 mm × 500 mm-800 mm × 500 mm | 0 | -1.PP_SO-102 | 3000 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 17 | ODA | 500 | 45 | 800 | 800 | 0.201079 | 560 | 860 | 860 | 800 × 500-800 × 500 | TA00.03.0354 | 0354 | yes | 135 | 10207.1 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 950 | 686.396 | 688.83 | 636.396 | 500 | 263.604 | 372.792 | 900 | 800 | 1000 | 500 | 207.107 | 0 | 9853.55 | 353.553 | 207.107 | 257.107 | 800 | 800 | 800 | 800 | 400 | 372.792 | 1400 | 1400
13806198 | -1.PP_SO-102 |  |  |  | 800 mm × 500 mm-630 mm × 500 mm | 0 | 800 mm × 500 mm-630 mm × 500 mm | 0 | -1.PP_SO-102 | 3000 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 17 | ODA | 500 | 45 | 800 | 630 | 0.166778 | 560 | 860 | 690 | 800 × 500-630 × 500 | TA00.03.0355 | 0355 | yes | 135 | 10086.9 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 950 | 686.396 | 643.243 | 516.188 | 500 | 383.812 | 132.376 | 319.584 | 630 | 830 | 415 | 207.107 | 85 | 9793.45 | 293.449 | 292.107 | 136.899 | 800 | 800 | 800 | 630 | 400 | 132.376 | 819.584 | 1400
13806215 | -1.PP_SO-102 | 280 | 0.03465 | 0.3836 | 630 mm × 280 mm-630 mm × 280 mm | 0 | 630 mm × 280 mm-630 mm × 280 mm | 0 | -1.PP_SO-102 | 3000 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 17 | ODA | 280 | 45 | 630 | 630 | 0.0768997 | 340 | 690 | 690 | 630 × 280-630 × 280 | TA00.03.0356 | 0356 | yes | 135 | 10171.9 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 780 | 566.188 | 558.718 | 516.188 | 415 | 213.812 | 302.376 | 730 | 630 | 830 | 415 | 171.899 | 0 | 9878.45 | 293.449 | 171.899 | 221.899 | 630 | 630 | 630 | 630 | 315 | 302.376 | 1230 | 1145
13806228 | -1.PP_SO-102 | 280 | 0.03465 | 0.3836 | 630 mm × 280 mm-630 mm × 280 mm | 0 | 630 mm × 280 mm-630 mm × 280 mm | 0 | -1.PP_SO-102 | 3000 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 17 | ODA | 280 | 45 | 630 | 630 | 0.0768997 | 340 | 690 | 690 | 630 × 280-630 × 280 | TA00.03.0357 | 0357 | yes | 135 | 10171.9 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 780 | 566.188 | 558.718 | 516.188 | 415 | 213.812 | 302.376 | 730 | 630 | 830 | 415 | 171.899 | 0 | 9878.45 | 293.449 | 171.899 | 221.899 | 630 | 630 | 630 | 630 | 315 | 302.376 | 1230 | 1145
13824915 | 2.NP_SO-102 | 400 | 0.055 | 0.844 | 1000 mm × 400 mm-1000 mm × 400 mm | 0 | 1000 mm × 400 mm-1000 mm × 400 mm | 40.4023 | 2.NP_SO-102 | 2750 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 14 | ODA | 400 | 90 | 1000 | 1000 | 0.420988 | 460 | 1060 | 1060 | 1000 × 400-1000 × 400 | TA00.03.0398 | 0398 | yes | 90 | 10600 | 0 | 50 | 0 | 5 | 1150 | 1150 | 1555.63 | 1100 | 600 | 0 | 1100 | 1100 | 1000 | 1200 | 600 | 600 | 0 | 10000 | 0 | 600 | 650 | 1000 | 1000 | 1000 | 1000 | 500 | 1100 | 1600 | 1700
13825228 | 2.NP_SO-102 | 400 | 0.055 | 0.844 | 1800 mm × 400 mm-1000 mm × 400 mm | 0 | 1800 mm × 400 mm-1000 mm × 400 mm | 0 | 2.NP_SO-102 | 2750 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 14 | ODA | 400 | 90 | 1000 | 1800 | 0.790411 | 460 | 1060 | 1860 | 1800 × 400-1000 × 400 | TA00.03.0399 | 0399 | yes | 90 | 11000 | 0 | 50 | 0 | 5 | 1950 | 1150 | 2195.45 | 1900 | 600 | 0 | 1100 | 1100 | 1000 | 2000 | 1000 | 600 | -400 | 10000 | 0 | 600 | 1050 | 1000 | 1800 | 1800 | 1800 | 500 | 1900 | 1600 | 2500
13845471 | 2.NP_SO-102 | 1800 | 0.022 | 1.638 | 400 mm × 1800 mm-400 mm × 1800 mm | 0 | 400 mm × 1800 mm-400 mm × 1800 mm | 0 | 2.NP_SO-102 | 2750 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 14 | ODA | 1800 | 90 | 400 | 400 | 0.41849 | 1860 | 460 | 460 | 400 × 1800-400 × 1800 | TA00.03.0412 | 0412 | yes | 90 | 10300 | 0 | 50 | 0 | 5 | 550 | 550 | 707.107 | 500 | 300 | 0 | 500 | 500 | 400 | 600 | 300 | 300 | 0 | 10000 | 0 | 300 | 350 | 1800 | 1800 | 400 | 1800 | 200 | 500 | 1000 | 800
13846611 | 2.NP_SO-102 | 560 | 0.06875 | 1.4616 | 1250 mm × 560 mm-1250 mm × 560 mm | 0 | 1250 mm × 560 mm-1250 mm × 560 mm | 0 | 2.NP_SO-102 | 2700 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 560 | 90 | 1250 | 1250 | 0.874222 | 620 | 1310 | 1310 | 1250 × 560-1250 × 560 | TA00.03.0416 | 0416 | yes | 90 | 10725 | 0 | 50 | 0 | 5 | 1400 | 1400 | 1909.19 | 1350 | 725 | 0 | 1350 | 1350 | 1250 | 1450 | 725 | 725 | 0 | 10000 | 0 | 725 | 775 | 1250 | 1250 | 1250 | 1250 | 625 | 1350 | 1850 | 2075
13847170 | 2.NP_SO-102 | 560 | 0.06875 | 1.4616 | 1250 mm × 560 mm-1250 mm × 560 mm | 0 | 1250 mm × 560 mm-1250 mm × 560 mm | 0 | 2.NP_SO-102 | 2800 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 560 | 90 | 1250 | 1250 | 0.874222 | 620 | 1310 | 1310 | 1250 × 560-1250 × 560 | TA00.03.0421 | 0421 | yes | 90 | 10725 | 0 | 50 | 0 | 5 | 1400 | 1400 | 1909.19 | 1350 | 725 | 0 | 1350 | 1350 | 1250 | 1450 | 725 | 725 | 0 | 10000 | 0 | 725 | 775 | 1250 | 1250 | 1250 | 1250 | 625 | 1350 | 1850 | 2075
13854331 | -1.PP_SO-102 | 1250 | 0.0308 | 1.5375 | 560 mm × 1250 mm-560 mm × 1250 mm | 0 | 560 mm × 1250 mm-560 mm × 1250 mm | 0 | -1.PP_SO-102 | 1783.91 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 8 | ODA | 1250 | 30 | 560 | 560 | 0.216277 | 1310 | 620 | 620 | 560 × 1250-560 × 1250 | TA00.03.0444 | 0444 | yes | 150 | 10101.8 | 43.3013 | 25 | 4.33013 | 2.5 | 431.051 | 380 | 341.641 | 330 | 380 | 153.154 | 176.846 | 660 | 560 | 760 | 380 | 101.821 | 0 | 9911.82 | 329.09 | 101.821 | 151.821 | 1250 | 1250 | 560 | 1250 | 280 | 176.846 | 1160 | 1040
13855999 | -1.PP_SO-102 | 560 | 0.088 | 1.8536 | 1600 mm × 560 mm-1250 mm × 560 mm | 0 | 1600 mm × 560 mm-1250 mm × 560 mm | 0 | -1.PP_SO-102 | 1783.91 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 8 | ODA | 560 | 90 | 1600 | 1250 | 1.1496 | 620 | 1660 | 1310 | 1600 × 560-1250 × 560 | TA00.03.0446 | 0446 | yes | 90 | 10725 | 0 | 50 | 0 | 5 | 1400 | 1750 | 2170.83 | 1350 | 900 | 0 | 1350 | 1350 | 1250 | 1450 | 725 | 900 | 175 | 10000 | 0 | 900 | 775 | 1600 | 1600 | 1600 | 1250 | 800 | 1350 | 1850 | 2600
13863132 | 2.NP_SO-102 | 1800 | 0.022 | 1.638 | 800 mm × 1800 mm-400 mm × 1800 mm | 0 | 800 mm × 1800 mm-400 mm × 1800 mm | 0 | 2.NP_SO-102 | 1809 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 14 | ODA | 1800 | 90 | 400 | 800 | 0.818091 | 1860 | 460 | 860 | 800 × 1800-400 × 1800 | TA00.03.0447 | 0447 | yes | 90 | 10500 | 0 | 50 | 0 | 5 | 950 | 550 | 1029.56 | 900 | 300 | 0 | 500 | 500 | 400 | 1000 | 500 | 300 | -200 | 10000 | 0 | 300 | 550 | 1800 | 1800 | 800 | 1800 | 200 | 900 | 1000 | 1200
13896742 | 2.NP_SO-102 | 315 | 0.0308 | 0.38745 | 560 mm × 315 mm-560 mm × 315 mm | 0 | 560 mm × 315 mm-560 mm × 315 mm | 0 | 2.NP_SO-102 | 2775 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 7 | ODA | 315 | 45 | 560 | 560 | 0.0720507 | 375 | 620 | 620 | 560 × 315-560 × 315 | TA00.03.0626 | 0626 | yes | 135 | 10157.4 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 710 | 516.69 | 505.142 | 466.69 | 380 | 193.31 | 273.381 | 660 | 560 | 760 | 380 | 157.401 | 0 | 9888.7 | 268.701 | 157.401 | 207.401 | 560 | 560 | 560 | 560 | 280 | 273.381 | 1160 | 1040
13917391 | -1.PP_SO-102 | 400 | 0.022 | 0.364 | 500 mm × 400 mm-400 mm × 400 mm | 15 | 530 mm × 430 mm-430 mm × 430 mm | 0 | -1.PP_SO-102 | -1450 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 400 | 90 | 400 | 500 | 0.115199 | 460 | 460 | 560 | 500 × 400-400 × 400 | TA00.03.0700 | 0700 | yes | 90 | 10350 | 0 | 50 | 0 | 5 | 650 | 550 | 781.025 | 600 | 300 | 0 | 500 | 500 | 400 | 700 | 350 | 300 | -50 | 10000 | 0 | 300 | 400 | 400 | 500 | 500 | 500 | 200 | 600 | 1000 | 900 | Izolace - Typ izolace: Protipožární
13918509 | -1.PP_SO-102 | 560 | 0.022 | 0.5096 | 400 mm × 560 mm-315 mm × 560 mm | 15 | 430 mm × 590 mm-345 mm × 590 mm | 0 | -1.PP_SO-102 | 3120 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 21 | ODA | 560 | 90 | 400 | 315 | 0.113126 | 620 | 460 | 375 | 400 × 560-315 × 560 | TA00.03.0702 | 0702 | yes | 90 | 10257.5 | 0 | 50 | 0 | 5 | 465 | 550 | 649.788 | 415 | 300 | 0 | 415 | 415 | 315 | 515 | 257.5 | 300 | 42.5 | 10000 | 0 | 300 | 307.5 | 560 | 560 | 400 | 560 | 200 | 415 | 915 | 800 | Izolace - Typ izolace: Protipožární
13968059 | -1.PP_SO-102 | 1600 | 0.0308 | 1.968 | 560 mm × 1600 mm-560 mm × 1600 mm | 0 | 560 mm × 1600 mm-560 mm × 1600 mm | 0 | -1.PP_SO-102 | 1783.91 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 8 | ODA | 1600 | 90 | 560 | 560 | 0.633388 | 1660 | 620 | 620 | 560 × 1600-560 × 1600 | TA00.03.0852 | 0852 | yes | 90 | 10380 | 0 | 50 | 0 | 5 | 710 | 710 | 933.381 | 660 | 380 | 0 | 660 | 660 | 560 | 760 | 380 | 380 | 0 | 10000 | 0 | 380 | 430 | 1600 | 1600 | 560 | 1600 | 280 | 660 | 1160 | 1040
13992408 | 4.NP_SO-102 | 450 | 0.0275 | 0.4995 | 500 mm × 450 mm-500 mm × 450 mm | 0 | 500 mm × 450 mm-500 mm × 450 mm | 0 | STŘECHA_SO-102 | 1000 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 10 | ODA | 450 | 90 | 500 | 500 | 0.148449 | 510 | 560 | 560 | 500 × 450-500 × 450 | TA00.03.0908 | 0908 | yes | 90 | 10350 | 0 | 50 | 0 | 5 | 650 | 650 | 848.528 | 600 | 350 | 0 | 600 | 600 | 500 | 700 | 350 | 350 | 0 | 10000 | 0 | 350 | 400 | 500 | 500 | 500 | 500 | 250 | 600 | 1100 | 950
14008423 | 4.NP_SO-102 | 900 | 0.02475 | 0.909 | 450 mm × 900 mm-450 mm × 900 mm | 0 | 450 mm × 900 mm-450 mm × 900 mm | 16.5225 | STŘECHA_SO-102 | -4350 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 3 | ODA | 900 | 90 | 450 | 450 | 0.251305 | 960 | 510 | 510 | 450 × 900-450 × 900 | TA00.03.0950 | 0950 | yes | 90 | 10325 | 0 | 50 | 0 | 5 | 600 | 600 | 777.817 | 550 | 325 | 0 | 550 | 550 | 450 | 650 | 325 | 325 | 0 | 10000 | 0 | 325 | 375 | 900 | 900 | 450 | 900 | 225 | 550 | 1050 | 875
14009759 | 3.NP_SO-102 | 560 | 0.017325 | 0.4144 | 315 mm × 560 mm-315 mm × 560 mm | 0 | 315 mm × 560 mm-315 mm × 560 mm | 0 | 3.NP_SO-102 | 3500 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 7 | ODA | 560 | 90 | 315 | 315 | 0.0907533 | 620 | 375 | 375 | 315 × 560-315 × 560 | TA00.03.0952 | 0952 | yes | 90 | 10257.5 | 0 | 50 | 0 | 5 | 465 | 465 | 586.899 | 415 | 257.5 | 0 | 415 | 415 | 315 | 515 | 257.5 | 257.5 | 0 | 10000 | 0 | 257.5 | 307.5 | 560 | 560 | 315 | 560 | 157.5 | 415 | 915 | 672.5
14009937 | 3.NP_SO-102 | 1600 | 0.022 | 1.456 | 400 mm × 1600 mm-400 mm × 1600 mm | 0 | 400 mm × 1600 mm-400 mm × 1600 mm | 22.9381 | 3.NP_SO-102 | 3500 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 6 | ODA | 1600 | 90 | 400 | 400 | 0.371991 | 1660 | 460 | 460 | 400 × 1600-400 × 1600 | TA00.03.0953 | 0953 | yes | 90 | 10300 | 0 | 50 | 0 | 5 | 550 | 550 | 707.107 | 500 | 300 | 0 | 500 | 500 | 400 | 600 | 300 | 300 | 0 | 10000 | 0 | 300 | 350 | 1600 | 1600 | 400 | 1600 | 200 | 500 | 1000 | 800
14010185 | 3.NP_SO-102 | 1000 | 0.022 | 0.91 | 400 mm × 1000 mm-400 mm × 1000 mm | 0 | 400 mm × 1000 mm-400 mm × 1000 mm | 0 | 3.NP_SO-102 | 3500 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 14 | ODA | 1000 | 90 | 400 | 400 | 0.232494 | 1060 | 460 | 460 | 400 × 1000-400 × 1000 | TA00.03.0954 | 0954 | yes | 90 | 10300 | 0 | 50 | 0 | 5 | 550 | 550 | 707.107 | 500 | 300 | 0 | 500 | 500 | 400 | 600 | 300 | 300 | 0 | 10000 | 0 | 300 | 350 | 1000 | 1000 | 400 | 1000 | 200 | 500 | 1000 | 800
14030562 | 2.NP_SO-102 | 400 | 0.055 | 0.844 | 1000 mm × 400 mm-1000 mm × 400 mm | 0 | 1000 mm × 400 mm-1000 mm × 400 mm | 0 | 2.NP_SO-102 | 2159 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 11 | ETA | 400 | 90 | 1000 | 1000 | 0.420988 | 460 | 1060 | 1060 | 1000 × 400-1000 × 400 | TA00.03.0982 | 0982 | yes | 90 | 10600 | 0 | 50 | 0 | 5 | 1150 | 1150 | 1555.63 | 1100 | 600 | 0 | 1100 | 1100 | 1000 | 1200 | 600 | 600 | 0 | 10000 | 0 | 600 | 650 | 1000 | 1000 | 1000 | 1000 | 500 | 1100 | 1600 | 1700
14032231 | 2.NP_SO-102 | 400 | 0.055 | 0.844 | 1000 mm × 400 mm-1000 mm × 400 mm | 0 | 1000 mm × 400 mm-1000 mm × 400 mm | 0 | 2.NP_SO-102 | 2159 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 11 | ETA | 400 | 90 | 1000 | 1000 | 0.420988 | 460 | 1060 | 1060 | 1000 × 400-1000 × 400 | TA00.03.0983 | 0983 | yes | 90 | 10600 | 0 | 50 | 0 | 5 | 1150 | 1150 | 1555.63 | 1100 | 600 | 0 | 1100 | 1100 | 1000 | 1200 | 600 | 600 | 0 | 10000 | 0 | 600 | 650 | 1000 | 1000 | 1000 | 1000 | 500 | 1100 | 1600 | 1700
14032232 | 2.NP_SO-102 | 1000 | 0.022 | 0.91 | 400 mm × 1000 mm-400 mm × 1000 mm | 0 | 400 mm × 1000 mm-400 mm × 1000 mm | 0 | 2.NP_SO-102 | 2159 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 11 | ETA | 1000 | 90 | 400 | 400 | 0.232494 | 1060 | 460 | 460 | 400 × 1000-400 × 1000 | TA00.03.0984 | 0984 | yes | 90 | 10300 | 0 | 50 | 0 | 5 | 550 | 550 | 707.107 | 500 | 300 | 0 | 500 | 500 | 400 | 600 | 300 | 300 | 0 | 10000 | 0 | 300 | 350 | 1000 | 1000 | 400 | 1000 | 200 | 500 | 1000 | 800
14032915 | 2.NP_SO-102 | 400 | 0.055 | 0.844 | 1000 mm × 400 mm-1000 mm × 400 mm | 0 | 1000 mm × 400 mm-1000 mm × 400 mm | 0 | 2.NP_SO-102 | 2539.59 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 11 | SUP | 400 | 90 | 1000 | 1000 | 0.420988 | 460 | 1060 | 1060 | 1000 × 400-1000 × 400 | TA00.03.0987 | 0987 | yes | 90 | 10600 | 0 | 50 | 0 | 5 | 1150 | 1150 | 1555.63 | 1100 | 600 | 0 | 1100 | 1100 | 1000 | 1200 | 600 | 600 | 0 | 10000 | 0 | 600 | 650 | 1000 | 1000 | 1000 | 1000 | 500 | 1100 | 1600 | 1700
14032929 | 2.NP_SO-102 | 400 | 0.055 | 0.844 | 1000 mm × 400 mm-1000 mm × 400 mm | 0 | 1000 mm × 400 mm-1000 mm × 400 mm | 0 | 2.NP_SO-102 | 2539.59 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 11 | SUP | 400 | 90 | 1000 | 1000 | 0.420988 | 460 | 1060 | 1060 | 1000 × 400-1000 × 400 | TA00.03.0988 | 0988 | yes | 90 | 10600 | 0 | 50 | 0 | 5 | 1150 | 1150 | 1555.63 | 1100 | 600 | 0 | 1100 | 1100 | 1000 | 1200 | 600 | 600 | 0 | 10000 | 0 | 600 | 650 | 1000 | 1000 | 1000 | 1000 | 500 | 1100 | 1600 | 1700
14032942 | 2.NP_SO-102 | 1000 | 0.022 | 0.91 | 400 mm × 1000 mm-400 mm × 1000 mm | 0 | 400 mm × 1000 mm-400 mm × 1000 mm | 0 | 2.NP_SO-102 | 809 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 11 | SUP | 1000 | 90 | 400 | 400 | 0.232494 | 1060 | 460 | 460 | 400 × 1000-400 × 1000 | TA00.03.0990 | 0990 | yes | 90 | 10300 | 0 | 50 | 0 | 5 | 550 | 550 | 707.107 | 500 | 300 | 0 | 500 | 500 | 400 | 600 | 300 | 300 | 0 | 10000 | 0 | 300 | 350 | 1000 | 1000 | 400 | 1000 | 200 | 500 | 1000 | 800
14066238 | -1.PP_SO-102 | 280 | 0.022 | 0.2548 | 400 mm × 280 mm-400 mm × 280 mm | 15 | 430 mm × 310 mm-430 mm × 310 mm | 0 | -1.PP_SO-102 | 2600 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 280 | 90 | 400 | 400 | 0.0650984 | 340 | 460 | 460 | 400 × 280-400 × 280 | TA00.03.1124 | 1124 | yes | 90 | 10300 | 0 | 50 | 0 | 5 | 550 | 550 | 707.107 | 500 | 300 | 0 | 500 | 500 | 400 | 600 | 300 | 300 | 0 | 10000 | 0 | 300 | 350 | 400 | 400 | 400 | 400 | 200 | 500 | 1000 | 800 | Izolace - Typ izolace: Protipožární
14067813 | -1.PP_SO-102 | 450 | 0.022 | 0.4095 | 710 mm × 450 mm-400 mm × 450 mm | 15 | 740 mm × 480 mm-430 mm × 480 mm | 0 | -1.PP_SO-102 | 2600 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 450 | 90 | 400 | 710 | 0.182045 | 510 | 460 | 770 | 710 × 450-400 × 450 | TA00.03.1128 | 1128 | yes | 90 | 10455 | 0 | 50 | 0 | 5 | 860 | 550 | 951.893 | 810 | 300 | 0 | 500 | 500 | 400 | 910 | 455 | 300 | -155 | 10000 | 0 | 300 | 505 | 450 | 710 | 710 | 710 | 200 | 810 | 1000 | 1110 | Izolace - Typ izolace: Protipožární
14124621 | 1.NP_SO-102 | 400 | 0.055 | 0.844 | 1000 mm × 400 mm-1000 mm × 400 mm | 0 | 1000 mm × 400 mm-1000 mm × 400 mm | 0 | 1.NP_SO-102 | 3050 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 11 | ETA | 400 | 90 | 1000 | 1000 | 0.420988 | 460 | 1060 | 1060 | 1000 × 400-1000 × 400 | TA00.03.1297 | 1297 | yes | 90 | 10600 | 0 | 50 | 0 | 5 | 1150 | 1150 | 1555.63 | 1100 | 600 | 0 | 1100 | 1100 | 1000 | 1200 | 600 | 600 | 0 | 10000 | 0 | 600 | 650 | 1000 | 1000 | 1000 | 1000 | 500 | 1100 | 1600 | 1700
14124622 | 2.NP_SO-102 | 1000 | 0.022 | 0.91 | 400 mm × 1000 mm-400 mm × 1000 mm | 0 | 400 mm × 1000 mm-400 mm × 1000 mm | 0 | 2.NP_SO-102 | -750 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 11 | ETA | 1000 | 90 | 400 | 400 | 0.232494 | 1060 | 460 | 460 | 400 × 1000-400 × 1000 | TA00.03.1298 | 1298 | yes | 90 | 10300 | 0 | 50 | 0 | 5 | 550 | 550 | 707.107 | 500 | 300 | 0 | 500 | 500 | 400 | 600 | 300 | 300 | 0 | 10000 | 0 | 300 | 350 | 1000 | 1000 | 400 | 1000 | 200 | 500 | 1000 | 800
14145777 | 2.NP_SO-102 | 1000 | 0.022 | 0.91 | 400 mm × 1000 mm-400 mm × 1000 mm | 0 | 400 mm × 1000 mm-400 mm × 1000 mm | 0 | 2.NP_SO-102 | 2750 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 14 | ODA | 1000 | 90 | 400 | 400 | 0.232494 | 1060 | 460 | 460 | 400 × 1000-400 × 1000 | TA00.03.1335 | 1335 | yes | 90 | 10300 | 0 | 50 | 0 | 5 | 550 | 550 | 707.107 | 500 | 300 | 0 | 500 | 500 | 400 | 600 | 300 | 300 | 0 | 10000 | 0 | 300 | 350 | 1000 | 1000 | 400 | 1000 | 200 | 500 | 1000 | 800
14145809 | 2.NP_SO-102 | 1600 | 0.022 | 1.456 | 400 mm × 1600 mm-400 mm × 1600 mm | 0 | 400 mm × 1600 mm-400 mm × 1600 mm | 22.9381 | 2.NP_SO-102 | 2543.58 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 6 | ODA | 1600 | 90 | 400 | 400 | 0.371991 | 1660 | 460 | 460 | 400 × 1600-400 × 1600 | TA00.03.1337 | 1337 | yes | 90 | 10300 | 0 | 50 | 0 | 5 | 550 | 550 | 707.107 | 500 | 300 | 0 | 500 | 500 | 400 | 600 | 300 | 300 | 0 | 10000 | 0 | 300 | 350 | 1600 | 1600 | 400 | 1600 | 200 | 500 | 1000 | 800
14146225 | 2.NP_SO-102 | 315 | 0.0308 | 0.38745 | 560 mm × 315 mm-560 mm × 315 mm | 0 | 560 mm × 315 mm-560 mm × 315 mm | 0 | 2.NP_SO-102 | 2775 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 7 | ODA | 315 | 45 | 560 | 560 | 0.0720507 | 375 | 620 | 620 | 560 × 315-560 × 315 | TA00.03.1338 | 1338 | yes | 135 | 10157.4 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 710 | 516.69 | 505.142 | 466.69 | 380 | 193.31 | 273.381 | 660 | 560 | 760 | 380 | 157.401 | 0 | 9888.7 | 268.701 | 157.401 | 207.401 | 560 | 560 | 560 | 560 | 280 | 273.381 | 1160 | 1040
14146226 | 2.NP_SO-102 | 560 | 0.017325 | 0.4144 | 315 mm × 560 mm-315 mm × 560 mm | 0 | 315 mm × 560 mm-315 mm × 560 mm | 0 | 2.NP_SO-102 | 2775 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 7 | ODA | 560 | 90 | 315 | 315 | 0.0907533 | 620 | 375 | 375 | 315 × 560-315 × 560 | TA00.03.1339 | 1339 | yes | 90 | 10257.5 | 0 | 50 | 0 | 5 | 465 | 465 | 586.899 | 415 | 257.5 | 0 | 415 | 415 | 315 | 515 | 257.5 | 257.5 | 0 | 10000 | 0 | 257.5 | 307.5 | 560 | 560 | 315 | 560 | 157.5 | 415 | 915 | 672.5
14146297 | 2.NP_SO-102 | 900 | 0.02475 | 0.909 | 450 mm × 900 mm-400 mm × 900 mm | 0 | 450 mm × 900 mm-400 mm × 900 mm | -1960410 | 2.NP_SO-102 | 1759 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 3 | ODA | 900 | 90 | 450 | 400 | 0.234222 | 960 | 510 | 460 | 450 × 900-400 × 900 | TA00.03.1341 | 1341 | yes | 90 | 10300 | 0 | 50 | 0 | 5 | 550 | 600 | 743.303 | 500 | 325 | 0 | 500 | 500 | 400 | 600 | 300 | 325 | 25 | 10000 | 0 | 325 | 350 | 900 | 900 | 450 | 900 | 225 | 500 | 1000 | 875
14151429 | -1.PP_SO-102 | 1600 | 0.0308 | 1.968 | 560 mm × 1600 mm-560 mm × 1600 mm | 0 | 560 mm × 1600 mm-560 mm × 1600 mm | 0 | -1.PP_SO-102 | 559 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 8 | ODA | 1600 | 90 | 560 | 560 | 0.633388 | 1660 | 620 | 620 | 560 × 1600-560 × 1600 | TA00.03.1364 | 1364 | yes | 90 | 10380 | 0 | 50 | 0 | 5 | 710 | 710 | 933.381 | 660 | 380 | 0 | 660 | 660 | 560 | 760 | 380 | 380 | 0 | 10000 | 0 | 380 | 430 | 1600 | 1600 | 560 | 1600 | 280 | 660 | 1160 | 1040
14155816 | 4.NP_SO-102 | 450 | 0.0275 | 0.4995 | 500 mm × 450 mm-500 mm × 450 mm | 0 | 500 mm × 450 mm-500 mm × 450 mm | 0 | 4.NP_SO-102 | 5090 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 25 | ODA | 450 | 90 | 500 | 500 | 0.148449 | 510 | 560 | 560 | 500 × 450-500 × 450 | TA00.03.1374 | 1374 | yes | 90 | 10350 | 0 | 50 | 0 | 5 | 650 | 650 | 848.528 | 600 | 350 | 0 | 600 | 600 | 500 | 700 | 350 | 350 | 0 | 10000 | 0 | 350 | 400 | 500 | 500 | 500 | 500 | 250 | 600 | 1100 | 950 | Fázování - Bouráno ve FÁZI 2: yes
14155851 | 4.NP_SO-102 | 450 | 0.0275 | 0.4995 | 500 mm × 450 mm-500 mm × 450 mm | 0 | 500 mm × 450 mm-500 mm × 450 mm | 0 | STŘECHA_SO-102 | 1240 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 25 | ODA | 450 | 90 | 500 | 500 | 0.148449 | 510 | 560 | 560 | 500 × 450-500 × 450 | TA00.03.1376 | 1376 | yes | 90 | 10350 | 0 | 50 | 0 | 5 | 650 | 650 | 848.528 | 600 | 350 | 0 | 600 | 600 | 500 | 700 | 350 | 350 | 0 | 10000 | 0 | 350 | 400 | 500 | 500 | 500 | 500 | 250 | 600 | 1100 | 950 | Fázování - Bouráno ve FÁZI 2: yes
14156187 | 4.NP_SO-102 | 450 | 0.0275 | 0.4995 | 500 mm × 450 mm-500 mm × 450 mm | 0 | 500 mm × 450 mm-500 mm × 450 mm | 0 | STŘECHA_SO-102 | 1240 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 25 | ODA | 450 | 90 | 500 | 500 | 0.148449 | 510 | 560 | 560 | 500 × 450-500 × 450 | TA00.03.1379 | 1379 | yes | 90 | 10350 | 0 | 50 | 0 | 5 | 650 | 650 | 848.528 | 600 | 350 | 0 | 600 | 600 | 500 | 700 | 350 | 350 | 0 | 10000 | 0 | 350 | 400 | 500 | 500 | 500 | 500 | 250 | 600 | 1100 | 950 | Fázování - Bouráno ve FÁZI 2: yes
14157967 | 4.NP_SO-102 | 400 | 0.055 | 0.844 | 1120 mm × 400 mm-1000 mm × 400 mm | 0 | 1120 mm × 400 mm-1000 mm × 400 mm | 0 | 4.NP_SO-102 | 5100 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 400 | 90 | 1000 | 1120 | 0.476451 | 460 | 1060 | 1180 | 1120 × 400-1000 × 400 | TA00.03.1380 | 1380 | yes | 90 | 10660 | 0 | 50 | 0 | 5 | 1270 | 1150 | 1642.68 | 1220 | 600 | 0 | 1100 | 1100 | 1000 | 1320 | 660 | 600 | -60 | 10000 | 0 | 600 | 710 | 1000 | 1120 | 1120 | 1120 | 500 | 1220 | 1600 | 1820
14158681 | 4.NP_SO-102 | 1120 | 0.022 | 1.0192 | 400 mm × 1120 mm-400 mm × 1120 mm | 0 | 400 mm × 1120 mm-400 mm × 1120 mm | 0 | STŘECHA_SO-102 | 1250 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 1120 | 90 | 400 | 400 | 0.260394 | 1180 | 460 | 460 | 400 × 1120-400 × 1120 | TA00.03.1384 | 1384 | yes | 90 | 10300 | 0 | 50 | 0 | 5 | 550 | 550 | 707.107 | 500 | 300 | 0 | 500 | 500 | 400 | 600 | 300 | 300 | 0 | 10000 | 0 | 300 | 350 | 1120 | 1120 | 400 | 1120 | 200 | 500 | 1000 | 800
14158871 | 4.NP_SO-102 | 630 | 0.03465 | 0.8631 | 630 mm × 630 mm-630 mm × 630 mm | 0 | 630 mm × 630 mm-630 mm × 630 mm | 0 | STŘECHA_SO-102 | 1250 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 630 | 45 | 630 | 630 | 0.173024 | 690 | 690 | 690 | 630 × 630-630 × 630 | TA00.03.1385 | 1385 | yes | 135 | 10171.9 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 780 | 566.188 | 558.718 | 516.188 | 415 | 213.812 | 302.376 | 730 | 630 | 830 | 415 | 171.899 | 0 | 9878.45 | 293.449 | 171.899 | 221.899 | 630 | 630 | 630 | 630 | 315 | 302.376 | 1230 | 1145
14159389 | 4.NP_SO-102 | 1120 | 0.022 | 1.0192 | 400 mm × 1120 mm-400 mm × 1120 mm | 0 | 400 mm × 1120 mm-400 mm × 1120 mm | 0 | STŘECHA_SO-102 | 1250 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 1120 | 90 | 400 | 400 | 0.260394 | 1180 | 460 | 460 | 400 × 1120-400 × 1120 | TA00.03.1386 | 1386 | yes | 90 | 10300 | 0 | 50 | 0 | 5 | 550 | 550 | 707.107 | 500 | 300 | 0 | 500 | 500 | 400 | 600 | 300 | 300 | 0 | 10000 | 0 | 300 | 350 | 1120 | 1120 | 400 | 1120 | 200 | 500 | 1000 | 800
14159531 | 4.NP_SO-102 | 630 | 0.03465 | 0.8631 | 630 mm × 630 mm-630 mm × 630 mm | 0 | 630 mm × 630 mm-630 mm × 630 mm | 0 | STŘECHA_SO-102 | 1800 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 630 | 45 | 630 | 630 | 0.173024 | 690 | 690 | 690 | 630 × 630-630 × 630 | TA00.03.1388 | 1388 | yes | 135 | 10171.9 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 780 | 566.188 | 558.718 | 516.188 | 415 | 213.812 | 302.376 | 730 | 630 | 830 | 415 | 171.899 | 0 | 9878.45 | 293.449 | 171.899 | 221.899 | 630 | 630 | 630 | 630 | 315 | 302.376 | 1230 | 1145
14159533 | 4.NP_SO-102 | 630 | 0.055 | 1.3293 | 1000 mm × 630 mm-630 mm × 630 mm | 0 | 1000 mm × 630 mm-630 mm × 630 mm | 0 | 4.NP_SO-102 | 5650 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 12 | ODA | 630 | 90 | 1000 | 630 | 0.485373 | 690 | 1060 | 690 | 1000 × 630-630 × 630 | TA00.03.1389 | 1389 | yes | 90 | 10415 | 0 | 50 | 0 | 5 | 780 | 1150 | 1320.19 | 730 | 600 | 0 | 730 | 730 | 630 | 830 | 415 | 600 | 185 | 10000 | 0 | 600 | 465 | 1000 | 1000 | 1000 | 630 | 500 | 730 | 1230 | 1700
14184285 | 2.NP_SO-102 | 1120 | 0.03465 | 1.5344 | 630 mm × 1120 mm-630 mm × 1120 mm | 0 | 630 mm × 1120 mm-630 mm × 1120 mm | 0 | 2.NP_SO-102 | 2759 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 10 | EHA | 1120 | 90 | 630 | 630 | 0.537585 | 1180 | 690 | 690 | 630 × 1120-630 × 1120 | TA00.03.1505 | 1505 |  | 90 | 10415 | 0 | 50 | 0 | 5 | 780 | 780 | 1032.38 | 730 | 415 | 0 | 730 | 730 | 630 | 830 | 415 | 415 | 0 | 10000 | 0 | 415 | 465 | 1120 | 1120 | 630 | 1120 | 315 | 730 | 1230 | 1145

# IfcDuctFitting: Pravoúhlý přechod, koleno, poloměr, přírubový:Standardní (27)
Type - Material: 128-64-0
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - ID kategorie: R; Kód sestavy: TA00; Název typu: Standardní; Označení typu: 03; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: Pravoúhlý přechod, koleno, poloměr, přírubový
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Grafika - Použít měřítko poznámky: yes
Kóty - e: 0 mm; f: 0 mm; r: 100 mm; Rozšíření příruby: 30 mm; Tloušťka příruby: 5 mm
Jiné - Typ: Standardní; Id typu: 1165284; Rodina: Pravoúhlý přechod, koleno, poloměr, přírubový; Rodina a typ: Pravoúhlý přechod, koleno, poloměr, přírubový: Standardní; Viditelnost 1: yes; Viditelnost 2: no; Délka 17: 500 mm; e1: 50 mm; e2: 50 mm; f1: 50 mm; f2: 50 mm; r1: 100 mm; Šířka 2: 200 mm
Name (Pravoúhlý přechod, koleno, poloměr, přírubový:Standardní:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | alfa (deg) = alfa 2 (deg) = alfa 3 (deg) = alfa 4 (deg) | a (mm) = c (mm) = Výš. (mm) | b (mm) | d (mm) | Objem (m3) | Příruba a (mm) = Příruba c (mm) | Příruba b (mm) | Příruba d (mm) | Velikost | Kód prvku | Označení | Páteřní trasa | alfa 1 (deg) | Délka 10 (mm) | Délka 12 (mm) | Délka 20 (mm) = Délka 21 (mm) = Posouzení 2 (mm) | Délka 5 (mm) | Délka 7 (mm) | Délka 1 (mm) | Délka 11 (mm) | Délka 13 (mm) | Délka 14 (mm) | Délka 15 (mm) | Délka 16 (mm) | Délka 18 (mm) = Délka 19 (mm) | Délka 2 (mm) | Délka 22 (mm) | Délka 23 (mm) = r2 (mm) = r3 (mm) | Délka 24 (mm) | Délka 25 (mm) | Délka 3 (mm) | Délka 4 (mm) | Délka 6 (mm) | Délka 8 (mm) | Délka 9 (mm) | Max ab (mm) | Max abcd (mm) | Max bd (mm) | Max cd (mm) | Polovina b (mm) | Posouzení 1 (mm) | r4 (mm) | Šířka 1 (mm)
13113594 | 2.NP_SO-102 | 1120 | 0.02475 | 1.1312 | 450 mm × 1120 mm-450 mm × 1120 mm | 0 | 2.NP_SO-102 | 384 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 5 | EHA | 90 | 1120 | 450 | 450 | 0.312735 | 1180 | 510 | 510 | 450 × 1120-450 × 1120 | TA00.03.0030 | 0030 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10325 | 50 | 5 | 600 | 600 | 777.817 | 550 | 325 | 550 | 550 | 450 | 650 | 325 | 325 | 10000 | 325 | 375 | 1120 | 1120 | 450 | 1120 | 225 | 550 | 1050 | 875
13638087 | -1.PP_SO-102 | 500 | 0.077 | 1.455 | 1400 mm × 500 mm-1250 mm × 500 mm | 0 | -1.PP_SO-102 | 3050 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 1 | EHA | 90 | 500 | 1400 | 1250 | 0.885923 | 560 | 1460 | 1310 | 1400 × 500-1250 × 500 | TA00.03.0152 | 0152 | yes | 90 | 0 | 0 | 0 | 75 | 0 | 10725 | 50 | 5 | 1400 | 1550 | 2018.04 | 1350 | 800 | 1350 | 1350 | 1250 | 1450 | 725 | 800 | 10000 | 800 | 775 | 1400 | 1400 | 1400 | 1250 | 700 | 1350 | 1850 | 2300
13638357 | -1.PP_SO-102 | 1400 | 0.0275 | 1.554 | 500 mm × 1400 mm-500 mm × 1400 mm | 0 | -1.PP_SO-102 | 2300 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 1 | EHA | 45 | 1400 | 500 | 500 | 0.269422 | 1460 | 560 | 560 | 500 × 1400-500 × 1400 | TA00.03.0153 | 0153 | yes | 135 | 35.3553 | 3.53553 | 175.736 | 0 | 247.487 | 10145 | 35.3553 | 3.53553 | 650 | 474.264 | 459.22 | 424.264 | 350 | 248.528 | 600 | 500 | 700 | 350 | 144.975 | 9897.49 | 144.975 | 194.975 | 1400 | 1400 | 500 | 1400 | 250 | 248.528 | 1100 | 950
13638468 | -1.PP_SO-102 | 1400 | 0.0275 | 1.554 | 500 mm × 1400 mm-500 mm × 1400 mm | 0 | -1.PP_SO-102 | 3050 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 1 | EHA | 45 | 1400 | 500 | 500 | 0.269422 | 1460 | 560 | 560 | 500 × 1400-500 × 1400 | TA00.03.0154 | 0154 | yes | 135 | 35.3553 | 3.53553 | 175.736 | 0 | 247.487 | 10145 | 35.3553 | 3.53553 | 650 | 474.264 | 459.22 | 424.264 | 350 | 248.528 | 600 | 500 | 700 | 350 | 144.975 | 9897.49 | 144.975 | 194.975 | 1400 | 1400 | 500 | 1400 | 250 | 248.528 | 1100 | 950
13639771 | -1.PP_SO-102 | 710 | 0.06875 | 1.8531 | 1250 mm × 710 mm-1120 mm × 710 mm |  | -1.PP_SO-102 | -101 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 17 | EHA | 90 | 710 | 1250 | 1120 | 1.0296 | 770 | 1310 | 1180 | 1250 × 710-1120 × 710 | TA00.03.0155 | 0155 | yes | 90 | 0 | 0 | 0 | 65 | 0 | 10660 | 50 | 5 | 1270 | 1400 | 1819.59 | 1220 | 725 | 1220 | 1220 | 1120 | 1320 | 660 | 725 | 10000 | 725 | 710 | 1250 | 1250 | 1250 | 1120 | 625 | 1220 | 1720 | 2075
13650910 | -1.PP_SO-102 | 500 | 0.044 | 0.855 | 800 mm × 500 mm-500 mm × 500 mm | 0 | -1.PP_SO-102 | 2930 | Fáze 2 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | 90 | 500 | 800 | 500 | 0.263196 | 560 | 860 | 560 | 800 × 500-500 × 500 | TA00.03.0170 | 0170 | yes | 90 | 0 | 0 | 0 | 150 | 0 | 10350 | 50 | 5 | 650 | 950 | 1081.67 | 600 | 500 | 600 | 600 | 500 | 700 | 350 | 500 | 10000 | 500 | 400 | 800 | 800 | 800 | 500 | 400 | 600 | 1100 | 1400
13650977 | -1.PP_SO-102 | 500 | 0.044 | 0.855 | 800 mm × 500 mm-500 mm × 500 mm | 0 | -1.PP_SO-102 | 2930 | Fáze 2 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | 90 | 500 | 800 | 500 | 0.263196 | 560 | 860 | 560 | 800 × 500-500 × 500 | TA00.03.0171 | 0171 | yes | 90 | 0 | 0 | 0 | 150 | 0 | 10350 | 50 | 5 | 650 | 950 | 1081.67 | 600 | 500 | 600 | 600 | 500 | 700 | 350 | 500 | 10000 | 500 | 400 | 800 | 800 | 800 | 500 | 400 | 600 | 1100 | 1400
13697843 | -1.PP_SO-102 | 1200 | 0.0275 | 1.332 | 500 mm × 1200 mm-500 mm × 1200 mm | 0 | -1.PP_SO-102 | 409 | Fáze 2 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | 90 | 1200 | 500 | 500 | 0.395865 | 1260 | 560 | 560 | 500 × 1200-500 × 1200 | TA00.03.0175 | 0175 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10350 | 50 | 5 | 650 | 650 | 848.528 | 600 | 350 | 600 | 600 | 500 | 700 | 350 | 350 | 10000 | 350 | 400 | 1200 | 1200 | 500 | 1200 | 250 | 600 | 1100 | 950
13697871 | -1.PP_SO-102 | 1200 | 0.0275 | 1.332 | 500 mm × 1200 mm-500 mm × 1200 mm | 0 | -1.PP_SO-102 | 1109 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 17 | ODA | 90 | 1200 | 500 | 500 | 0.395865 | 1260 | 560 | 560 | 500 × 1200-500 × 1200 | TA00.03.0177 | 0177 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10350 | 50 | 5 | 650 | 650 | 848.528 | 600 | 350 | 600 | 600 | 500 | 700 | 350 | 350 | 10000 | 350 | 400 | 1200 | 1200 | 500 | 1200 | 250 | 600 | 1100 | 950
13759152 | 2.NP_SO-102 | 630 | 0.0616 | 1.4805 | 1600 mm × 630 mm-1120 mm × 630 mm | 0 | 2.NP_SO-102 | 2650 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 8 | EHA | 90 | 630 | 1120 | 1600 | 1.19473 | 690 | 1180 | 1660 | 1600 × 630-1120 × 630 | TA00.03.0255 | 0255 | yes | 90 | 0 | 0 | 0 | -240 | 0 | 10900 | 50 | 5 | 1750 | 1270 | 2092.46 | 1700 | 660 | 1220 | 1220 | 1120 | 1800 | 900 | 660 | 10000 | 660 | 950 | 1120 | 1600 | 1600 | 1600 | 560 | 1700 | 1720 | 2360
13787059 | -1.PP_SO-102 | 1100 | 0.132 | 5.401 | 2400 mm × 1100 mm-710 mm × 1100 mm | 0 | -1.PP_SO-102 | -471 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 11 | EHA | 90 | 1100 | 2400 | 710 | 2.25213 | 1160 | 2460 | 770 | 2400 × 1100-710 × 1100 | TA00.03.0294 | 0294 | yes | 90 | 0 | 0 | 0 | 845 | 0 | 10455 | 50 | 5 | 860 | 2550 | 2627.95 | 810 | 1300 | 810 | 810 | 710 | 910 | 455 | 1300 | 10000 | 1300 | 505 | 2400 | 2400 | 2400 | 1100 | 1200 | 810 | 1310 | 3800
13824313 | 2.NP_SO-102 | 800 | 0.03905 | 1.224 | 1800 mm × 800 mm-710 mm × 800 mm | 0 | 2.NP_SO-102 | 2650 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 13 | EHA | 90 | 800 | 710 | 1800 | 1.22271 | 860 | 770 | 1860 | 1800 × 800-710 × 800 | TA00.03.0395 | 0395 | yes | 90 | 0 | 0 | 0 | -545 | 0 | 11000 | 50 | 5 | 1950 | 860 | 2065.45 | 1900 | 455 | 810 | 810 | 710 | 2000 | 1000 | 455 | 10000 | 455 | 1050 | 800 | 1800 | 1800 | 1800 | 355 | 1900 | 1310 | 2355
13824374 | 2.NP_SO-102 | 710 | 0.044 | 1.2141 | 800 mm × 710 mm-800 mm × 710 mm | 0 | 2.NP_SO-102 | 2650 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 13 | EHA | 90 | 710 | 800 | 800 | 0.508583 | 770 | 860 | 860 | 800 × 710-800 × 710 | TA00.03.0396 | 0396 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10500 | 50 | 5 | 950 | 950 | 1272.79 | 900 | 500 | 900 | 900 | 800 | 1000 | 500 | 500 | 10000 | 500 | 550 | 800 | 800 | 800 | 800 | 400 | 900 | 1400 | 1400
13824405 | 2.NP_SO-102 | 710 | 0.044 | 1.2141 | 800 mm × 710 mm-800 mm × 710 mm | 0 | 2.NP_SO-102 | 709 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 13 | EHA | 90 | 710 | 800 | 800 | 0.508583 | 770 | 860 | 860 | 800 × 710-800 × 710 | TA00.03.0397 | 0397 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10500 | 50 | 5 | 950 | 950 | 1272.79 | 900 | 500 | 900 | 900 | 800 | 1000 | 500 | 500 | 10000 | 500 | 550 | 800 | 800 | 800 | 800 | 400 | 900 | 1400 | 1400
13897141 | 2.NP_SO-102 | 1120 | 0.02475 | 1.1312 | 600 mm × 1120 mm-450 mm × 1120 mm | 0 | 2.NP_SO-102 | 2700 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 5 | EHA | 90 | 1120 | 450 | 600 | 0.414376 | 1180 | 510 | 660 | 600 × 1120-450 × 1120 | TA00.03.0630 | 0630 | yes | 90 | 0 | 0 | 0 | -75 | 0 | 10400 | 50 | 5 | 750 | 600 | 890.225 | 700 | 325 | 550 | 550 | 450 | 800 | 400 | 325 | 10000 | 325 | 450 | 1120 | 1120 | 600 | 1120 | 225 | 700 | 1050 | 1025
13919394 | 4.NP_SO-102 | 630 | 0.0275 | 0.6993 | 500 mm × 630 mm-500 mm × 630 mm | 0 | 4.NP_SO-102 | 3296.23 | Fáze 2 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | 30 | 630 | 500 | 500 | 0.0923767 | 690 | 560 | 560 | 500 × 630-500 × 630 | TA00.03.0705 | 0705 | yes | 150 | 43.3013 | 4.33013 | 139.23 | 0 | 303.109 | 10093.8 | 25 | 2.5 | 396.41 | 350 | 310.583 | 300 | 350 | 160.77 | 600 | 500 | 700 | 350 | 93.7822 | 9918.78 | 93.7822 | 143.782 | 630 | 630 | 500 | 630 | 250 | 160.77 | 1100 | 950
13919411 | 4.NP_SO-102 | 630 | 0.0275 | 0.6993 | 500 mm × 630 mm-500 mm × 630 mm | 0 | 4.NP_SO-102 | 2777.24 | Fáze 2 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | 30 | 630 | 500 | 500 | 0.0923767 | 690 | 560 | 560 | 500 × 630-500 × 630 | TA00.03.0708 | 0708 | yes | 150 | 43.3013 | 4.33013 | 139.23 | 0 | 303.109 | 10093.8 | 25 | 2.5 | 396.41 | 350 | 310.583 | 300 | 350 | 160.77 | 600 | 500 | 700 | 350 | 93.7822 | 9918.78 | 93.7822 | 143.782 | 630 | 630 | 500 | 630 | 250 | 160.77 | 1100 | 950
13965747 | -1.PP_SO-102 | 710 | 0.06875 | 1.8531 | 1250 mm × 710 mm-1250 mm × 710 mm |  | -1.PP_SO-102 | 2300 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 17 | EHA | 90 | 710 | 1250 | 1250 | 1.10839 | 770 | 1310 | 1310 | 1250 × 710-1250 × 710 | TA00.03.0836 | 0836 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10725 | 50 | 5 | 1400 | 1400 | 1909.19 | 1350 | 725 | 1350 | 1350 | 1250 | 1450 | 725 | 725 | 10000 | 725 | 775 | 1250 | 1250 | 1250 | 1250 | 625 | 1350 | 1850 | 2075
13965751 | -1.PP_SO-102 | 1250 | 0.03905 | 1.9125 | 710 mm × 1250 mm-710 mm × 1250 mm |  | -1.PP_SO-102 | 2300 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 17 | EHA | 90 | 1250 | 710 | 710 | 0.73193 | 1310 | 770 | 770 | 710 × 1250-710 × 1250 | TA00.03.0837 | 0837 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10455 | 50 | 5 | 860 | 860 | 1145.51 | 810 | 455 | 810 | 810 | 710 | 910 | 455 | 455 | 10000 | 455 | 505 | 1250 | 1250 | 710 | 1250 | 355 | 810 | 1310 | 1265
14116058 | -1.PP_SO-102 | 500 | 0.03465 | 0.685 | 800 mm × 500 mm-630 mm × 500 mm | 0 | -1.PP_SO-102 | 2930 | Fáze 2 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | 90 | 500 | 630 | 800 | 0.306716 | 560 | 690 | 860 | 800 × 500-630 × 500 | TA00.03.1225 | 1225 | yes | 90 | 0 | 0 | 0 | -85 | 0 | 10500 | 50 | 5 | 950 | 780 | 1158.84 | 900 | 415 | 730 | 730 | 630 | 1000 | 500 | 415 | 10000 | 415 | 550 | 630 | 800 | 800 | 800 | 315 | 900 | 1230 | 1315
14119668 | 2.NP_SO-102 | 630 | 0.0616 | 1.4805 | 2400 mm × 630 mm-1120 mm × 630 mm |  | 2.NP_SO-102 | 2109 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 19 | EHA | 90 | 630 | 1120 | 2400 | 1.83733 | 690 | 1180 | 2460 | 2400 × 630-1120 × 630 | TA00.03.1252 | 1252 | yes | 90 | 0 | 0 | 0 | -640 | 0 | 11300 | 50 | 5 | 2550 | 1270 | 2781.8 | 2500 | 660 | 1220 | 1220 | 1120 | 2600 | 1300 | 660 | 10000 | 660 | 1350 | 1120 | 2400 | 2400 | 2400 | 560 | 2500 | 1720 | 3160
14151072 | 2.NP_SO-102 |  |  |  | 2000 mm × 900 mm-710 mm × 900 mm | 0 | 2.NP_SO-102 | 709 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 13 | EHA | 89.526 | 900 | 2000 | 710 | 1.67533 | 960 | 2060 | 770 | 2000 × 900-710 × 900 | TA00.03.1363 | 1363 | yes | 90.474 | 0.413655 | 0.0413655 | 17.3187 | 645 | 3.76426 | 10445.9 | 49.9983 | 4.99983 | 253876 | 2149.93 | 2244.54 | 809.972 | 1100 | 792.654 | 799.239 | 710 | 910 | 455 | 1090.94 | 9990.93 | 1096.27 | 495.915 | 2000 | 2000 | 2000 | 900 | 1000 | 792.654 | 1299.24 | 3200
14184116 | 2.NP_SO-102 | 800 | 0.03465 | 1.096 | 1800 mm × 800 mm-630 mm × 800 mm | 0 | 2.NP_SO-102 | 559 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 10 | EHA | 90 | 800 | 630 | 1800 | 1.11875 | 860 | 690 | 1860 | 1800 × 800-630 × 800 | TA00.03.1503 | 1503 |  | 90 | 0 | 0 | 0 | -585 | 0 | 11000 | 50 | 5 | 1950 | 780 | 2035.41 | 1900 | 415 | 730 | 730 | 630 | 2000 | 1000 | 415 | 10000 | 415 | 1050 | 800 | 1800 | 1800 | 1800 | 315 | 1900 | 1230 | 2315
14184278 | 2.NP_SO-102 | 630 | 0.044 | 1.0773 | 1120 mm × 630 mm-800 mm × 630 mm | 0 | 2.NP_SO-102 | 559 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 10 | EHA | 90 | 630 | 800 | 1120 | 0.643806 | 690 | 860 | 1180 | 1120 × 630-800 × 630 | TA00.03.1504 | 1504 |  | 90 | 0 | 0 | 0 | -160 | 0 | 10660 | 50 | 5 | 1270 | 950 | 1516.05 | 1220 | 500 | 900 | 900 | 800 | 1320 | 660 | 500 | 10000 | 500 | 710 | 800 | 1120 | 1120 | 1120 | 400 | 1220 | 1400 | 1720
14188787 | 4.NP_SO-102 | 1600 | 0.0275 | 1.776 | 500 mm × 1600 mm-500 mm × 1600 mm | 0 | 4.NP_SO-102 | 4579.33 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 1 | EHA | 90 | 1600 | 500 | 500 | 0.52782 | 1660 | 560 | 560 | 500 × 1600-500 × 1600 | TA00.03.1513 | 1513 |  | 90 | 0 | 0 | 0 | 0 | 0 | 10350 | 50 | 5 | 650 | 650 | 848.528 | 600 | 350 | 600 | 600 | 500 | 700 | 350 | 350 | 10000 | 350 | 400 | 1600 | 1600 | 500 | 1600 | 250 | 600 | 1100 | 950
14193587 | 4.NP_SO-102 | 1600 | 0.0275 | 1.776 | 500 mm × 1600 mm-500 mm × 1600 mm | 0 | STŘECHA_SO-102 | 729.33 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 1 | EHA | 15 | 1600 | 500 | 500 | 0.161304 | 1660 | 560 | 560 | 500 × 1600-500 × 1600 | TA00.03.1526 | 1526 |  | 165 | 48.2963 | 4.82963 | 76.2999 | 0 | 338.074 | 10046.1 | 12.941 | 1.2941 | 210.77 | 205.291 | 156.631 | 155.291 | 350 | 78.9915 | 600 | 500 | 700 | 350 | 46.0784 | 9955.49 | 46.0784 | 96.0784 | 1600 | 1600 | 500 | 1600 | 250 | 78.9915 | 1100 | 950
14193598 | 4.NP_SO-102 | 1600 | 0.0275 | 1.776 | 500 mm × 1600 mm-500 mm × 1600 mm | 0 | STŘECHA_SO-102 | 820 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 1 | EHA | 15 | 1600 | 500 | 500 | 0.161304 | 1660 | 560 | 560 | 500 × 1600-500 × 1600 | TA00.03.1527 | 1527 |  | 165 | 48.2963 | 4.82963 | 76.2999 | 0 | 338.074 | 10046.1 | 12.941 | 1.2941 | 210.77 | 205.291 | 156.631 | 155.291 | 350 | 78.9915 | 600 | 500 | 700 | 350 | 46.0784 | 9955.49 | 46.0784 | 96.0784 | 1600 | 1600 | 500 | 1600 | 250 | 78.9915 | 1100 | 950

# IfcDuctFitting: Pravoúhlý přechod, koleno, poloměr, přírubový:Standardní (78)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - ID kategorie: R; Kód sestavy: TA00; Název typu: Standardní; Označení typu: 03; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: Pravoúhlý přechod, koleno, poloměr, přírubový
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Grafika - Použít měřítko poznámky: yes
Kóty - e: 0 mm; f: 0 mm; r: 100 mm; Rozšíření příruby: 30 mm; Tloušťka příruby: 5 mm
Jiné - Typ: Standardní; Id typu: 1165284; Rodina: Pravoúhlý přechod, koleno, poloměr, přírubový; Rodina a typ: Pravoúhlý přechod, koleno, poloměr, přírubový: Standardní; Viditelnost 1: yes; Viditelnost 2: no; Délka 17: 500 mm; e1: 50 mm; e2: 50 mm; f1: 50 mm; f2: 50 mm; r1: 100 mm; Šířka 2: 200 mm
Name (Pravoúhlý přechod, koleno, poloměr, přírubový:Standardní:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | alfa (deg) = alfa 2 (deg) = alfa 3 (deg) = alfa 4 (deg) | a (mm) = c (mm) = Výš. (mm) | b (mm) | d (mm) | Objem (m3) | Příruba a (mm) = Příruba c (mm) | Příruba b (mm) | Příruba d (mm) | Velikost | Kód prvku | Označení | Páteřní trasa | Délka 5 (mm) | alfa 1 (deg) | Délka 1 (mm) | Délka 10 (mm) | Délka 11 (mm) | Délka 12 (mm) | Délka 13 (mm) | Délka 14 (mm) | Délka 15 (mm) | Délka 16 (mm) | Délka 18 (mm) = Délka 19 (mm) | Délka 2 (mm) | Délka 20 (mm) = Délka 21 (mm) = Posouzení 2 (mm) | Délka 22 (mm) | Délka 23 (mm) = r2 (mm) = r3 (mm) | Délka 24 (mm) | Délka 25 (mm) | Délka 3 (mm) | Délka 4 (mm) | Délka 6 (mm) | Délka 7 (mm) | Délka 8 (mm) | Délka 9 (mm) | Max ab (mm) | Max abcd (mm) | Max bd (mm) | Max cd (mm) | Polovina b (mm) | Posouzení 1 (mm) | r4 (mm) | Šířka 1 (mm) | Tlaková ztráta (Pa)
13640126 | -1.PP_SO-102 | 560 | 0.077 | 1.6296 | 1400 mm × 560 mm-1400 mm × 560 mm | 0 | 1400 mm × 560 mm-1400 mm × 560 mm | -1.PP_SO-102 | 2405.78 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 45 | 560 | 1400 | 1400 | 0.578841 | 620 | 1460 | 1460 | 1400 × 560-1400 × 560 | TA00.03.0156 | 0156 | yes | 0 | 135 | 10331.4 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 1550 | 1110.66 | 1148.05 | 1060.66 | 800 | 439.34 | 621.32 | 1500 | 1400 | 1600 | 800 | 331.371 | 9765.69 | 565.685 | 331.371 | 381.371 | 1400 | 1400 | 1400 | 1400 | 700 | 621.32 | 2000 | 2300
13640412 | -1.PP_SO-102 | 1600 | 0.0308 | 1.968 | 560 mm × 1600 mm-560 mm × 1600 mm | 0 | 560 mm × 1600 mm-560 mm × 1600 mm | -1.PP_SO-102 | 2405.78 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 30 | 1600 | 560 | 560 | 0.276835 | 1660 | 620 | 620 | 560 × 1600-560 × 1600 | TA00.03.0157 | 0157 | yes | 0 | 150 | 10101.8 | 43.3013 | 25 | 4.33013 | 2.5 | 431.051 | 380 | 341.641 | 330 | 380 | 153.154 | 176.846 | 660 | 560 | 760 | 380 | 101.821 | 9911.82 | 329.09 | 101.821 | 151.821 | 1600 | 1600 | 560 | 1600 | 280 | 176.846 | 1160 | 1040
13640422 | -1.PP_SO-102 | 1600 | 0.0308 | 1.968 | 560 mm × 1600 mm-560 mm × 1600 mm | 0 | 560 mm × 1600 mm-560 mm × 1600 mm | -1.PP_SO-102 | 2100 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 30 | 1600 | 560 | 560 | 0.276835 | 1660 | 620 | 620 | 560 × 1600-560 × 1600 | TA00.03.0158 | 0158 | yes | 0 | 150 | 10101.8 | 43.3013 | 25 | 4.33013 | 2.5 | 431.051 | 380 | 341.641 | 330 | 380 | 153.154 | 176.846 | 660 | 560 | 760 | 380 | 101.821 | 9911.82 | 329.09 | 101.821 | 151.821 | 1600 | 1600 | 560 | 1600 | 280 | 176.846 | 1160 | 1040
13640555 | -1.PP_SO-102 | 1120 | 0.022 | 1.0192 | 400 mm × 1120 mm-400 mm × 1120 mm | 0 | 400 mm × 1120 mm-400 mm × 1120 mm | -1.PP_SO-102 | 2480 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 21 | ETA | 45 | 1120 | 400 | 400 | 0.154837 | 1180 | 460 | 460 | 400 × 1120-400 × 1120 | TA00.03.0159 | 0159 | yes | 0 | 135 | 10124.3 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 550 | 403.553 | 382.683 | 353.553 | 300 | 146.447 | 207.107 | 500 | 400 | 600 | 300 | 124.264 | 9912.13 | 212.132 | 124.264 | 174.264 | 1120 | 1120 | 400 | 1120 | 200 | 207.107 | 1000 | 800
13640586 | -1.PP_SO-102 | 1120 | 0.022 | 1.0192 | 400 mm × 1120 mm-400 mm × 1120 mm | 0 | 400 mm × 1120 mm-400 mm × 1120 mm | -1.PP_SO-102 | 3020 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 21 | ETA | 45 | 1120 | 400 | 400 | 0.154837 | 1180 | 460 | 460 | 400 × 1120-400 × 1120 | TA00.03.0160 | 0160 | yes | 0 | 135 | 10124.3 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 550 | 403.553 | 382.683 | 353.553 | 300 | 146.447 | 207.107 | 500 | 400 | 600 | 300 | 124.264 | 9912.13 | 212.132 | 124.264 | 174.264 | 1120 | 1120 | 400 | 1120 | 200 | 207.107 | 1000 | 800
13647842 | -1.PP_SO-102 | 800 | 0.0275 | 0.888 | 500 mm × 800 mm-500 mm × 800 mm | 0 | 500 mm × 800 mm-500 mm × 800 mm | -1.PP_SO-102 | 3070 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 90 | 800 | 500 | 500 | 0.26391 | 860 | 560 | 560 | 500 × 800-500 × 800 | TA00.03.0165 | 0165 | yes | 0 | 90 | 10350 | 0 | 50 | 0 | 5 | 650 | 650 | 848.528 | 600 | 350 | 0 | 600 | 600 | 500 | 700 | 350 | 350 | 10000 | 0 | 350 | 400 | 800 | 800 | 500 | 800 | 250 | 600 | 1100 | 950
13648026 | -1.PP_SO-102 | 800 | 0.0275 | 0.888 | 500 mm × 800 mm-500 mm × 800 mm | 0 | 500 mm × 800 mm-500 mm × 800 mm | -1.PP_SO-102 | 1109 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 90 | 800 | 500 | 500 | 0.26391 | 860 | 560 | 560 | 500 × 800-500 × 800 | TA00.03.0168 | 0168 | yes | 0 | 90 | 10350 | 0 | 50 | 0 | 5 | 650 | 650 | 848.528 | 600 | 350 | 0 | 600 | 600 | 500 | 700 | 350 | 350 | 10000 | 0 | 350 | 400 | 800 | 800 | 500 | 800 | 250 | 600 | 1100 | 950
13650490 | -1.PP_SO-102 | 800 | 0.0275 | 0.888 | 500 mm × 800 mm-500 mm × 800 mm | 0 | 500 mm × 800 mm-500 mm × 800 mm | -1.PP_SO-102 | 3000 | Fáze 2 | Čerstvý | Přívod vzduchu | ODA 17 | ODA | 90 | 800 | 500 | 500 | 0.26391 | 860 | 560 | 560 | 500 × 800-500 × 800 | TA00.03.0169 | 0169 | yes | 0 | 90 | 10350 | 0 | 50 | 0 | 5 | 650 | 650 | 848.528 | 600 | 350 | 0 | 600 | 600 | 500 | 700 | 350 | 350 | 10000 | 0 | 350 | 400 | 800 | 800 | 500 | 800 | 250 | 600 | 1100 | 950 | 0
13706621 | -1.PP_SO-102 | 500 | 0.03465 | 0.685 | 630 mm × 500 mm-630 mm × 500 mm | 0 | 630 mm × 500 mm-630 mm × 500 mm | -1.PP_SO-102 | 3080 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 500 | 630 | 630 | 0.239993 | 560 | 690 | 690 | 630 × 500-630 × 500 | TA00.03.0185 | 0185 | yes | 0 | 90 | 10415 | 0 | 50 | 0 | 5 | 780 | 780 | 1032.38 | 730 | 415 | 0 | 730 | 730 | 630 | 830 | 415 | 415 | 10000 | 0 | 415 | 465 | 630 | 630 | 630 | 630 | 315 | 730 | 1230 | 1145 | 0
13709197 | 2.NP_SO-102 | 560 | 0.06875 | 1.4616 | 1250 mm × 560 mm-710 mm × 560 mm | 0 | 1250 mm × 560 mm-710 mm × 560 mm | 2.NP_SO-102 | 2800 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 90 | 560 | 1250 | 710 | 0.58948 | 620 | 1310 | 770 | 1250 × 560-710 × 560 | TA00.03.0192 | 0192 | yes | 270 | 90 | 10455 | 0 | 50 | 0 | 5 | 860 | 1400 | 1574.36 | 810 | 725 | 0 | 810 | 810 | 710 | 910 | 455 | 725 | 10000 | 0 | 725 | 505 | 1250 | 1250 | 1250 | 710 | 625 | 810 | 1310 | 2075 | 0
13710611 | 4.NP_SO-102 | 630 | 0.0154 | 0.4221 | 500 mm × 630 mm-280 mm × 630 mm | 0 | 500 mm × 630 mm-280 mm × 630 mm | 4.NP_SO-102 | 2827.52 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 90 | 630 | 280 | 500 | 0.146196 | 690 | 340 | 560 | 500 × 630-280 × 630 | TA00.03.0193 | 0193 | yes | -110 | 90 | 10350 | 0 | 50 | 0 | 5 | 650 | 430 | 710.211 | 600 | 240 | 0 | 380 | 380 | 280 | 700 | 350 | 240 | 10000 | 0 | 240 | 400 | 630 | 630 | 500 | 630 | 140 | 600 | 880 | 840 | 0
13745587 | 2.NP_SO-102 | 710 | 0.03905 | 1.0863 | 710 mm × 710 mm-710 mm × 710 mm | 0 | 710 mm × 710 mm-710 mm × 710 mm | 2.NP_SO-102 | 2800 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 90 | 710 | 710 | 710 | 0.415736 | 770 | 770 | 770 | 710 × 710-710 × 710 | TA00.03.0231 | 0231 | yes | 0 | 90 | 10455 | 0 | 50 | 0 | 5 | 860 | 860 | 1145.51 | 810 | 455 | 0 | 810 | 810 | 710 | 910 | 455 | 455 | 10000 | 0 | 455 | 505 | 710 | 710 | 710 | 710 | 355 | 810 | 1310 | 1265 | 0
13766916 | 4.NP_SO-102 | 500 | 0.0154 | 0.335 | 280 mm × 500 mm-280 mm × 500 mm | 0 | 280 mm × 500 mm-280 mm × 500 mm | 4.NP_SO-102 | 3060 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 500 | 280 | 280 | 0.068178 | 560 | 340 | 340 | 280 × 500-280 × 500 | TA00.03.0266 | 0266 | yes | 0 | 90 | 10240 | 0 | 50 | 0 | 5 | 430 | 430 | 537.401 | 380 | 240 | 0 | 380 | 380 | 280 | 480 | 240 | 240 | 10000 | 0 | 240 | 290 | 500 | 500 | 280 | 500 | 140 | 380 | 880 | 620 | 0
13767568 | -1.PP_SO-102 | 500 | 0.03465 | 0.685 | 630 mm × 500 mm-400 mm × 500 mm | 0 | 630 mm × 500 mm-400 mm × 500 mm | -1.PP_SO-102 | 2499.7 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 500 | 630 | 400 | 0.180073 | 560 | 690 | 460 | 630 × 500-400 × 500 | TA00.03.0269 | 0269 | yes | 115 | 90 | 10300 | 0 | 50 | 0 | 5 | 550 | 780 | 884.816 | 500 | 415 | 0 | 500 | 500 | 400 | 600 | 300 | 415 | 10000 | 0 | 415 | 350 | 630 | 630 | 630 | 500 | 315 | 500 | 1000 | 1145 | 0
13767598 | -1.PP_SO-102 | 400 | 0.03905 | 0.612 | 710 mm × 400 mm-710 mm × 400 mm | 0 | 710 mm × 400 mm-710 mm × 400 mm | -1.PP_SO-102 | 2499.7 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 400 | 710 | 710 | 0.234218 | 460 | 770 | 770 | 710 × 400-710 × 400 | TA00.03.0271 | 0271 | yes | 0 | 90 | 10455 | 0 | 50 | 0 | 5 | 860 | 860 | 1145.51 | 810 | 455 | 0 | 810 | 810 | 710 | 910 | 455 | 455 | 10000 | 0 | 455 | 505 | 710 | 710 | 710 | 710 | 355 | 810 | 1310 | 1265 | 0
13768029 | -1.PP_SO-102 | 710 | 0.022 | 0.6461 | 400 mm × 710 mm-400 mm × 710 mm | 0 | 400 mm × 710 mm-400 mm × 710 mm | -1.PP_SO-102 | 2499.7 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 45 | 710 | 400 | 400 | 0.0981555 | 770 | 460 | 460 | 400 × 710-400 × 710 | TA00.03.0272 | 0272 | yes | 0 | 135 | 10124.3 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 550 | 403.553 | 382.684 | 353.553 | 300 | 146.447 | 207.107 | 500 | 400 | 600 | 300 | 124.264 | 9912.13 | 212.132 | 124.264 | 174.264 | 710 | 710 | 400 | 710 | 200 | 207.107 | 1000 | 800 | 0
13789050 | -1.PP_SO-102 | 400 | 0.0616 | 0.94 | 1120 mm × 400 mm-1120 mm × 400 mm | 0 | 1120 mm × 400 mm-1120 mm × 400 mm | -1.PP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 400 | 1120 | 1120 | 0.513512 | 460 | 1180 | 1180 | 1120 × 400-1120 × 400 | TA00.03.0297 | 0297 | yes | 0 | 90 | 10660 | 0 | 50 | 0 | 5 | 1270 | 1270 | 1725.34 | 1220 | 660 | 0 | 1220 | 1220 | 1120 | 1320 | 660 | 660 | 10000 | 0 | 660 | 710 | 1120 | 1120 | 1120 | 1120 | 560 | 1220 | 1720 | 1880
13789167 | -1.PP_SO-102 | 400 | 0.0616 | 0.94 | 1120 mm × 400 mm-1120 mm × 400 mm | 0 | 1120 mm × 400 mm-1120 mm × 400 mm | -1.PP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 45 | 400 | 1120 | 1120 | 0.281506 | 460 | 1180 | 1180 | 1120 × 400-1120 × 400 | TA00.03.0298 | 0298 | yes | 0 | 135 | 10273.4 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 1270 | 912.67 | 933.748 | 862.67 | 660 | 357.33 | 505.341 | 1220 | 1120 | 1320 | 660 | 273.381 | 9806.69 | 466.69 | 273.381 | 323.381 | 1120 | 1120 | 1120 | 1120 | 560 | 505.341 | 1720 | 1880
13789191 | -1.PP_SO-102 | 400 | 0.0616 | 0.94 | 1120 mm × 400 mm-1120 mm × 400 mm | 0 | 1120 mm × 400 mm-1120 mm × 400 mm | -1.PP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 45 | 400 | 1120 | 1120 | 0.281506 | 460 | 1180 | 1180 | 1120 × 400-1120 × 400 | TA00.03.0299 | 0299 | yes | 0 | 135 | 10273.4 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 1270 | 912.67 | 933.748 | 862.67 | 660 | 357.33 | 505.341 | 1220 | 1120 | 1320 | 660 | 273.381 | 9806.69 | 466.69 | 273.381 | 323.381 | 1120 | 1120 | 1120 | 1120 | 560 | 505.341 | 1720 | 1880
13789724 | -1.PP_SO-102 | 800 | 0.022 | 0.728 | 400 mm × 800 mm-400 mm × 800 mm | 0 | 400 mm × 800 mm-400 mm × 800 mm | -1.PP_SO-102 | 2400 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 45 | 800 | 400 | 400 | 0.110598 | 860 | 460 | 460 | 400 × 800-400 × 800 | TA00.03.0301 | 0301 | yes | 0 | 135 | 10124.3 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 550 | 403.553 | 382.683 | 353.553 | 300 | 146.447 | 207.107 | 500 | 400 | 600 | 300 | 124.264 | 9912.13 | 212.132 | 124.264 | 174.264 | 800 | 800 | 400 | 800 | 200 | 207.107 | 1000 | 800
13791701 | -1.PP_SO-102 | 500 | 0.03465 | 0.685 | 630 mm × 500 mm-630 mm × 500 mm | 0 | 630 mm × 500 mm-630 mm × 500 mm | -1.PP_SO-102 | 3080 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 500 | 630 | 630 | 0.239993 | 560 | 690 | 690 | 630 × 500-630 × 500 | TA00.03.0303 | 0303 | yes | 0 | 90 | 10415 | 0 | 50 | 0 | 5 | 780 | 780 | 1032.38 | 730 | 415 | 0 | 730 | 730 | 630 | 830 | 415 | 415 | 10000 | 0 | 415 | 465 | 630 | 630 | 630 | 630 | 315 | 730 | 1230 | 1145 | 0
13792183 | 4.NP_SO-102 | 630 | 0.0154 | 0.4221 | 280 mm × 630 mm-280 mm × 630 mm | 0 | 280 mm × 630 mm-280 mm × 630 mm | 4.NP_SO-102 | 3050 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 630 | 280 | 280 | 0.0859043 | 690 | 340 | 340 | 280 × 630-280 × 630 | TA00.03.0307 | 0307 | yes | 0 | 90 | 10240 | 0 | 50 | 0 | 5 | 430 | 430 | 537.401 | 380 | 240 | 0 | 380 | 380 | 280 | 480 | 240 | 240 | 10000 | 0 | 240 | 290 | 630 | 630 | 280 | 630 | 140 | 380 | 880 | 620
13797498 | -1.PP_SO-102 |  |  |  | 1400 mm × 560 mm-1120 mm × 560 mm | 0 | 1400 mm × 560 mm-1120 mm × 560 mm | -1.PP_SO-102 | 2405.78 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 45 | 560 | 1400 | 1120 | 0.48024 | 620 | 1460 | 1180 | 1400 × 560-1120 × 560 | TA00.03.0338 | 0338 | yes | 140 | 135 | 10133.4 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 1550 | 1110.66 | 1072.56 | 862.67 | 800 | 637.33 | 225.341 | 544.02 | 1120 | 1320 | 660 | 331.371 | 9666.69 | 466.69 | 471.371 | 183.381 | 1400 | 1400 | 1400 | 1120 | 700 | 225.341 | 1044.02 | 2300
13805219 | -1.PP_SO-102 | 710 | 0.022 | 0.6461 | 400 mm × 710 mm-400 mm × 710 mm | 0 | 400 mm × 710 mm-400 mm × 710 mm | -1.PP_SO-102 | 3150 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 45 | 710 | 400 | 400 | 0.0981556 | 770 | 460 | 460 | 400 × 710-400 × 710 | TA00.03.0353 | 0353 | yes | 0 | 135 | 10124.3 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 550 | 403.553 | 382.683 | 353.553 | 300 | 146.447 | 207.107 | 500 | 400 | 600 | 300 | 124.264 | 9912.13 | 212.132 | 124.264 | 174.264 | 710 | 710 | 400 | 710 | 200 | 207.107 | 1000 | 800 | 0
