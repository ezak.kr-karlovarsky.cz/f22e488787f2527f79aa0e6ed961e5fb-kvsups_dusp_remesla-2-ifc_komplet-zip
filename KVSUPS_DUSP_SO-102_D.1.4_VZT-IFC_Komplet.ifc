Properties of the parts of a building model (IFC4), part 39 of 45

# IfcDuctSegment: Hranaté potrubí:POZINK/T spoj (368)
Name (Hranaté potrubí:POZINK/T spoj:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Reynoldsovo číslo | Dynamický tlak (Pa) | Průtok (m3/s) | Rychlost (m/s) | Tlaková ztráta (Pa) | Tření (kg/m2/s2) | Referenční podlaží | Sklon | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Koeficient ztrát | Ekvivaletní průměr (mm) | Hydraulický průměr (mm) | Klasifikace systému | Název systému | Plocha (m2) | Řez | Typ systému | Zkratka systému | Délka (mm) | Šířka (mm) | Velikost | Výška (mm) | Kód prvku | Označení | Páteřní trasa | Group
13934874 | 2.NP_SO-102 | 315 | 0.0746804 | 0.825139 | 1250 mm × 315 mm | 0 | 1250 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3037.5 | 2880 | 2880 | 2722.5 | Fáze 1 | 0 | 649.124 | 503.195 | Přívod vzduchu | SUP 9 | 0.187 | 228 | Přívodní | SUP | 59.7443 | 1250 | 1250 × 315 | 315 | PO02.03.1022 | 1022 | yes | SUP 9
13935322 | 2.NP_SO-102 | 400 | 0.214013 | 1.13697 | 1250 mm × 400 mm | 0 | 1250 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3120 | 2920 | 2920 | 2720 | Fáze 1 | 0 | 743.753 | 606.061 | Zpětný vzduch | ETA 14 | 0.564994 | 209 | Odváděný | ETA | 171.21 | 1250 | 1250 × 400 | 400 | PO02.03.1023 | 1023 | yes | ETA 14
13935414 | 2.NP_SO-102 | 400 | 0.0440056 | 1.02816 | 1250 mm × 400 mm | 0 | 1250 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3120 | 2920 | 2920 | 2720 | Fáze 1 | 0 | 743.753 | 606.061 | Zpětný vzduch | ETA 14 | 0.116175 | 143 | Odváděný | ETA | 35.2045 | 1250 | 1250 × 400 | 400 | PO02.03.1024 | 1024 | yes | ETA 14
13944623 | -1.PP_SO-102 | 280 | 1.88088 | 2.85723 | 400 mm × 280 mm | 0 | 400 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3120 | 2980 | 2980 | 2840 | Fáze 1 | 0 | 364.399 | 329.412 | Zpětný vzduch | ETA 1 | 6.39499 | 124 | Odváděný | ETA | 4702.2 | 400 | 400 × 280 | 280 | PO02.03.1057 | 1057 | yes | ETA 1
13944772 | -1.PP_SO-102 | 250 | 2.39292 | 3.19114 | 400 mm × 250 mm | 0 | 400 mm × 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3105 | 2980 | 2980 | 2855 | Fáze 1 | 0 | 343.333 | 307.692 | Zpětný vzduch | ETA 1 | 7.77698 | 140 | Odváděný | ETA | 5982.29 | 400 | 400 × 250 | 250 | PO02.03.1058 | 1058 | yes | ETA 1
13945051 | -1.PP_SO-102 | 400 | 1.48205 | 2.23792 | 710 mm × 400 mm | 0 | 710 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3180 | 2980 | 2980 | 2780 | Fáze 1 | 0 | 576.682 | 511.712 | Zpětný vzduch | ETA 1 | 4.63403 | 117 | Odváděný | ETA | 2087.4 | 710 | 710 × 400 | 400 | PO02.03.1059 | 1059 | yes | ETA 1
13946425 | -1.PP_SO-102 | 160 | 0.232155 | 0.33664 | 315 mm × 160 mm | 0 | 315 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2660 | 2580 | 2580 | 2500 | Fáze 1 | 0 | 241.985 | 212.211 | Zpětný vzduch | ETA 97 | 0.70015 | 41 | Odváděný | ETA | 737 | 315 | 315 × 160 | 160 | PO02.03.1061 | 1061 | yes | ETA 97
13947276 | -1.PP_SO-102 | 400 | 3.08265 | 5.33225 | 500 mm × 400 mm | 0 | 500 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3180 | 2980 | 2980 | 2780 | Fáze 1 | 0 | 488.12 | 444.444 | Zpětný vzduch | ETA 1 | 11.0976 | 111 | Odváděný | ETA | 6165.31 | 500 | 500 × 400 | 400 | PO02.03.1062 | 1062 | yes | ETA 1
13947292 | -1.PP_SO-102 | 400 | 3.12266 | 5.39626 | 500 mm × 400 mm | 0 | 500 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3180 | 2980 | 2980 | 2780 | Fáze 1 | 0 | 488.12 | 444.444 | Zpětný vzduch | ETA 1 | 11.2416 | 81 | Odváděný | ETA | 6245.32 | 500 | 500 × 400 | 400 | PO02.03.1063 | 1063 | yes | ETA 1
13959232 | -1.PP_SO-102 | 560 | 0.0177444 | 0.920842 | 800 mm × 560 mm | 0 | 800 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2680 | 2400 | 2400 | 2120 | Fáze 1 | 0 | 728.798 | 658.824 | Zpětný vzduch | ETA 1 | 0.0603308 | 147 | Odváděný | ETA | 22.1804 | 800 | 800 × 560 | 560 | PO02.03.1097 | 1097 | yes | ETA 1
13959765 | -1.PP_SO-102 | 500 | 0.14692 | 0.863206 | 630 mm × 500 mm | 0 | 630 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3330 | 3080 | 3080 | 2830 | Fáze 1 | 0 | 612.517 | 557.522 | Zpětný vzduch | ETA 7 | 0.527046 | 433 | Odváděný | ETA | 233.206 | 630 | 630 × 500 | 500 | PO02.03.1101 | 1101 | yes | ETA 7
13959884 | -1.PP_SO-102 | 500 | 2.73282 | 4.96781 | 630 mm × 500 mm | 0 | 630 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3330 | 3080 | 3080 | 2830 | Fáze 1 | 0 | 612.517 | 557.522 | Zpětný vzduch | ETA 7 | 9.80344 | 433 | Odváděný | ETA | 4337.81 | 630 | 630 × 500 | 500 | PO02.03.1102 | 1102 | yes | ETA 7
13959963 | -1.PP_SO-102 | 400 | 0.455334 | 1.08105 | 710 mm × 400 mm | 0 | 710 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2699.7 | 2499.7 | 2499.7 | 2299.7 | Fáze 2 | 0 | 576.682 | 511.712 | Zpětný vzduch | ETA 7 | 1.42372 | 166 | Odváděný | ETA | 641.316 | 710 | 710 × 400 | 400 | PO02.03.1104 | 1104 | yes | ETA 7
13965828 | -1.PP_SO-102 | 710 | 0.96305 | 2.86902 | 1250 mm × 710 mm | 0 | 1250 mm × 710 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2655 | 2300 | 2300 | 1945 | Fáze 1 | 0 | 1019.73 | 905.612 | Odváděný vzduch | EHA 17 | 3.02012 | 15 | Znehodnocený | EHA | 770.44 | 1250 | 1250 × 710 | 710 | PO02.03.1127 | 1127 | yes | EHA 17
13968405 | -1.PP_SO-102 | 1100 | 0.125166 | 5.39474 | 2400 mm × 1100 mm | 0 | 2400 mm × 1100 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 1379 | 829 | 829 | 279 | Fáze 1 | 0 | 1743.53 | 1508.57 | Přívod vzduchu | ODA 8 | 0.365067 | 8 | Čerstvý | ODA | 52.1524 | 2400 | 2400 × 1100 | 1100 | PO02.03.1135 | 1135 | yes | ODA 8
13971567 | 3.NP_SO-102 | 300 | 0.3464 | 0.7398 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 | 0 | 3350 | 3200 | 3200 | 3050 | Fáze 1 | 0 | 520.268 | 436.364 | Zpětný vzduch | ETA 53 | 0.9526 | 1 | Odváděný | ETA | 433 | 800 | 800 × 300 | 300 | PO02.03.1137 | 1137 | no | ETA 53
13978664 | 4.NP_SO-102 | 250 | 0.0372197 | 0.196312 | 160 mm × 250 mm | 0 | 160 mm × 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 | 0 | 2952.52 | 2827.52 | 2827.52 | 2702.52 | Fáze 1 | 0 | 217.288 | 195.122 | Zpětný vzduch | ETA 3 | 0.190751 | 8 | Odváděný | ETA | 232.623 | 160 | 160 × 250 | 250 | PO02.03.1142 | 1142 | no | ETA 3
13978754 | 4.NP_SO-102 | 500 | 0.00992 | 0.222 | 160 mm × 500 mm | 0 | 160 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 | 0 | 3077.52 | 2827.52 | 2827.52 | 2577.52 | Fáze 1 | 0 | 297.501 | 242.424 | Zpětný vzduch | ETA 3 | 0.08184 | 35 | Odváděný | ETA | 62 | 160 | 160 × 500 | 500 | PO02.03.1143 | 1143 | no | ETA 3
13989866 | -1.PP_SO-102 | 400 | 8.68203 | 7.09745 | 1120 mm × 400 mm | 0 | 1120 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3280 | 3080 | 3080 | 2880 | Fáze 1 | 0 | 708.812 | 589.474 | Zpětný vzduch | ETA 7 | 23.5655 | 306 | Odváděný | ETA | 7751.81 | 1120 | 1120 × 400 | 400 | PO02.03.1182 | 1182 | yes | ETA 7
13992397 | 4.NP_SO-102 | 450 | 0.545755 | 1.43236 | 500 mm × 450 mm | 0 | 500 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | STŘECHA_SO-102 | 0 | 1225 | 1000 | 1000 | 775 | Fáze 1 | 0 | 518.354 | 473.684 | Přívod vzduchu | ODA 10 | 2.07387 | 2 | Čerstvý | ODA | 1091.51 | 500 | 500 × 450 | 450 | PO02.03.1198 | 1198 | yes | ODA 10
14003030 | 4.NP_SO-102 | 630 | 0.442143 | 1.67925 | 710 mm × 630 mm | 0 | 710 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | STŘECHA_SO-102 | 0 | 1555 | 1240 | 1240 | 925 | Fáze 1 | 0 | 730.788 | 667.612 | Přívod vzduchu | ODA 25 | 1.66893 | 15 | Čerstvý | ODA | 622.736 | 710 | 710 × 630 | 630 | PO02.03.1222 | 1222 | yes | ODA 25 | Fázování - Bouráno ve FÁZI 2: yes
14008412 | 2.NP_SO-102 | 450 | 0.648 | 1.458 | 900 mm × 450 mm | 0 | 900 mm × 450 mm | 201222 | 15.4898 | 2.05556 | 5.07545 | 0.323484 | 0.449284 | 2.NP_SO-102 | 0 | 7725 | 7500 | 7500 | 7275 | Fáze 1 | 0.0208837 | 685.519 | 600 | Přívod vzduchu | ODA 3 | 1.944 | 2 | Čerstvý | ODA | 720 | 900 | 900 × 450 | 450 | PO02.03.1239 | 1239 | yes | ODA 3
14008634 | 2.NP_SO-102 | 800 | 0.376218 | 3.21442 | 1800 mm × 800 mm | 0 | 1800 mm × 800 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 959 | 559 | 559 | 159 | Fáze 1 | 0 | 1285.81 | 1107.69 | Odváděný vzduch | EHA 10 | 1.08685 | 3 | Znehodnocený | EHA | 209.01 | 1800 | 1800 × 800 | 800 | PO02.03.1240 | 1240 | yes | EHA 10
14008719 | 2.NP_SO-102 | 315 | 3.108 | 3.8493 | 560 mm × 315 mm | 0 | 560 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2857.5 | 2700 | 2700 | 2542.5 | Fáze 1 | 0 | 454.468 | 403.2 | Odváděný vzduch | EHA 5 | 9.7125 | 5 | Znehodnocený | EHA | 5550 | 560 | 560 × 315 | 315 | PO02.03.1241 | 1241 | yes | EHA 5 | Identifikační data - Komentáře: VÝFUK POD STROPEM
14009745 | 2.NP_SO-102 | 4100 | 0.1764 | 7.175 | 560 mm × 315 mm | 0 | 560 mm × 315 mm | 146838 | 18.2655 | 0.972222 | 5.51146 | 3.49043 | 0.851325 | 2.NP_SO-102 |  | 7187.5 | 7187.5 | 3087.5 | 3087.5 | Fáze 1 | 0.191094 | 454.468 | 403.2 | Přívod vzduchu | ODA 7 | 7.175 | 5 | Čerstvý | ODA | 4100 | 560 | 560 × 315 | 315 | PO02.03.1242 | 1242 | yes | ODA 7
14009754 | 3.NP_SO-102 | 315 | 0.4186 | 0.823725 | 560 mm × 315 mm | 0 | 560 mm × 315 mm | 146838 | 18.2655 | 0.972222 | 5.51146 | 0.636366 | 0.851325 | 3.NP_SO-102 | 0 | 3657.5 | 3500 | 3500 | 3342.5 | Fáze 1 | 0.0348397 | 454.468 | 403.2 | Přívod vzduchu | ODA 7 | 1.30813 | 5 | Čerstvý | ODA | 747.5 | 560 | 560 × 315 | 315 | PO02.03.1243 | 1243 | yes | ODA 7
14009919 | 2.NP_SO-102 | 4246.42 | 0.64 | 16.9857 | 1600 mm × 400 mm | 0 | 1600 mm × 400 mm | 275321 | 25.4868 | 4.16667 | 6.51042 | 2.81838 | 0.663707 | 2.NP_SO-102 |  | 7145 | 7145 | 2898.58 | 2898.58 | Fáze 1 | 0.110582 | 827.082 | 640 | Přívod vzduchu | ODA 6 | 16.9857 | 2 | Čerstvý | ODA | 4246.42 | 1600 | 1600 × 400 | 400 | PO02.03.1244 | 1244 | yes | ODA 6
14009932 | 3.NP_SO-102 | 400 | 1.14219 | 1.8511 | 1600 mm × 400 mm | 0 | 1600 mm × 400 mm | 275321 | 25.4868 | 4.16667 | 6.51042 | 0.473801 | 0.663707 | 3.NP_SO-102 | 0 | 3700 | 3500 | 3500 | 3300 | Fáze 1 | 0.0185901 | 827.082 | 640 | Přívod vzduchu | ODA 6 | 2.85548 | 2 | Čerstvý | ODA | 713.87 | 1600 | 1600 × 400 | 400 | PO02.03.1245 | 1245 | yes | ODA 6
14010138 | 2.NP_SO-102 | 4040 | 0.4 | 11.312 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 277943 | 32.5825 | 2.94444 | 7.36111 | 3.88074 | 0.960578 | 2.NP_SO-102 |  | 7145 | 7145 | 3105 | 3105 | Fáze 1 | 0.119105 | 674.06 | 571.429 | Přívod vzduchu | ODA 14 | 11.312 | 2 | Čerstvý | ODA | 4040 | 1000 | 1000 × 400 | 400 | PO02.03.1246 | 1246 | yes | ODA 14
14010149 | 3.NP_SO-102 | 400 | 0.685 | 1.348 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 277943 | 32.5825 | 2.94444 | 7.36111 | 0.657996 | 0.960578 | 3.NP_SO-102 | 0 | 3700 | 3500 | 3500 | 3300 | Fáze 1 | 0.0201948 | 674.06 | 571.429 | Přívod vzduchu | ODA 14 | 1.918 | 2 | Čerstvý | ODA | 685 | 1000 | 1000 × 400 | 400 | PO02.03.1247 | 1247 | yes | ODA 14
14010667 | 2.NP_SO-102 | 1100 | 0.096 | 5.368 | 2400 mm × 1100 mm | 0 | 2400 mm × 1100 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2659 | 2109 | 2109 | 1559 | Fáze 1 | 0 | 1743.53 | 1508.57 | Zpětný vzduch | ETA 11 | 0.28 | 1 | Odváděný | ETA | 40 | 2400 | 2400 × 1100 | 1100 | PO02.03.1248 | 1248 | yes | ETA 11
14010766 | 2.NP_SO-102 | 1100 | 0.11255 | 5.38317 | 2400 mm × 1100 mm | 0 | 2400 mm × 1100 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 1359 | 809 | 809 | 259 | Fáze 1 | 0 | 1743.53 | 1508.57 | Přívod vzduchu | SUP 11 | 0.328272 | 1 | Přívodní | SUP | 46.8959 | 2400 | 2400 × 1100 | 1100 | PO02.03.1249 | 1249 | yes | SUP 11
14010900 | 2.NP_SO-102 | 450 | 0.0588368 | 0.952953 | 1000 mm × 450 mm | 0 | 1000 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2384 | 2159 | 2159 | 1934 | Fáze 1 | 0 | 719.216 | 620.69 | Zpětný vzduch | ETA 11 | 0.170627 | 40 | Odváděný | ETA | 58.8368 | 1000 | 1000 × 450 | 450 | PO02.03.1250 | 1250 | yes | ETA 11
14010914 | 2.NP_SO-102 | 450 | 1.3096 | 2.07864 | 1000 mm × 450 mm | 0 | 1000 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2384 | 2159 | 2159 | 1934 | Fáze 1 | 0 | 719.216 | 620.69 | Zpětný vzduch | ETA 11 | 3.79785 | 40 | Odváděný | ETA | 1309.6 | 1000 | 1000 × 450 | 450 | PO02.03.1251 | 1251 | yes | ETA 11 | Identifikační data - Komentáře: VZT21
14011708 | 2.NP_SO-102 | 1000 | 0.323217 | 2.41608 | 400 mm × 1000 mm | 0 | 400 mm × 1000 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3039.59 | 2539.59 | 2539.59 | 2039.59 | Fáze 1 | 0 | 674.06 | 571.429 | Přívod vzduchu | SUP 11 | 2.26252 | 113 | Přívodní | SUP | 808.042 | 400 | 400 × 1000 | 1000 | PO02.03.1252 | 1252 | yes | SUP 11 | Identifikační data - Komentáře: VZT21
14012010 | 2.NP_SO-102 | 1547.08 | 0.4 | 4.33181 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 1884.59 | 337.514 | 1884.59 | 337.514 | Fáze 1 | 0 | 674.06 | 571.429 | Přívod vzduchu | SUP 11 | 4.33181 | 113 | Přívodní | SUP | 1547.08 | 1000 | 1000 × 400 | 400 | PO02.03.1253 | 1253 | yes | SUP 11
14012063 | 2.NP_SO-102 | 800 | 0.362268 | 2.17963 | 1000 mm × 800 mm | 0 | 1000 mm × 800 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 1209 | 809 | 809 | 409 | Fáze 1 | 0 | 976.24 | 888.889 | Přívod vzduchu | SUP 11 | 1.30417 | 3 | Přívodní | SUP | 362.268 | 1000 | 1000 × 800 | 800 | PO02.03.1254 | 1254 | yes | SUP 11
14012066 | 2.NP_SO-102 | 4 | 0.4 | 0.0112 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 254 | 250 | 254 | 250 | Fáze 1 | 0 | 674.06 | 571.429 | Přívod vzduchu | SUP 11 | 0.0112 | 52 | Přívodní | SUP | 4 | 1000 | 1000 × 400 | 400 | PO02.03.1255 | 1255 | yes | SUP 11
14012853 | 2.NP_SO-102 | 804.736 | 0.4 | 2.25326 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 1054.74 | 250 | 1054.74 | 250 | Fáze 1 | 0 | 674.06 | 571.429 | Zpětný vzduch | ETA 11 | 2.25326 | 73 | Odváděný | ETA | 804.736 | 1000 | 1000 × 400 | 400 | PO02.03.1256 | 1256 | yes | ETA 11; SUP 64
14013309 | 2.NP_SO-102 | 170 | 0.4 | 0.476 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | -250 | -420 | -250 | -420 | Fáze 1 | 0 | 674.06 | 571.429 | Zpětný vzduch | ETA 11 | 0.476 | 52 | Odváděný | ETA | 170 | 1000 | 1000 × 400 | 400 | PO02.03.1257 | 1257 | yes | ETA 11
14014354 | 2.NP_SO-102 | 120 | 0.4 | 0.336 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | -250 | -370 | -250 | -370 | Fáze 1 | 0 | 674.06 | 571.429 | Přívod vzduchu | SUP 15 | 0.336 | 81 | Přívodní | SUP | 120 | 1000 | 1000 × 400 | 400 | PO02.03.1258 | 1258 | yes | SUP 15 | Identifikační data - Komentáře: VZT21
14014355 | 1.NP_SO-102 | 450 | 0.0259965 | 0.923397 | 1000 mm × 450 mm | 0 | 1000 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-102 | 0 | 3475 | 3250 | 3250 | 3025 | Fáze 1 | 0 | 719.216 | 620.69 | Přívod vzduchu | SUP 15 | 0.0753899 | 131 | Přívodní | SUP | 25.9965 | 1000 | 1000 × 450 | 450 | PO02.03.1259 | 1259 | yes | SUP 15
14015500 | 2.NP_SO-102 | 400 | 0.0472893 | 0.837831 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2359 | 2159 | 2159 | 1959 | Fáze 1 | 0 | 674.06 | 571.429 | Zpětný vzduch | ETA 11 | 0.13241 | 63 | Odváděný | ETA | 47.2893 | 1000 | 1000 × 400 | 400 | PO02.03.1260 | 1260 | yes | ETA 11
14016138 | 2.NP_SO-102 | 145 | 0.4 | 0.406 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | -250 | -395 | -250 | -395 | Fáze 1 | 0 | 674.06 | 571.429 | Zpětný vzduch | ETA 11 | 0.406 | 87 | Odváděný | ETA | 145 | 1000 | 1000 × 400 | 400 | PO02.03.1261 | 1261 | yes | ETA 11 | Identifikační data - Komentáře: VZT21
14017065 | 3.NP_SO-102 | 3359.89 | 0.25 | 6.71977 | 500 mm × 500 mm | 0 | 500 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 |  | 2634.7 | 2634.7 | -725.185 | -725.185 | Fáze 1 | 0 | 546.583 | 500 | Zpětný vzduch | ETA 7 | 6.71977 | 114 | Odváděný | ETA | 3359.89 | 500 | 500 × 500 | 500 | PO02.03.1265 | 1265 | yes | ETA 7
14030524 | 2.NP_SO-102 | 1000 | 1.8121 | 5.82689 | 900 mm × 1000 mm | 0 | 900 mm × 1000 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2659 | 2159 | 2159 | 1659 | Fáze 1 | 0 | 1036.71 | 947.368 | Zpětný vzduch | ETA 11 | 7.6511 | 17 | Odváděný | ETA | 2013.45 | 900 | 900 × 1000 | 1000 | PO02.03.1281 | 1281 | yes | ETA 11
14030555 | 2.NP_SO-102 | 400 | 0.02 | 0.816 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2359 | 2159 | 2159 | 1959 | Fáze 1 | 0 | 674.06 | 571.429 | Zpětný vzduch | ETA 11 | 0.056 | 63 | Odváděný | ETA | 20 | 1000 | 1000 × 400 | 400 | PO02.03.1282 | 1282 | yes | ETA 11
14030596 | 2.NP_SO-102 | 400 | 0.0695919 | 0.855674 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2359 | 2159 | 2159 | 1959 | Fáze 1 | 0 | 674.06 | 571.429 | Zpětný vzduch | ETA 11 | 0.194857 | 63 | Odváděný | ETA | 69.5919 | 1000 | 1000 × 400 | 400 | PO02.03.1283 | 1283 | yes | ETA 11
14032928 | 2.NP_SO-102 | 720.59 | 0.4 | 2.01765 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 1884.59 | 1164 | 1884.59 | 1164 | Fáze 1 | 0 | 674.06 | 571.429 | Přívod vzduchu | SUP 11 | 2.01765 | 113 | Přívodní | SUP | 720.59 | 1000 | 1000 × 400 | 400 | PO02.03.1284 | 1284 | yes | SUP 11
14032934 | 2.NP_SO-102 | 400 | 0.825987 | 1.46079 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 1009 | 809 | 809 | 609 | Fáze 1 | 0 | 674.06 | 571.429 | Přívod vzduchu | SUP 11 | 2.31276 | 113 | Přívodní | SUP | 825.987 | 1000 | 1000 × 400 | 400 | PO02.03.1285 | 1285 | yes | SUP 11
14033031 | 2.NP_SO-102 | 225 | 0.200156 | 0.40514 | 500 mm × 225 mm | 0 | 500 mm × 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3037.5 | 2925 | 2925 | 2812.5 | Fáze 1 | 0 | 359.608 | 310.345 | Zpětný vzduch | ETA 14 | 0.580451 | 253 | Odváděný | ETA | 400.311 | 500 | 500 × 225 | 225 | PO02.03.1286 | 1286 | yes | ETA 14
14033047 | 2.NP_SO-102 | 225 | 0.0473611 | 0.267625 | 500 mm × 225 mm | 0 | 500 mm × 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3037.5 | 2925 | 2925 | 2812.5 | Fáze 1 | 0 | 359.608 | 310.345 | Zpětný vzduch | ETA 14 | 0.137347 | 270 | Odváděný | ETA | 94.7222 | 500 | 500 × 225 | 225 | PO02.03.1287 | 1287 | yes | ETA 14
14033275 | 2.NP_SO-102 | 225 | 0.0526594 | 0.272393 | 500 mm × 225 mm | 0 | 500 mm × 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3037.5 | 2925 | 2925 | 2812.5 | Fáze 1 | 0 | 359.608 | 310.345 | Zpětný vzduch | ETA 14 | 0.152712 | 253 | Odváděný | ETA | 105.319 | 500 | 500 × 225 | 225 | PO02.03.1288 | 1288 | yes | ETA 14
14033457 | 2.NP_SO-102 | 225 | 0.14767 | 0.357903 | 500 mm × 225 mm | 0 | 500 mm × 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3037.5 | 2925 | 2925 | 2812.5 | Fáze 1 | 0 | 359.608 | 310.345 | Zpětný vzduch | ETA 14 | 0.428243 | 253 | Odváděný | ETA | 295.34 | 500 | 500 × 225 | 225 | PO02.03.1289 | 1289 | yes | ETA 14
14033564 | 2.NP_SO-102 | 554.48 | 0.1125 | 0.803995 | 500 mm × 225 mm | 0 | 500 mm × 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 3746.98 | 3746.98 | 3192.5 | 3192.5 | Fáze 1 | 0 | 359.608 | 310.345 | Zpětný vzduch | ETA 14 | 0.803995 | 270 | Odváděný | ETA | 554.48 | 500 | 500 × 225 | 225 | PO02.03.1290 | 1290 | yes | ETA 14
14033643 | 2.NP_SO-102 | 500 | 0.00936478 | 0.266621 | 500 mm × 225 mm | 0 | 500 mm × 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 100 | 4100.11 | 4020.56 | 3991.13 | 3911.58 | Fáze 1 | 0 | 359.608 | 310.345 | Zpětný vzduch | ETA 14 | 0.0603508 | 270 | Odváděný | ETA | 41.6213 | 500 | 500 × 225 | 225 | PO02.03.1291 | 1291 | yes | ETA 14
14036605 | 2.NP_SO-102 | 225 | 0.391404 | 0.577264 | 500 mm × 225 mm | 0 | 500 mm × 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3037.5 | 2925 | 2925 | 2812.5 | Fáze 1 | 0 | 359.608 | 310.345 | Zpětný vzduch | ETA 14 | 1.13507 | 270 | Odváděný | ETA | 782.809 | 500 | 500 × 225 | 225 | PO02.03.1295 | 1295 | yes | ETA 14
14036882 | 2.NP_SO-102 | 225 | 0.0989531 | 0.314058 | 500 mm × 225 mm | 0 | 500 mm × 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2992.5 | 2880 | 2880 | 2767.5 | Fáze 1 | 0 | 359.608 | 310.345 | Přívod vzduchu | SUP 9 | 0.286964 | 436 | Přívodní | SUP | 197.906 | 500 | 500 × 225 | 225 | PO02.03.1296 | 1296 | yes | SUP 9
14037060 | 2.NP_SO-102 | 225 | 0.0825874 | 0.299329 | 500 mm × 225 mm | 0 | 500 mm × 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2992.5 | 2880 | 2880 | 2767.5 | Fáze 1 | 0 | 359.608 | 310.345 | Přívod vzduchu | SUP 9 | 0.239503 | 437 | Přívodní | SUP | 165.175 | 500 | 500 × 225 | 225 | PO02.03.1297 | 1297 | yes | SUP 9
14037276 | 3.NP_SO-102 | 562.579 | 0.125 | 0.843869 | 500 mm × 250 mm | 0 | 500 mm × 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 |  | -603.606 | -1166.18 | -603.606 | -1166.18 | Fáze 1 | 0 | 380.844 | 333.333 | Přívod vzduchu | SUP 9 | 0.843869 | 442 | Přívodní | SUP | 562.579 | 500 | 500 × 250 | 250 | PO02.03.1298 | 1298 | yes | SUP 9
14040834 | 2.NP_SO-102 | 710 | 0.223299 | 1.4548 | 710 mm × 710 mm | 0 | 710 mm × 710 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3155 | 2800 | 2800 | 2445 | Fáze 1 | 0 | 776.147 | 710 | Zpětný vzduch | ETA 3 | 0.893197 | 9 | Odváděný | ETA | 314.506 | 710 | 710 × 710 | 710 | PO02.03.1320 | 1320 | yes | ETA 3
14041302 | 2.NP_SO-102 | 560 | 0.0895686 | 1.48025 | 1250 mm × 560 mm | 0 | 1250 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3080 | 2800 | 2800 | 2520 | Fáze 1 | 0 | 896.83 | 773.481 | Zpětný vzduch | ETA 3 | 0.259391 | 27 | Odváděný | ETA | 71.6548 | 1250 | 1250 × 560 | 560 | PO02.03.1321 | 1321 | yes | ETA 3
14041517 | 2.NP_SO-102 | 560 | 0.0617728 | 1.45535 | 1250 mm × 560 mm | 0 | 1250 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3080 | 2800 | 2800 | 2520 | Fáze 1 | 0 | 896.83 | 773.481 | Zpětný vzduch | ETA 3 | 0.178894 | 25 | Odváděný | ETA | 49.4182 | 1250 | 1250 × 560 | 560 | PO02.03.1322 | 1322 | yes | ETA 3
14051670 | 2.NP_SO-102 | 315 | 0.751906 | 1.16646 | 1250 mm × 315 mm | 0 | 1250 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3037.5 | 2880 | 2880 | 2722.5 | Fáze 1 | 0 | 649.124 | 503.195 | Přívod vzduchu | SUP 9 | 1.88277 | 464 | Přívodní | SUP | 601.524 | 1250 | 1250 × 315 | 315 | PO02.03.1335 | 1335 | yes | SUP 9
14055983 | 3.NP_SO-102 | 500 | 0.289889 | 1.09014 | 630 mm × 500 mm | 0 | 630 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 | 0 | 3250 | 3000 | 3000 | 2750 | Fáze 1 | 0 | 612.517 | 557.522 | Zpětný vzduch | ETA 3 | 1.03992 | 37 | Odváděný | ETA | 460.141 | 630 | 630 × 500 | 500 | PO02.03.1363 | 1363 | yes | ETA 3 | Identifikační data - Komentáře: VZT19
14062051 | 4.NP_SO-102 | 2210.26 | 0.4473 | 5.92351 | 710 mm × 630 mm | 15 | 740 mm × 660 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 |  | 812.171 | -1398.09 | 812.171 | -1398.09 | Fáze 1 | 0 | 730.788 | 667.612 | Přívod vzduchu | ODA 12 | 5.92351 | 16 | Čerstvý | ODA | 2210.26 | 710 | 710 × 630 | 630 | PO02.03.1397 | 1397 | yes | ODA 12 | Identifikační data - Komentáře: VZT29; Izolace - Typ izolace: Protipožární
14062774 | 4.NP_SO-102 | 1120 | 0.498484 | 3.68751 | 400 mm × 1120 mm | 0 | 400 mm × 1120 mm | 0 | 0 | 0 | 0 | 0 | 0 | STŘECHA_SO-102 | 0 | 1810 | 1250 | 1250 | 690 | Fáze 1 | 0 | 708.812 | 589.474 | Přívod vzduchu | ODA 12 | 3.78848 | 19 | Čerstvý | ODA | 1246.21 | 400 | 400 × 1120 | 1120 | PO02.03.1398 | 1398 | yes | ODA 12
14065958 | -1.PP_SO-102 | 355 | 0.0335476 | 0.537648 | 710 mm × 355 mm | 0 | 710 mm × 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3327.5 | 3150 | 3150 | 2972.5 | Fáze 2 | 0 | 540.798 | 473.333 | Zpětný vzduch | ETA 7 | 0.100643 | 388 | Odváděný | ETA | 47.2501 | 710 | 710 × 355 | 355 | PO02.03.1414 | 1414 | yes | ETA 7
14066192 | -1.PP_SO-102 | 400 | 0.00572664 | 0.240362 | 280 mm × 400 mm | 0 | 280 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2800 | 2600 | 2600 | 2400 | Fáze 1 | 0 | 364.399 | 329.412 | Přívod vzduchu | ODA 12 | 0.0278151 | 8 | Čerstvý | ODA | 20.4523 | 280 | 280 × 400 | 400 | PO02.03.1415 | 1415 | yes | ODA 12
14066286 | -1.PP_SO-102 | 400 | 0.02385 | 0.4024 | 450 mm × 400 mm | 15 | 480 mm × 430 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2800 | 2600 | 2600 | 2400 | Fáze 1 | 0 | 463.59 | 423.529 | Přívod vzduchu | ODA 12 | 0.0901 | 23 | Čerstvý | ODA | 53 | 450 | 450 × 400 | 400 | PO02.03.1416 | 1416 | yes | ODA 12 | Izolace - Typ izolace: Protipožární
14066492 | 1.NP_SO-102 | 280 | 0.0179582 | 0.274348 | 450 mm × 280 mm | 15 | 480 mm × 310 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-102 | 0 | 3236.2 | 3096.2 | 3096.2 | 2956.2 | Fáze 1 | 0 | 385.34 | 345.205 | Přívod vzduchu | ODA 12 | 0.0582644 | 22 | Čerstvý | ODA | 39.9071 | 450 | 450 × 280 | 280 | PO02.03.1417 | 1417 | yes | ODA 12 | Izolace - Typ izolace: Protipožární
14068663 | 2.NP_SO-102 | 315 | 0.43006 | 0.836618 | 560 mm × 315 mm | 0 | 560 mm × 315 mm | 146838 | 18.2655 | 0.972222 | 5.51146 | 0.653788 | 0.851325 | 2.NP_SO-102 | 0 | 2932.5 | 2775 | 2775 | 2617.5 | Fáze 1 | 0.0357936 | 454.468 | 403.2 | Přívod vzduchu | ODA 7 | 1.34394 | 5 | Čerstvý | ODA | 767.965 | 560 | 560 × 315 | 315 | PO02.03.1420 | 1420 | yes | ODA 7
14068767 | 2.NP_SO-102 | 400 | 0.871352 | 1.71568 | 1600 mm × 400 mm | 0 | 1600 mm × 400 mm | 275321 | 25.4868 | 4.16667 | 6.51042 | 0.361452 | 0.663707 | 2.NP_SO-102 | 0 | 2743.58 | 2543.58 | 2543.58 | 2343.58 | Fáze 1 | 0.0141819 | 827.082 | 640 | Přívod vzduchu | ODA 6 | 2.17838 | 2 | Čerstvý | ODA | 544.595 | 1600 | 1600 × 400 | 400 | PO02.03.1421 | 1421 | yes | ODA 6
14068907 | 2.NP_SO-102 | 400 | 0.537988 | 1.23039 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 277943 | 32.5825 | 2.94444 | 7.36111 | 0.516779 | 0.960578 | 2.NP_SO-102 | 0 | 2950 | 2750 | 2750 | 2550 | Fáze 1 | 0.0158606 | 674.06 | 571.429 | Přívod vzduchu | ODA 14 | 1.50637 | 2 | Čerstvý | ODA | 537.988 | 1000 | 1000 × 400 | 400 | PO02.03.1422 | 1422 | yes | ODA 14
14076895 | 2.NP_SO-102 | 501 | 0.625 | 1.7535 | 1250 mm × 500 mm | 0 | 1250 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 2465 | 1964 | 2465 | 1964 | Fáze 1 | 0 | 842.576 | 714.286 | Zpětný vzduch | ETA 14 | 1.7535 | 487 | Odváděný | ETA | 501 | 1250 | 1250 × 500 | 500 | PO02.03.1430 | 1430 | yes | ETA 14
14076985 | 2.NP_SO-102 | 500 | 0.0567836 | 1.29543 | 1250 mm × 500 mm | 0 | 1250 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 809 | 559 | 559 | 309 | Fáze 1 | 0 | 842.576 | 714.286 | Přívod vzduchu | SUP 9 | 0.158994 | 487 | Přívodní | SUP | 45.4269 | 1250 | 1250 × 500 | 500 | PO02.03.1431 | 1431 | yes | SUP 9
14077577 | 2.NP_SO-102 | 500 | 1.74511 | 2.64609 | 1250 mm × 500 mm | 0 | 1250 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 1809 | 1559 | 1559 | 1309 | Fáze 1 | 0 | 842.576 | 714.286 | Zpětný vzduch | ETA 14 | 4.88632 | 487 | Odváděný | ETA | 1396.09 | 1250 | 1250 × 500 | 500 | PO02.03.1432 | 1432 | yes | ETA 14
14077942 | 2.NP_SO-102 | 500 | 0.102979 | 1.33238 | 1250 mm × 500 mm | 0 | 1250 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3120 | 2870 | 2870 | 2620 | Fáze 1 | 0 | 842.576 | 714.286 | Zpětný vzduch | ETA 14 | 0.288342 | 489 | Odváděný | ETA | 82.3835 | 1250 | 1250 × 500 | 500 | PO02.03.1433 | 1433 | yes | ETA 14
14078291 | 2.NP_SO-102 | 600 | 1.07979 | 2.66383 | 1500 mm × 600 mm | 0 | 1500 mm × 600 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 859 | 559 | 559 | 259 | Fáze 1 | 0 | 1011.09 | 857.143 | Přívod vzduchu | SUP 9 | 3.02342 | 488 | Přívodní | SUP | 719.861 | 1500 | 1500 × 600 | 600 | PO02.03.1434 | 1434 | yes | SUP 9
14080866 | -1.PP_SO-102 | 354.842 | 0.896 | 1.53292 | 1600 mm × 560 mm | 0 | 1600 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 |  | 1348.84 | 1348.84 | 994 | 994 | Fáze 1 | 0 | 1001.2 | 829.63 | Přívod vzduchu | ODA 8 | 1.53292 | 9 | Čerstvý | ODA | 354.842 | 1600 | 1600 × 560 | 560 | PO02.03.1447 | 1447 | yes | ODA 8
14084278 | 2.NP_SO-102 | 400 | 0.153702 | 1.09837 | 1250 mm × 400 mm | 0 | 1250 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3120 | 2920 | 2920 | 2720 | Fáze 1 | 0 | 743.753 | 606.061 | Zpětný vzduch | ETA 14 | 0.405775 | 492 | Odváděný | ETA | 122.962 | 1250 | 1250 × 400 | 400 | PO02.03.1462 | 1462 | yes | ETA 14
14084291 | 2.NP_SO-102 | 400 | 0.0741391 | 1.04745 | 1250 mm × 400 mm | 0 | 1250 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3120 | 2920 | 2920 | 2720 | Fáze 1 | 0 | 743.753 | 606.061 | Zpětný vzduch | ETA 14 | 0.195727 | 492 | Odváděný | ETA | 59.3113 | 1250 | 1250 × 400 | 400 | PO02.03.1463 | 1463 | yes | ETA 14
14108533 | -1.PP_SO-102 | 315 | 0.126065 | 0.473842 | 500 mm × 315 mm | 0 | 500 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3237.5 | 3080 | 3080 | 2922.5 | Fáze 1 | 0 | 430.977 | 386.503 | Zpětný vzduch | ETA 7 | 0.410973 | 432 | Odváděný | ETA | 252.131 | 500 | 500 × 315 | 315 | PO02.03.1465 | 1465 | yes | ETA 7
14109722 | -1.PP_SO-102 | 355 | 6.95334 | 6.73909 | 800 mm × 355 mm | 0 | 800 mm × 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3257.5 | 3080 | 3080 | 2902.5 | Fáze 1 | 0 | 570.981 | 491.775 | Zpětný vzduch | ETA 7 | 20.0778 | 387 | Odváděný | ETA | 8691.67 | 800 | 800 × 355 | 355 | PO02.03.1468 | 1468 | yes | ETA 7
14110268 | -1.PP_SO-102 | 800 | 0.180567 | 1.38182 | 800 mm × 355 mm | 0 | 800 mm × 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 100 | 3155.34 | 3029.83 | 2670.17 | 2544.66 | Fáze 2 | 0 | 570.981 | 491.775 | Zpětný vzduch | ETA 7 | 1.17496 | 390 | Odváděný | ETA | 508.64 | 800 | 800 × 355 | 355 | PO02.03.1470 | 1470 | yes | ETA 7 | Identifikační data - Komentáře: PŘIPOJENÍ PŘÍVODNÍHO A ODVODNÍHO POTRUBÍ V II.ETAPĚ VÝSTAVBY
14110278 | -1.PP_SO-102 | 355 | 0.028699 | 0.59347 | 800 mm × 355 mm | 0 | 800 mm × 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3327.5 | 3150 | 3150 | 2972.5 | Fáze 2 | 0 | 570.981 | 491.775 | Zpětný vzduch | ETA 7 | 0.0828685 | 390 | Odváděný | ETA | 35.8738 | 800 | 800 × 355 | 355 | PO02.03.1471 | 1471 | yes | ETA 7
14121622 | 2.NP_SO-102 | 280 | 0.095 | 0.3864 | 500 mm × 280 mm | 0 | 500 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3236.2 | 3096.2 | 3096.2 | 2956.2 | Fáze 1 | 0 | 404.809 | 358.974 | Přívod vzduchu | ODA 18 | 0.2964 | 1 | Čerstvý | ODA | 190 | 500 | 500 × 280 | 280 | PO02.03.1511 | 1511 | yes | ODA 18
14122721 | -1.PP_SO-102 | 400 | 0.696215 | 1.33622 | 800 mm × 400 mm | 0 | 800 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2600 | 2400 | 2400 | 2200 | Fáze 1 | 0 | 609.35 | 533.333 | Zpětný vzduch | ETA 1 | 2.08865 | 151 | Odváděný | ETA | 870.269 | 800 | 800 × 400 | 400 | PO02.03.1515 | 1515 | yes | ETA 1
14124010 | 2.NP_SO-102 | 3037.5 | 0.1764 | 5.52825 | 280 mm × 630 mm | 0 | 280 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 7752871 | 6892.5 | 6892.5 | 3855 | 3855 | Fáze 2 | 0 | 450.033 | 387.692 | Přívod vzduchu | SUP 24 | 5.52825 | 258 | Přívodní | SUP | 3037.5 | 280 | 280 × 630 | 630 | PO02.03.1517 | 1517 | yes | SUP 24
14132247 | 1.NP_SO-102 | 104.1 | 0.099225 | 0.131166 | 315 mm × 315 mm | 0 | 315 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-102 |  | 3068.34 | 3068.34 | 2964.24 | 2964.24 | Fáze 1 | 0 | 344.347 | 315 | Přívod vzduchu | SUP 11 | 0.131166 | 197 | Přívodní | SUP | 104.1 | 315 | 315 × 315 | 315 | PO02.03.1520 | 1520 | yes | SUP 11
14132431 | 1.NP_SO-102 | 5.1 | 0.099225 | 0.006426 | 315 mm × 315 mm | 0 | 315 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-102 |  | 3003.34 | 3003.34 | 2998.24 | 2998.24 | Fáze 1 | 0 | 344.347 | 315 | Přívod vzduchu | SUP 11 | 0.006426 | 184 | Přívodní | SUP | 5.1 | 315 | 315 × 315 | 315 | PO02.03.1525 | 1525 | yes | SUP 11
14132598 | 1.NP_SO-102 | 25.1 | 0.099225 | 0.031626 | 315 mm × 315 mm | 0 | 315 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-102 |  | 3068.34 | 3068.34 | 3043.24 | 3043.24 | Fáze 1 | 0 | 344.347 | 315 | Přívod vzduchu | SUP 11 | 0.031626 | 160 | Přívodní | SUP | 25.1 | 315 | 315 × 315 | 315 | PO02.03.1528 | 1528 | yes | SUP 11
14138160 | -1.PP_SO-102 | 315 | 0.575 | 1.0773 | 1250 mm × 315 mm | 0 | 1250 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2905 | 2747.5 | 2747.5 | 2590 | Fáze 1 | 0 | 649.124 | 503.195 | Přívod vzduchu | SUP 24 | 1.4398 | 471 | Přívodní | SUP | 460 | 1250 | 1250 × 315 | 315 | PO02.03.1538 | 1538 | yes | SUP 24
14138184 | -1.PP_SO-102 | 315 | 0.696119 | 1.59069 | 315 mm × 315 mm | 0 | 315 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2905 | 2747.5 | 2747.5 | 2590 | Fáze 1 | 0 | 344.347 | 315 | Přívod vzduchu | SUP 24 | 2.78447 | 477 | Přívodní | SUP | 2209.9 | 315 | 315 × 315 | 315 | PO02.03.1539 | 1539 | yes | SUP 24
14138311 | -1.PP_SO-102 | 315 | 0.10495 | 0.408351 | 315 mm × 315 mm | 0 | 315 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2905 | 2747.5 | 2747.5 | 2590 | Fáze 1 | 0 | 344.347 | 315 | Přívod vzduchu | SUP 24 | 0.419801 | 475 | Přívodní | SUP | 333.176 | 315 | 315 × 315 | 315 | PO02.03.1540 | 1540 | yes | SUP 24
14138529 | -1.PP_SO-102 | 400 | 0.222797 | 1.05119 | 200 mm × 400 mm | 0 | 200 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2604.86 | 2404.86 | 2404.86 | 2204.86 | Fáze 1 | 0 | 304.675 | 266.667 | Zpětný vzduch | ETA 1 | 1.33678 | 157 | Odváděný | ETA | 1113.98 | 200 | 200 × 400 | 400 | PO02.03.1541 | 1541 | yes | ETA 1
14138685 | -1.PP_SO-102 | 560 | 0.204 | 1.3664 | 200 mm × 560 mm | 0 | 200 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2684.86 | 2404.86 | 2404.86 | 2124.86 | Fáze 1 | 0 | 354.406 | 294.737 | Zpětný vzduch | ETA 1 | 1.5504 | 158 | Odváděný | ETA | 1020 | 200 | 200 × 560 | 560 | PO02.03.1542 | 1542 | yes | ETA 1
14138906 | -1.PP_SO-102 | 400 | 0.00356633 | 0.174265 | 200 mm × 400 mm | 0 | 200 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2604.86 | 2404.86 | 2404.86 | 2204.86 | Fáze 1 | 0 | 304.675 | 266.667 | Zpětný vzduch | ETA 1 | 0.021398 | 157 | Odváděný | ETA | 17.8317 | 200 | 200 × 400 | 400 | PO02.03.1543 | 1543 | no | ETA 1
14145827 | 2.NP_SO-102 | 400 | 0.317704 | 1.43885 | 1600 mm × 400 mm | 0 | 1600 mm × 400 mm | 275321 | 25.4868 | 4.16667 | 6.51042 | 0.131789 | 0.663707 | 2.NP_SO-102 | 0 | 2743.58 | 2543.58 | 2543.58 | 2343.58 | Fáze 1 | 0.00517087 | 827.082 | 640 | Přívod vzduchu | ODA 6 | 0.794259 | 2 | Čerstvý | ODA | 198.565 | 1600 | 1600 × 400 | 400 | PO02.03.1545 | 1545 | yes | ODA 6
14145900 | 2.NP_SO-102 | 400 | 2.05701 | 2.44561 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 277943 | 32.5825 | 2.94444 | 7.36111 | 1.97592 | 0.960578 | 2.NP_SO-102 | 0 | 2950 | 2750 | 2750 | 2550 | Fáze 1 | 0.0606436 | 674.06 | 571.429 | Přívod vzduchu | ODA 14 | 5.75963 | 2 | Čerstvý | ODA | 2057.01 | 1000 | 1000 × 400 | 400 | PO02.03.1546 | 1546 | yes | ODA 14
14146247 | 2.NP_SO-102 | 315 | 1.208 | 1.71179 | 560 mm × 315 mm | 0 | 560 mm × 315 mm | 146838 | 18.2655 | 0.972222 | 5.51146 | 1.83642 | 0.851325 | 2.NP_SO-102 | 0 | 2932.5 | 2775 | 2775 | 2617.5 | Fáze 1 | 0.10054 | 454.468 | 403.2 | Přívod vzduchu | ODA 7 | 3.77498 | 5 | Čerstvý | ODA | 2157.13 | 560 | 560 × 315 | 315 | PO02.03.1547 | 1547 | yes | ODA 7
14146431 | 2.NP_SO-102 | 400 | 0.50516 | 1.16903 | 900 mm × 400 mm | 0 | 900 mm × 400 mm | 208961 | 19.6043 | 2.05556 | 5.70988 | 0.346733 | 0.617745 | 2.NP_SO-102 | 0 | 1959 | 1759 | 1759 | 1559 | Fáze 1 | 0.0176866 | 642.905 | 553.846 | Přívod vzduchu | ODA 3 | 1.45935 | 3 | Čerstvý | ODA | 561.288 | 900 | 900 × 400 | 400 | PO02.03.1548 | 1548 | yes | ODA 3
14149682 | 2.NP_SO-102 | 665.356 | 0.1764 | 1.21095 | 630 mm × 280 mm | 0 | 630 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 2395 | 1729.64 | 2395 | 1729.64 | Fáze 1 | 0 | 450.033 | 387.692 | Zpětný vzduch | ETA 3 | 1.21095 | 2 | Odváděný | ETA | 665.356 | 630 | 630 × 280 | 280 | PO02.03.1566 | 1566 | yes | ETA 3
14149714 | 2.NP_SO-102 | 450 | 0.00634137 | 0.576059 | 630 mm × 450 mm | 0 | 630 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 1574.64 | 1349.64 | 1349.64 | 1124.64 | Fáze 1 | 0 | 580.007 | 525 | Zpětný vzduch | ETA 3 | 0.0217418 | 3 | Odváděný | ETA | 10.0657 | 630 | 630 × 450 | 450 | PO02.03.1567 | 1567 | yes | ETA 3
14152109 | 4.NP_SO-102 | 800 | 0.0717614 | 1.42352 | 800 mm × 800 mm | 0 | 800 mm × 800 mm | 0 | 0 | 0 | 0 | 0 | 0 | STŘECHA_SO-102 | 0 | 1640 | 1240 | 1240 | 840 | Fáze 1 | 0 | 874.532 | 800 | Přívod vzduchu | ODA 25 | 0.287046 | 7 | Čerstvý | ODA | 89.7017 | 800 | 800 × 800 | 800 | PO02.03.1568 | 1568 | yes | ODA 25
14155566 | 4.NP_SO-102 | 315 | 0.964132 | 2.12671 | 315 mm × 315 mm | 0 | 315 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 | 0 | 4722.99 | 4565.49 | 4565.49 | 4407.99 | Fáze 1 | 0 | 344.347 | 315 | Zpětný vzduch | ETA 97 | 3.85653 | 43 | Odváděný | ETA | 3060.74 | 315 | 315 × 315 | 315 | PO02.03.1572 | 1572 | yes | ETA 97
14156178 | 4.NP_SO-102 | 450 | 0.200059 | 0.810107 | 500 mm × 450 mm | 0 | 500 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | STŘECHA_SO-102 | 0 | 1465 | 1240 | 1240 | 1015 | Fáze 1 | 0 | 518.354 | 473.684 | Přívod vzduchu | ODA 25 | 0.760226 | 6 | Čerstvý | ODA | 400.119 | 500 | 500 × 450 | 450 | PO02.03.1573 | 1573 | yes | ODA 25 | Fázování - Bouráno ve FÁZI 2: yes
14156649 | 4.NP_SO-102 | 630 | 1.62096 | 3.30241 | 1000 mm × 630 mm | 0 | 1000 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 | 0 | 5965 | 5650 | 5650 | 5335 | Fáze 1 | 0 | 861.954 | 773.006 | Přívod vzduchu | ODA 12 | 5.28434 | 3 | Čerstvý | ODA | 1620.96 | 1000 | 1000 × 630 | 630 | PO02.03.1574 | 1574 | yes | ODA 12
14157971 | 4.NP_SO-102 | 1120 | 0.248724 | 2.28886 | 400 mm × 1120 mm | 0 | 400 mm × 1120 mm | 0 | 0 | 0 | 0 | 0 | 0 | STŘECHA_SO-102 | 0 | 1810 | 1250 | 1250 | 690 | Fáze 1 | 0 | 708.812 | 589.474 | Přívod vzduchu | ODA 12 | 1.8903 | 19 | Čerstvý | ODA | 621.81 | 400 | 400 × 1120 | 1120 | PO02.03.1575 | 1575 | yes | ODA 12
14158617 | 4.NP_SO-102 | 630 | 0.0142728 | 0.822346 | 630 mm × 630 mm | 0 | 630 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | STŘECHA_SO-102 | 0 | 1565 | 1250 | 1250 | 935 | Fáze 1 | 0 | 688.694 | 630 | Přívod vzduchu | ODA 12 | 0.0570911 | 2 | Čerstvý | ODA | 22.6552 | 630 | 630 × 630 | 630 | PO02.03.1576 | 1576 |  | ODA 12
14158702 | 4.NP_SO-102 | 1120 | 0.115822 | 1.5446 | 400 mm × 1120 mm | 0 | 400 mm × 1120 mm | 0 | 0 | 0 | 0 | 0 | 0 | STŘECHA_SO-102 | 0 | 1810 | 1250 | 1250 | 690 | Fáze 1 | 0 | 708.812 | 589.474 | Přívod vzduchu | ODA 12 | 0.880244 | 19 | Čerstvý | ODA | 289.554 | 400 | 400 × 1120 | 1120 | PO02.03.1577 | 1577 | yes | ODA 12
14158864 | 4.NP_SO-102 | 630 | 0.204133 | 1.20207 | 630 mm × 630 mm | 0 | 630 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | STŘECHA_SO-102 | 100 | 1862.3 | 1639.56 | 1410.44 | 1187.7 | Fáze 1 | 0 | 688.694 | 630 | Přívod vzduchu | ODA 12 | 0.816531 | 2 | Čerstvý | ODA | 324.02 | 630 | 630 × 630 | 630 | PO02.03.1578 | 1578 | yes | ODA 12
14159060 | 4.NP_SO-102 | 630 | 0.0356389 | 0.865078 | 630 mm × 630 mm | 0 | 630 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | STŘECHA_SO-102 | 0 | 2115 | 1800 | 1800 | 1485 | Fáze 1 | 0 | 688.694 | 630 | Přívod vzduchu | ODA 12 | 0.142556 | 2 | Čerstvý | ODA | 56.5697 | 630 | 630 × 630 | 630 | PO02.03.1579 | 1579 |  | ODA 12
14159894 | -1.PP_SO-102 | 355 | 2.35146 | 2.65492 | 800 mm × 355 mm | 0 | 800 mm × 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2727.5 | 2550 | 2550 | 2372.5 | Fáze 1 | 0 | 570.981 | 491.775 | Zpětný vzduch | ETA 7 | 6.78984 | 390 | Odváděný | ETA | 2939.33 | 800 | 800 × 355 | 355 | PO02.03.1580 | 1580 | yes | ETA 7 | Identifikační data - Komentáře: ZASLEPENÁ ODBOČKA PŘÍPRAVA PRO NAPOJENÍ MÍSTNOSTÍ VE II.ETAPĚ VÝSTAVBY
14164890 | 2.NP_SO-102 | 1620 | 0.315 | 4.2606 | 315 mm × 1000 mm | 0 | 315 mm × 1000 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 2553.32 | 2553.32 | 933.315 | 933.315 | Fáze 1 | 0 | 589.734 | 479.087 | Zpětný vzduch | ETA 5 | 4.2606 | 1 | Odváděný | ETA | 1620 | 315 | 315 × 1000 | 1000 | PO02.03.1581 | 1581 | yes | ETA 5
14173213 | -1.PP_SO-102 | 160 | 3.08399 | 3.23374 | 315 mm × 160 mm | 0 | 315 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2660 | 2580 | 2580 | 2500 | Fáze 1 | 0 | 241.985 | 212.211 | Zpětný vzduch | ETA 97 | 9.30092 | 11 | Odváděný | ETA | 9790.44 | 315 | 315 × 160 | 160 | PO02.03.1594 | 1594 | yes | ETA 97
14173279 | -1.PP_SO-102 | 315 | 0.0289413 | 0.214756 | 315 mm × 160 mm | 0 | 315 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 100 | 2856.08 | 2799.52 | 2671.61 | 2615.04 | Fáze 1 | 0 | 241.985 | 212.211 | Zpětný vzduch | ETA 97 | 0.171839 | 11 | Odváděný | ETA | 180.883 | 315 | 315 × 160 | 160 | PO02.03.1595 | 1595 |  | ETA 97
14173292 | -1.PP_SO-102 | 160 | 0.0947782 | 0.197083 | 315 mm × 160 mm | 0 | 315 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2971.13 | 2891.13 | 2891.13 | 2811.13 | Fáze 1 | 0 | 241.985 | 212.211 | Zpětný vzduch | ETA 97 | 0.285839 | 11 | Odváděný | ETA | 300.883 | 315 | 315 × 160 | 160 | PO02.03.1596 | 1596 |  | ETA 97
14173304 | -1.PP_SO-102 | 315 | 0.0289413 | 0.214756 | 315 mm × 160 mm | 0 | 315 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 100 | 2856.08 | 2671.61 | 2799.52 | 2615.04 | Fáze 1 | 0 | 241.985 | 212.211 | Zpětný vzduch | ETA 97 | 0.171839 | 11 | Odváděný | ETA | 180.883 | 315 | 315 × 160 | 160 | PO02.03.1597 | 1597 |  | ETA 97
14176553 | -1.PP_SO-102 | 400 | 0.900589 | 1.54059 | 800 mm × 400 mm | 0 | 800 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2700 | 2500 | 2500 | 2300 | Fáze 2 | 0 | 609.35 | 533.333 | Přívod vzduchu | SUP 24 | 2.70177 | 555 | Přívodní | SUP | 1125.74 | 800 | 800 × 400 | 400 | PO02.03.1606 | 1606 | yes | SUP 24 | Identifikační data - Komentáře: PŘIPOJENÍ PŘÍVODNÍHO A ODVODNÍHO POTRUBÍ V II.ETAPĚ VÝSTAVBY
14176744 | -1.PP_SO-102 | 400 | 4.52077 | 5.16077 | 800 mm × 400 mm | 0 | 800 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3330 | 3130 | 3130 | 2930 | Fáze 2 | 0 | 609.35 | 533.333 | Přívod vzduchu | SUP 24 | 13.5623 | 555 | Přívodní | SUP | 5650.96 | 800 | 800 × 400 | 400 | PO02.03.1607 | 1607 | yes | SUP 24
14176745 | -1.PP_SO-102 | 800 | 0.212971 | 1.49188 | 800 mm × 400 mm | 0 | 800 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 100 | 3144.66 | 2626.76 | 3003.24 | 2485.34 | Fáze 2 | 0 | 609.35 | 533.333 | Přívod vzduchu | SUP 24 | 1.27782 | 555 | Přívodní | SUP | 532.426 | 800 | 800 × 400 | 400 | PO02.03.1608 | 1608 | yes | SUP 24
14181639 | 1.NP_SO-102 | 51.6 | 0.099225 | 0.065016 | 315 mm × 315 mm | 0 | 315 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-102 |  | 3055.9 | 3055.9 | 3004.3 | 3004.3 | Fáze 1 | 0 | 344.347 | 315 | Přívod vzduchu | SUP 15 | 0.065016 | 197 | Přívodní | SUP | 51.6 | 315 | 315 × 315 | 315 | PO02.03.1621 | 1621 | yes | SUP 15
14181810 | 1.NP_SO-102 | 9.1 | 0.099225 | 0.011466 | 315 mm × 315 mm | 0 | 315 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-102 |  | 3123.4 | 3123.4 | 3114.3 | 3114.3 | Fáze 1 | 0 | 344.347 | 315 | Přívod vzduchu | SUP 15 | 0.011466 | 207 | Přívodní | SUP | 9.1 | 315 | 315 × 315 | 315 | PO02.03.1629 | 1629 | yes | SUP 15
14182363 | 1.NP_SO-102 | 6.6 | 0.099225 | 0.008316 | 315 mm × 315 mm | 0 | 315 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-102 |  | 3055.9 | 3055.9 | 3049.3 | 3049.3 | Fáze 1 | 0 | 344.347 | 315 | Přívod vzduchu | SUP 15 | 0.008316 | 217 | Přívodní | SUP | 6.6 | 315 | 315 × 315 | 315 | PO02.03.1634 | 1634 | yes | SUP 15
14184105 | 2.NP_SO-102 | 800 | 0.0189 | 1.056 | 630 mm × 800 mm | 0 | 630 mm × 800 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 959 | 559 | 559 | 159 | Fáze 1 | 0 | 774.691 | 704.895 | Odváděný vzduch | EHA 10 | 0.0858 | 2 | Znehodnocený | EHA | 30 | 630 | 630 × 800 | 800 | PO02.03.1641 | 1641 |  | EHA 10
14184277 | 2.NP_SO-102 | 1175 | 0.7056 | 4.1125 | 1120 mm × 630 mm | 0 | 1120 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 2289 | 2289 | 1114 | 1114 | Fáze 1 | 0 | 908.935 | 806.4 | Odváděný vzduch | EHA 10 | 4.1125 | 1 | Znehodnocený | EHA | 1175 | 1120 | 1120 × 630 | 630 | PO02.03.1642 | 1642 |  | EHA 10
14192711 | 4.NP_SO-102 | 500 | 1.07033 | 2.26895 | 1600 mm × 500 mm | 0 | 1600 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | STŘECHA_SO-102 | 0 | 979.33 | 729.33 | 729.33 | 479.33 | Fáze 1 | 0 | 939.333 | 761.905 | Odváděný vzduch | EHA 1 | 2.80961 | 1 | Znehodnocený | EHA | 668.954 | 1600 | 1600 × 500 | 500 | PO02.03.1654 | 1654 |  | EHA 1
14193578 | 4.NP_SO-102 | 1600 | 0.0740824 | 2.07413 | 1600 mm × 500 mm | 0 | 1600 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | STŘECHA_SO-102 | 26.7949 | 1035.32 | 793.839 | 755.491 | 514.01 | Fáze 1 | 0 | 939.333 | 761.905 | Odváděný vzduch | EHA 1 | 0.622292 | 1 | Znehodnocený | EHA | 148.165 | 1600 | 1600 × 500 | 500 | PO02.03.1655 | 1655 |  | EHA 1
14193591 | 4.NP_SO-102 | 500 | 2.62481 | 3.2405 | 1600 mm × 500 mm | 0 | 1600 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | STŘECHA_SO-102 | 0 | 1070 | 820 | 820 | 570 | Fáze 1 | 0 | 939.333 | 761.905 | Odváděný vzduch | EHA 1 | 6.89012 | 1 | Znehodnocený | EHA | 1640.5 | 1600 | 1600 × 500 | 500 | PO02.03.1656 | 1656 |  | EHA 1
14194373 | 2.NP_SO-102 | 160 | 0.0310292 | 0.179859 | 500 mm × 160 mm | 0 | 500 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2815 | 2735 | 2735 | 2655 | Fáze 1 | 0 | 297.501 | 242.424 | Přívod vzduchu | SUP 13 | 0.0819171 | 338 | Přívodní | SUP | 62.0584 | 500 | 500 × 160 | 160 | PO02.03.1657 | 1657 |  | SUP 13
14194493 | 2.NP_SO-102 | 160 | 0.746176 | 0.637553 | 500 mm × 160 mm | 0 | 500 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3160 | 3080 | 3080 | 3000 | Fáze 1 | 0 | 297.501 | 242.424 | Přívod vzduchu | SUP 13 | 1.96991 | 338 | Přívodní | SUP | 1492.35 | 500 | 500 × 160 | 160 | PO02.03.1658 | 1658 |  | SUP 13
14194681 | 2.NP_SO-102 | 500 | 0.04 | 0.41 | 500 mm × 160 mm | 0 | 500 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 100 | 3059.96 | 3003.39 | 2826.61 | 2770.04 | Fáze 2 | 0 | 297.501 | 242.424 | Přívod vzduchu | SUP 13 | 0.33 | 338 | Přívodní | SUP | 250 | 500 | 500 × 160 | 160 | PO02.03.1659 | 1659 |  | SUP 13
14194769 | 2.NP_SO-102 | 160 | 0.00662312 | 0.164239 | 500 mm × 160 mm | 0 | 500 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3175 | 3095 | 3095 | 3015 | Fáze 2 | 0 | 297.501 | 242.424 | Přívod vzduchu | SUP 13 | 0.017485 | 338 | Přívodní | SUP | 13.2462 | 500 | 500 × 160 | 160 | PO02.03.1660 | 1660 |  | SUP 13
14194973 | 3.NP_SO-102 | 160 | 0.217118 | 0.298955 | 500 mm × 160 mm | 0 | 500 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 | 0 | 2815 | 2735 | 2735 | 2655 | Fáze 2 | 0 | 297.501 | 242.424 | Přívod vzduchu | SUP 13 | 0.573191 | 333 | Přívodní | SUP | 434.236 | 500 | 500 × 160 | 160 | PO02.03.1661 | 1661 |  | SUP 13
14194974 | 3.NP_SO-102 | 500 | 0.0411314 | 0.417071 | 500 mm × 160 mm | 0 | 500 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 | 100 | 3064.96 | 3008.39 | 2826.61 | 2770.04 | Fáze 1 | 0 | 297.501 | 242.424 | Přívod vzduchu | SUP 13 | 0.339334 | 336 | Přívodní | SUP | 257.071 | 500 | 500 × 160 | 160 | PO02.03.1662 | 1662 |  | SUP 13
14194976 | 3.NP_SO-102 | 160 | 0.0132139 | 0.168457 | 500 mm × 160 mm | 0 | 500 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 | 0 | 3180 | 3100 | 3100 | 3020 | Fáze 1 | 0 | 297.501 | 242.424 | Přívod vzduchu | SUP 13 | 0.0348846 | 336 | Přívodní | SUP | 26.4278 | 500 | 500 × 160 | 160 | PO02.03.1663 | 1663 |  | SUP 13
14194979 | 3.NP_SO-102 | 500 | 0.04 | 0.41 | 500 mm × 160 mm | 0 | 500 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 | 100 | 3059.96 | 3003.39 | 2826.61 | 2770.04 | Fáze 2 | 0 | 297.501 | 242.424 | Přívod vzduchu | SUP 13 | 0.33 | 333 | Přívodní | SUP | 250 | 500 | 500 × 160 | 160 | PO02.03.1664 | 1664 |  | SUP 13
14194981 | 3.NP_SO-102 | 160 | 0.00663263 | 0.164245 | 500 mm × 160 mm | 0 | 500 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 | 0 | 3175 | 3095 | 3095 | 3015 | Fáze 2 | 0 | 297.501 | 242.424 | Přívod vzduchu | SUP 13 | 0.0175101 | 333 | Přívodní | SUP | 13.2653 | 500 | 500 × 160 | 160 | PO02.03.1665 | 1665 |  | SUP 13
14196489 | 2.NP_SO-102 | 500 | 0.0366059 | 0.388787 | 500 mm × 160 mm | 0 | 500 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 100 | 3044.96 | 2988.39 | 2826.61 | 2770.04 | Fáze 1 | 0 | 297.501 | 242.424 | Přívod vzduchu | SUP 13 | 0.301999 | 338 | Přívodní | SUP | 228.787 | 500 | 500 × 160 | 160 | PO02.03.1666 | 1666 |  | SUP 13
14196745 | 2.NP_SO-102 | 160 | 0.176971 | 0.273261 | 500 mm × 160 mm | 0 | 500 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2815 | 2735 | 2735 | 2655 | Fáze 2 | 0 | 297.501 | 242.424 | Přívod vzduchu | SUP 13 | 0.467203 | 338 | Přívodní | SUP | 353.942 | 500 | 500 × 160 | 160 | PO02.03.1667 | 1667 |  | SUP 13

# IfcDuctSegment: Hranaté potrubí:POZINK/vývod (238)
Type - Material: 0-0-255
Type - Požární ochrana - Požární odolnost: A1
Type - Materiály a povrchové úpravy - Materiál: Kov, pozink
Type - Stavba - Drsnost: 0.15 mm
Type - Identifikační data - ID kategorie: PO; Kód sestavy: PO02; Komentáře k typům: POZINK; Název typu: POZINK/vývod; Označení typu: 02; Popis: Potrubí hranaté pozink; Popis sestavy: Pozinkované
Type - Jiné - Kategorie: Potrubí; MJ: m; Název rodiny: Hranaté potrubí
Classification: PO02 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Mechanické – tok - Reynoldsovo číslo: 0; Doplňkový průtok: 0 m3/s; Dynamický tlak: 0 Pa; Průtok: 0 m3/s; Rychlost: 0 m/s; Tlaková ztráta: 0 Pa; Tření: 0 kg/m2/s2
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Mechanické - Koeficient ztrát: 0; Uzamknutí velikosti: no
Jiné - Id typu: 9070482; Rodina: Hranaté potrubí; Rodina a typ: Hranaté potrubí: POZINK/vývod; Typ: POZINK/vývod
Name (Hranaté potrubí:POZINK/vývod:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Sklon | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Spodní výška (mm) | Fáze vytvoření | Typ systému | Ekvivaletní průměr (mm) | Hydraulický průměr (mm) | Klasifikace systému | Název systému = Group | Plocha (m2) | Řez | Zkratka systému | Délka (mm) | Šířka (mm) | Velikost | Výška (mm) | Kód prvku | Označení | Páteřní trasa
12918689 | 1.NP_SO-102 | 315 | 3.62359 | 3.6626 | 710 mm × 315 mm | 0 | 710 mm × 315 mm | 0 | 3475 | 3317.5 | 3317.5 | 1.NP_SO-102 | 3160 | Fáze 1 | Přívodní | 506.691 | 436.39 | Přívod vzduchu | SUP 15 | 10.4625 | 132 | SUP | 5103.65 | 710 | 710 × 315 | 315 | PO02.02.0016 | 0016 | yes
12918743 | 1.NP_SO-102 | 400 | 10.445 | 9.156 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 0 | 3250 | 3050 | 3050 | 1.NP_SO-102 | 2850 | Fáze 1 | Odváděný | 674.06 | 571.429 | Zpětný vzduch | ETA 11 | 29.246 | 87 | ETA | 10445 | 1000 | 1000 × 400 | 400 | PO02.02.0017 | 0017 | yes
13109700 | 2.NP_SO-102 | 315 | 0.119321 | 0.847638 | 1250 mm × 315 mm | 0 | 1250 mm × 315 mm | 0 | 3037.5 | 2880 | 2880 | 2.NP_SO-102 | 2722.5 | Fáze 1 | Přívodní | 649.124 | 503.195 | Přívod vzduchu | SUP 9 | 0.29878 | 446 | SUP | 95.4568 | 1250 | 1250 × 315 | 315 | PO02.02.0052 | 0052 | yes
13227297 | -1.PP_SO-102 | 315 | 0.0378 | 0.27405 | 315 mm × 315 mm | 0 | 315 mm × 315 mm | 0 | 3237.5 | 3080 | 3080 | -1.PP_SO-102 | 2922.5 | Fáze 1 | Odváděný | 344.347 | 315 | Zpětný vzduch | ETA 7 | 0.1512 | 281 | ETA | 120 | 315 | 315 × 315 | 315 | PO02.02.0235 | 0235 | yes
13440247 | -1.PP_SO-102 | 400 | 3.02301 | 3.66301 | 800 mm × 400 mm | 0 | 800 mm × 400 mm | 0 | 3270 | 3070 | 3070 | -1.PP_SO-102 | 2870 | Fáze 2 | Odváděný | 609.35 | 533.333 | Zpětný vzduch | ETA 17 | 9.06902 | 123 | ETA | 3778.76 | 800 | 800 × 400 | 400 | PO02.02.0275 | 0275 | yes
13647690 | -1.PP_SO-102 | 500 | 1.02812 | 2.08515 | 800 mm × 500 mm | 0 | 800 mm × 500 mm | 0 | 3320 | 3070 | 3070 | -1.PP_SO-102 | 2820 | Fáze 2 | Odváděný | 686.665 | 615.385 | Zpětný vzduch | ETA 17 | 3.3414 | 165 | ETA | 1285.15 | 800 | 800 × 500 | 500 | PO02.02.0347 | 0347 | yes
13647789 | -1.PP_SO-102 | 500 | 0.203015 | 1.05377 | 800 mm × 500 mm | 0 | 800 mm × 500 mm | 0 | 3320 | 3070 | 3070 | -1.PP_SO-102 | 2820 | Fáze 2 | Přívodní | 686.665 | 615.385 | Přívod vzduchu | SUP 12 | 0.659799 | 54 | SUP | 253.769 | 800 | 800 × 500 | 500 | PO02.02.0348 | 0348 | yes
13647835 | -1.PP_SO-102 | 70.5 | 0.4 | 0.1833 | 800 mm × 500 mm | 0 | 800 mm × 500 mm |  | 1584.5 | 1514 | 1584.5 | -1.PP_SO-102 | 1514 | Fáze 2 | Odváděný | 686.665 | 615.385 | Zpětný vzduch | ETA 17 | 0.1833 | 26 | ETA | 70.5 | 800 | 800 × 500 | 500 | PO02.02.0349 | 0349 | yes
13647943 | -1.PP_SO-102 | 500 | 2.742 | 3.485 | 1200 mm × 500 mm | 0 | 1200 mm × 500 mm | 0 | 659 | 409 | 409 | -1.PP_SO-102 | 159 | Fáze 2 | Přívodní | 827.324 | 705.882 | Přívod vzduchu | SUP 12 | 7.769 | 14 | SUP | 2285 | 1200 | 1200 × 500 | 500 | PO02.02.0350 | 0350 | yes
13647950 | -1.PP_SO-102 | 500 | 0.102039 | 0.927549 | 800 mm × 500 mm | 0 | 800 mm × 500 mm | 0 | 659 | 409 | 409 | -1.PP_SO-102 | 159 | Fáze 2 | Přívodní | 686.665 | 615.385 | Přívod vzduchu | SUP 12 | 0.331627 | 2 | SUP | 127.549 | 800 | 800 × 500 | 500 | PO02.02.0351 | 0351 | yes
13647991 | -1.PP_SO-102 | 391 | 0.4 | 1.0166 | 800 mm × 500 mm | 0 | 800 mm × 500 mm |  | 2665 | 2665 | 2274 | -1.PP_SO-102 | 2274 | Fáze 2 | Přívodní | 686.665 | 615.385 | Přívod vzduchu | SUP 12 | 1.0166 | 54 | SUP | 391 | 800 | 800 × 500 | 500 | PO02.02.0352 | 0352 | yes
13648010 | -1.PP_SO-102 | 500 | 0.127836 | 0.959795 | 800 mm × 500 mm | 0 | 800 mm × 500 mm | 0 | 1359 | 1109 | 1109 | -1.PP_SO-102 | 859 | Fáze 2 | Odváděný | 686.665 | 615.385 | Zpětný vzduch | ETA 17 | 0.415466 | 26 | ETA | 159.795 | 800 | 800 × 500 | 500 | PO02.02.0353 | 0353 | yes
13648393 | -1.PP_SO-102 | 70.5 | 0.4 | 0.1833 | 800 mm × 500 mm | 0 | 800 mm × 500 mm |  | 2665 | 2594.5 | 2665 | -1.PP_SO-102 | 2594.5 | Fáze 2 | Odváděný | 686.665 | 615.385 | Zpětný vzduch | ETA 17 | 0.1833 | 26 | ETA | 70.5 | 800 | 800 × 500 | 500 | PO02.02.0354 | 0354 | yes
13648815 | -1.PP_SO-102 | 500 | 0.271836 | 1.13979 | 800 mm × 500 mm | 0 | 800 mm × 500 mm | 0 | 1359 | 1109 | 1109 | -1.PP_SO-102 | 859 | Fáze 2 | Odváděný | 686.665 | 615.385 | Zpětný vzduch | ETA 17 | 0.883466 | 26 | ETA | 339.795 | 800 | 800 × 500 | 500 | PO02.02.0355 | 0355 | yes
13648892 | -1.PP_SO-102 | 500 | 0.113874 | 0.942343 | 800 mm × 500 mm | 0 | 800 mm × 500 mm | 0 | 659 | 409 | 409 | -1.PP_SO-102 | 159 | Fáze 2 | Přívodní | 686.665 | 615.385 | Přívod vzduchu | SUP 12 | 0.370092 | 2 | SUP | 142.343 | 800 | 800 × 500 | 500 | PO02.02.0356 | 0356 | yes
13648918 | -1.PP_SO-102 | 87.868 | 0.4 | 0.228457 | 800 mm × 500 mm | 0 | 800 mm × 500 mm |  | 1264 | 1264 | 1176.13 | -1.PP_SO-102 | 1176.13 | Fáze 2 | Přívodní | 686.665 | 615.385 | Přívod vzduchu | SUP 12 | 0.228457 | 54 | SUP | 87.868 | 800 | 800 × 500 | 500 | PO02.02.0357 | 0357 | yes
13650203 | -1.PP_SO-102 | 500 | 0.960556 | 2.00069 | 800 mm × 500 mm | 0 | 800 mm × 500 mm | 0 | 3320 | 3070 | 3070 | -1.PP_SO-102 | 2820 | Fáze 2 | Odváděný | 686.665 | 615.385 | Zpětný vzduch | ETA 17 | 3.12181 | 165 | ETA | 1200.69 | 800 | 800 × 500 | 500 | PO02.02.0358 | 0358 | yes
13650267 | -1.PP_SO-102 | 500 | 0.0150493 | 0.818812 | 800 mm × 500 mm | 0 | 800 mm × 500 mm | 0 | 3320 | 3070 | 3070 | -1.PP_SO-102 | 2820 | Fáze 2 | Přívodní | 686.665 | 615.385 | Přívod vzduchu | SUP 12 | 0.0489103 | 54 | SUP | 18.8116 | 800 | 800 × 500 | 500 | PO02.02.0359 | 0359 | yes
13650410 | -1.PP_SO-102 | 500 | 0.15 | 1.325 | 1200 mm × 500 mm | 0 | 1200 mm × 500 mm | 0 | 1359 | 1109 | 1109 | -1.PP_SO-102 | 859 | Fáze 2 | Čerstvý | 827.324 | 705.882 | Přívod vzduchu | ODA 17 | 0.425 | 5 | ODA | 125 | 1200 | 1200 × 500 | 500 | PO02.02.0360 | 0360 | yes
13650476 | -1.PP_SO-102 | 598.157 | 0.4 | 1.55521 | 800 mm × 500 mm | 0 | 800 mm × 500 mm |  | 2595 | 2595 | 1996.84 | -1.PP_SO-102 | 1996.84 | Fáze 2 | Čerstvý | 686.665 | 615.385 | Přívod vzduchu | ODA 17 | 1.55521 | 4 | ODA | 598.157 | 800 | 800 × 500 | 500 | PO02.02.0361 | 0361 | yes
13650485 | -1.PP_SO-102 | 500 | 0.426109 | 1.33264 | 800 mm × 500 mm | 0 | 800 mm × 500 mm | 0 | 3250 | 3000 | 3000 | -1.PP_SO-102 | 2750 | Fáze 2 | Čerstvý | 686.665 | 615.385 | Přívod vzduchu | ODA 17 | 1.38485 | 4 | ODA | 532.636 | 800 | 800 × 500 | 500 | PO02.02.0362 | 0362 | yes
13650522 | -1.PP_SO-102 | 500 | 1.062 | 2.085 | 1200 mm × 500 mm | 0 | 1200 mm × 500 mm | 0 | 659 | 409 | 409 | -1.PP_SO-102 | 159 | Fáze 2 | Znehodnocený | 827.324 | 705.882 | Odváděný vzduch | EHA 7 | 3.009 | 9 | EHA | 885 | 1200 | 1200 × 500 | 500 | PO02.02.0363 | 0363 | yes
13650540 | -1.PP_SO-102 | 165.787 | 0.4 | 0.431046 | 800 mm × 500 mm | 0 | 800 mm × 500 mm |  | 2525 | 2525 | 2359.21 | -1.PP_SO-102 | 2359.21 | Fáze 2 | Znehodnocený | 686.665 | 615.385 | Odváděný vzduch | EHA 7 | 0.431046 | 8 | EHA | 165.787 | 800 | 800 × 500 | 500 | PO02.02.0364 | 0364 | yes
13650694 | -1.PP_SO-102 | 52.3702 | 0.4 | 0.136163 | 800 mm × 500 mm | 0 | 800 mm × 500 mm |  | 1349.21 | 1349.21 | 1296.84 | -1.PP_SO-102 | 1296.84 | Fáze 2 | Znehodnocený | 686.665 | 615.385 | Odváděný vzduch | EHA 7 | 0.136163 | 8 | EHA | 52.3702 | 800 | 800 × 500 | 500 | PO02.02.0365 | 0365 | yes
13650781 | -1.PP_SO-102 | 500 | 0.0835688 | 0.904461 | 800 mm × 500 mm | 0 | 800 mm × 500 mm | 0 | 3250 | 3000 | 3000 | -1.PP_SO-102 | 2750 | Fáze 2 | Čerstvý | 686.665 | 615.385 | Přívod vzduchu | ODA 17 | 0.271598 | 4 | ODA | 104.461 | 800 | 800 × 500 | 500 | PO02.02.0366 | 0366 | yes
13650905 | -1.PP_SO-102 | 500 | 0.162397 | 0.824794 | 500 mm × 500 mm | 0 | 500 mm × 500 mm | 0 | 3180 | 2930 | 2930 | -1.PP_SO-102 | 2680 | Fáze 2 | Znehodnocený | 546.583 | 500 | Odváděný vzduch | EHA 7 | 0.649588 | 7 | EHA | 324.794 | 500 | 500 × 500 | 500 | PO02.02.0367 | 0367 | yes
13650970 | -1.PP_SO-102 | 500 | 2.8346 | 5.12937 | 630 mm × 500 mm | 0 | 630 mm × 500 mm | 0 | 3180 | 2930 | 2930 | -1.PP_SO-102 | 2680 | Fáze 2 | Znehodnocený | 612.517 | 557.522 | Odváděný vzduch | EHA 7 | 10.1686 | 5 | EHA | 4499.37 | 630 | 630 × 500 | 500 | PO02.02.0368 | 0368 | yes
13651049 | -1.PP_SO-102 | 500 | 0.272 | 1.14 | 800 mm × 500 mm | 0 | 800 mm × 500 mm | 0 | 3180 | 2930 | 2930 | -1.PP_SO-102 | 2680 | Fáze 2 | Znehodnocený | 686.665 | 615.385 | Odváděný vzduch | EHA 7 | 0.884 | 6 | EHA | 340 | 800 | 800 × 500 | 500 | PO02.02.0369 | 0369 | yes
13651162 | -1.PP_SO-102 | 500 | 0.309456 | 1.1212 | 630 mm × 500 mm | 15 | 660 mm × 530 mm | 0 | 3180 | 2930 | 2930 | -1.PP_SO-102 | 2680 | Fáze 2 | Znehodnocený | 612.517 | 557.522 | Odváděný vzduch | EHA 7 | 1.11011 | 2 | EHA | 491.201 | 630 | 630 × 500 | 500 | PO02.02.0370 | 0370 | yes | Izolace - Typ izolace: Protipožární
13651195 | 2.NP_SO-102 | 15136.5 | 0.315 | 34.2086 | 500 mm × 630 mm | 0 | 500 mm × 630 mm |  | 10628.5 | 10628.5 | -4508.08 | 2.NP_SO-102 | -4508.08 | Fáze 2 | Znehodnocený | 612.517 | 557.522 | Odváděný vzduch | EHA 7 | 34.2086 | 1 | EHA | 15136.5 | 500 | 500 × 630 | 630 | PO02.02.0371 | 0371 | yes | Identifikační data - Komentáře: VZT20
13651746 | -1.PP_SO-102 | 500 | 1.0368 | 2.09599 | 800 mm × 500 mm | 0 | 800 mm × 500 mm | 0 | 3250 | 3000 | 3000 | -1.PP_SO-102 | 2750 | Fáze 2 | Čerstvý | 686.665 | 615.385 | Přívod vzduchu | ODA 17 | 3.36959 | 4 | ODA | 1295.99 | 800 | 800 × 500 | 500 | PO02.02.0375 | 0375 | yes
13651920 | -1.PP_SO-102 | 355 | 6.22554 | 6.09316 | 800 mm × 355 mm | 15 | 830 mm × 385 mm | 0 | 3107.5 | 2930 | 2930 | -1.PP_SO-102 | 2752.5 | Fáze 2 | Znehodnocený | 570.981 | 491.775 | Odváděný vzduch | EHA 7 | 17.9762 | 3 | EHA | 7781.92 | 800 | 800 × 355 | 355 | PO02.02.0377 | 0377 | yes | Izolace - Typ izolace: Protipožární
13707770 | 2.NP_SO-102 | 400 | 0.0616763 | 0.443353 | 400 mm × 400 mm | 0 | 400 mm × 400 mm | 0 | 3295 | 3095 | 3095 | 2.NP_SO-102 | 2895 | Fáze 2 | Přívodní | 437.266 | 400 | Přívod vzduchu | SUP 24 | 0.246705 | 480 | SUP | 154.191 | 400 | 400 × 400 | 400 | PO02.02.0390 | 0390 | yes | Identifikační data - Komentáře: VZT18
13806191 | -1.PP_SO-102 | 280 | 7.20163 | 6.75425 | 630 mm × 280 mm | 0 | 630 mm × 280 mm | 0 | 3140 | 3000 | 3000 | -1.PP_SO-102 | 2860 | Fáze 2 | Čerstvý | 450.033 | 387.692 | Přívod vzduchu | ODA 17 | 20.8047 | 2 | ODA | 11431.2 | 630 | 630 × 280 | 280 | PO02.02.0581 | 0581 | yes
13806200 | -1.PP_SO-102 | 280 | 0.785108 | 1.05067 | 630 mm × 280 mm | 0 | 630 mm × 280 mm | 0 | 3140 | 3000 | 3000 | -1.PP_SO-102 | 2860 | Fáze 2 | Čerstvý | 450.033 | 387.692 | Přívod vzduchu | ODA 17 | 2.26809 | 2 | ODA | 1246.2 | 630 | 630 × 280 | 280 | PO02.02.0582 | 0582 | yes
