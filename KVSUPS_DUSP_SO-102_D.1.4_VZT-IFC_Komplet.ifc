Properties of the parts of a building model (IFC4), part 16 of 45

# IfcAirTerminal: Mřížka - přívod:TRS-K, H 75, L 225-1225 (276)
Name (Mřížka - přívod:TRS-K, H 75, L 225-1225:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Délka (mm) = Délka L (mm) = Šířka potrubí (mm) | Délka mřížky (mm) | Objem (m3) | Plocha (m2) | Šířka (mm) = Šířka H (mm) = Výška potrubí (mm) | Šířka mřížky (mm) | Velikost | Kód prvku | Označení | Délka 1 (mm)
13883175 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3040 | Fáze 1 | SUP 1 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0101 | 0101 | 21.25
13883199 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3040 | Fáze 1 | SUP 1 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0102 | 0102 | 21.25
13883227 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3040 | Fáze 1 | SUP 1 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0103 | 0103 | 21.25
13883259 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3040 | Fáze 1 | SUP 1 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0104 | 0104 | 21.25
13883299 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3040 | Fáze 1 | SUP 1 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0105 | 0105 | 21.25
13883327 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3040 | Fáze 1 | SUP 1 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0106 | 0106 | 21.25
13883490 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3040 | Fáze 1 | SUP 1 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0107 | 0107 | 21.25
13883518 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3040 | Fáze 1 | SUP 1 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0108 | 0108 | 21.25
13883546 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3040 | Fáze 1 | SUP 1 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0109 | 0109 | 21.25
13883718 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3040 | Fáze 1 | SUP 1 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0110 | 0110 | 26.25
13883753 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3040 | Fáze 1 | SUP 1 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0111 | 0111 | 26.25
13883781 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3040 | Fáze 1 | SUP 1 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0112 | 0112 | 26.25
13883809 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3040 | Fáze 1 | SUP 1 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0113 | 0113 | 26.25
13883833 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3040 | Fáze 1 | SUP 1 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0114 | 0114 | 26.25
13883869 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3040 | Fáze 1 | SUP 1 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0115 | 0115 | 26.25
13885977 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3100 | Fáze 1 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0116 | 0116 | 16.25
13886002 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3100 | Fáze 1 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0117 | 0117 | 16.25
13886026 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3100 | Fáze 1 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0118 | 0118 | 16.25
13886214 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3100 | Fáze 1 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0119 | 0119 | 16.25
13886238 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3100 | Fáze 1 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0120 | 0120 | 16.25
13886262 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3100 | Fáze 1 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0121 | 0121 | 16.25
13886879 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0122 | 0122 | 26.25
13886907 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0123 | 0123 | 26.25
13886998 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0124 | 0124 | 26.25
13887108 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0125 | 0125 | 26.25
13887132 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0126 | 0126 | 26.25
13887166 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0127 | 0127 | 26.25
13887720 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0128 | 0128 | 26.25
13887746 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0129 | 0129 | 26.25
13887766 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0130 | 0130 | 26.25
13888201 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3095 | Fáze 2 | SUP 13 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0131 | 0131 | 26.25
13888229 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3095 | Fáze 2 | SUP 13 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0132 | 0132 | 26.25
13888259 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3095 | Fáze 2 | SUP 13 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0133 | 0133 | 26.25
13888340 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3095 | Fáze 2 | SUP 13 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0134 | 0134 | 21.25
13888380 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3095 | Fáze 2 | SUP 13 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0135 | 0135 | 21.25
13888404 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3095 | Fáze 2 | SUP 13 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0136 | 0136 | 21.25
13888495 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3095 | Fáze 2 | SUP 13 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0137 | 0137 | 21.25
13888582 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3095 | Fáze 2 | SUP 13 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0138 | 0138 | 21.25
13888614 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3095 | Fáze 2 | SUP 13 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0139 | 0139 | 21.25
13888790 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 24 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0140 | 0140 | 21.25
13888818 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 24 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0141 | 0141 | 21.25
13888842 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 24 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0142 | 0142 | 21.25
13888903 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 24 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0143 | 0143 | 21.25
13888923 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 24 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0144 | 0144 | 21.25
13889022 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 24 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0145 | 0145 | 21.25
13889058 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 24 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0146 | 0146 | 21.25
13889092 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 24 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0147 | 0147 | 21.25
13889124 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 24 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0148 | 0148 | 21.25
13889162 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 55 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0149 | 0149 | 21.25
13889188 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 55 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0150 | 0150 | 21.25
13889212 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 55 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0151 | 0151 | 21.25
13889302 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 57 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0152 | 0152 | 26.25
13889328 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 57 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0153 | 0153 | 26.25
13889360 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 57 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0154 | 0154 | 26.25
13889390 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 59 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0155 | 0155 | 26.25
13889414 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 59 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0156 | 0156 | 26.25
13889446 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 59 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0157 | 0157 | 26.25
13889968 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 63 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0158 | 0158 | 16.25
13889969 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 63 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0159 | 0159 | 16.25
13890081 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3080 | Fáze 1 | SUP 13 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0160 | 0160 | 21.25
13890117 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3080 | Fáze 1 | SUP 13 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0161 | 0161 | 21.25
13890141 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3080 | Fáze 1 | SUP 13 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0162 | 0162 | 21.25
13890270 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3080 | Fáze 1 | SUP 13 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0163 | 0163 | 21.25
13890290 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3080 | Fáze 1 | SUP 13 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0164 | 0164 | 21.25
13890423 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3080 | Fáze 1 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0165 | 0165 | 16.25
13890496 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3080 | Fáze 1 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0166 | 0166 | 16.25
13890703 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3080 | Fáze 1 | SUP 17 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0167 | 0167 | 21.25
13890743 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3080 | Fáze 1 | SUP 17 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0168 | 0168 | 21.25
13890817 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 17 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0169 | 0169 | 21.25
13890938 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 17 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0170 | 0170 | 21.25
13890974 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 17 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0171 | 0171 | 21.25
13891057 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 17 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0172 | 0172 | 21.25
13891085 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 17 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0173 | 0173 | 21.25
13891186 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3040 | Fáze 1 | SUP 17 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0174 | 0174 | 21.25
13891212 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3080 | Fáze 1 | SUP 17 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0175 | 0175 | 21.25
13891281 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3080.21 | Fáze 1 | SUP 17 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0176 | 0176 | 21.25
13891359 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2940 | Fáze 1 | SUP 9 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0177 | 0177 | 21.25
13891381 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2940 | Fáze 1 | SUP 9 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0178 | 0178 | 21.25
13891405 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2940 | Fáze 1 | SUP 9 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0179 | 0179 | 21.25
13891461 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2940 | Fáze 1 | SUP 9 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0180 | 0180 | 21.25
13891485 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2940 | Fáze 1 | SUP 9 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0181 | 0181 | 21.25
13891509 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2940 | Fáze 1 | SUP 9 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0182 | 0182 | 21.25
13893094 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2600 | Fáze 1 | SUP 9 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0188 | 0188 | 16.25
13893240 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2600 | Fáze 1 | SUP 9 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.04.0189 | 0189 | 11.25
13893278 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2600 | Fáze 1 | SUP 9 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.04.0190 | 0190 | 11.25
13911260 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3100 | Fáze 2 | SUP 12 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0217 | 0217 | 26.25
13911361 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3100 | Fáze 2 | SUP 12 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0218 | 0218 | 26.25
13911391 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3100 | Fáze 2 | SUP 12 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0219 | 0219 | 26.25
13911415 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3100 | Fáze 2 | SUP 12 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0220 | 0220 | 26.25
13911443 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3100 | Fáze 2 | SUP 12 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0221 | 0221 | 26.25
13913701 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2700 | Fáze 2 | SUP 12 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0225 | 0225 | 26.25
13913736 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2700 | Fáze 2 | SUP 12 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0226 | 0226 | 26.25
13913831 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3100 | Fáze 2 | SUP 12 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0227 | 0227 | 26.25
13913895 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3100 | Fáze 2 | SUP 12 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0228 | 0228 | 26.25
13913944 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3100 | Fáze 2 | SUP 12 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0229 | 0229 | 26.25
13913997 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3100 | Fáze 2 | SUP 12 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0230 | 0230 | 26.25
13914939 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3180 | Fáze 1 | SUP 17 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0233 | 0233 | 16.25
13915031 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3180 | Fáze 1 | SUP 17 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0234 | 0234 | 16.25
13915400 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2900 | Fáze 1 | SUP 17 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0235 | 0235 | 21.25
13915611 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2952.5 | Fáze 1 | SUP 9 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0236 | 0236 | 21.25
13915655 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2937.5 | Fáze 1 | SUP 9 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0237 | 0237 | 21.25
13915707 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2937.5 | Fáze 1 | SUP 9 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0238 | 0238 | 21.25
13915814 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2937.5 | Fáze 1 | SUP 9 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0239 | 0239 | 21.25
13915862 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2937.5 | Fáze 1 | SUP 9 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0240 | 0240 | 21.25
13915892 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2937.5 | Fáze 1 | SUP 9 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0241 | 0241 | 21.25
13915916 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2937.5 | Fáze 1 | SUP 9 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0242 | 0242 | 21.25
13915936 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2937.5 | Fáze 1 | SUP 9 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0243 | 0243 | 21.25
13916039 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2937.5 | Fáze 1 | SUP 9 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0244 | 0244 | 21.25
13916061 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2937.5 | Fáze 1 | SUP 9 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0245 | 0245 | 21.25
13916091 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2952.5 | Fáze 1 | SUP 9 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0246 | 0246 | 21.25
13916113 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2937.5 | Fáze 1 | SUP 9 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0247 | 0247 | 21.25
13916479 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2880 | Fáze 1 | SUP 7 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0249 | 0249 | 26.25
13916505 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2880 | Fáze 1 | SUP 7 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0250 | 0250 | 26.25
13916525 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2880 | Fáze 1 | SUP 7 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0251 | 0251 | 26.25
13916549 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2880 | Fáze 1 | SUP 7 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0252 | 0252 | 26.25
13916579 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2880 | Fáze 1 | SUP 7 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0253 | 0253 | 26.25
13924929 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3100 | Fáze 2 | SUP 12 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0266 | 0266 | 26.25
13924957 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3100 | Fáze 2 | SUP 12 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0267 | 0267 | 26.25
13924991 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0268 | 0268 | 26.25
13925021 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0269 | 0269 | 26.25
13925057 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0270 | 0270 | 26.25
13925085 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0271 | 0271 | 26.25
13925435 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 1 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0272 | 0272 | 26.25
13925516 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 1 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0273 | 0273 | 26.25
13925540 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 1 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0274 | 0274 | 26.25
13925588 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 1 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0275 | 0275 | 26.25
13925612 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 1 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0276 | 0276 | 26.25
13925663 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 1 | SUP 35 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0277 | 0277 | 26.25
13925687 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 1 | SUP 35 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0278 | 0278 | 26.25
13925723 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2895 | Fáze 1 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0279 | 0279 | 26.25
13929206 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3150 | Fáze 1 | SUP 13 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0280 | 0280 | 26.25
13929288 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3150 | Fáze 1 | SUP 13 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0281 | 0281 | 26.25
13929325 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3150 | Fáze 1 | SUP 13 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0282 | 0282 | 26.25
13929379 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | -805 | Fáze 1 | SUP 20 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0283 | 0283 | 26.25
13929422 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | -805 | Fáze 1 | SUP 20 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0284 | 0284 | 26.25
13929470 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | -805 | Fáze 1 | SUP 20 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0285 | 0285 | 26.25
13930245 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3150 | Fáze 1 | SUP 13 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0286 | 0286 | 26.25
13930269 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3150 | Fáze 1 | SUP 13 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0287 | 0287 | 26.25
13930293 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3150 | Fáze 1 | SUP 13 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0288 | 0288 | 26.25
13930337 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3200.1 | Fáze 1 | SUP 9 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0289 | 0289 | 26.25
13930361 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3200.1 | Fáze 1 | SUP 9 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0290 | 0290 | 26.25
13930393 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3200.1 | Fáze 1 | SUP 9 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0291 | 0291 | 26.25
13930417 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3200.1 | Fáze 1 | SUP 9 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0292 | 0292 | 26.25
13930449 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3200.1 | Fáze 1 | SUP 9 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0293 | 0293 | 26.25
13930473 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3200.1 | Fáze 1 | SUP 9 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0294 | 0294 | 26.25
13939635 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3180 | Fáze 1 | SUP 17 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.04.0304 | 0304 | 11.25
13939689 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3180 | Fáze 1 | SUP 17 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.04.0305 | 0305 | 11.25
13939898 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3180 | Fáze 1 | SUP 17 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.04.0306 | 0306 | 11.25
13947479 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2700 | Fáze 1 | SUP 4 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0334 | 0334 | 21.25
13947519 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2700 | Fáze 1 | SUP 4 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0335 | 0335 | 21.25
13954879 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 1 | SUP 14 | 325 | 379 | 0.00509174 | 0.127452 | 160 | 214 | 325 × 160 | VV07.04.0346 | 0346 | 16.25
13955347 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3145.16 | Fáze 1 | SUP 9 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.04.0347 | 0347 | 26.25
13955371 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3145.16 | Fáze 1 | SUP 9 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.04.0348 | 0348 | 26.25
13955842 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2880 | Fáze 1 | SUP 7 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0349 | 0349 | 26.25
13956206 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2880 | Fáze 1 | SUP 7 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0351 | 0351 | 21.25
13956453 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2700 | Fáze 1 | SUP 4 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0352 | 0352 | 21.25
13956532 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2700 | Fáze 1 | SUP 4 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0353 | 0353 | 21.25
13956623 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2700 | Fáze 1 | SUP 4 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0354 | 0354 | 21.25
13960324 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3100 | Fáze 2 | SUP 5 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.04.0358 | 0358 | 11.25
13968888 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0367 | 0367 | 26.25
13968922 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0368 | 0368 | 26.25
13968950 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0369 | 0369 | 26.25
13968982 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0370 | 0370 | 26.25
13969006 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0371 | 0371 | 26.25
13969040 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0372 | 0372 | 26.25
13969205 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3095 | Fáze 2 | SUP 22 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0373 | 0373 | 26.25
13969225 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3095 | Fáze 2 | SUP 22 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0374 | 0374 | 26.25
13969245 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3095 | Fáze 2 | SUP 22 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0375 | 0375 | 26.25
13969305 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3095 | Fáze 2 | SUP 50 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0376 | 0376 | 21.25
13969335 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3095 | Fáze 2 | SUP 50 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0377 | 0377 | 21.25
13969363 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3095 | Fáze 2 | SUP 50 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0378 | 0378 | 21.25
13969482 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3095 | Fáze 2 | SUP 45 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0379 | 0379 | 21.25
13969510 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3095 | Fáze 2 | SUP 45 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0380 | 0380 | 21.25
13969534 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3095 | Fáze 2 | SUP 45 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0381 | 0381 | 21.25
13969570 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3095 | Fáze 2 | SUP 48 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0382 | 0382 | 21.25
13969598 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3095 | Fáze 2 | SUP 48 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0383 | 0383 | 21.25
13969622 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3095 | Fáze 2 | SUP 48 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0384 | 0384 | 21.25
13975944 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3040 | Fáze 1 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0409 | 0409 | 26.25
13975968 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3040 | Fáze 1 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0410 | 0410 | 26.25
13976008 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3040 | Fáze 1 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0411 | 0411 | 26.25
13977736 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2900 | Fáze 1 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0417 | 0417 | 16.25
13977774 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2900 | Fáze 1 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0418 | 0418 | 16.25
13979528 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3095 | Fáze 2 | SUP 13 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0428 | 0428 | 26.25
13982264 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3180 | Fáze 1 | SUP 23 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0437 | 0437 | 21.25
13982296 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3180 | Fáze 1 | SUP 23 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0438 | 0438 | 21.25
13982320 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3180 | Fáze 1 | SUP 23 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0439 | 0439 | 21.25
13984908 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3099.91 | Fáze 1 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0445 | 0445 | 16.25
13984932 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3099.91 | Fáze 1 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0446 | 0446 | 16.25
13984964 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3099.91 | Fáze 1 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0447 | 0447 | 16.25
13985140 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3100 | Fáze 1 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0448 | 0448 | 16.25
13985168 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3100 | Fáze 1 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0449 | 0449 | 16.25
13985192 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3100 | Fáze 1 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0450 | 0450 | 16.25
13985492 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3100 | Fáze 2 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0451 | 0451 | 16.25
13985516 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3100 | Fáze 2 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0452 | 0452 | 16.25
13990872 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3099.91 | Fáze 1 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0458 | 0458 | 16.25
13990924 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3099.91 | Fáze 1 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0459 | 0459 | 16.25
13991475 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3100 | Fáze 1 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0462 | 0462 | 16.25
13991502 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3100 | Fáze 1 | SUP 13 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0463 | 0463 | 16.25
13993944 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3100 | Fáze 2 | SUP 12 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.04.0471 | 0471 | 11.25
13996801 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3145.16 | Fáze 1 | SUP 9 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.04.0480 | 0480 | 26.25
13996866 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3145.16 | Fáze 1 | SUP 9 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.04.0481 | 0481 | 26.25
13996910 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3145.16 | Fáze 1 | SUP 9 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.04.0482 | 0482 | 26.25
13997310 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3145.16 | Fáze 1 | SUP 9 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.04.0483 | 0483 | 26.25
13997885 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3180 | Fáze 1 | SUP 9 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.04.0484 | 0484 | 26.25
13997907 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3180 | Fáze 1 | SUP 9 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.04.0485 | 0485 | 26.25
13997933 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3180 | Fáze 1 | SUP 9 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.04.0486 | 0486 | 26.25
13997961 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3180 | Fáze 1 | SUP 9 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.04.0487 | 0487 | 26.25
14003474 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3100 | Fáze 2 | SUP 5 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.04.0499 | 0499 | 11.25
14003534 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3100 | Fáze 2 | SUP 5 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.04.0500 | 0500 | 11.25
14003738 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3137.04 | Fáze 2 | SUP 5 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.04.0501 | 0501 | 11.25
14004379 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2980 | Fáze 2 | SUP 5 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.04.0503 | 0503 | 11.25
14004785 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2980 | Fáze 2 | SUP 5 | 225 | 279 | 0.00354994 | 0.096652 | 160 | 214 | 225 × 160 | VV07.04.0504 | 0504 | 11.25
14007117 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2700 | Fáze 2 | SUP 5 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.04.0507 | 0507 | 11.25
14007848 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3077.14 | Fáze 1 | SUP 25 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0508 | 0508 | 21.25
14007963 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3077.14 | Fáze 1 | SUP 25 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0509 | 0509 | 21.25
14008100 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2952.33 | Fáze 1 | SUP 4 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0510 | 0510 | 21.25
14038367 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3145.16 | Fáze 1 | SUP 9 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.04.0526 | 0526 | 26.25
14038607 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3080 | Fáze 1 | SUP 17 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0527 | 0527 | 16.25
14038705 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3080.1 | Fáze 1 | SUP 17 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0528 | 0528 | 16.25
14039603 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 1 | SUP 14 | 225 | 279 | 0.00279646 | 0.083597 | 125 | 179 | 225 × 125 | VV07.04.0529 | 0529 | 11.25
14039676 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 1 | SUP 14 | 225 | 279 | 0.00279646 | 0.083597 | 125 | 179 | 225 × 125 | VV07.04.0530 | 0530 | 11.25
14039913 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2895 | Fáze 1 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0532 | 0532 | 26.25
14050963 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2600 | Fáze 1 | SUP 9 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0539 | 0539 | 16.25
14055008 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2400 | Fáze 2 | SUP 5 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.04.0552 | 0552 | 11.25
14055255 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3145.16 | Fáze 1 | SUP 9 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0553 | 0553 | 16.25
14055537 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3145.16 | Fáze 1 | SUP 9 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.04.0554 | 0554 | 11.25
14055833 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3200 | Fáze 1 | SUP 9 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.04.0556 | 0556 | 11.25
14057820 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3200 | Fáze 1 | SUP 9 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.04.0561 | 0561 | 11.25
14058068 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 1 | SUP 24 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.04.0562 | 0562 | 11.25
14059327 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2430 | Fáze 1 | SUP 24 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0565 | 0565 | 16.25
14059356 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2430 | Fáze 1 | SUP 24 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0566 | 0566 | 16.25
14064335 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 1 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0571 | 0571 | 26.25
14064385 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 1 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0572 | 0572 | 26.25
14064553 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 1 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0573 | 0573 | 26.25
14064968 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0574 | 0574 | 26.25
14065014 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.04.0575 | 0575 | 26.25
14078827 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 1 | SUP 24 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.04.0582 | 0582 | 11.25
14136380 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3250 | Fáze 2 | SUP 5 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.04.0591 | 0591 | 11.25
14138416 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2590 | Fáze 1 | SUP 24 | 825 | 879 | 0.00617686 | 0.198747 | 75 | 129 | 825 × 75 | VV07.04.0594 | 0594 | 41.25
14152733 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2900 | Fáze 1 | SUP 17 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0600 | 0600 | 21.25

# IfcAirTerminal: Mřížka - přívod:TRS-K, H 75, L 225-1225 (17)
Type - Material: 0-128-64
Type - Požární ochrana - Požární odolnost: A1
Type - Mechanické – tok - Max. průtok: 0.008 m3/s; Min. průtok: 0.0015 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Tloušťka panelu: 7 mm; Výška: 27 mm
Type - Identifikační data - Kód sestavy: VV07; Model: TRS - K; Název typu: TRS-K, H 75, L 225-1225; Označení typu: 04; Popis sestavy: Mřížka; Výrobce: TROX
Type - Jiné - Kategorie: Vyústky vzduchotechniky; Název rodiny: Mřížka - přívod
Classification: VV07 Uniformat (Uniformat)
Mechanické – tok - Proudění vzduchu: 0 m3/s; Průtok: 0 m3/s; Tlakový spád: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: NAC; CCI Technický systém: HF
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Zkratka systému: ODA
Kóty - Průměr vedení: 250 mm; Výška mřížky T: 94 mm
Jiné - Typ: TRS-K, H 75, L 225-1225; Id typu: 13433494; Rodina: Mřížka - přívod; Rodina a typ: Mřížka - přívod: TRS-K, H 75, L 225-1225
Name (Mřížka - přívod:TRS-K, H 75, L 225-1225:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Délka (mm) = Délka L (mm) = Šířka potrubí (mm) | Délka mřížky (mm) | Objem (m3) | Plocha (m2) | Šířka (mm) = Šířka H (mm) = Výška potrubí (mm) | Šířka mřížky (mm) | Velikost | Kód prvku | Označení | Délka 1 (mm)
13808837 | -2.PP_SO-102 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 2550 | Fáze 1 | ODA 12 | 400 | 454 | 0.0191606 | 0.336872 | 500 | 554 | 400 × 500 | VV07.04.0029 | 0029 | 20
13819069 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3096.2 | Fáze 1 | ODA 25 | 500 | 554 | 0.0191606 | 0.336872 | 400 | 454 | 500 × 400 | VV07.04.0030 | 0030 | 25 | Fázování - Bouráno ve FÁZI 2: yes
13819164 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2990.01 | Fáze 1 | ODA 25 | 500 | 554 | 0.0191606 | 0.336872 | 400 | 454 | 500 × 400 | VV07.04.0031 | 0031 | 25 | Fázování - Bouráno ve FÁZI 2: yes
13819339 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3196.2 | Fáze 1 | ODA 25 | 500 | 554 | 0.0191606 | 0.336872 | 400 | 454 | 500 × 400 | VV07.04.0032 | 0032 | 25 | Fázování - Bouráno ve FÁZI 2: yes
13819539 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3096.2 | Fáze 1 | ODA 25 | 450 | 504 | 0.0172617 | 0.309472 | 400 | 454 | 450 × 400 | VV07.04.0033 | 0033 | 22.5 | Fázování - Bouráno ve FÁZI 2: yes
13910357 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3100 | Fáze 2 | ODA 21 | 575 | 629 | 0.0233697 | 0.396047 | 425 | 479 | 575 × 425 | VV07.04.0213 | 0213 | 28.75
13910899 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3095 | Fáze 2 | ODA 21 | 575 | 629 | 0.0233697 | 0.396047 | 425 | 479 | 575 × 425 | VV07.04.0214 | 0214 | 28.75
13910933 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2775 | Fáze 2 | ODA 21 | 575 | 629 | 0.0233697 | 0.396047 | 425 | 479 | 575 × 425 | VV07.04.0215 | 0215 | 28.75
13910969 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3120 | Fáze 2 | ODA 21 | 575 | 629 | 0.0233697 | 0.396047 | 425 | 479 | 575 × 425 | VV07.04.0216 | 0216 | 28.75
13918458 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3120 | Fáze 2 | ODA 21 | 575 | 629 | 0.0233697 | 0.396047 | 425 | 479 | 575 × 425 | VV07.04.0254 | 0254 | 28.75
13922170 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2800 | Fáze 1 | ODA 12 | 630 | 684 | 0.016946 | 0.314752 | 280 | 334 | 630 × 280 | VV07.04.0255 | 0255 | 31.5
13922246 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3096.2 | Fáze 1 | ODA 12 | 630 | 684 | 0.016946 | 0.314752 | 280 | 334 | 630 × 280 | VV07.04.0256 | 0256 | 31.5
13922371 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3096.2 | Fáze 1 | ODA 18 | 500 | 554 | 0.0134753 | 0.259112 | 280 | 334 | 500 × 280 | VV07.04.0257 | 0257 | 25
13922567 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3096.2 | Fáze 1 | ODA 12 | 450 | 504 | 0.0121404 | 0.237712 | 280 | 334 | 450 × 280 | VV07.04.0258 | 0258 | 22.5
13923230 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 1287.9 | Fáze 1 | ODA 13 | 525 | 579 | 0.0114077 | 0.232797 | 225 | 279 | 525 × 225 | VV07.04.0259 | 0259 | 26.25
13923491 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | -2656.49 | Fáze 1 | ODA 13 | 525 | 579 | 0.0114077 | 0.232797 | 225 | 279 | 525 × 225 | VV07.04.0260 | 0260 | 26.25
14067857 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2600 | Fáze 1 | ODA 12 | 450 | 504 | 0.0172617 | 0.309472 | 400 | 454 | 450 × 400 | VV07.04.0578 | 0578 | 22.5

# IfcAirTerminal: Protidešťová žaluzie_Hranatá_Sání.CC:Protidešťová žaluzie_Hranatá_Sání.CC (13)
Type - Material: Protidešťová žuzie
Type - Požární ochrana - Požární odolnost: A1
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Pohon_Servo: yes
Type - Kóty - Délka: 50 mm; TLOUŠŤKA: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.30.60.11.17.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VV08; Nadpis OmniClass: Fixed Exterior Louvers and Grilles; Název typu: Protidešťová žaluzie_Hranatá_Sání.CC; Označení typu: 02; Popis: Protidešťová žaluzie; Popis sestavy: Žaluzie; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Vyústky vzduchotechniky; Název rodiny: Protidešťová žaluzie_Hranatá_Sání.CC; Pohon_Ruční: no
Classification: VV08 Uniformat (Uniformat)
Mechanické – tok - Poměr průtoku: 1; Průtok: 0 m3/s; TLAKOVÝ SPÁD: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: NAC; CCI Technický systém: HF
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Zkratka systému: ODA
Jiné - Id typu: 13758609; Rodina: Protidešťová žaluzie_Hranatá_Sání.CC; Rodina a typ: Protidešťová žaluzie_Hranatá_Sání.CC: Protidešťová žaluzie_Hranatá_Sání.CC; Typ: Protidešťová žaluzie_Hranatá_Sání.CC
Name (Protidešťová žaluzie_Hranatá_Sání.CC:Protidešťová žaluzie_Hranatá_Sání.CC:...) | In | Perimeter (mm) | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Objem (m3) | Plocha (m2) | ŠÍŘKA (mm) | Velikost | VÝŠKA (mm) | Kód prvku | Označení | C
13758660 | -1.PP_SO-102 | 3100 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2400 | Fáze 1 | ODA 8 | 0.05325 | 1.1755 | 1500 | 1500 × 710 | 710 | VV08.02.0013 | 0013 | 6
13795424 | -1.PP_SO-102 | 900 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3078 | Fáze 1 | ODA 1 | 0.008 | 0.2 | 400 | 400 × 400 | 400 | VV08.02.0016 | 0016 | 4
13795436 | -1.PP_SO-102 | 900 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3100 | Fáze 1 | ODA 2 | 0.008 | 0.2 | 400 | 400 × 400 | 400 | VV08.02.0017 | 0017 | 4
13796900 | 1.NP_SO-102 | 600 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3092.8 | Fáze 1 | ODA 19 | 0.003125 | 0.0875 | 250 | 250 × 250 | 250 | VV08.02.0020 | 0020 | 3
13801965 | 4.NP_SO-102 | 1520 | STŘECHA_SO-102 | Podlaží : STŘECHA_SO-102 | 1475.5 | Fáze 2 | ODA 21 | 0.022365 | 0.5143 | 710 | 710 × 630 | 630 | VV08.02.0022 | 0022 | 5
13802304 | 4.NP_SO-102 | 1520 | STŘECHA_SO-102 | Podlaží : STŘECHA_SO-102 | 1000 | Fáze 1 | ODA 4 | 0.022365 | 0.5143 | 710 | 710 × 630 | 630 | VV08.02.0023 | 0023 | 5
13806293 | -1.PP_SO-102 | 1700 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3000 | Fáze 2 | ODA 17 | 0.02 | 0.465 | 800 | 800 × 500 | 500 | VV08.02.0025 | 0025 | 4
14003230 | 4.NP_SO-102 | 1520 | STŘECHA_SO-102 | Podlaží : STŘECHA_SO-102 | 1240 | Fáze 1 | ODA 25 | 0.022365 | 0.5143 | 710 | 710 × 630 | 630 | VV08.02.0498 | 0498 | 5 | Fázování - Bouráno ve FÁZI 2: yes
14008499 | 3.NP_SO-102 | 1900 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3500 | Fáze 1 | ODA 3 | 0.02025 | 0.4725 | 900 | 900 × 450 | 450 | VV08.02.0511 | 0511 | 4
14009810 | 3.NP_SO-102 | 1220 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3500 | Fáze 1 | ODA 7 | 0.00882 | 0.22015 | 560 | 560 × 315 | 315 | VV08.02.0516 | 0516 | 3
14010077 | 3.NP_SO-102 | 3300 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3500 | Fáze 1 | ODA 6 | 0.032 | 0.74 | 1600 | 1600 × 400 | 400 | VV08.02.0517 | 0517 | 4
14010319 | 3.NP_SO-102 | 2100 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3500 | Fáze 1 | ODA 14 | 0.02 | 0.47 | 1000 | 1000 × 400 | 400 | VV08.02.0518 | 0518 | 4
14157737 | 4.NP_SO-102 | 2340 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 5650 | Fáze 1 | ODA 12 | 0.03528 | 0.7931 | 1120 | 1120 × 630 | 630 | VV08.02.0601 | 0601 | 5

# IfcAirTerminal: Protidešťová žaluzie_Hranatá_Výfuk.CC:Protidešťová žaluzie_Hranatá_Výfuk.CC (11)
Type - Material: Protidešťová žuzie
Type - Požární ochrana - Požární odolnost: A1
Type - Vazby - Výchozí výška: 0 mm
Type - Grafika - Pohon_Servo: yes
Type - Kóty - Délka: 50 mm; TLOUŠŤKA: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.30.60.11.17.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VV08; Nadpis OmniClass: Fixed Exterior Louvers and Grilles; Název typu: Protidešťová žaluzie_Hranatá_Výfuk.CC; Označení typu: 03; Popis: Protidešťová žaluzie; Popis sestavy: Žaluzie; URL: www.cadconsulting.cz
Type - Jiné - Kategorie: Vyústky vzduchotechniky; Pohon_Ruční: no; Název rodiny: Protidešťová žaluzie_Hranatá_Výfuk.CC
Classification: VV08 Uniformat (Uniformat)
Mechanické – tok - Poměr průtoku: 1; Průtok: 0 m3/s; TLAKOVÝ SPÁD: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: NAC; CCI Technický systém: HF
Mechanické - Klasifikace systému: Odváděný vzduch
Jiné - Id typu: 13796570; Rodina: Protidešťová žaluzie_Hranatá_Výfuk.CC; Rodina a typ: Protidešťová žaluzie_Hranatá_Výfuk.CC: Protidešťová žaluzie_Hranatá_Výfuk.CC; Typ: Protidešťová žaluzie_Hranatá_Výfuk.CC
Name (Protidešťová žaluzie_Hranatá_Výfuk.CC:Protidešťová žaluzie_Hranatá_Výfuk.CC:...) | In | Perimeter (mm) | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Fáze vytvoření | Objem (m3) | Plocha (m2) | ŠÍŘKA (mm) | Velikost | VÝŠKA (mm) | Kód prvku | Označení | C | Typ systému | Název systému = Group | Zkratka systému
13796787 | 1.NP_SO-102 | 900 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3723 | Fáze 1 | 0.008 | 0.2 | 400 | 400 × 400 | 400 | VV08.03.0018 | 0018 | 4
13796834 | 1.NP_SO-102 | 900 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3723 | Fáze 1 | 0.008 | 0.2 | 400 | 400 × 400 | 400 | VV08.03.0019 | 0019 | 4
13797065 | 2.NP_SO-102 | 600 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3678 | Fáze 1 | 0.003125 | 0.0875 | 250 | 250 × 250 | 250 | VV08.03.0021 | 0021 | 3 | Znehodnocený | EHA 12 | EHA
13802881 | 4.NP_SO-102 | 3300 | STŘECHA_SO-102 | Podlaží : STŘECHA_SO-102 | 820 | Fáze 1 | 0.04 | 0.905 | 1600 | 1600 × 500 | 500 | VV08.03.0024 | 0024 | 4 | Znehodnocený | EHA 1 | EHA
13902674 | 4.NP_SO-102 | 1520 | STŘECHA_SO-102 | Podlaží : STŘECHA_SO-102 | 1050 | Fáze 1 | 0.022365 | 0.5143 | 710 | 710 × 630 | 630 | VV08.03.0199 | 0199 | 5 | Znehodnocený | EHA 3 | EHA
13902891 | 4.NP_SO-102 | 900 | STŘECHA_SO-102 | Podlaží : STŘECHA_SO-102 | 967 | Fáze 1 | 0.005 | 0.1325 | 400 | 400 × 250 | 250 | VV08.03.0200 | 0200 | 3 | Odváděný | ETA 8 | ETA
13985640 | 4.NP_SO-102 | 1360 | STŘECHA_SO-102 | Podlaží : STŘECHA_SO-102 | 690 | Fáze 2 | 0.01575 | 0.3715 | 630 | 630 × 500 | 500 | VV08.03.0454 | 0454 | 4 | Znehodnocený | EHA 7 | EHA
14008926 | 2.NP_SO-102 | 2340 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2759 | Fáze 1 | 0.03528 | 0.7931 | 1120 | 1120 × 630 | 630 | VV08.03.0512 | 0512 | 5 | Znehodnocený | EHA 10 | EHA
14009012 | 2.NP_SO-102 | 1220 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2700 | Fáze 1 | 0.00882 | 0.22015 | 560 | 560 × 315 | 315 | VV08.03.0513 | 0513 | 3 | Znehodnocený | EHA 5 | EHA
14009229 | 2.NP_SO-102 | 3300 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2650 | Fáze 1 | 0.04 | 0.905 | 1600 | 1600 × 500 | 500 | VV08.03.0514 | 0514 | 4 | Znehodnocený | EHA 8 | EHA
14009700 | 2.NP_SO-102 | 3300 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2650 | Fáze 1 | 0.04 | 0.905 | 1600 | 1600 × 500 | 500 | VV08.03.0515 | 0515 | 4 | Znehodnocený | EHA 13 | EHA

# IfcBuildingElementProxy: 18_1_VZT_Ucebny_sever:18_1_VZT_Ucebny_sever, 18_1_VZT_Ucebny_sever:18_1_VZT_Ucebny_sever:13786471
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Weight: 3267 kg
Type - Grafika - magiFamilyGeom: MagiCAD_Geniox 24 1-4 NP uèebny sever/1-4 NP uèebny sever
Type - Kóty - Délka: 5664 mm; MC Height: 2700 mm; MC Length: 5664 mm; MC Width: 2482 mm; Šířka: 2482 mm; Výška: 2600 mm
Type - Identifikační data - Kód sestavy: JV01; magiPartTypeId: 210; magiProductCode: Geniox 24 1-4 NP uèebny sever/1-4 NP uèebny sever; magiProductId: Geniox 24 1-4 NP uèebny sever/1-4 NP uèebny sever; Model: Geniox 24 : 1-4 NP uèebny sever/1-4 NP uèebny sever; Název typu: 18_1_VZT_Ucebny_sever; Označení typu: 08; Popis sestavy: Samostatná; VersionID: 1.0/2023.1
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: 18_1_VZT_Ucebny_sever
Classification: JV01 Uniformat (Uniformat); Group: SUP 24; EHA 11; ODA 8
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 174.496 m2; NetVolume: 35.7691 m3
Mechanické – tok - Exhaust 1 Airflow max ls: 8 m3/s; Exhaust 1 Airflow min ls: 1.9 m3/s; Exhaust 1 Airflow operation point max ls: 4.2 m3/s; Exhaust 1 Airflow operation point min ls: 3.8 m3/s; Exhaust 1 Flow: 4 m3/s; Exhaust 1 Pressure drop: 0 Pa; Extract 1 Airflow max ls: 8 m3/s; Extract 1 Airflow min ls: 1.9 m3/s; Extract 1 Airflow operation point max ls: 4.2 m3/s; Extract 1 Airflow operation point min ls: 3.8 m3/s; Extract 1 Flow: 4 m3/s; Extract 1 Pressure drop: 0 Pa; Outdoor 1 Airflow max ls: 8 m3/s; Outdoor 1 Airflow min ls: 1.9 m3/s; Outdoor 1 Airflow operation point max ls: 4.2 m3/s; Outdoor 1 Airflow operation point min ls: 3.8 m3/s; Outdoor 1 Flow: 4 m3/s; Outdoor 1 Pressure drop: 0 Pa; Pressure rise, extract: 300 Pa; Pressure rise, supply: 300 Pa; Průtok vzduchu čerstvý: 4 m3/s; Průtok vzduchu odváděný: 4 m3/s; Průtok vzduchu přívodní: 4 m3/s; Průtok vzduchu znehodnocený: 4 m3/s; Supply 1 Airflow max ls: 8 m3/s; Supply 1 Airflow min ls: 1.9 m3/s; Supply 1 Airflow operation point max ls: 4.2 m3/s; Supply 1 Airflow operation point min ls: 3.8 m3/s; Supply 1 Flow: 4 m3/s; Supply 1 Pressure drop: 300 Pa
Text - CCI Funkční systém: J; CCI Komponenta: GQB; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Hostitel: Podlaží : -1.PP_SO-102; Odsazení od hostitele: -1280 mm; Výška od podlaží: -1280 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Exhaust 1 Sound generation: 78 86 76 77 73 69 65 60 dB; Extract 1 Sound generation: 71 75 67 59 53 47 39 33 dB; Fan efficiency, extract: 70.0 %; Fan efficiency, supply: 68.5 %; Fan speed, extract: 1244 RPM; Fan speed, supply: 1318 RPM; Heat recovery: 85.7 %; Klasifikace systému: Přívod vzduchu,Zpětný vzduch,Odváděný vzduch; Název systému: SUP 24,ODA 8,EHA 11; Outdoor 1 Sound generation: 70 78 69 61 56 50 41 35 dB; SFPe, dimensional filters excluding frequency converter: 1.76 kW/(m3/s); SFPe, výp. tlak. ztráta filtrù, s FM: 1.85 kW/(m3/s); SFPv, clean filters excluding frequency converter: 1.66 kW/(m3/s); SFPv, clean filters including frequency converter: 1.75 kW/(m3/s); Sound power level, extract: 64 dB(A); Sound power level, supply: 77 dB(A); Supply 1 Sound generation: 77 87 74 76 70 64 59 51 dB
Kóty - Objem: 35.7691 m3; Plocha: 87.2591 m2
Identifikační data - Kód prvku: JV01.08.0008; Komentáře: VZT č.18 VZT jednotka horizontální Vp/Vo=14400 m3/h dp=300 Pa ZZT-deskový P=14,0 kW; Označení: 0008; Productdata: © MagiCAD Group, all rights reserved
Jiné - Páteřní trasa: yes; Id typu: 13786432; Rodina: 18_1_VZT_Ucebny_sever; Rodina a typ: 18_1_VZT_Ucebny_sever: 18_1_VZT_Ucebny_sever; Typ: 18_1_VZT_Ucebny_sever

# IfcBuildingElementProxy: 19_1_VZT_Ucebny jih:19_1_VZT_Ucebny jih, 19_1_VZT_Ucebny jih:19_1_VZT_Ucebny jih:13862870
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Weight: 2147 kg
Type - Grafika - magiFamilyGeom: MagiCAD_Geniox 20 1-4NP uèebny jih/1-4NP uèebny jih
Type - Kóty - Délka: 4664 mm; MC Height: 2300 mm; MC Length: 4964 mm; MC Width: 2082 mm; Šířka: 2200 mm; Výška: 2082 mm
Type - Identifikační data - Kód sestavy: JV01; magiPartTypeId: 210; Název typu: 19_1_VZT_Ucebny jih; Označení typu: 10; Popis sestavy: Samostatná; VersionID: 1.0/2023.1
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: 19_1_VZT_Ucebny jih
Classification: JV01 Uniformat (Uniformat); Group: SUP 13; EHA 13; ETA 91
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 104.517 m2; NetVolume: 22.8192 m3
Mechanické – tok - Exhaust 1 Airflow max ls: 5.5 m3/s; Exhaust 1 Airflow min ls: 1.3 m3/s; Exhaust 1 Airflow operation point max ls: 2.771 m3/s; Exhaust 1 Airflow operation point min ls: 2.507 m3/s; Exhaust 1 Flow: 2.639 m3/s; Exhaust 1 Pressure drop: 0 Pa; Extract 1 Airflow max ls: 5.5 m3/s; Extract 1 Airflow min ls: 1.3 m3/s; Extract 1 Airflow operation point max ls: 2.771 m3/s; Extract 1 Airflow operation point min ls: 2.507 m3/s; Extract 1 Flow: 2.639 m3/s; Extract 1 Pressure drop: 0 Pa; Outdoor 1 Airflow max ls: 5.5 m3/s; Outdoor 1 Airflow min ls: 1.3 m3/s; Outdoor 1 Airflow operation point max ls: 2.771 m3/s; Outdoor 1 Airflow operation point min ls: 2.507 m3/s; Outdoor 1 Flow: 2.639 m3/s; Outdoor 1 Pressure drop: 0 Pa; Pressure rise, extract: 300 Pa; Pressure rise, supply: 300 Pa; Průtok vzduchu čerstvý: 2.94444 m3/s; Průtok vzduchu odváděný: 2.94444 m3/s; Průtok vzduchu přívodní: 2.94444 m3/s; Průtok vzduchu znehodnocený: 2.94444 m3/s; Supply 1 Airflow max ls: 5.5 m3/s; Supply 1 Airflow min ls: 1.3 m3/s; Supply 1 Airflow operation point max ls: 2.771 m3/s; Supply 1 Airflow operation point min ls: 2.507 m3/s; Supply 1 Flow: 2.639 m3/s; Supply 1 Pressure drop: 300 Pa
Text - CCI Funkční systém: J; CCI Komponenta: GQB; CCI Technický systém: HF
Vazby - Odsazení od hostitele: 0 mm; Podlaží: 2.NP_SO-102; Výška od podlaží: 0 mm; Hostitel: Podlaží : 2.NP_SO-102
