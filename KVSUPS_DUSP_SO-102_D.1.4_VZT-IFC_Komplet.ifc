Properties of the parts of a building model (IFC4), part 43 of 45

# IfcDuctSegment: Kulaté potrubí:SPIRO POZINK/T spoj (978)
Name (Kulaté potrubí:SPIRO POZINK/T spoj:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Volná velikost | Celková velikost | Tloušťka izolace (mm) | Dynamický tlak (Pa) | Průtok (m3/s) | Reynoldsovo číslo | Rychlost (m/s) | Tlaková ztráta (Pa) | Tření (kg/m2/s2) | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Sklon | Spodní výška (mm) | Fáze vytvoření | Ekvivaletní průměr (mm) = Hydraulický průměr (mm) = Průměr (mm) = Velikost | Klasifikace systému | Koeficient ztrát | Název systému | Řez | Typ systému | Zkratka systému | Kód prvku | Označení | Páteřní trasa | Group
13867463 | 4.NP_SO-102 | 2380 | 0.0989649 | 2.65433 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2917.5 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 13 | 64 | Přívodní | SUP | PO02.01.0807 | 0807 | yes | SUP 13 | Identifikační data - Komentáře: ZASLEPENÁ ODBOČKA PŘÍPRAVA PRO NAPOJENÍ MÍSTNOSTÍ VE II.ETAPĚ VÝSTAVBY
13867502 | 4.NP_SO-102 | 591.675 | 0.0397548 | 0.41823 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 149 | Přívodní | SUP | PO02.01.0808 | 0808 | no | SUP 13
13867542 | 4.NP_SO-102 | 6221.36 | 0.04908 | 4.88624 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3220 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2970 | Fáze 2 | 250 | Přívod vzduchu | 0 | SUP 18 | 177 | Přívodní | SUP | PO02.01.0809 | 0809 | no | SUP 18
13867564 | 4.NP_SO-102 | 6151.53 | 0.0397548 | 4.34826 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 185 | Přívodní | SUP | PO02.01.0810 | 0810 | no | SUP 13
13867714 | 4.NP_SO-102 | 1073.66 | 0.0201032 | 0.539682 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 4.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 24 | 237 | Přívodní | SUP | PO02.01.0811 | 0811 | yes | SUP 24
13867753 | 4.NP_SO-102 | 709.37 | 0.0201032 | 0.356568 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 4.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 24 | 237 | Přívodní | SUP | PO02.01.0812 | 0812 | no | SUP 24
13867915 | 4.NP_SO-102 | 614.192 | 0.0397548 | 0.434147 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 24 | 186 | Přívodní | SUP | PO02.01.0813 | 0813 | no | SUP 24
13868042 | 4.NP_SO-102 | 337.242 | 0.0397548 | 0.238383 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 24 | 186 | Přívodní | SUP | PO02.01.0814 | 0814 | yes | SUP 24
13868092 | 4.NP_SO-102 | 116.956 | 0.0201032 | 0.0587883 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 4.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 24 | 241 | Přívodní | SUP | PO02.01.0815 | 0815 | no | SUP 24
13868192 | 4.NP_SO-102 | 10379 | 0.0314112 | 6.52131 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3195 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2995 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 24 | 533 | Přívodní | SUP | PO02.01.0816 | 0816 | yes | SUP 24
13868349 | 4.NP_SO-102 | 646.422 | 0.0314112 | 0.406159 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3195 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2995 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 24 | 534 | Přívodní | SUP | PO02.01.0817 | 0817 | no | SUP 24
13868421 | 4.NP_SO-102 | 306.566 | 0.0397548 | 0.216699 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 24 | 84 | Přívodní | SUP | PO02.01.0818 | 0818 | no | SUP 24
13868529 | 4.NP_SO-102 | 130.076 | 0.0397548 | 0.0919456 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 21 | 151 | Přívodní | SUP | PO02.01.0819 | 0819 | no | SUP 21
13868663 | 4.NP_SO-102 | 7100 | 0.0397548 | 5.01869 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 39 | 154 | Přívodní | SUP | PO02.01.0820 | 0820 | no | SUP 39
13868710 | 4.NP_SO-102 | 191.632 | 0.0397548 | 0.135457 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 24 | 538 | Přívodní | SUP | PO02.01.0821 | 0821 | no | SUP 24
13868725 | 4.NP_SO-102 | 2798.04 | 0.061566 | 2.46129 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2955 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 24 | 531 | Přívodní | SUP | PO02.01.0822 | 0822 | yes | SUP 24
13868789 | 4.NP_SO-102 | 830.432 | 0.0397548 | 0.586998 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 39 | 154 | Přívodní | SUP | PO02.01.0823 | 0823 | no | SUP 39
13868889 | 4.NP_SO-102 | 7109.17 | 0.0397548 | 5.02518 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 24 | 542 | Přívodní | SUP | PO02.01.0824 | 0824 | no | SUP 24
13868917 | 4.NP_SO-102 | 865.066 | 0.0397548 | 0.611479 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 24 | 542 | Přívodní | SUP | PO02.01.0825 | 0825 | no | SUP 24
13869130 | 4.NP_SO-102 | 70.3883 | 0.0397548 | 0.0497546 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 247 | Přívodní | SUP | PO02.01.0826 | 0826 | no | SUP 13
13869145 | 4.NP_SO-102 | 8191.88 | 0.0989649 | 9.13612 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2917.5 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 13 | 150 | Přívodní | SUP | PO02.01.0827 | 0827 | yes | SUP 13
13869298 | 4.NP_SO-102 | 3705.44 | 0.0254431 | 2.09538 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3270 | 3180 | 3180 | 4.NP_SO-102 | 0 | 3090 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 13 | 251 | Přívodní | SUP | PO02.01.0828 | 0828 | no | SUP 13
13869352 | 4.NP_SO-102 | 738.067 | 0.0254431 | 0.417367 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3270 | 3180 | 3180 | 4.NP_SO-102 | 0 | 3090 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 40 | 163 | Přívodní | SUP | PO02.01.0829 | 0829 | no | SUP 40
13870815 | 3.NP_SO-102 | 51.0831 | 0.0397548 | 0.0361085 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 13 | 81 | Přívodní | SUP | PO02.01.0830 | 0830 | no | SUP 13
13870855 | 3.NP_SO-102 | 47.2082 | 0.0397548 | 0.0333695 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 13 | 129 | Přívodní | SUP | PO02.01.0831 | 0831 | no | SUP 13
13871010 | 3.NP_SO-102 | 299.445 | 0.04908 | 0.235183 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3220 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2970 | Fáze 2 | 250 | Přívod vzduchu | 0 | SUP 13 | 123 | Přívodní | SUP | PO02.01.0832 | 0832 | no | SUP 13
13871080 | 3.NP_SO-102 | 530.734 | 0.0201032 | 0.266776 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 3.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 13 | 141 | Přívodní | SUP | PO02.01.0833 | 0833 | no | SUP 13
13871108 | 3.NP_SO-102 | 10225 | 0.04908 | 8.03067 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3220 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2970 | Fáze 2 | 250 | Přívod vzduchu | 0 | SUP 13 | 100 | Přívodní | SUP | PO02.01.0834 | 0834 | yes | SUP 13
13871207 | 3.NP_SO-102 | 929.505 | 0.04908 | 0.730032 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3220 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2970 | Fáze 2 | 250 | Přívod vzduchu | 0 | SUP 13 | 123 | Přívodní | SUP | PO02.01.0835 | 0835 | yes | SUP 13
13871300 | 3.NP_SO-102 | 1020 | 0.0201032 | 0.512708 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 3.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 13 | 141 | Přívodní | SUP | PO02.01.0836 | 0836 | no | SUP 13
13871372 | 3.NP_SO-102 | 268.476 | 0.0201032 | 0.134951 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 3.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 13 | 141 | Přívodní | SUP | PO02.01.0837 | 0837 | no | SUP 13
13871404 | 3.NP_SO-102 | 7109.27 | 0.0201032 | 3.57351 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 3.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 13 | 141 | Přívodní | SUP | PO02.01.0838 | 0838 | no | SUP 13
13871479 | 3.NP_SO-102 | 331.064 | 0.0397548 | 0.234016 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 13 | 115 | Přívodní | SUP | PO02.01.0839 | 0839 | no | SUP 13
13871488 | 3.NP_SO-102 | 252.374 | 0.0397548 | 0.178393 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 13 | 115 | Přívodní | SUP | PO02.01.0840 | 0840 | no | SUP 13
13871586 | 3.NP_SO-102 | 558.58 | 0.0397548 | 0.394837 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 13 | 135 | Přívodní | SUP | PO02.01.0841 | 0841 | no | SUP 13
13871792 | 3.NP_SO-102 | 48.6213 | 0.0397548 | 0.0343684 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 13 | 135 | Přívodní | SUP | PO02.01.0842 | 0842 | no | SUP 13
13874826 | 2.NP_SO-102 | 79.0055 | 0.0201032 | 0.0397125 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3160 | 3080 | 3080 | 2.NP_SO-102 | 0 | 3000 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 13 | 220 | Přívodní | SUP | PO02.01.0844 | 0844 | no | SUP 13
13874840 | 2.NP_SO-102 | 6846.72 | 0.159008 | 9.67933 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3305 | 3080 | 3080 | 2.NP_SO-102 | 0 | 2855 | Fáze 1 | 450 | Přívod vzduchu | 0 | SUP 13 | 168 | Přívodní | SUP | PO02.01.0845 | 0845 | yes | SUP 13
13874848 | 2.NP_SO-102 | 4340 | 0.0201032 | 2.18152 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3160 | 3080 | 3080 | 2.NP_SO-102 | 0 | 3000 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 13 | 220 | Přívodní | SUP | PO02.01.0846 | 0846 | no | SUP 13
13875085 | 2.NP_SO-102 | 718.767 | 0.0397548 | 0.508066 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 50 | 153 | Přívodní | SUP | PO02.01.0847 | 0847 | no | SUP 50
13875226 | 2.NP_SO-102 | 200.271 | 0.0397548 | 0.141563 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 45 | 149 | Přívodní | SUP | PO02.01.0848 | 0848 | no | SUP 45
13875284 | 2.NP_SO-102 | 56.2666 | 0.0397548 | 0.0397725 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 48 | 151 | Přívodní | SUP | PO02.01.0849 | 0849 | no | SUP 48
13875400 | 2.NP_SO-102 | 701.262 | 0.061566 | 0.616862 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 88 | Přívodní | SUP | PO02.01.0850 | 0850 | no | SUP 24
13875424 | 2.NP_SO-102 | 6800 | 0.061566 | 5.98159 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 107 | Přívodní | SUP | PO02.01.0851 | 0851 | no | SUP 24
13875623 | 2.NP_SO-102 | 778.089 | 0.061566 | 0.684443 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 22 | 97 | Přívodní | SUP | PO02.01.0852 | 0852 | no | SUP 22
13875796 | 2.NP_SO-102 | 800.013 | 0.061566 | 0.703728 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 88 | Přívodní | SUP | PO02.01.0853 | 0853 | yes | SUP 24
13875844 | 2.NP_SO-102 | 454.622 | 0.061566 | 0.399906 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 89 | Přívodní | SUP | PO02.01.0854 | 0854 | no | SUP 24
13875898 | 2.NP_SO-102 | 3449.46 | 0.061566 | 3.0343 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 82 | Přívodní | SUP | PO02.01.0855 | 0855 | yes | SUP 24
13876026 | 2.NP_SO-102 | 4170.99 | 0.0397548 | 2.9483 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 13 | 332 | Přívodní | SUP | PO02.01.0856 | 0856 | yes | SUP 13
13876106 | 2.NP_SO-102 | 198.151 | 0.0397548 | 0.140065 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 13 | 300 | Přívodní | SUP | PO02.01.0857 | 0857 | no | SUP 13
13876166 | 2.NP_SO-102 | 225.449 | 0.0397548 | 0.15936 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 13 | 302 | Přívodní | SUP | PO02.01.0858 | 0858 | no | SUP 13
13876423 | 2.NP_SO-102 | 863.319 | 0.04908 | 0.67805 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3165 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2915 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 24 | 549 | Přívodní | SUP | PO02.01.0859 | 0859 | no | SUP 24
13876536 | 2.NP_SO-102 | 662.645 | 0.04908 | 0.52044 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3165 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2915 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 24 | 549 | Přívodní | SUP | PO02.01.0860 | 0860 | yes | SUP 24
13876681 | 2.NP_SO-102 | 323.929 | 0.0397548 | 0.228972 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3152.5 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2927.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 24 | 197 | Přívodní | SUP | PO02.01.0861 | 0861 | no | SUP 24
13876755 | 2.NP_SO-102 | 140.137 | 0.0397548 | 0.099057 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3152.5 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2927.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 24 | 199 | Přívodní | SUP | PO02.01.0862 | 0862 | no | SUP 24
13876766 | 2.NP_SO-102 | 101.713 | 0.0397548 | 0.0718967 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3152.5 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2927.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 24 | 199 | Přívodní | SUP | PO02.01.0863 | 0863 | no | SUP 24
13876779 | 2.NP_SO-102 | 6999.63 | 0.0779194 | 6.92685 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3197.5 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2882.5 | Fáze 1 | 315 | Přívod vzduchu | 0 | SUP 24 | 198 | Přívodní | SUP | PO02.01.0864 | 0864 | yes | SUP 24
13876810 | 2.NP_SO-102 | 629.918 | 0.0397548 | 0.445262 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3152.5 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2927.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 24 | 197 | Přívodní | SUP | PO02.01.0865 | 0865 | no | SUP 24
13876931 | 2.NP_SO-102 | 521.889 | 0.061566 | 0.459077 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 24 | 214 | Přívodní | SUP | PO02.01.0866 | 0866 | no | SUP 24
13876967 | 2.NP_SO-102 | 164.377 | 0.061566 | 0.144594 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 24 | 214 | Přívodní | SUP | PO02.01.0867 | 0867 | no | SUP 24
13876997 | 2.NP_SO-102 | 605.14 | 0.061566 | 0.532309 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 55 | 222 | Přívodní | SUP | PO02.01.0868 | 0868 | no | SUP 55
13877042 | 2.NP_SO-102 | 164.377 | 0.061566 | 0.144594 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 55 | 222 | Přívodní | SUP | PO02.01.0869 | 0869 | no | SUP 55
13877286 | 2.NP_SO-102 | 7420.7 | 0.196306 | 11.6564 | 500 mm | 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3290 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2790 | Fáze 1 | 500 | Přívod vzduchu | 0 | SUP 24 | 211 | Přívodní | SUP | PO02.01.0870 | 0870 | yes | SUP 24
13877539 | 2.NP_SO-102 | 2361.71 | 0.04908 | 1.85488 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3165 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2915 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 24 | 548 | Přívodní | SUP | PO02.01.0871 | 0871 | yes | SUP 24
13877614 | 2.NP_SO-102 | 292.382 | 0.061566 | 0.257193 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 24 | 448 | Přívodní | SUP | PO02.01.0872 | 0872 | no | SUP 24
13877658 | 2.NP_SO-102 | 219.438 | 0.061566 | 0.193028 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 24 | 449 | Přívodní | SUP | PO02.01.0873 | 0873 | no | SUP 24
13877721 | 2.NP_SO-102 | 137.707 | 0.061566 | 0.121133 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 24 | 130 | Přívodní | SUP | PO02.01.0874 | 0874 | no | SUP 24
13877785 | 2.NP_SO-102 | 564.184 | 0.0201032 | 0.28359 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3120 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2960 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 11 | Přívodní | SUP | PO02.01.0875 | 0875 | yes | SUP 24
13877893 | 2.NP_SO-102 | 106.425 | 0.061566 | 0.0936166 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 57 | 226 | Přívodní | SUP | PO02.01.0876 | 0876 | no | SUP 57
13877921 | 2.NP_SO-102 | 113.59 | 0.061566 | 0.0999187 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 59 | 230 | Přívodní | SUP | PO02.01.0877 | 0877 | no | SUP 59
13877944 | 2.NP_SO-102 | 870.06 | 0.0201032 | 0.43734 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3120 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2960 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 11 | Přívodní | SUP | PO02.01.0878 | 0878 | no | SUP 24
13878012 | 2.NP_SO-102 | 6074.68 | 0.0201032 | 3.05347 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3160 | 3080 | 3080 | 2.NP_SO-102 | 0 | 3000 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 13 | 220 | Přívodní | SUP | PO02.01.0879 | 0879 | no | SUP 13
13878094 | 2.NP_SO-102 | 311.318 | 0.0201032 | 0.156485 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3160 | 3080 | 3080 | 2.NP_SO-102 | 0 | 3000 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 13 | 220 | Přívodní | SUP | PO02.01.0880 | 0880 | no | SUP 13
13878159 | 2.NP_SO-102 | 1110.61 | 0.0254431 | 0.628035 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3170 | 3080 | 3080 | 2.NP_SO-102 | 0 | 2990 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 13 | 216 | Přívodní | SUP | PO02.01.0881 | 0881 | no | SUP 13
13878211 | 2.NP_SO-102 | 1163.85 | 0.04908 | 0.914085 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3205 | 3080 | 3080 | 2.NP_SO-102 | 0 | 2955 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 13 | 178 | Přívodní | SUP | PO02.01.0882 | 0882 | no | SUP 13
13878265 | 2.NP_SO-102 | 6369.48 | 0.04908 | 5.00258 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3205 | 3080 | 3080 | 2.NP_SO-102 | 0 | 2955 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 13 | 210 | Přívodní | SUP | PO02.01.0883 | 0883 | no | SUP 13
13878279 | 2.NP_SO-102 | 92.0951 | 0.0254431 | 0.0520786 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3170 | 3080 | 3080 | 2.NP_SO-102 | 0 | 2990 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 13 | 216 | Přívodní | SUP | PO02.01.0884 | 0884 | no | SUP 13
13878419 | 2.NP_SO-102 | 10.5412 | 0.0397548 | 0.00745117 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3192.5 | 3080 | 3080 | 2.NP_SO-102 | 0 | 2967.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 180 | Přívodní | SUP | PO02.01.0885 | 0885 | no | SUP 13
13879766 | 4.NP_SO-102 | 119.639 | 0.04908 | 0.0939645 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3220 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2970 | Fáze 2 | 250 | Přívod vzduchu | 0 | SUP 18 | 158 | Přívodní | SUP | PO02.01.0886 | 0886 | no | SUP 18
13879780 | 4.NP_SO-102 | 156.366 | 0.061566 | 0.137547 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 18 | 95 | Přívodní | SUP | PO02.01.0887 | 0887 | yes | SUP 18
13880571 | 4.NP_SO-102 | 140.242 | 0.0201032 | 0.0704932 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 4.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 24 | 241 | Přívodní | SUP | PO02.01.0888 | 0888 | no | SUP 24
13882279 | 4.NP_SO-102 | 200.175 | 0.0254431 | 0.113196 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3185 | 3095 | 3095 | 4.NP_SO-102 | 0 | 3005 | Fáze 2 | 180 | Přívod vzduchu | 0 | SUP 18 | 166 | Přívodní | SUP | PO02.01.0889 | 0889 | no | SUP 18
13882311 | 4.NP_SO-102 | 153.607 | 0.0254431 | 0.0868625 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3185 | 3095 | 3095 | 4.NP_SO-102 | 0 | 3005 | Fáze 2 | 180 | Přívod vzduchu | 0 | SUP 18 | 152 | Přívodní | SUP | PO02.01.0890 | 0890 | no | SUP 18
13884141 | 3.NP_SO-102 | 4660.32 | 0.061566 | 4.09943 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 100 | Přívodní | SUP | PO02.01.0891 | 0891 | yes | SUP 24
13884263 | 3.NP_SO-102 | 907.802 | 0.061566 | 0.798545 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 493 | Přívodní | SUP | PO02.01.0892 | 0892 | yes | SUP 24
13884430 | 3.NP_SO-102 | 1468.49 | 0.061566 | 1.29175 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 81 | Přívodní | SUP | PO02.01.0893 | 0893 | no | SUP 24
13884550 | 3.NP_SO-102 | 514.652 | 0.061566 | 0.452712 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 98 | Přívodní | SUP | PO02.01.0894 | 0894 | no | SUP 24
13884572 | 3.NP_SO-102 | 19.8499 | 0.061566 | 0.0174609 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 81 | Přívodní | SUP | PO02.01.0895 | 0895 | no | SUP 24
13884648 | 3.NP_SO-102 | 7108.53 | 0.061566 | 6.25299 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3235 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2955 | Fáze 2 | 280 | Přívod vzduchu | 0 | SUP 24 | 123 | Přívodní | SUP | PO02.01.0896 | 0896 | no | SUP 24
13884910 | 3.NP_SO-102 | 830.446 | 0.0397548 | 0.587008 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3152.5 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2927.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 1 | 288 | Přívodní | SUP | PO02.01.0897 | 0897 | yes | SUP 1
13884947 | 3.NP_SO-102 | 588.306 | 0.0397548 | 0.415849 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3152.5 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2927.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 1 | 288 | Přívodní | SUP | PO02.01.0898 | 0898 | no | SUP 1
13884989 | 3.NP_SO-102 | 126.107 | 0.04908 | 0.0990442 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3165 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2915 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 1 | 304 | Přívodní | SUP | PO02.01.0899 | 0899 | no | SUP 1
13885013 | 3.NP_SO-102 | 219.822 | 0.04908 | 0.172648 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3165 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2915 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 1 | 304 | Přívodní | SUP | PO02.01.0900 | 0900 | no | SUP 1
13885066 | 3.NP_SO-102 | 10.2614 | 0.0397548 | 0.00725335 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3152.5 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2927.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 1 | 307 | Přívodní | SUP | PO02.01.0901 | 0901 | no | SUP 1
13885113 | 3.NP_SO-102 | 535.633 | 0.04908 | 0.420685 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3165 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2915 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 1 | 308 | Přívodní | SUP | PO02.01.0902 | 0902 | no | SUP 1
13885405 | 3.NP_SO-102 | 624.588 | 0.04908 | 0.49055 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3165 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2915 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 1 | 270 | Přívodní | SUP | PO02.01.0903 | 0903 | no | SUP 1
13885443 | 3.NP_SO-102 | 680.244 | 0.061566 | 0.598374 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 1 | 311 | Přívodní | SUP | PO02.01.0904 | 0904 | no | SUP 1
13885547 | 3.NP_SO-102 | 813.864 | 0.061566 | 0.715912 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 1 | 52 | Přívodní | SUP | PO02.01.0905 | 0905 | no | SUP 1
13885617 | 3.NP_SO-102 | 61.2606 | 0.04908 | 0.048114 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3165 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2915 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 1 | 270 | Přívodní | SUP | PO02.01.0906 | 0906 | no | SUP 1
13885647 | 3.NP_SO-102 | 6967.42 | 0.061566 | 6.12886 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 1 | 330 | Přívodní | SUP | PO02.01.0907 | 0907 | no | SUP 1
13885679 | 3.NP_SO-102 | 7155.69 | 0.061566 | 6.29448 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2900 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 1 | 335 | Přívodní | SUP | PO02.01.0908 | 0908 | no | SUP 1
13885762 | 3.NP_SO-102 | 7363.56 | 0.0254431 | 4.164 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3130 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2950 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 24 | 385 | Přívodní | SUP | PO02.01.0909 | 0909 | no | SUP 24
13885817 | 3.NP_SO-102 | 407.307 | 0.0254431 | 0.230326 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3130 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2950 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 24 | 421 | Přívodní | SUP | PO02.01.0910 | 0910 | no | SUP 24
13886112 | 3.NP_SO-102 | 130.996 | 0.0254431 | 0.0740764 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3190 | 3100 | 3100 | 3.NP_SO-102 | 0 | 3010 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 13 | 191 | Přívodní | SUP | PO02.01.0911 | 0911 | no | SUP 13
13886376 | 3.NP_SO-102 | 6476.38 | 0.0397548 | 4.57788 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3212.5 | 3100 | 3100 | 3.NP_SO-102 | 0 | 2987.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 205 | Přívodní | SUP | PO02.01.0912 | 0912 | no | SUP 13
13886519 | 3.NP_SO-102 | 494.611 | 0.0254431 | 0.279696 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3190 | 3100 | 3100 | 3.NP_SO-102 | 0 | 3010 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 13 | 191 | Přívodní | SUP | PO02.01.0913 | 0913 | no | SUP 13
13886719 | 3.NP_SO-102 | 332.746 | 0.0397548 | 0.235204 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3212.5 | 3100 | 3100 | 3.NP_SO-102 | 0 | 2987.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 20 | Přívodní | SUP | PO02.01.0914 | 0914 | no | SUP 13
13889966 | 2.NP_SO-102 | 7117.18 | 0.0201032 | 3.57749 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3120 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2960 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 63 | 236 | Přívodní | SUP | PO02.01.0915 | 0915 | no | SUP 63
13895739 | 1.NP_SO-102 | 1340 | 0.0201032 | 0.673557 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 1.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 12 | 234 | Přívodní | SUP | PO02.01.0917 | 0917 | no | SUP 12
13895906 | 1.NP_SO-102 | 1372.18 | 0.0201032 | 0.689734 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 1.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 251 | Odváděný | ETA | PO02.01.0918 | 0918 | no | ETA 7
13895916 | 1.NP_SO-102 | 760 | 0.0201032 | 0.382018 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 1.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 253 | Odváděný | ETA | PO02.01.0919 | 0919 | no | ETA 7
13895934 | 1.NP_SO-102 | 427.818 | 0.0201032 | 0.215045 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 1.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 249 | Odváděný | ETA | PO02.01.0920 | 0920 | no | ETA 7
13895944 | 1.NP_SO-102 | 386.079 | 0.0201032 | 0.194065 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 1.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 249 | Odváděný | ETA | PO02.01.0921 | 0921 | no | ETA 7
13895955 | 1.NP_SO-102 | 4340 | 0.0201032 | 2.18152 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 1.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 249 | Odváděný | ETA | PO02.01.0922 | 0922 | no | ETA 7
13907371 | 1.NP_SO-102 | 387.385 | 0.0779194 | 0.383357 | 315 mm | 345 mm | 15 | 0 | 0 | 0 | 0 | 0 | 0 | 2807.5 | 2650 | 2650 | 1.NP_SO-102 | 0 | 2492.5 | Fáze 1 | 315 | Přívod vzduchu | 0 | SUP 24 | 559 | Přívodní | SUP | PO02.01.0945 | 0945 | yes | SUP 24 | Identifikační data - Komentáře: ZASLEPENÁ ODBOČKA PŘÍPRAVA PRO NAPOJENÍ MÍSTNOSTÍ VE II.ETAPĚ VÝSTAVBY; Izolace - Typ izolace: Protipožární
13908054 | 1.NP_SO-102 | 3944.08 | 0.0201032 | 1.98251 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 1.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 12 | 234 | Přívodní | SUP | PO02.01.0946 | 0946 | no | SUP 12
13908073 | 1.NP_SO-102 | 4311.09 | 0.0989649 | 4.80801 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3277.5 | 3100 | 3100 | 1.NP_SO-102 | 0 | 2922.5 | Fáze 2 | 355 | Přívod vzduchu | 0 | SUP 12 | 190 | Přívodní | SUP | PO02.01.0947 | 0947 | no | SUP 12
13908403 | 1.NP_SO-102 | 571.793 | 0.0989649 | 0.637701 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3277.5 | 3100 | 3100 | 1.NP_SO-102 | 0 | 2922.5 | Fáze 2 | 355 | Přívod vzduchu | 0 | SUP 12 | 213 | Přívodní | SUP | PO02.01.0948 | 0948 | no | SUP 12
13908664 | 1.NP_SO-102 | 934.257 | 0.0989649 | 1.04194 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3277.5 | 3100 | 3100 | 1.NP_SO-102 | 0 | 2922.5 | Fáze 2 | 355 | Přívod vzduchu | 0 | SUP 12 | 213 | Přívodní | SUP | PO02.01.0949 | 0949 | no | SUP 12
13908746 | 1.NP_SO-102 | 456.606 | 0.0254431 | 0.258205 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3190 | 3100 | 3100 | 1.NP_SO-102 | 0 | 3010 | Fáze 2 | 180 | Přívod vzduchu | 0 | SUP 12 | 230 | Přívodní | SUP | PO02.01.0950 | 0950 | no | SUP 12
13908798 | 1.NP_SO-102 | 459.534 | 0.0254431 | 0.25986 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3190 | 3100 | 3100 | 1.NP_SO-102 | 0 | 3010 | Fáze 2 | 180 | Přívod vzduchu | 0 | SUP 12 | 230 | Přívodní | SUP | PO02.01.0951 | 0951 | no | SUP 12
13908924 | 1.NP_SO-102 | 1920.9 | 0.0779194 | 1.90092 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3257.5 | 3100 | 3100 | 1.NP_SO-102 | 0 | 2942.5 | Fáze 2 | 315 | Přívod vzduchu | 0 | SUP 12 | 203 | Přívodní | SUP | PO02.01.0952 | 0952 | no | SUP 12
13908941 | 1.NP_SO-102 | 4000 | 0.0254431 | 2.26195 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3190 | 3100 | 3100 | 1.NP_SO-102 | 0 | 3010 | Fáze 2 | 180 | Přívod vzduchu | 0 | SUP 12 | 211 | Přívodní | SUP | PO02.01.0953 | 0953 | no | SUP 12
13909082 | 1.NP_SO-102 | 3900 | 0.0779194 | 3.85945 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3257.5 | 3100 | 3100 | 1.NP_SO-102 | 0 | 2942.5 | Fáze 2 | 315 | Přívod vzduchu | 0 | SUP 12 | 203 | Přívodní | SUP | PO02.01.0954 | 0954 | no | SUP 12
13909350 | 1.NP_SO-102 | 538.77 | 0.0779194 | 0.533168 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3257.5 | 3100 | 3100 | 1.NP_SO-102 | 0 | 2942.5 | Fáze 2 | 315 | Přívod vzduchu | 0 | SUP 12 | 197 | Přívodní | SUP | PO02.01.0955 | 0955 | no | SUP 12
13909451 | 1.NP_SO-102 | 58.9808 | 0.0779194 | 0.0583675 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3257.5 | 3100 | 3100 | 1.NP_SO-102 | 0 | 2942.5 | Fáze 2 | 315 | Přívod vzduchu | 0 | SUP 12 | 197 | Přívodní | SUP | PO02.01.0956 | 0956 | no | SUP 12
13909577 | 1.NP_SO-102 | 5506.54 | 0.04908 | 4.32482 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3225 | 3100 | 3100 | 1.NP_SO-102 | 0 | 2975 | Fáze 2 | 250 | Přívod vzduchu | 0 | SUP 12 | 207 | Přívodní | SUP | PO02.01.0957 | 0957 | no | SUP 12
13911014 | 1.NP_SO-102 | 327.041 | 0.0201032 | 0.164389 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 24 | 1 | Přívodní | SUP | PO02.01.0960 | 0960 | no | SUP 24
13911065 | 1.NP_SO-102 | 313.515 | 0.0201032 | 0.15759 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 24 | 1 | Přívodní | SUP | PO02.01.0961 | 0961 | no | SUP 24
13911118 | 1.NP_SO-102 | 751.183 | 0.0201032 | 0.377586 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 24 | 484 | Přívodní | SUP | PO02.01.0962 | 0962 | no | SUP 24
13911167 | 1.NP_SO-102 | 1595 | 0.0201032 | 0.801735 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 24 | 91 | Přívodní | SUP | PO02.01.0963 | 0963 | yes | SUP 24
13911568 | 1.NP_SO-102 | 1088.09 | 0.0254431 | 0.6153 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2910 | 2820 | 2820 | 1.NP_SO-102 | 0 | 2730 | Fáze 2 | 180 | Zpětný vzduch | 0 | ETA 10 | 57 | Odváděný | ETA | PO02.01.0964 | 0964 | no | ETA 10
13911619 | 1.NP_SO-102 | 7767.17 | 0.0254431 | 4.39223 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2910 | 2820 | 2820 | 1.NP_SO-102 | 0 | 2730 | Fáze 2 | 180 | Zpětný vzduch | 0 | ETA 10 | 57 | Odváděný | ETA | PO02.01.0965 | 0965 | no | ETA 10
13911665 | 1.NP_SO-102 | 1157.39 | 0.0989649 | 1.2908 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2917.5 | 2740 | 2740 | 1.NP_SO-102 | 0 | 2562.5 | Fáze 2 | 355 | Zpětný vzduch | 0 | ETA 17 | 21 | Odváděný | ETA | PO02.01.0966 | 0966 | yes | ETA 17
13911689 | 1.NP_SO-102 | 571.793 | 0.0989649 | 0.637701 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2917.5 | 2740 | 2740 | 1.NP_SO-102 | 0 | 2562.5 | Fáze 2 | 355 | Zpětný vzduch | 0 | ETA 17 | 21 | Odváděný | ETA | PO02.01.0967 | 0967 | yes | ETA 17
13911856 | 1.NP_SO-102 | 258.72 | 0.159008 | 0.365756 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3325 | 3100 | 3100 | 1.NP_SO-102 | 0 | 2875 | Fáze 2 | 450 | Přívod vzduchu | 0 | SUP 12 | 239 | Přívodní | SUP | PO02.01.0968 | 0968 | yes | SUP 12 | Identifikační data - Komentáře: VZT20
13911998 | 1.NP_SO-102 | 128.166 | 0.159008 | 0.18119 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2965 | 2740 | 2740 | 1.NP_SO-102 | 0 | 2515 | Fáze 2 | 450 | Zpětný vzduch | 0 | ETA 17 | 58 | Odváděný | ETA | PO02.01.0969 | 0969 | yes | ETA 17
13914105 | 1.NP_SO-102 | 229.895 | 0.061566 | 0.202226 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2880 | 2740 | 2740 | 1.NP_SO-102 | 0 | 2600 | Fáze 2 | 280 | Zpětný vzduch | 0 | ETA 17 | 11 | Odváděný | ETA | PO02.01.0972 | 0972 | yes | ETA 17
13914135 | 1.NP_SO-102 | 429.449 | 0.061566 | 0.377763 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2880 | 2740 | 2740 | 1.NP_SO-102 | 0 | 2600 | Fáze 2 | 280 | Zpětný vzduch | 0 | ETA 17 | 62 | Odváděný | ETA | PO02.01.0973 | 0973 | no | ETA 17
13914247 | 1.NP_SO-102 | 4203.92 | 0.0254431 | 2.37726 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3190 | 3100 | 3100 | 1.NP_SO-102 | 0 | 3010 | Fáze 2 | 180 | Přívod vzduchu | 0 | SUP 12 | 51 | Přívodní | SUP | PO02.01.0974 | 0974 | no | SUP 12
13914374 | 1.NP_SO-102 | 294.034 | 0.0254431 | 0.166272 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3190 | 3100 | 3100 | 1.NP_SO-102 | 0 | 3010 | Fáze 2 | 180 | Přívod vzduchu | 0 | SUP 12 | 51 | Přívodní | SUP | PO02.01.0975 | 0975 | no | SUP 12
13914408 | 2.NP_SO-102 | 593.311 | 0.0201032 | 0.298231 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2780 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2620 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 12 | 48 | Odváděný | ETA | PO02.01.0976 | 0976 | no | ETA 12
13914418 | 2.NP_SO-102 | 980 | 0.0201032 | 0.492602 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2780 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2620 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 12 | 48 | Odváděný | ETA | PO02.01.0977 | 0977 | no | ETA 12
13914449 | 2.NP_SO-102 | 1598.24 | 0.0201032 | 0.803363 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2780 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2620 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 12 | 48 | Odváděný | ETA | PO02.01.0978 | 0978 | no | ETA 12
13914460 | 2.NP_SO-102 | 2780 | 0.0201032 | 1.39738 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2780 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2620 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 12 | 48 | Odváděný | ETA | PO02.01.0979 | 0979 | no | ETA 12
13914469 | 2.NP_SO-102 | 2233.61 | 0.0201032 | 1.12273 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2780 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2620 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 12 | 48 | Odváděný | ETA | PO02.01.0980 | 0980 | no | ETA 12
13914480 | 2.NP_SO-102 | 880 | 0.0201032 | 0.442336 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2780 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2620 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 12 | 50 | Odváděný | ETA | PO02.01.0981 | 0981 | no | ETA 12
13914551 | 2.NP_SO-102 | 520 | 0.0201032 | 0.261381 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2780 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2620 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 12 | 52 | Odváděný | ETA | PO02.01.0982 | 0982 | no | ETA 12
13915162 | 2.NP_SO-102 | 416.226 | 0.0201032 | 0.209218 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3260 | 3180 | 3180 | 2.NP_SO-102 | 0 | 3100 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 17 | 133 | Přívodní | SUP | PO02.01.0983 | 0983 | no | SUP 17
13915174 | 2.NP_SO-102 | 2748.63 | 0.0254431 | 1.55431 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3270 | 3180 | 3180 | 2.NP_SO-102 | 0 | 3090 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 17 | 130 | Přívodní | SUP | PO02.01.0984 | 0984 | no | SUP 17
13915312 | 2.NP_SO-102 | 1482.97 | 0.0201032 | 0.745423 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2980 | 2900 | 2900 | 2.NP_SO-102 | 0 | 2820 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 17 | 154 | Přívodní | SUP | PO02.01.0985 | 0985 | no | SUP 17
13915323 | 2.NP_SO-102 | 263.431 | 0.0201032 | 0.132415 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3189.71 | 2946.86 | 3133.14 | 2.NP_SO-102 | 100 | 2890.29 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 17 | 133 | Přívodní | SUP | PO02.01.0986 | 0986 | no | SUP 17
13924548 | -1.PP_SO-102 | 1470.55 | 0.0989649 | 1.64005 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3327.5 | 3150 | 3150 | -1.PP_SO-102 | 0 | 2972.5 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 18 | 30 | Odváděný | ETA | PO02.01.1002 | 1002 | yes | ETA 18
13925969 | 1.NP_SO-102 | 6791.08 | 0.0201032 | 3.41357 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 14 | 5 | Přívodní | SUP | PO02.01.1003 | 1003 | yes | SUP 14
13926116 | 1.NP_SO-102 | 18.8785 | 0.0201032 | 0.00948934 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 23 | 11 | Odváděný | ETA | PO02.01.1004 | 1004 | yes | ETA 23
13926313 | 1.NP_SO-102 | 60.5132 | 0.0201032 | 0.0304173 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2975 | 2895 | 2895 | 1.NP_SO-102 | 0 | 2815 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 366 | Přívodní | SUP | PO02.01.1005 | 1005 | no | SUP 24
13926335 | 1.NP_SO-102 | 199.768 | 0.0201032 | 0.100415 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2975 | 2895 | 2895 | 1.NP_SO-102 | 0 | 2815 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 370 | Přívodní | SUP | PO02.01.1006 | 1006 | no | SUP 24
13926568 | 1.NP_SO-102 | 74.3199 | 0.0201032 | 0.0373572 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2975 | 2895 | 2895 | 1.NP_SO-102 | 0 | 2815 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 366 | Přívodní | SUP | PO02.01.1007 | 1007 | no | SUP 24
13926590 | 1.NP_SO-102 | 282.241 | 0.0201032 | 0.14187 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2975 | 2895 | 2895 | 1.NP_SO-102 | 0 | 2815 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 370 | Přívodní | SUP | PO02.01.1008 | 1008 | no | SUP 24
13926666 | 1.NP_SO-102 | 557.675 | 0.0254431 | 0.315358 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3185 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3005 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 2 | 12 | Přívodní | SUP | PO02.01.1009 | 1009 | no | SUP 2
13926789 | 1.NP_SO-102 | 53.4751 | 0.0254431 | 0.0302395 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3185 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3005 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 35 | 8 | Přívodní | SUP | PO02.01.1010 | 1010 | no | SUP 35
13926849 | 1.NP_SO-102 | 6107.84 | 0.0254431 | 3.4539 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3185 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3005 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 24 | 377 | Přívodní | SUP | PO02.01.1011 | 1011 | no | SUP 24
13926878 | 1.NP_SO-102 | 127.091 | 0.0254431 | 0.0718685 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3185 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3005 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 24 | 383 | Přívodní | SUP | PO02.01.1012 | 1012 | no | SUP 24
13927094 | 1.NP_SO-102 | 579.543 | 0.0254431 | 0.327724 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3185 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3005 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 24 | 63 | Přívodní | SUP | PO02.01.1013 | 1013 | no | SUP 24
13928638 | 1.NP_SO-102 | 179.698 | 0.0314112 | 0.112908 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3195 | 3095 | 3095 | 1.NP_SO-102 | 0 | 2995 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 20 | 148 | Přívodní | SUP | PO02.01.1015 | 1015 | no | SUP 20
13928777 | 1.NP_SO-102 | 179.698 | 0.0314112 | 0.112908 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3195 | 3095 | 3095 | 1.NP_SO-102 | 0 | 2995 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 20 | 236 | Přívodní | SUP | PO02.01.1016 | 1016 | no | SUP 20 | Identifikační data - Komentáře: rozvody VZT vedené dále v úrovni 1.PP
13928965 | 1.NP_SO-102 | 5745.67 | 0.0254431 | 3.2491 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3240 | 3150 | 3150 | 1.NP_SO-102 | 0 | 3060 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 13 | 230 | Přívodní | SUP | PO02.01.1017 | 1017 | no | SUP 13
13929070 | 1.NP_SO-102 | 340.155 | 0.0254431 | 0.192353 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3240 | 3150 | 3150 | 1.NP_SO-102 | 0 | 3060 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 13 | 51 | Přívodní | SUP | PO02.01.1018 | 1018 | yes | SUP 13
13930930 | 2.NP_SO-102 | 2144.75 | 0.0989649 | 2.39197 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3117.5 | 2940 | 2940 | 2.NP_SO-102 | 0 | 2762.5 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 9 | 281 | Přívodní | SUP | PO02.01.1019 | 1019 | yes | SUP 9
13931067 | 2.NP_SO-102 | 310.722 | 0.0989649 | 0.346537 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3117.5 | 2940 | 2940 | 2.NP_SO-102 | 0 | 2762.5 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 9 | 281 | Přívodní | SUP | PO02.01.1020 | 1020 | yes | SUP 9
13935472 | 2.NP_SO-102 | 65 | 0.0989649 | 0.0724923 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3087.5 | 2910 | 2910 | 2.NP_SO-102 | 0 | 2732.5 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 14 | 328 | Odváděný | ETA | PO02.01.1025 | 1025 | no | ETA 14
13935542 | 2.NP_SO-102 | 429.32 | 0.0314112 | 0.26975 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3280 | 3180 | 3180 | 2.NP_SO-102 | 0 | 3080 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 17 | 103 | Přívodní | SUP | PO02.01.1026 | 1026 | no | SUP 17
13935716 | 2.NP_SO-102 | 189.668 | 0.125636 | 0.238343 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3380 | 3180 | 3180 | 2.NP_SO-102 | 0 | 2980 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 17 | 19 | Přívodní | SUP | PO02.01.1027 | 1027 | yes | SUP 17
13935803 | 2.NP_SO-102 | 215.151 | 0.125636 | 0.270367 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3380 | 3180 | 3180 | 2.NP_SO-102 | 0 | 2980 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 17 | 135 | Přívodní | SUP | PO02.01.1028 | 1028 | yes | SUP 17
13935838 | 2.NP_SO-102 | 180.016 | 0.0314112 | 0.113108 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3280 | 3180 | 3180 | 2.NP_SO-102 | 0 | 3080 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 17 | 103 | Přívodní | SUP | PO02.01.1029 | 1029 | no | SUP 17
13935931 | 2.NP_SO-102 | 128.023 | 0.0254431 | 0.0723953 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2790 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2610 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 12 | 55 | Odváděný | ETA | PO02.01.1030 | 1030 | no | ETA 12
13935996 | 2.NP_SO-102 | 169.716 | 0.0254431 | 0.0959722 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2790 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2610 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 12 | 43 | Odváděný | ETA | PO02.01.1031 | 1031 | no | ETA 12
13936122 | 2.NP_SO-102 | 752.294 | 0.159008 | 1.06353 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3076.43 | 2851.43 | 2851.43 | 2.NP_SO-102 | 0 | 2626.43 | Fáze 1 | 450 | Zpětný vzduch | 0 | ETA 12 | 107 | Odváděný | ETA | PO02.01.1032 | 1032 | yes | ETA 12
13936294 | 2.NP_SO-102 | 385.084 | 0.125636 | 0.483911 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3050 | 2850 | 2850 | 2.NP_SO-102 | 0 | 2650 | Fáze 1 | 400 | Zpětný vzduch | 0 | ETA 12 | 105 | Odváděný | ETA | PO02.01.1033 | 1033 | yes | ETA 12
13936454 | 2.NP_SO-102 | 940 | 0.0254431 | 0.531557 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2790 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2610 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 12 | 43 | Odváděný | ETA | PO02.01.1034 | 1034 | no | ETA 12
13936660 | 2.NP_SO-102 | 393.338 | 0.0254431 | 0.222428 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2790 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2610 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 12 | 68 | Odváděný | ETA | PO02.01.1035 | 1035 | no | ETA 12
13937319 | 2.NP_SO-102 | 4932.95 | 0.0989649 | 5.50155 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3097.5 | 2920 | 2920 | 2.NP_SO-102 | 0 | 2742.5 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 14 | 293 | Odváděný | ETA | PO02.01.1036 | 1036 | yes | ETA 14
13937461 | 2.NP_SO-102 | 1744.14 | 0.0779194 | 1.72601 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3007.5 | 2850 | 2850 | 2.NP_SO-102 | 0 | 2692.5 | Fáze 1 | 315 | Zpětný vzduch | 0 | ETA 12 | 87 | Odváděný | ETA | PO02.01.1037 | 1037 | yes | ETA 12
13937498 | 2.NP_SO-102 | 2521.07 | 0.04908 | 1.98004 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2975 | 2850 | 2850 | 2.NP_SO-102 | 0 | 2725 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 12 | 80 | Odváděný | ETA | PO02.01.1038 | 1038 | yes | ETA 12
13937599 | 2.NP_SO-102 | 2495.5 | 0.0397548 | 1.76397 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2962.5 | 2850 | 2850 | 2.NP_SO-102 | 0 | 2737.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 12 | 85 | Odváděný | ETA | PO02.01.1039 | 1039 | yes | ETA 12
13937613 | 2.NP_SO-102 | 1160 | 0.0201032 | 0.58308 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2930 | 2850 | 2850 | 2.NP_SO-102 | 0 | 2770 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 12 | 91 | Odváděný | ETA | PO02.01.1040 | 1040 | yes | ETA 12
13937893 | 2.NP_SO-102 | 2565.68 | 0.0314112 | 1.61206 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2950 | 2850 | 2850 | 2.NP_SO-102 | 0 | 2750 | Fáze 1 | 200 | Zpětný vzduch | 0 | ETA 12 | 93 | Odváděný | ETA | PO02.01.1045 | 1045 | yes | ETA 12
13938728 | 2.NP_SO-102 | 8983.4 | 0.0201032 | 4.51555 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2989.72 | 2909.72 | 2909.72 | 2.NP_SO-102 | 0 | 2829.72 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 12 | 99 | Odváděný | ETA | PO02.01.1047 | 1047 | yes | ETA 12
13939366 | 2.NP_SO-102 | 24.916 | 0.0989649 | 0.027788 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3027.5 | 2850 | 2850 | 2.NP_SO-102 | 0 | 2672.5 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 12 | 106 | Odváděný | ETA | PO02.01.1048 | 1048 | yes | ETA 12
13939450 | 2.NP_SO-102 | 6111.4 | 0.0201032 | 3.07192 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3260 | 3180 | 3180 | 2.NP_SO-102 | 0 | 3100 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 17 | 145 | Přívodní | SUP | PO02.01.1049 | 1049 | yes | SUP 17
13939464 | 2.NP_SO-102 | 4989.32 | 0.0314112 | 3.13488 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3280 | 3180 | 3180 | 2.NP_SO-102 | 0 | 3080 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 17 | 122 | Přívodní | SUP | PO02.01.1050 | 1050 | yes | SUP 17
13939574 | 2.NP_SO-102 | 632.323 | 0.0201032 | 0.31784 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3260 | 3180 | 3180 | 2.NP_SO-102 | 0 | 3100 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 17 | 145 | Přívodní | SUP | PO02.01.1051 | 1051 | yes | SUP 17
13939575 | 2.NP_SO-102 | 291.716 | 0.0201032 | 0.146632 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3260 | 3180 | 3180 | 2.NP_SO-102 | 0 | 3100 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 17 | 145 | Přívodní | SUP | PO02.01.1052 | 1052 | yes | SUP 17
13939810 | 2.NP_SO-102 | 1178.38 | 0.0314112 | 0.7404 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3280 | 3180 | 3180 | 2.NP_SO-102 | 0 | 3080 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 17 | 14 | Přívodní | SUP | PO02.01.1053 | 1053 | yes | SUP 17
13940365 | -1.PP_SO-102 | 545.356 | 0.04908 | 0.428322 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2475 | 2350 | 2350 | -1.PP_SO-102 | 0 | 2225 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 27 | 45 | Odváděný | ETA | PO02.01.1054 | 1054 | no | ETA 27
13943500 | -1.PP_SO-102 | 3445.43 | 0.0201032 | 1.73186 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2430 | 2350 | 2350 | -1.PP_SO-102 | 0 | 2270 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 27 | 38 | Odváděný | ETA | PO02.01.1055 | 1055 | no | ETA 27
13943571 | -1.PP_SO-102 | 632.5 | 0.0201032 | 0.317929 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2430 | 2350 | 2350 | -1.PP_SO-102 | 0 | 2270 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 27 | 148 | Odváděný | ETA | PO02.01.1056 | 1056 | no | ETA 27
13950072 | -1.PP_SO-102 | 173.715 | 0.04908 | 0.136436 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2825 | 2700 | 2700 | -1.PP_SO-102 | 0 | 2575 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 4 | 29 | Přívodní | SUP | PO02.01.1064 | 1064 | no | SUP 4
13950340 | -1.PP_SO-102 | 62.8894 | 0.125636 | 0.0790291 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 2880 | 2880 | -1.PP_SO-102 | 0 | 2680 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 7 | 30 | Přívodní | SUP | PO02.01.1065 | 1065 | yes | SUP 7
13950529 | -1.PP_SO-102 | 93.9982 | 0.125636 | 0.118122 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 2880 | 2880 | -1.PP_SO-102 | 0 | 2680 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 7 | 22 | Přívodní | SUP | PO02.01.1066 | 1066 | yes | SUP 7
13950656 | -1.PP_SO-102 | 498.965 | 0.125636 | 0.627018 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3350 | 3150 | 3150 | -1.PP_SO-102 | 0 | 2950 | Fáze 1 | 400 | Zpětný vzduch | 0 | ETA 18 | 36 | Odváděný | ETA | PO02.01.1067 | 1067 | yes | ETA 18
13950834 | -1.PP_SO-102 | 543.239 | 0.125636 | 0.682654 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3350 | 3150 | 3150 | -1.PP_SO-102 | 0 | 2950 | Fáze 1 | 400 | Zpětný vzduch | 0 | ETA 18 | 36 | Odváděný | ETA | PO02.01.1068 | 1068 | yes | ETA 18
13950860 | -1.PP_SO-102 | 36.7654 | 0.125636 | 0.0462008 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3350 | 3150 | 3150 | -1.PP_SO-102 | 0 | 2950 | Fáze 1 | 400 | Zpětný vzduch | 0 | ETA 18 | 36 | Odváděný | ETA | PO02.01.1069 | 1069 | yes | ETA 18
13950959 | -1.PP_SO-102 | 1373.73 | 0.0201032 | 0.69051 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2960 | 2880 | 2880 | -1.PP_SO-102 | 0 | 2800 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 7 | 28 | Přívodní | SUP | PO02.01.1070 | 1070 | no | SUP 7
13951022 | -1.PP_SO-102 | 1653.92 | 0.0989649 | 1.84456 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3327.5 | 3150 | 3150 | -1.PP_SO-102 | 0 | 2972.5 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 18 | 30 | Odváděný | ETA | PO02.01.1071 | 1071 | yes | ETA 18
13951991 | -1.PP_SO-102 | 328.239 | 0.0989649 | 0.366074 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3253.97 | 3076.47 | 3076.47 | -1.PP_SO-102 | 0 | 2898.97 | Fáze 1 | 355 | Přívod vzduchu | 0 | ODA 1 | 4 | Čerstvý | ODA | PO02.01.1074 | 1074 | yes | ODA 1
13952071 | -1.PP_SO-102 | 30.5204 | 0.0989649 | 0.0340384 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3253.97 | 3076.47 | 3076.47 | -1.PP_SO-102 | 0 | 2898.97 | Fáze 1 | 355 | Přívod vzduchu | 0 | ODA 1 | 2 | Čerstvý | ODA | PO02.01.1075 | 1075 | yes | ODA 1
13952420 | -1.PP_SO-102 | 238.32 | 0.0989649 | 0.26579 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3098.01 | 2972.49 | 2803.98 | -1.PP_SO-102 | 100 | 2678.47 | Fáze 1 | 355 | Přívod vzduchu | 0 | ODA 1 | 4 | Čerstvý | ODA | PO02.01.1076 | 1076 | yes | ODA 1
13952539 | -1.PP_SO-102 | 1300 | 0.0201032 | 0.653451 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2780 | 2700 | 2700 | -1.PP_SO-102 | 0 | 2620 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 4 | 21 | Přívodní | SUP | PO02.01.1077 | 1077 | no | SUP 4
13952552 | -1.PP_SO-102 | 7720 | 0.0201032 | 3.8805 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2780 | 2700 | 2700 | -1.PP_SO-102 | 0 | 2620 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 4 | 21 | Přívodní | SUP | PO02.01.1078 | 1078 | no | SUP 4
13954311 | 1.NP_SO-102 | 120.396 | 0.0201032 | 0.0605176 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 23 | 2 | Odváděný | ETA | PO02.01.1079 | 1079 | yes | ETA 23
13954320 | 1.NP_SO-102 | 586.29 | 0.0201032 | 0.294702 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 23 | 3 | Odváděný | ETA | PO02.01.1080 | 1080 | yes | ETA 23
13955574 | -1.PP_SO-102 | 3249.08 | 0.125636 | 4.08291 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 2880 | 2880 | -1.PP_SO-102 | 0 | 2680 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 7 | 30 | Přívodní | SUP | PO02.01.1081 | 1081 | yes | SUP 7
13955731 | -1.PP_SO-102 | 5150.74 | 0.125636 | 6.47261 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 2880 | 2880 | -1.PP_SO-102 | 0 | 2680 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 7 | 30 | Přívodní | SUP | PO02.01.1082 | 1082 | yes | SUP 7
13955981 | -1.PP_SO-102 | 15.0443 | 0.0201032 | 0.00756207 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3230 | 3150 | 3150 | -1.PP_SO-102 | 0 | 3070 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 18 | 37 | Odváděný | ETA | PO02.01.1083 | 1083 | no | ETA 18
13955990 | -1.PP_SO-102 | 319.952 | 0.125636 | 0.402063 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3350 | 3150 | 3150 | -1.PP_SO-102 | 0 | 2950 | Fáze 1 | 400 | Zpětný vzduch | 0 | ETA 18 | 36 | Odváděný | ETA | PO02.01.1084 | 1084 | yes | ETA 18
13956000 | -1.PP_SO-102 | 700.281 | 0.0201032 | 0.352 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3230 | 3150 | 3150 | -1.PP_SO-102 | 0 | 3070 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 18 | 37 | Odváděný | ETA | PO02.01.1085 | 1085 | no | ETA 18
13956009 | -1.PP_SO-102 | 1043.84 | 0.0201032 | 0.524692 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3230 | 3150 | 3150 | -1.PP_SO-102 | 0 | 3070 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 18 | 37 | Odváděný | ETA | PO02.01.1086 | 1086 | no | ETA 18
13956158 | -1.PP_SO-102 | 910.883 | 0.0201032 | 0.45786 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2960 | 2880 | 2880 | -1.PP_SO-102 | 0 | 2800 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 7 | 28 | Přívodní | SUP | PO02.01.1087 | 1087 | no | SUP 7
13956169 | -1.PP_SO-102 | 3293.73 | 0.0201032 | 1.65561 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2960 | 2880 | 2880 | -1.PP_SO-102 | 0 | 2800 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 7 | 28 | Přívodní | SUP | PO02.01.1088 | 1088 | no | SUP 7
13957139 | 2.NP_SO-102 | 12811.6 | 0.0201032 | 6.43982 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2680 | 2600 | 2600 | 2.NP_SO-102 | 0 | 2520 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 9 | 462 | Přívodní | SUP | PO02.01.1089 | 1089 | no | SUP 9
13957300 | 2.NP_SO-102 | 174.321 | 0.0201032 | 0.0876234 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3020 | 2940 | 2940 | 2.NP_SO-102 | 0 | 2860 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 9 | 462 | Přívodní | SUP | PO02.01.1090 | 1090 | no | SUP 9
13957309 | 2.NP_SO-102 | 237.75 | 0.0989649 | 0.265154 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3117.5 | 2940 | 2940 | 2.NP_SO-102 | 0 | 2762.5 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 9 | 281 | Přívodní | SUP | PO02.01.1091 | 1091 | yes | SUP 9
13957317 | 2.NP_SO-102 | 348.284 | 0.0201032 | 0.175067 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2949.71 | 2893.14 | 2646.86 | 2.NP_SO-102 | 100 | 2590.29 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 9 | 462 | Přívodní | SUP | PO02.01.1092 | 1092 | no | SUP 9
13957564 | 2.NP_SO-102 | 2634.45 | 0.0254431 | 1.48975 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2670 | 2580 | 2580 | 2.NP_SO-102 | 0 | 2490 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 14 | 222 | Odváděný | ETA | PO02.01.1093 | 1093 | no | ETA 14
13957600 | 2.NP_SO-102 | 2592 | 0.0201032 | 1.30288 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2660 | 2580 | 2580 | 2.NP_SO-102 | 0 | 2500 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 14 | 220 | Odváděný | ETA | PO02.01.1094 | 1094 | no | ETA 14
13957652 | 2.NP_SO-102 | 904.142 | 0.0201032 | 0.454471 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2660 | 2580 | 2580 | 2.NP_SO-102 | 0 | 2500 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 14 | 226 | Odváděný | ETA | PO02.01.1095 | 1095 | no | ETA 14
13957702 | 2.NP_SO-102 | 2250.4 | 0.0201032 | 1.13117 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2660 | 2580 | 2580 | 2.NP_SO-102 | 0 | 2500 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 14 | 218 | Odváděný | ETA | PO02.01.1096 | 1096 | no | ETA 14
13959381 | -1.PP_SO-102 | 463.286 | 0.0779194 | 0.458469 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3237.5 | 3080 | 3080 | -1.PP_SO-102 | 0 | 2922.5 | Fáze 1 | 315 | Zpětný vzduch | 0 | ETA 7 | 62 | Odváděný | ETA | PO02.01.1098 | 1098 | no | ETA 7
13959415 | -1.PP_SO-102 | 136.057 | 0.0779194 | 0.134643 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3237.5 | 3080 | 3080 | -1.PP_SO-102 | 0 | 2922.5 | Fáze 1 | 315 | Zpětný vzduch | 0 | ETA 7 | 434 | Odváděný | ETA | PO02.01.1099 | 1099 | yes | ETA 7
13959466 | -1.PP_SO-102 | 594.217 | 0.0779194 | 0.588038 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3237.5 | 3080 | 3080 | -1.PP_SO-102 | 0 | 2922.5 | Fáze 1 | 315 | Zpětný vzduch | 0 | ETA 7 | 434 | Odváděný | ETA | PO02.01.1100 | 1100 | yes | ETA 7 | Identifikační data - Komentáře: VZT18
13959920 | -1.PP_SO-102 | 458.824 | 0.0779194 | 0.454053 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3057.5 | 2900 | 2900 | -1.PP_SO-102 | 0 | 2742.5 | Fáze 2 | 315 | Zpětný vzduch | 0 | ETA 7 | 422 | Odváděný | ETA | PO02.01.1103 | 1103 | yes | ETA 7
13960600 | -1.PP_SO-102 | 890.284 | 0.0254431 | 0.503444 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3159.01 | 3068.87 | 3069.01 | -1.PP_SO-102 | 0.0155008 | 2978.87 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 27 | 92 | Odváděný | ETA | PO02.01.1108 | 1108 | no | ETA 27
