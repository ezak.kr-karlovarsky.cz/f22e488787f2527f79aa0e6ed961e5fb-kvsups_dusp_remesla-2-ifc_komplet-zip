Properties of the parts of a building model (IFC4), part 20 of 45

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:1800x710x1500 (2)
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 1.93106 m3; Plocha: 7.8811 m2; Velikost: 1800 × 710-1800 × 710
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13846375; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 1800x710x1500; Typ: 1800x710x1500
Name (Tlumič hluku hranatý kulisový.LH:1800x710x1500:...) | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13821922 | 2650 | Znehodnocený | Odváděný vzduch | EHA 13 | EHA | TC03.26.0056 | 0056
13846244 | 709 | Přívodní | Přívod vzduchu | SUP 13 | SUP | TC03.26.0107 | 0107

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:1800x800x1250, Tlumič hluku hranatý kulisový.LH:1800x800x1250:13855526
In: 2.NP_SO-102
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1250 mm; Jmenovitá velikost vstupu - šířka: 1800 mm; Jmenovitá velikost vstupu - výška: 800 mm; Jmenovitá velikost výstupu - šířka: 1800 mm; Jmenovitá velikost výstupu - výška: 800 mm; Průtočná mezera: 100 mm; Šířka: 1800 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 800 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 1800x800x1250; Označení typu: 37; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: ODA 3
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 15.724 m2; NetVolume: 1.81573 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1800 mm × 800 mm-1800 mm × 800 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1800 mm × 800 mm-1800 mm × 800 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 2.05556 m3/s; Tlaková ztráta: -122526 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Výška od podlaží: 1559 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Název systému: ODA 3; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 1.81573 m3; Plocha: 7.862 m2; Velikost: 1800 × 800-1800 × 800
Identifikační data - Kód prvku: TC03.37.0131; Označení: 0131
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13855435; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 1800x800x1250; Typ: 1800x800x1250

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:1800x800x1250, Tlumič hluku hranatý kulisový.LH:1800x800x1250:13855466
In: 2.NP_SO-102
Type - Material: 128-64-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1250 mm; Jmenovitá velikost vstupu - šířka: 1800 mm; Jmenovitá velikost vstupu - výška: 800 mm; Jmenovitá velikost výstupu - šířka: 1800 mm; Jmenovitá velikost výstupu - výška: 800 mm; Průtočná mezera: 100 mm; Šířka: 1800 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 800 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 1800x800x1250; Označení typu: 37; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: EHA 10
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 15.724 m2; NetVolume: 1.81573 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1800 mm × 800 mm-1800 mm × 800 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1800 mm × 800 mm-1800 mm × 800 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Výška od podlaží: 559 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Znehodnocený; Klasifikace systému: Odváděný vzduch; Název systému: EHA 10; Zkratka systému: EHA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 1.81573 m3; Plocha: 7.862 m2; Velikost: 1800 × 800-1800 × 800
Identifikační data - Kód prvku: TC03.37.0130; Označení: 0130
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13855435; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 1800x800x1250; Typ: 1800x800x1250

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:2400x1100x1500, Tlumič hluku hranatý kulisový.LH:2400x1100x1500:13853073
In: -1.PP_SO-102
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1500 mm; Jmenovitá velikost vstupu - šířka: 2400 mm; Jmenovitá velikost vstupu - výška: 1100 mm; Jmenovitá velikost výstupu - šířka: 2400 mm; Jmenovitá velikost výstupu - výška: 1100 mm; Průtočná mezera: 100 mm; Šířka: 2400 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 1100 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 2400x1100x1500; Označení typu: 35; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: SUP 24
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 27.122 m2; NetVolume: 3.98817 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 2400 mm × 1100 mm-2400 mm × 1100 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 2400 mm × 1100 mm-2400 mm × 1100 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Výška od podlaží: -471 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 24; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 3.98817 m3; Plocha: 13.561 m2; Velikost: 2400 × 1100-2400 × 1100
Identifikační data - Kód prvku: TC03.35.0126; Označení: 0126
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13787074; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 2400x1100x1500; Typ: 2400x1100x1500

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:600x300x1000, Tlumič hluku hranatý kulisový.LH:600x300x1000:14037012
In: 2.NP_SO-102
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Jmenovitá velikost vstupu - šířka: 600 mm; Jmenovitá velikost vstupu - výška: 300 mm; Jmenovitá velikost výstupu - šířka: 600 mm; Jmenovitá velikost výstupu - výška: 300 mm; Průtočná mezera: 100 mm; Šířka: 600 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 300 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 600x300x1000; Označení typu: 64; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: SUP 9
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.09 m2; NetVolume: 0.182275 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 600 mm × 300 mm-600 mm × 300 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 600 mm × 300 mm-600 mm × 300 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Výška od podlaží: 2880 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 9; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.182275 m3; Plocha: 1.545 m2; Velikost: 600 × 300-600 × 300
Identifikační data - Kód prvku: TC03.64.0405; Označení: 0405
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13826915; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 600x300x1000; Typ: 600x300x1000

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:600x600x1000, Tlumič hluku hranatý kulisový.LH:600x600x1000:13810659
In: -1.PP_SO-102
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Jmenovitá velikost vstupu - šířka: 600 mm; Jmenovitá velikost vstupu - výška: 600 mm; Jmenovitá velikost výstupu - šířka: 600 mm; Jmenovitá velikost výstupu - výška: 600 mm; Průtočná mezera: 100 mm; Šířka: 600 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 600 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 600x600x1000; Označení typu: 19; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: ODA 2
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.836 m2; NetVolume: 0.364225 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 600 mm × 600 mm-600 mm × 600 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 600 mm × 600 mm-600 mm × 600 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0.611111 m3/s; Tlaková ztráta: 0.138619 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Výška od podlaží: 3100 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Název systému: ODA 2; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.364225 m3; Plocha: 2.418 m2; Velikost: 600 × 600-600 × 600
Identifikační data - Kód prvku: TC03.19.0037; Označení: 0037
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13760112; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 600x600x1000; Typ: 600x600x1000

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:600x600x1000 (4)
In: -1.PP_SO-102
Type - Material: 128-64-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Jmenovitá velikost vstupu - šířka: 600 mm; Jmenovitá velikost vstupu - výška: 600 mm; Jmenovitá velikost výstupu - šířka: 600 mm; Jmenovitá velikost výstupu - výška: 600 mm; Průtočná mezera: 100 mm; Šířka: 600 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 600 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 600x600x1000; Označení typu: 19; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.836 m2; NetVolume: 0.364225 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 600 mm × 600 mm-600 mm × 600 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 600 mm × 600 mm-600 mm × 600 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.364225 m3; Plocha: 2.418 m2; Velikost: 600 × 600-600 × 600
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13760112; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 600x600x1000; Typ: 600x600x1000
Name (Tlumič hluku hranatý kulisový.LH:600x600x1000:...) | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13810638 | 3100 | Znehodnocený | Odváděný vzduch | EHA 2 | EHA | TC03.19.0036 | 0036
13810960 | 3077.14 | Přívodní | Přívod vzduchu | SUP 4 | SUP | TC03.19.0038 | 0038
13951909 | 3076.47 | Znehodnocený | Odváděný vzduch | EHA 9 | EHA | TC03.19.0342 | 0342
13952069 | 3076.47 | Čerstvý | Přívod vzduchu | ODA 1 | ODA | TC03.19.0343 | 0343

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:630x355x1000, Tlumič hluku hranatý kulisový.LH:630x355x1000:13810976
In: -1.PP_SO-102
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Jmenovitá velikost vstupu - šířka: 630 mm; Jmenovitá velikost vstupu - výška: 355 mm; Jmenovitá velikost výstupu - šířka: 630 mm; Jmenovitá velikost výstupu - výška: 355 mm; Průtočná mezera: 100 mm; Šířka: 630 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 355 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 630x355x1000; Označení typu: 20; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: ETA 27
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.5406 m2; NetVolume: 0.226404 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 630 mm × 355 mm-630 mm × 355 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 630 mm × 355 mm-630 mm × 355 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Výška od podlaží: 3076.1 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 27; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.226404 m3; Plocha: 1.7703 m2; Velikost: 630 × 355-630 × 355
Identifikační data - Kód prvku: TC03.20.0039; Označení: 0039
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13737759; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 630x355x1000; Typ: 630x355x1000

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:630x500x1000 (3)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Jmenovitá velikost vstupu - šířka: 630 mm; Jmenovitá velikost vstupu - výška: 500 mm; Jmenovitá velikost výstupu - šířka: 630 mm; Jmenovitá velikost výstupu - výška: 500 mm; Průtočná mezera: 100 mm; Šířka: 630 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 500 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 630x500x1000; Označení typu: 58; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.4106 m2; NetVolume: 0.31874 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 630 mm × 500 mm-630 mm × 500 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 630 mm × 500 mm-630 mm × 500 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.31874 m3; Plocha: 2.2053 m2; Velikost: 630 × 500-630 × 500
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13959849; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 630x500x1000; Typ: 630x500x1000
Name (Tlumič hluku hranatý kulisový.LH:630x500x1000:...) | In | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13959882 | -1.PP_SO-102 | -1.PP_SO-102 | 3080 | Odváděný | Zpětný vzduch | ETA 7 | ETA | TC03.58.0352 | 0352
14033395 | 2.NP_SO-102 | 2.NP_SO-102 | 2925 | Odváděný | Zpětný vzduch | ETA 14 | ETA | TC03.58.0402 | 0402
14038079 | 2.NP_SO-102 | 2.NP_SO-102 | 2880 | Přívodní | Přívod vzduchu | SUP 9 | SUP | TC03.58.0408 | 0408

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:800x500x1000 (5)
In: -1.PP_SO-102
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Jmenovitá velikost vstupu - šířka: 800 mm; Jmenovitá velikost vstupu - výška: 500 mm; Jmenovitá velikost výstupu - šířka: 800 mm; Jmenovitá velikost výstupu - výška: 500 mm; Průtočná mezera: 100 mm; Šířka: 800 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 500 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 800x500x1000; Označení typu: 05; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.298 m2; NetVolume: 0.404675 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 800 mm × 500 mm-800 mm × 500 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 800 mm × 500 mm-800 mm × 500 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 2
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.404675 m3; Plocha: 2.649 m2; Velikost: 800 × 500-800 × 500
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13648289; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 800x500x1000; Typ: 800x500x1000
Name (Tlumič hluku hranatý kulisový.LH:800x500x1000:...) | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení | Tlaková ztráta (Pa)
13648391 | 2089.5 | Odváděný | Zpětný vzduch | ETA 17 | ETA | TC03.05.0009 | 0009
13648813 | 1109 | Odváděný | Zpětný vzduch | ETA 17 | ETA | TC03.05.0010 | 0010
13648890 | 409 | Přívodní | Přívod vzduchu | SUP 12 | SUP | TC03.05.0011 | 0011 | 0
13648916 | 1769 | Přívodní | Přívod vzduchu | SUP 12 | SUP | TC03.05.0012 | 0012 | 0
13650692 | 1854.21 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | TC03.05.0015 | 0015 | 0

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:800x500x1500 (2)
In: -1.PP_SO-102
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1500 mm; Jmenovitá velikost vstupu - šířka: 800 mm; Jmenovitá velikost vstupu - výška: 500 mm; Jmenovitá velikost výstupu - šířka: 800 mm; Jmenovitá velikost výstupu - výška: 500 mm; Průtočná mezera: 100 mm; Šířka: 800 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 500 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 800x500x1500; Označení typu: 07; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.598 m2; NetVolume: 0.604675 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 800 mm × 500 mm-800 mm × 500 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 800 mm × 500 mm-800 mm × 500 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 2
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.604675 m3; Plocha: 3.299 m2; Velikost: 800 × 500-800 × 500
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13650596; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 800x500x1500; Typ: 800x500x1500
Name (Tlumič hluku hranatý kulisový.LH:800x500x1500:...) | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13650779 | 3000 | Čerstvý | Přívod vzduchu | ODA 17 | ODA | TC03.07.0016 | 0016
13651047 | 2930 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | TC03.07.0017 | 0017

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:800x560x1000, Tlumič hluku hranatý kulisový.LH:800x560x1000:13959230
In: -1.PP_SO-102
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Jmenovitá velikost vstupu - šířka: 800 mm; Jmenovitá velikost vstupu - výška: 560 mm; Jmenovitá velikost výstupu - šířka: 800 mm; Jmenovitá velikost výstupu - výška: 560 mm; Průtočná mezera: 100 mm; Šířka: 800 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 560 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 800x560x1000; Označení typu: 55; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: ETA 1
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.7192 m2; NetVolume: 0.453185 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 800 mm × 560 mm-800 mm × 560 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 800 mm × 560 mm-800 mm × 560 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Výška od podlaží: 2400 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 1; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.453185 m3; Plocha: 2.8596 m2; Velikost: 800 × 560-800 × 560
Identifikační data - Kód prvku: TC03.55.0347; Označení: 0347
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13959190; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 800x560x1000; Typ: 800x560x1000

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:900x1000x2500, Tlumič hluku hranatý kulisový.LH:900x1000x2500:13697215
In: 2.NP_SO-102
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 2500 mm; Jmenovitá velikost vstupu - šířka: 900 mm; Jmenovitá velikost vstupu - výška: 1000 mm; Jmenovitá velikost výstupu - šířka: 900 mm; Jmenovitá velikost výstupu - výška: 1000 mm; Průtočná mezera: 100 mm; Šířka: 900 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 1000 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 900x1000x2500; Označení typu: 08; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: ETA 11
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 15.33 m2; NetVolume: 2.25998 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 900 mm × 1000 mm-900 mm × 1000 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 900 mm × 1000 mm-900 mm × 1000 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Výška od podlaží: 2159 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 11; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 2.25998 m3; Plocha: 7.665 m2; Velikost: 900 × 1000-900 × 1000
Identifikační data - Kód prvku: TC03.08.0018; Označení: 0018
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13697112; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 900x1000x2500; Typ: 900x1000x2500

# IfcBuildingElementProxy: Tlumič hluku kruhový.LH:160x1000 (21)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Hrubá délka: 1100 mm; Hrubý poloměr: 130 mm; Hrubý průměr: 260 mm; Jmenovitá velikost vstupu: 160 mm; Jmenovitá velikost výstupu: 160 mm; Poloměr: 80 mm; Průměr: 160 mm; Tloušťka izolace: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.11.14.27; ID kategorie: TK; Kód sestavy: TC02; Nadpis OmniClass: Sound Attenuators; Název typu: 160x1000; Označení typu: 40; Popis: Tlumič hluku kruhový; Popis sestavy: Akustický
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku kruhový.LH
Classification: TC02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.05367 m2; NetVolume: 0.0551009 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 160 mm-160 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 160 mm-160 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0551009 m3; Velikost: 160-160
Jiné - Rodina: Tlumič hluku kruhový.LH; Id typu: 13704437; Rodina a typ: Tlumič hluku kruhový.LH: 160x1000; Typ: 160x1000
Name (Tlumič hluku kruhový.LH:160x1000:...) | In | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13867155 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | TC02.40.0143 | 0143
13867275 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | TC02.40.0145 | 0145
13867751 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | TC02.40.0152 | 0152
13869350 | 4.NP_SO-102 |  | 4.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 40 | SUP | TC02.40.0165 | 0165
13871370 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | TC02.40.0181 | 0181
13877942 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | TC02.40.0225 | 0225
13878092 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | TC02.40.0227 | 0227
13880569 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | TC02.40.0248 | 0248
13911116 | 1.NP_SO-102 | 0 | 1.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | TC02.40.0289 | 0289
13926311 | 1.NP_SO-102 | 0 | 1.NP_SO-102 | 2895 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | TC02.40.0305 | 0305
13926333 | 1.NP_SO-102 | 0 | 1.NP_SO-102 | 2895 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | TC02.40.0306 | 0306
13926787 | 1.NP_SO-102 | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 35 | SUP | TC02.40.0310 | 0310
13926847 | 1.NP_SO-102 | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | TC02.40.0311 | 0311
13991945 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | 3099.91 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | TC02.40.0384 | 0384
13991989 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | TC02.40.0385 | 0385
14064136 | 1.NP_SO-102 | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | TC02.40.0432 | 0432
14064760 | 1.NP_SO-102 | 0 | 1.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | TC02.40.0434 | 0434
14078626 | 1.NP_SO-102 | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | TC02.40.0445 | 0445
14078943 | 1.NP_SO-102 | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | TC02.40.0446 | 0446
14113857 | -1.PP_SO-102 | 0 | -1.PP_SO-102 | 2600 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | TC02.40.0454 | 0454
14190816 | -1.PP_SO-102 | 0 | -1.PP_SO-102 | 3287.81 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | TC02.40.0467 | 0467

# IfcBuildingElementProxy: Tlumič hluku kruhový.LH:180x1000 (14)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Hrubá délka: 1100 mm; Hrubý poloměr: 140 mm; Hrubý průměr: 280 mm; Jmenovitá velikost vstupu: 180 mm; Jmenovitá velikost výstupu: 180 mm; Poloměr: 90 mm; Průměr: 180 mm; Tloušťka izolace: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.11.14.27; ID kategorie: TK; Kód sestavy: TC02; Nadpis OmniClass: Sound Attenuators; Název typu: 180x1000; Označení typu: 44; Popis: Tlumič hluku kruhový; Popis sestavy: Akustický
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku kruhový.LH
Classification: TC02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.1611 m2; NetVolume: 0.0641169 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 180 mm-180 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 180 mm-180 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0641169 m3; Velikost: 180-180
Jiné - Rodina: Tlumič hluku kruhový.LH; Id typu: 13868486; Rodina a typ: Tlumič hluku kruhový.LH: 180x1000; Typ: 180x1000
Name (Tlumič hluku kruhový.LH:180x1000:...) | In | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení | Tlaková ztráta (Pa)
13868295 | 4.NP_SO-102 | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | TC02.44.0157 | 0157
13878277 | 2.NP_SO-102 | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | TC02.44.0231 | 0231 | 0
13884945 | 3.NP_SO-102 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | TC02.44.0256 | 0256 | 0
13885760 | 3.NP_SO-102 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | TC02.44.0267 | 0267 | 0
13886096 | 3.NP_SO-102 | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | TC02.44.0269 | 0269 | 0
13908744 | 1.NP_SO-102 | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | TC02.44.0280 | 0280 | 0
13911012 | 1.NP_SO-102 | 1.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | TC02.44.0287 | 0287 | 0
13911617 | 1.NP_SO-102 | 1.NP_SO-102 | 2820 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 10 | ETA | TC02.44.0292 | 0292
13989022 | -1.PP_SO-102 | -1.PP_SO-102 | 3070.86 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | TC02.44.0379 | 0379 | 0
13989524 | -1.PP_SO-102 | -1.PP_SO-102 | 3077.14 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 25 | SUP | TC02.44.0381 | 0381 | 0
14028999 | 1.NP_SO-102 | 1.NP_SO-102 | 3095 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 19 | ODA | TC02.44.0399 | 0399 | 0 | Jiné - Páteřní trasa: yes
14029272 | 1.NP_SO-102 | 1.NP_SO-102 | 3095 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 12 | EHA | TC02.44.0400 | 0400 | 0 | Jiné - Páteřní trasa: yes
14056657 | 1.NP_SO-102 | 1.NP_SO-102 | 3095 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 23 | ETA | TC02.44.0422 | 0422 | 0 | Jiné - Páteřní trasa: yes
14056803 | 1.NP_SO-102 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 14 | SUP | TC02.44.0423 | 0423 | 0 | Jiné - Páteřní trasa: yes

# IfcBuildingElementProxy: Tlumič hluku kruhový.LH:225x1000 (25)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Hrubá délka: 1100 mm; Hrubý poloměr: 162.5 mm; Hrubý průměr: 325 mm; Jmenovitá velikost vstupu: 225 mm; Jmenovitá velikost výstupu: 225 mm; Poloměr: 112.5 mm; Průměr: 225 mm; Tloušťka izolace: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.11.14.27; ID kategorie: TK; Kód sestavy: TC02; Nadpis OmniClass: Sound Attenuators; Název typu: 225x1000; Označení typu: 45; Popis: Tlumič hluku kruhový; Popis sestavy: Akustický
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku kruhový.LH
Classification: TC02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.41662 m2; NetVolume: 0.0869296 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 225 mm-225 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 225 mm-225 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0869296 m3; Velikost: 225-225
Jiné - Rodina: Tlumič hluku kruhový.LH; Id typu: 13868587; Rodina a typ: Tlumič hluku kruhový.LH: 225x1000; Typ: 225x1000
Name (Tlumič hluku kruhový.LH:225x1000:...) | In | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení | Tlaková ztráta (Pa)
13868527 | 4.NP_SO-102 | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 21 | SUP | TC02.45.0159 | 0159
13868661 | 4.NP_SO-102 | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 39 | SUP | TC02.45.0160 | 0160
13868887 | 4.NP_SO-102 | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | TC02.45.0162 | 0162 | 0
13870853 | 3.NP_SO-102 | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | TC02.45.0178 | 0178 | 0
13871764 | 3.NP_SO-102 | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | TC02.45.0184 | 0184 | 0
13875045 | 2.NP_SO-102 | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 50 | SUP | TC02.45.0200 | 0200
13875206 | 2.NP_SO-102 | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 45 | SUP | TC02.45.0201 | 0201
13875266 | 2.NP_SO-102 | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 48 | SUP | TC02.45.0202 | 0202
13884987 | 3.NP_SO-102 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | TC02.45.0257 | 0257 | 0
13885064 | 3.NP_SO-102 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | TC02.45.0259 | 0259 | 0
13885615 | 3.NP_SO-102 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | TC02.45.0264 | 0264 | 0
13886374 | 3.NP_SO-102 | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | TC02.45.0270 | 0270 | 0
13928761 | 1.NP_SO-102 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 20 | SUP | TC02.45.0314 | 0314
13928945 | 1.NP_SO-102 | 1.NP_SO-102 | 3150 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | TC02.45.0315 | 0315 | 0
13935836 | 2.NP_SO-102 | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | TC02.45.0328 | 0328 | 0
13935994 | 2.NP_SO-102 | 2.NP_SO-102 | 2700 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | TC02.45.0330 | 0330
13940281 | -1.PP_SO-102 | -1.PP_SO-102 | 2350 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | TC02.45.0333 | 0333
13942223 | -1.PP_SO-102 | -1.PP_SO-102 | 2700 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | TC02.45.0334 | 0334
13960043 | -1.PP_SO-102 | -1.PP_SO-102 | 2600 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | TC02.45.0356 | 0356 | 0
13960177 | -1.PP_SO-102 | -1.PP_SO-102 | 3240 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | TC02.45.0358 | 0358 | 0
13984190 | 3.NP_SO-102 | 3.NP_SO-102 | 3099.91 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | TC02.45.0371 | 0371 | 0
13984846 | 3.NP_SO-102 | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | TC02.45.0375 | 0375 | 0
14051854 | 2.NP_SO-102 | 2.NP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | TC02.45.0419 | 0419 | 0
14052911 | 2.NP_SO-102 | 2.NP_SO-102 | 3010 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | TC02.45.0421 | 0421 | 0
14058932 | -1.PP_SO-102 | -1.PP_SO-102 | 2430 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | TC02.45.0426 | 0426 | 0

# IfcBuildingElementProxy: Tlumič hluku kruhový.LH:250x1000 (21)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Hrubá délka: 1100 mm; Hrubý poloměr: 175 mm; Hrubý průměr: 350 mm; Jmenovitá velikost vstupu: 250 mm; Jmenovitá velikost výstupu: 250 mm; Poloměr: 125 mm; Průměr: 250 mm; Tloušťka izolace: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.11.14.27; ID kategorie: TK; Kód sestavy: TC02; Nadpis OmniClass: Sound Attenuators; Název typu: 250x1000; Označení typu: 42; Popis: Tlumič hluku kruhový; Popis sestavy: Akustický
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku kruhový.LH
Classification: TC02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.56682 m2; NetVolume: 0.101115 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 250 mm-250 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 250 mm-250 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.101115 m3; Velikost: 250-250
Jiné - Rodina: Tlumič hluku kruhový.LH; Id typu: 13738742; Rodina a typ: Tlumič hluku kruhový.LH: 250x1000; Typ: 250x1000
Name (Tlumič hluku kruhový.LH:250x1000:...) | In | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Kód prvku | Označení
13867312 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | 3095 | Fáze 2 | SUP 18 | TC02.42.0146 | 0146
13867540 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | 3095 | Fáze 2 | SUP 18 | TC02.42.0149 | 0149
13867562 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | 3095 | Fáze 1 | SUP 13 | TC02.42.0150 | 0150
13867913 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | TC02.42.0153 | 0153
13870990 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | 3095 | Fáze 2 | SUP 13 | TC02.42.0179 | 0179
13875398 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | TC02.42.0203 | 0203
13875422 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | TC02.42.0204 | 0204
13875591 | 2.NP_SO-102 |  | 2.NP_SO-102 | 3095 | Fáze 2 | SUP 22 | TC02.42.0205 | 0205
13876401 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | 3040 | Fáze 1 | SUP 24 | TC02.42.0212 | 0212
13876711 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | 3040 | Fáze 1 | SUP 24 | TC02.42.0213 | 0213
13876965 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | 3040 | Fáze 1 | SUP 24 | TC02.42.0216 | 0216
13877040 | 2.NP_SO-102 |  | 2.NP_SO-102 | 3040 | Fáze 1 | SUP 55 | TC02.42.0217 | 0217
13877891 | 2.NP_SO-102 |  | 2.NP_SO-102 | 3040 | Fáze 1 | SUP 57 | TC02.42.0223 | 0223
13877919 | 2.NP_SO-102 |  | 2.NP_SO-102 | 3040 | Fáze 1 | SUP 59 | TC02.42.0224 | 0224
13878263 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | 3080 | Fáze 1 | SUP 13 | TC02.42.0230 | 0230
13884548 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | TC02.42.0252 | 0252
13884570 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | TC02.42.0253 | 0253
13884616 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | TC02.42.0254 | 0254
13885645 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | 3040 | Fáze 1 | SUP 1 | TC02.42.0265 | 0265
13885677 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | 3040 | Fáze 1 | SUP 1 | TC02.42.0266 | 0266
13982139 | 4.NP_SO-102 |  | 4.NP_SO-102 | 3180 | Fáze 1 | SUP 23 | TC02.42.0370 | 0370

# IfcBuildingElementProxy: Tlumič hluku kruhový.LH:315x1000, Tlumič hluku kruhový.LH:315x1000:13959464
In: -1.PP_SO-102
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Hrubá délka: 1100 mm; Hrubý poloměr: 207.5 mm; Hrubý průměr: 415 mm; Jmenovitá velikost vstupu: 315 mm; Jmenovitá velikost výstupu: 315 mm; Poloměr: 157.5 mm; Průměr: 315 mm; Tloušťka izolace: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.11.14.27; ID kategorie: TK; Kód sestavy: TC02; Nadpis OmniClass: Sound Attenuators; Název typu: 315x1000; Označení typu: 56; Popis: Tlumič hluku kruhový; Popis sestavy: Akustický
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku kruhový.LH
Classification: TC02 Uniformat (Uniformat); Group: ETA 7
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.98492 m2; NetVolume: 0.143053 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 315 mm-315 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 315 mm-315 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Výška od podlaží: 3080 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 7; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.143053 m3; Velikost: 315-315
Identifikační data - Kód prvku: TC02.56.0350; Označení: 0350
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku kruhový.LH; Typ: 315x1000; Id typu: 13959507; Rodina a typ: Tlumič hluku kruhový.LH: 315x1000

# IfcBuildingElementProxy: Tlumič hluku kruhový.LH:355x1000 (8)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Hrubá délka: 1100 mm; Hrubý poloměr: 227.5 mm; Hrubý průměr: 455 mm; Jmenovitá velikost vstupu: 355 mm; Jmenovitá velikost výstupu: 355 mm; Poloměr: 177.5 mm; Průměr: 355 mm; Tloušťka izolace: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.11.14.27; ID kategorie: TK; Kód sestavy: TC02; Nadpis OmniClass: Sound Attenuators; Název typu: 355x1000; Označení typu: 48; Popis: Tlumič hluku kruhový; Popis sestavy: Akustický
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku kruhový.LH
Classification: TC02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.26197 m2; NetVolume: 0.172491 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 355 mm-355 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 355 mm-355 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.172491 m3; Velikost: 355-355
Jiné - Rodina: Tlumič hluku kruhový.LH; Id typu: 13908632; Rodina a typ: Tlumič hluku kruhový.LH: 355x1000; Typ: 355x1000
Name (Tlumič hluku kruhový.LH:355x1000:...) | In | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení | Páteřní trasa
13908662 | 1.NP_SO-102 | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | TC02.48.0279 | 0279
13909348 | 1.NP_SO-102 | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | TC02.48.0282 | 0282
13911663 | 1.NP_SO-102 | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | TC02.48.0293 | 0293 | yes
13914133 | 1.NP_SO-102 | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | TC02.48.0300 | 0300
13931023 | 2.NP_SO-102 | 2.NP_SO-102 | 2940 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | TC02.48.0319 | 0319 | yes
13935801 | 2.NP_SO-102 | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | TC02.48.0327 | 0327 | yes
13939364 | 2.NP_SO-102 | 2.NP_SO-102 | 2850 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | TC02.48.0332 | 0332 | yes
14051201 | 2.NP_SO-102 | 2.NP_SO-102 | 2910 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | TC02.48.0417 | 0417 | yes

# IfcBuildingElementProxy: Tlumič hluku kruhový.LH:400x1000 (2)
In: -1.PP_SO-102
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Hrubá délka: 1100 mm; Hrubý poloměr: 250 mm; Hrubý průměr: 500 mm; Jmenovitá velikost vstupu: 400 mm; Jmenovitá velikost výstupu: 400 mm; Poloměr: 200 mm; Průměr: 400 mm; Tloušťka izolace: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.11.14.27; ID kategorie: TK; Kód sestavy: TC02; Nadpis OmniClass: Sound Attenuators; Název typu: 400x1000; Označení typu: 54; Popis: Tlumič hluku kruhový; Popis sestavy: Akustický
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku kruhový.LH
Classification: TC02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.59174 m2; NetVolume: 0.208911 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 400 mm-400 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 400 mm-400 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.208911 m3; Velikost: 400-400
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku kruhový.LH; Id typu: 13950488; Rodina a typ: Tlumič hluku kruhový.LH: 400x1000; Typ: 400x1000
Name (Tlumič hluku kruhový.LH:400x1000:...) | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13950527 | 2880 | Přívodní | Přívod vzduchu | SUP 7 | SUP | TC02.54.0340 | 0340
13950858 | 3150 | Odváděný | Zpětný vzduch | ETA 18 | ETA | TC02.54.0341 | 0341

# IfcBuildingElementProxy: Tlumič hluku kruhový.LH:Průměr × Délka (2)
In: -1.PP_SO-102
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Hrubá délka: 1100 mm; Hrubý poloměr: 175 mm; Hrubý průměr: 350 mm; Jmenovitá velikost vstupu: 250 mm; Jmenovitá velikost výstupu: 250 mm; Poloměr: 125 mm; Průměr: 250 mm; Tloušťka izolace: 50 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.11.14.27; ID kategorie: TK; Kód sestavy: TC02; Nadpis OmniClass: Sound Attenuators; Název typu: Průměr × Délka; Označení typu: 02; Popis: Tlumič hluku kruhový; Popis sestavy: Akustický
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku kruhový.LH
Classification: TC02 Uniformat (Uniformat); Group: ETA 8
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.56682 m2; NetVolume: 0.101115 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 250 mm-250 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 250 mm-250 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Výška od podlaží: 3160 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Odváděný vzduch; Název systému: ETA 8; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Objem: 0.101115 m3; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Velikost: 250-250; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm
