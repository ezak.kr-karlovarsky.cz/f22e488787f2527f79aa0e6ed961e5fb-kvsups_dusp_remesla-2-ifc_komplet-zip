Properties of the parts of a building model (IFC4), part 25 of 45

# IfcDistributionPort (8507)
Name | FlowDirection | SystemType | Group
InPort_13930337_1 | SINK | VENTILATION | SUP 9
OutPort_13864334_2 | SOURCE | VENTILATION | SUP 9
InPort_13930361_1 | SINK | VENTILATION | SUP 9
OutPort_13864334_3 | SOURCE | VENTILATION | SUP 9
Port_13864346_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13864347_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13864346_3 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14061474_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13864870_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14154952_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13864870_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13891461_1 | SINK | VENTILATION | SUP 9
OutPort_13864870_2 | SOURCE | VENTILATION | SUP 9
InPort_13891485_1 | SINK | VENTILATION | SUP 9
OutPort_13864870_3 | SOURCE | VENTILATION | SUP 9
InPort_13891509_1 | SINK | VENTILATION | SUP 9
OutPort_13864870_4 | SOURCE | VENTILATION | SUP 9
InPort_13865065_0 | SINK | VENTILATION | ETA 92
OutPort_13865063_1 | SOURCE | VENTILATION | ETA 92
InPort_13865063_2 | SINK | VENTILATION | ETA 92
OutPort_13865064_0 | SOURCE | VENTILATION | ETA 92
InPort_13865064_1 | SINK | VENTILATION | ETA 92
OutPort_13973525_1 | SOURCE | VENTILATION | ETA 92
OutPort_13865065_1 | SOURCE | VENTILATION | ETA 92
InPort_13865149_0 | SINK | VENTILATION | ETA 93
OutPort_13865147_1 | SOURCE | VENTILATION | ETA 93
InPort_13865147_2 | SINK | VENTILATION | ETA 93
OutPort_13865148_0 | SOURCE | VENTILATION | ETA 93
InPort_13865148_1 | SINK | VENTILATION | ETA 93
OutPort_13973655_1 | SOURCE | VENTILATION | ETA 93
OutPort_13865149_1 | SOURCE | VENTILATION | ETA 93
InPort_13865166_0 | SINK | VENTILATION | ETA 94
OutPort_13865164_1 | SOURCE | VENTILATION | ETA 94
InPort_13865164_2 | SINK | VENTILATION | ETA 94
OutPort_13865165_0 | SOURCE | VENTILATION | ETA 94
InPort_13865165_1 | SINK | VENTILATION | ETA 94
OutPort_13973833_1 | SOURCE | VENTILATION | ETA 94
OutPort_13865166_1 | SOURCE | VENTILATION | ETA 94
InPort_13865181_0 | SINK | VENTILATION | ETA 95
OutPort_13865179_1 | SOURCE | VENTILATION | ETA 95
InPort_13865179_2 | SINK | VENTILATION | ETA 95
OutPort_13865180_0 | SOURCE | VENTILATION | ETA 95
InPort_13865180_1 | SINK | VENTILATION | ETA 95
OutPort_13973861_1 | SOURCE | VENTILATION | ETA 95
OutPort_13865181_1 | SOURCE | VENTILATION | ETA 95
InPort_13865427_0 | SINK | VENTILATION | ETA 17
OutPort_13960004_2 | SOURCE | VENTILATION | ETA 17
InPort_14116522_1 | SINK | VENTILATION | ETA 17
OutPort_13865427_1 | SOURCE | VENTILATION | ETA 17
InPort_13865498_0 | SINK | VENTILATION | ETA 17
OutPort_13902162_1 | SOURCE | VENTILATION | ETA 17
InPort_14115615_1 | SINK | VENTILATION | ETA 17
OutPort_13865498_1 | SOURCE | VENTILATION | ETA 17
InPort_13865528_1 | SINK | VENTILATION | ETA 17
OutPort_14115432_0 | SOURCE | VENTILATION | ETA 17
InPort_14116593_1 | SINK | VENTILATION | ETA 17
OutPort_13865528_2 | SOURCE | VENTILATION | ETA 17
InPort_13960049_1 | SINK | VENTILATION | ETA 17
OutPort_13865530_0 | SOURCE | VENTILATION | ETA 17
InPort_13865530_1 | SINK | VENTILATION | ETA 17
OutPort_14116604_1 | SOURCE | VENTILATION | ETA 17
Port_13865530_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14116569_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13865827_0 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13946467_2 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13865827_1 | SOURCEANDSINK | VENTILATION | ETA 97
InPort_13865827_2 | SINK | VENTILATION | ETA 97
OutPort_13948385_1 | SOURCE | VENTILATION | ETA 97
InPort_13865827_3 | SINK | VENTILATION | ETA 97
OutPort_13948415_1 | SOURCE | VENTILATION | ETA 97
InPort_13865852_1 | SINK | VENTILATION | ETA 97
OutPort_14104005_1 | SOURCE | VENTILATION | ETA 97
Port_13865852_2 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13865966_1 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13865861_0 | SOURCEANDSINK | VENTILATION | ETA 4
Port_13865861_1 | SOURCEANDSINK | VENTILATION | ETA 4
InPort_13865861_2 | SINK | VENTILATION | ETA 4
OutPort_13948283_1 | SOURCE | VENTILATION | ETA 4
InPort_13865861_3 | SINK | VENTILATION | ETA 4
OutPort_13948313_1 | SOURCE | VENTILATION | ETA 4
Port_13865966_2 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13946425_0 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13865985_0 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14173338_1 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13865985_1 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14173339_2 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13866224_0 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13898591_1 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13866224_1 | SOURCEANDSINK | VENTILATION | ETA 97
InPort_13866224_2 | SINK | VENTILATION | ETA 97
OutPort_13948158_1 | SOURCE | VENTILATION | ETA 97
InPort_13866224_3 | SINK | VENTILATION | ETA 97
OutPort_13948182_1 | SOURCE | VENTILATION | ETA 97
InPort_13866224_4 | SINK | VENTILATION | ETA 97
OutPort_13948245_1 | SOURCE | VENTILATION | ETA 97
Port_13866250_1 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13866260_0 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13866250_2 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13898590_0 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13866250_3 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14173213_0 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13866260_1 | SOURCEANDSINK | VENTILATION | ETA 97
InPort_13866260_2 | SINK | VENTILATION | ETA 97
OutPort_13946640_1 | SOURCE | VENTILATION | ETA 97
InPort_13866260_3 | SINK | VENTILATION | ETA 97
OutPort_13946670_1 | SOURCE | VENTILATION | ETA 97
InPort_13866260_4 | SINK | VENTILATION | ETA 97
OutPort_13946748_1 | SOURCE | VENTILATION | ETA 97
InPort_13866260_5 | SINK | VENTILATION | ETA 97
OutPort_13946784_1 | SOURCE | VENTILATION | ETA 97
InPort_13866687_1 | SINK | VENTILATION | SUP 18
OutPort_13882276_1 | SOURCE | VENTILATION | SUP 18
InPort_13866787_1 | SINK | VENTILATION | SUP 18
OutPort_13866687_2 | SOURCE | VENTILATION | SUP 18
InPort_13882276_2 | SINK | VENTILATION | SUP 18
OutPort_13866689_0 | SOURCE | VENTILATION | SUP 18
InPort_13866689_1 | SINK | VENTILATION | SUP 18
OutPort_13882291_1 | SOURCE | VENTILATION | SUP 18
InPort_13867277_0 | SINK | VENTILATION | SUP 18
OutPort_13866787_2 | SOURCE | VENTILATION | SUP 18
InPort_13866810_1 | SINK | VENTILATION | SUP 18
OutPort_13879740_2 | SOURCE | VENTILATION | SUP 18
InPort_13879742_2 | SINK | VENTILATION | SUP 18
OutPort_13866810_2 | SOURCE | VENTILATION | SUP 18
InPort_13879721_1 | SINK | VENTILATION | SUP 18
OutPort_13866812_0 | SOURCE | VENTILATION | SUP 18
InPort_13866812_1 | SINK | VENTILATION | SUP 18
OutPort_13879742_1 | SOURCE | VENTILATION | SUP 18
InPort_13879943_2 | SINK | VENTILATION | SUP 18
OutPort_13866873_0 | SOURCE | VENTILATION | SUP 18
InPort_13866873_1 | SINK | VENTILATION | SUP 18
OutPort_13879964_1 | SOURCE | VENTILATION | SUP 18
InPort_13866887_0 | SINK | VENTILATION | SUP 18
OutPort_13866901_3 | SOURCE | VENTILATION | SUP 18
InPort_13879964_2 | SINK | VENTILATION | SUP 18
OutPort_13866887_1 | SOURCE | VENTILATION | SUP 18
InPort_13866902_1 | SINK | VENTILATION | SUP 18
OutPort_13866901_2 | SOURCE | VENTILATION | SUP 18
InPort_13866943_2 | SINK | VENTILATION | SUP 18
OutPort_13866902_0 | SOURCE | VENTILATION | SUP 18
InPort_13867161_2 | SINK | VENTILATION | SUP 18
OutPort_13867155_1 | SOURCE | VENTILATION | SUP 18
InPort_13867155_2 | SINK | VENTILATION | SUP 18
OutPort_13867250_1 | SOURCE | VENTILATION | SUP 18
InPort_13867250_2 | SINK | VENTILATION | SUP 18
OutPort_13867157_0 | SOURCE | VENTILATION | SUP 18
InPort_13867157_1 | SINK | VENTILATION | SUP 18
OutPort_13867252_1 | SOURCE | VENTILATION | SUP 18
InPort_13867210_1 | SINK | VENTILATION | SUP 18
OutPort_13867208_2 | SOURCE | VENTILATION | SUP 18
InPort_13867252_2 | SINK | VENTILATION | SUP 18
OutPort_13867210_0 | SOURCE | VENTILATION | SUP 18
InPort_13867281_2 | SINK | VENTILATION | SUP 18
OutPort_13867275_1 | SOURCE | VENTILATION | SUP 18
InPort_13867275_2 | SINK | VENTILATION | SUP 18
OutPort_13867279_2 | SOURCE | VENTILATION | SUP 18
InPort_13882323_1 | SINK | VENTILATION | SUP 18
OutPort_13867277_1 | SOURCE | VENTILATION | SUP 18
InPort_13867279_1 | SINK | VENTILATION | SUP 18
OutPort_13882311_0 | SOURCE | VENTILATION | SUP 18
InPort_13867312_2 | SINK | VENTILATION | SUP 18
OutPort_13867314_0 | SOURCE | VENTILATION | SUP 18
InPort_13867314_1 | SINK | VENTILATION | SUP 18
OutPort_13879721_2 | SOURCE | VENTILATION | SUP 18
InPort_13867370_1 | SINK | VENTILATION | SUP 18
OutPort_13879943_1 | SOURCE | VENTILATION | SUP 18
InPort_13867392_1 | SINK | VENTILATION | SUP 18
OutPort_13867370_2 | SOURCE | VENTILATION | SUP 18
InPort_13867372_0 | SINK | VENTILATION | SUP 18
OutPort_13867392_2 | SOURCE | VENTILATION | SUP 18
InPort_13879904_1 | SINK | VENTILATION | SUP 18
OutPort_13867372_1 | SOURCE | VENTILATION | SUP 18
InPort_13867506_1 | SINK | VENTILATION | SUP 13
OutPort_13867433_0 | SOURCE | VENTILATION | SUP 13
InPort_13867433_1 | SINK | VENTILATION | SUP 13
OutPort_13867470_2 | SOURCE | VENTILATION | SUP 13
InPort_13867447_2 | SINK | VENTILATION | SUP 13
OutPort_13867502_0 | SOURCE | VENTILATION | SUP 13
InPort_13867450_0 | SINK | VENTILATION | SUP 13
OutPort_13867462_3 | SOURCE | VENTILATION | SUP 13
InPort_13867470_1 | SINK | VENTILATION | SUP 13
OutPort_13867450_1 | SOURCE | VENTILATION | SUP 13
Port_13867462_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13869145_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13867462_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13867463_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13867463_0 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13867500_1 | SINK | VENTILATION | SUP 13
OutPort_13867506_2 | SOURCE | VENTILATION | SUP 13
InPort_13867504_2 | SINK | VENTILATION | SUP 13
OutPort_13867500_2 | SOURCE | VENTILATION | SUP 13
InPort_13867502_1 | SINK | VENTILATION | SUP 13
OutPort_13867504_1 | SOURCE | VENTILATION | SUP 13
InPort_13867542_1 | SINK | VENTILATION | SUP 18
OutPort_13867540_2 | SOURCE | VENTILATION | SUP 18
Port_13867542_0 | SOURCEANDSINK | VENTILATION | SUP 18
InPort_13882745_1 | SINK | VENTILATION | SUP 18
OutPort_13867542_2 | SOURCE | VENTILATION | SUP 18
InPort_13882769_1 | SINK | VENTILATION | SUP 18
OutPort_13867542_3 | SOURCE | VENTILATION | SUP 18
InPort_13882797_1 | SINK | VENTILATION | SUP 18
OutPort_13867542_4 | SOURCE | VENTILATION | SUP 18
InPort_13867562_1 | SINK | VENTILATION | SUP 13
OutPort_13867568_2 | SOURCE | VENTILATION | SUP 13
InPort_13880035_1 | SINK | VENTILATION | SUP 13
OutPort_13867562_2 | SOURCE | VENTILATION | SUP 13
InPort_13867564_0 | SINK | VENTILATION | SUP 13
OutPort_13880035_2 | SOURCE | VENTILATION | SUP 13
Port_13867564_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13881819_1 | SINK | VENTILATION | SUP 13
OutPort_13867564_2 | SOURCE | VENTILATION | SUP 13
InPort_13881847_1 | SINK | VENTILATION | SUP 13
OutPort_13867564_3 | SOURCE | VENTILATION | SUP 13
InPort_13881867_1 | SINK | VENTILATION | SUP 13
OutPort_13867564_4 | SOURCE | VENTILATION | SUP 13
InPort_13867712_1 | SINK | VENTILATION | SUP 24
OutPort_13867718_2 | SOURCE | VENTILATION | SUP 24
InPort_13867716_2 | SINK | VENTILATION | SUP 24
OutPort_13867712_2 | SOURCE | VENTILATION | SUP 24
InPort_13867714_1 | SINK | VENTILATION | SUP 24
OutPort_13867716_1 | SOURCE | VENTILATION | SUP 24
InPort_13867751_2 | SINK | VENTILATION | SUP 24
OutPort_13867753_1 | SOURCE | VENTILATION | SUP 24
InPort_13867919_2 | SINK | VENTILATION | SUP 24
OutPort_13867913_1 | SOURCE | VENTILATION | SUP 24
InPort_13867913_2 | SINK | VENTILATION | SUP 24
OutPort_13867917_2 | SOURCE | VENTILATION | SUP 24
InPort_13867917_1 | SINK | VENTILATION | SUP 24
OutPort_13867915_1 | SOURCE | VENTILATION | SUP 24
InPort_13868040_1 | SINK | VENTILATION | SUP 24
OutPort_13868046_2 | SOURCE | VENTILATION | SUP 24
InPort_13868044_2 | SINK | VENTILATION | SUP 24
OutPort_13868040_2 | SOURCE | VENTILATION | SUP 24
InPort_13868042_1 | SINK | VENTILATION | SUP 24
OutPort_13868044_1 | SOURCE | VENTILATION | SUP 24
InPort_13868090_1 | SINK | VENTILATION | SUP 24
OutPort_13868092_1 | SOURCE | VENTILATION | SUP 24
InPort_13880571_0 | SINK | VENTILATION | SUP 24
OutPort_13868090_2 | SOURCE | VENTILATION | SUP 24
InPort_13868178_1 | SINK | VENTILATION | SUP 3
OutPort_13868178_2 | SOURCE | VENTILATION | SUP 3
Port_13868192_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14123656_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868192_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868194_1 | SOURCEANDSINK | VENTILATION | SUP 16
Port_13868194_2 | SOURCEANDSINK | VENTILATION | SUP 16
Port_13868196_1 | SOURCEANDSINK | VENTILATION | SUP 10
Port_13868196_2 | SOURCEANDSINK | VENTILATION | SUP 10
Port_13868295_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868626_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868295_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868628_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868349_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14123627_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868349_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868628_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13868419_1 | SINK | VENTILATION | SUP 36
OutPort_13868419_2 | SOURCE | VENTILATION | SUP 36
Port_13868421_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868423_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868423_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868425_2 | SOURCEANDSINK | VENTILATION | SUP 21
Port_13868527_2 | SOURCEANDSINK | VENTILATION | SUP 21
Port_13868529_1 | SOURCEANDSINK | VENTILATION | SUP 21
Port_13868661_2 | SOURCEANDSINK | VENTILATION | SUP 39
Port_13868663_0 | SOURCEANDSINK | VENTILATION | SUP 39
Port_13868663_1 | SOURCEANDSINK | VENTILATION | SUP 39
InPort_13881340_1 | SINK | VENTILATION | SUP 39
OutPort_13868663_2 | SOURCE | VENTILATION | SUP 39
InPort_13881376_1 | SINK | VENTILATION | SUP 39
OutPort_13868663_3 | SOURCE | VENTILATION | SUP 39
InPort_13881404_1 | SINK | VENTILATION | SUP 39
OutPort_13868663_4 | SOURCE | VENTILATION | SUP 39
Port_13868706_2 | SOURCEANDSINK | VENTILATION | SUP 39
Port_13868789_0 | SOURCEANDSINK | VENTILATION | SUP 39
Port_13868710_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868724_3 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868710_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868732_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868724_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868725_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868725_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868760_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13868787_1 | SINK | VENTILATION | SUP 38
OutPort_13868787_2 | SOURCE | VENTILATION | SUP 38
Port_13868789_1 | SOURCEANDSINK | VENTILATION | SUP 39
Port_13868791_1 | SOURCEANDSINK | VENTILATION | SUP 39
Port_13868791_2 | SOURCEANDSINK | VENTILATION | SUP 39
Port_13868793_2 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13868889_0 | SINK | VENTILATION | SUP 24
OutPort_13868887_2 | SOURCE | VENTILATION | SUP 24
Port_13868889_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13881535_1 | SINK | VENTILATION | SUP 24
OutPort_13868889_2 | SOURCE | VENTILATION | SUP 24
InPort_13881563_1 | SINK | VENTILATION | SUP 24
OutPort_13868889_3 | SOURCE | VENTILATION | SUP 24
InPort_13881591_1 | SINK | VENTILATION | SUP 24
OutPort_13868889_4 | SOURCE | VENTILATION | SUP 24
InPort_13868915_1 | SINK | VENTILATION | SUP 24
OutPort_13868921_2 | SOURCE | VENTILATION | SUP 24
InPort_13868919_2 | SINK | VENTILATION | SUP 24
OutPort_13868915_2 | SOURCE | VENTILATION | SUP 24
InPort_13868917_1 | SINK | VENTILATION | SUP 24
OutPort_13868919_1 | SOURCE | VENTILATION | SUP 24
Port_13869130_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13869144_3 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13869130_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13981727_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13869144_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13869243_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13869145_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13869243_2 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13869296_1 | SINK | VENTILATION | SUP 41
OutPort_13869296_2 | SOURCE | VENTILATION | SUP 41
Port_13869298_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13869323_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13869298_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13982822_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13869321_1 | SOURCEANDSINK | VENTILATION | SUP 40
Port_13869352_0 | SOURCEANDSINK | VENTILATION | SUP 40
Port_13869321_2 | SOURCEANDSINK | VENTILATION | SUP 40
Port_13869323_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13869350_1 | SOURCEANDSINK | VENTILATION | SUP 40
Port_13869356_2 | SOURCEANDSINK | VENTILATION | SUP 40
Port_13869350_2 | SOURCEANDSINK | VENTILATION | SUP 40
Port_13869354_2 | SOURCEANDSINK | VENTILATION | SUP 40
Port_13869352_1 | SOURCEANDSINK | VENTILATION | SUP 40
Port_13869354_1 | SOURCEANDSINK | VENTILATION | SUP 40
InPort_13870809_1 | SINK | VENTILATION | SUP 13
OutPort_13870819_2 | SOURCE | VENTILATION | SUP 13
InPort_13870817_2 | SINK | VENTILATION | SUP 13
OutPort_13870809_2 | SOURCE | VENTILATION | SUP 13
InPort_13870815_1 | SINK | VENTILATION | SUP 13
OutPort_13870817_1 | SOURCE | VENTILATION | SUP 13
InPort_13870855_1 | SINK | VENTILATION | SUP 13
OutPort_13870853_2 | SOURCE | VENTILATION | SUP 13
InPort_13870990_2 | SINK | VENTILATION | SUP 13
OutPort_13871010_1 | SOURCE | VENTILATION | SUP 13
InPort_13871080_0 | SINK | VENTILATION | SUP 13
OutPort_13871402_2 | SOURCE | VENTILATION | SUP 13
InPort_13871308_1 | SINK | VENTILATION | SUP 13
OutPort_13871080_1 | SOURCE | VENTILATION | SUP 13
InPort_13871107_1 | SINK | VENTILATION | SUP 13
OutPort_13871108_1 | SOURCE | VENTILATION | SUP 13
InPort_13871404_0 | SINK | VENTILATION | SUP 13
OutPort_13871107_3 | SOURCE | VENTILATION | SUP 13
InPort_13871203_1 | SINK | VENTILATION | SUP 13
OutPort_13871226_2 | SOURCE | VENTILATION | SUP 13
InPort_13871228_2 | SINK | VENTILATION | SUP 13
OutPort_13871203_2 | SOURCE | VENTILATION | SUP 13
InPort_13871207_1 | SINK | VENTILATION | SUP 13
OutPort_13871228_1 | SOURCE | VENTILATION | SUP 13
InPort_13871300_0 | SINK | VENTILATION | SUP 13
OutPort_13871370_1 | SOURCE | VENTILATION | SUP 13
Port_13871300_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13979528_1 | SINK | VENTILATION | SUP 13
OutPort_13871300_2 | SOURCE | VENTILATION | SUP 13
InPort_13871372_0 | SINK | VENTILATION | SUP 13
OutPort_13871308_2 | SOURCE | VENTILATION | SUP 13
InPort_13871370_2 | SINK | VENTILATION | SUP 13
OutPort_13871372_1 | SOURCE | VENTILATION | SUP 13
InPort_13871402_1 | SINK | VENTILATION | SUP 13
OutPort_13871404_1 | SOURCE | VENTILATION | SUP 13
InPort_13871590_1 | SINK | VENTILATION | SUP 13
OutPort_13871479_0 | SOURCE | VENTILATION | SUP 13
InPort_13871479_1 | SINK | VENTILATION | SUP 13
OutPort_13871510_1 | SOURCE | VENTILATION | SUP 13
InPort_13871485_1 | SINK | VENTILATION | SUP 13
OutPort_13871586_0 | SOURCE | VENTILATION | SUP 13
InPort_13871792_0 | SINK | VENTILATION | SUP 13
OutPort_13871485_2 | SOURCE | VENTILATION | SUP 13
InPort_13871488_0 | SINK | VENTILATION | SUP 13
OutPort_13871502_3 | SOURCE | VENTILATION | SUP 13
InPort_13871510_2 | SINK | VENTILATION | SUP 13
OutPort_13871488_1 | SOURCE | VENTILATION | SUP 13
Port_13871502_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14179561_0 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13871546_1 | SINK | VENTILATION | SUP 13
OutPort_13871590_2 | SOURCE | VENTILATION | SUP 13
InPort_13871588_2 | SINK | VENTILATION | SUP 13
OutPort_13871546_2 | SOURCE | VENTILATION | SUP 13
InPort_13871586_1 | SINK | VENTILATION | SUP 13
OutPort_13871588_1 | SOURCE | VENTILATION | SUP 13
InPort_13871764_2 | SINK | VENTILATION | SUP 13
OutPort_13871792_1 | SOURCE | VENTILATION | SUP 13
Port_13873057_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13873058_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13873057_3 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14038190_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13873058_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14164774_0 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13874826_0 | SINK | VENTILATION | SUP 13
OutPort_13878092_1 | SOURCE | VENTILATION | SUP 13
InPort_13874854_2 | SINK | VENTILATION | SUP 13
OutPort_13874826_1 | SOURCE | VENTILATION | SUP 13
Port_13874839_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13874840_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13878012_0 | SINK | VENTILATION | SUP 13
OutPort_13874839_3 | SOURCE | VENTILATION | SUP 13
InPort_13874848_0 | SINK | VENTILATION | SUP 13
OutPort_13874854_1 | SOURCE | VENTILATION | SUP 13
Port_13874848_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13890423_1 | SINK | VENTILATION | SUP 13
OutPort_13874848_2 | SOURCE | VENTILATION | SUP 13
InPort_13890496_1 | SINK | VENTILATION | SUP 13
OutPort_13874848_3 | SOURCE | VENTILATION | SUP 13
Port_13875045_2 | SOURCEANDSINK | VENTILATION | SUP 50
Port_13875085_1 | SOURCEANDSINK | VENTILATION | SUP 50
Port_13875206_2 | SOURCEANDSINK | VENTILATION | SUP 45
Port_13875226_1 | SOURCEANDSINK | VENTILATION | SUP 45
Port_13875266_2 | SOURCEANDSINK | VENTILATION | SUP 48
Port_13875284_1 | SOURCEANDSINK | VENTILATION | SUP 48
InPort_13969148_1 | SINK | VENTILATION | SUP 24
OutPort_13875398_1 | SOURCE | VENTILATION | SUP 24
InPort_13875398_2 | SINK | VENTILATION | SUP 24
OutPort_13875488_1 | SOURCE | VENTILATION | SUP 24
InPort_13875488_2 | SINK | VENTILATION | SUP 24
OutPort_13875400_1 | SOURCE | VENTILATION | SUP 24
InPort_13875507_1 | SINK | VENTILATION | SUP 24
OutPort_13875422_1 | SOURCE | VENTILATION | SUP 24
InPort_13875422_2 | SINK | VENTILATION | SUP 24
OutPort_13875509_1 | SOURCE | VENTILATION | SUP 24
InPort_13875509_2 | SINK | VENTILATION | SUP 24
OutPort_13875424_0 | SOURCE | VENTILATION | SUP 24
InPort_13875424_1 | SINK | VENTILATION | SUP 24
InPort_13968982_1 | SINK | VENTILATION | SUP 24
OutPort_13875424_2 | SOURCE | VENTILATION | SUP 24
InPort_13969006_1 | SINK | VENTILATION | SUP 24
OutPort_13875424_3 | SOURCE | VENTILATION | SUP 24
InPort_13969040_1 | SINK | VENTILATION | SUP 24
OutPort_13875424_4 | SOURCE | VENTILATION | SUP 24
Port_13875548_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13875898_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13875591_1 | SOURCEANDSINK | VENTILATION | SUP 22
Port_13875629_2 | SOURCEANDSINK | VENTILATION | SUP 22
Port_13875591_2 | SOURCEANDSINK | VENTILATION | SUP 22
Port_13875627_2 | SOURCEANDSINK | VENTILATION | SUP 22
Port_13875623_1 | SOURCEANDSINK | VENTILATION | SUP 22
Port_13875627_1 | SOURCEANDSINK | VENTILATION | SUP 22
InPort_13875772_1 | SINK | VENTILATION | SUP 24
OutPort_13875800_2 | SOURCE | VENTILATION | SUP 24
InPort_13875798_2 | SINK | VENTILATION | SUP 24
OutPort_13875772_2 | SOURCE | VENTILATION | SUP 24
InPort_13875796_1 | SINK | VENTILATION | SUP 24
OutPort_13875798_1 | SOURCE | VENTILATION | SUP 24
InPort_13875834_1 | SINK | VENTILATION | SUP 24
OutPort_13875848_2 | SOURCE | VENTILATION | SUP 24
InPort_13875846_2 | SINK | VENTILATION | SUP 24
OutPort_13875834_2 | SOURCE | VENTILATION | SUP 24
InPort_13875844_1 | SINK | VENTILATION | SUP 24
OutPort_13875846_1 | SOURCE | VENTILATION | SUP 24
InPort_13875870_1 | SINK | VENTILATION | SUP 42
OutPort_13875870_2 | SOURCE | VENTILATION | SUP 42
Port_13875898_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13875900_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13875900_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13875902_2 | SOURCEANDSINK | VENTILATION | SUP 22
InPort_13876012_1 | SINK | VENTILATION | SUP 49
OutPort_13876012_2 | SOURCE | VENTILATION | SUP 49
Port_13876026_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13876229_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13876092_1 | SINK | VENTILATION | SUP 46
OutPort_13876092_2 | SOURCE | VENTILATION | SUP 46
Port_13876106_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13876233_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13876142_1 | SINK | VENTILATION | SUP 47
OutPort_13876142_2 | SOURCE | VENTILATION | SUP 47
Port_13876166_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13876237_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13876227_2 | SOURCEANDSINK | VENTILATION | SUP 50
Port_13876229_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13876231_2 | SOURCEANDSINK | VENTILATION | SUP 45
Port_13876233_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13876235_2 | SOURCEANDSINK | VENTILATION | SUP 48
Port_13876237_2 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13876401_2 | SINK | VENTILATION | SUP 24
OutPort_13876423_0 | SOURCE | VENTILATION | SUP 24
InPort_13876423_1 | SINK | VENTILATION | SUP 24
OutPort_14150848_2 | SOURCE | VENTILATION | SUP 24
InPort_14150848_1 | SINK | VENTILATION | SUP 24
OutPort_13876536_0 | SOURCE | VENTILATION | SUP 24
InPort_13876536_1 | SINK | VENTILATION | SUP 24
OutPort_14150850_1 | SOURCE | VENTILATION | SUP 24
InPort_13877822_1 | SINK | VENTILATION | SUP 24
OutPort_13876681_0 | SOURCE | VENTILATION | SUP 24
InPort_13876681_1 | SINK | VENTILATION | SUP 24
OutPort_13876763_1 | SOURCE | VENTILATION | SUP 24
InPort_13877820_2 | SINK | VENTILATION | SUP 24
OutPort_13876711_1 | SOURCE | VENTILATION | SUP 24
InPort_13876711_2 | SINK | VENTILATION | SUP 24
OutPort_13877822_2 | SOURCE | VENTILATION | SUP 24
InPort_13876814_1 | SINK | VENTILATION | SUP 24
OutPort_13876755_0 | SOURCE | VENTILATION | SUP 24
InPort_13876755_1 | SINK | VENTILATION | SUP 24
OutPort_13876782_2 | SOURCE | VENTILATION | SUP 24
InPort_13876763_2 | SINK | VENTILATION | SUP 24
OutPort_13876810_0 | SOURCE | VENTILATION | SUP 24
InPort_13876766_0 | SINK | VENTILATION | SUP 24
OutPort_13876778_3 | SOURCE | VENTILATION | SUP 24
InPort_13876782_1 | SINK | VENTILATION | SUP 24
OutPort_13876766_1 | SOURCE | VENTILATION | SUP 24
InPort_14150871_1 | SINK | VENTILATION | SUP 24
OutPort_13876778_1 | SOURCE | VENTILATION | SUP 24
InPort_13876778_2 | SINK | VENTILATION | SUP 24
OutPort_13876779_1 | SOURCE | VENTILATION | SUP 24
InPort_13876808_1 | SINK | VENTILATION | SUP 24
OutPort_13876814_2 | SOURCE | VENTILATION | SUP 24
InPort_13876812_2 | SINK | VENTILATION | SUP 24
OutPort_13876808_2 | SOURCE | VENTILATION | SUP 24
InPort_13876810_1 | SINK | VENTILATION | SUP 24
OutPort_13876812_1 | SOURCE | VENTILATION | SUP 24
InPort_13876929_1 | SINK | VENTILATION | SUP 24
OutPort_13877598_2 | SOURCE | VENTILATION | SUP 24
InPort_13877600_2 | SINK | VENTILATION | SUP 24
OutPort_13876929_2 | SOURCE | VENTILATION | SUP 24
InPort_13876931_1 | SINK | VENTILATION | SUP 24
OutPort_13877600_1 | SOURCE | VENTILATION | SUP 24
InPort_13877824_2 | SINK | VENTILATION | SUP 24
OutPort_13876965_1 | SOURCE | VENTILATION | SUP 24
InPort_13876965_2 | SINK | VENTILATION | SUP 24
OutPort_13877826_2 | SOURCE | VENTILATION | SUP 24
InPort_13877826_1 | SINK | VENTILATION | SUP 24
OutPort_13876967_1 | SOURCE | VENTILATION | SUP 24
Port_13876997_0 | SOURCEANDSINK | VENTILATION | SUP 55
Port_13877618_1 | SOURCEANDSINK | VENTILATION | SUP 55
Port_13876997_1 | SOURCEANDSINK | VENTILATION | SUP 55
Port_13877367_1 | SOURCEANDSINK | VENTILATION | SUP 55
Port_13877040_1 | SOURCEANDSINK | VENTILATION | SUP 55
Port_13877828_2 | SOURCEANDSINK | VENTILATION | SUP 55
Port_13877040_2 | SOURCEANDSINK | VENTILATION | SUP 55
Port_13877830_2 | SOURCEANDSINK | VENTILATION | SUP 55
Port_13877042_0 | SOURCEANDSINK | VENTILATION | SUP 55
Port_13877367_2 | SOURCEANDSINK | VENTILATION | SUP 55
Port_13877042_1 | SOURCEANDSINK | VENTILATION | SUP 55
Port_13877830_1 | SOURCEANDSINK | VENTILATION | SUP 55
Port_13877285_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877286_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877294_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877658_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877365_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877614_0 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13877537_1 | SINK | VENTILATION | SUP 24
OutPort_14150873_2 | SOURCE | VENTILATION | SUP 24
InPort_14150850_2 | SINK | VENTILATION | SUP 24
OutPort_13877537_2 | SOURCE | VENTILATION | SUP 24
InPort_13877539_0 | SINK | VENTILATION | SUP 24
OutPort_14150871_2 | SOURCE | VENTILATION | SUP 24
InPort_14150873_1 | SINK | VENTILATION | SUP 24
OutPort_13877539_1 | SOURCE | VENTILATION | SUP 24
InPort_13877612_1 | SINK | VENTILATION | SUP 56
OutPort_13877612_2 | SOURCE | VENTILATION | SUP 56
Port_13877614_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877616_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877616_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877618_2 | SOURCEANDSINK | VENTILATION | SUP 55
InPort_13877656_1 | SINK | VENTILATION | SUP 58
OutPort_13877656_2 | SOURCE | VENTILATION | SUP 58
Port_13877658_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877660_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877660_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877662_2 | SOURCEANDSINK | VENTILATION | SUP 57
InPort_13877719_1 | SINK | VENTILATION | SUP 60
OutPort_13877719_2 | SOURCE | VENTILATION | SUP 60
Port_13877721_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877723_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877723_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877725_2 | SOURCEANDSINK | VENTILATION | SUP 59
InPort_13877785_1 | SINK | VENTILATION | SUP 24
OutPort_13877783_2 | SOURCE | VENTILATION | SUP 24
Port_13877891_1 | SOURCEANDSINK | VENTILATION | SUP 57
Port_13877897_2 | SOURCEANDSINK | VENTILATION | SUP 57
Port_13877891_2 | SOURCEANDSINK | VENTILATION | SUP 57
Port_13877895_2 | SOURCEANDSINK | VENTILATION | SUP 57
Port_13877893_1 | SOURCEANDSINK | VENTILATION | SUP 57
Port_13877895_1 | SOURCEANDSINK | VENTILATION | SUP 57
Port_13877919_1 | SOURCEANDSINK | VENTILATION | SUP 59
Port_13877925_2 | SOURCEANDSINK | VENTILATION | SUP 59
Port_13877919_2 | SOURCEANDSINK | VENTILATION | SUP 59
Port_13877923_2 | SOURCEANDSINK | VENTILATION | SUP 59
Port_13877921_1 | SOURCEANDSINK | VENTILATION | SUP 59
Port_13877923_1 | SOURCEANDSINK | VENTILATION | SUP 59
OutPort_13877942_1 | SOURCE | VENTILATION | SUP 24
InPort_13877942_2 | SINK | VENTILATION | SUP 24
OutPort_13877944_1 | SOURCE | VENTILATION | SUP 24
InPort_13878010_1 | SINK | VENTILATION | SUP 13
OutPort_13878012_1 | SOURCE | VENTILATION | SUP 13
InPort_13878094_0 | SINK | VENTILATION | SUP 13
OutPort_13878010_2 | SOURCE | VENTILATION | SUP 13
InPort_13878092_2 | SINK | VENTILATION | SUP 13
OutPort_13878094_1 | SOURCE | VENTILATION | SUP 13
InPort_13878159_1 | SINK | VENTILATION | SUP 13
OutPort_13878151_2 | SOURCE | VENTILATION | SUP 13
InPort_13878209_1 | SINK | VENTILATION | SUP 13
OutPort_13878389_1 | SOURCE | VENTILATION | SUP 13
InPort_13878391_1 | SINK | VENTILATION | SUP 13
OutPort_13878209_2 | SOURCE | VENTILATION | SUP 13
InPort_13878211_1 | SINK | VENTILATION | SUP 13
OutPort_13878391_2 | SOURCE | VENTILATION | SUP 13
InPort_13878263_1 | SINK | VENTILATION | SUP 13
OutPort_13878457_2 | SOURCE | VENTILATION | SUP 13
InPort_13878265_1 | SINK | VENTILATION | SUP 13
OutPort_13878263_2 | SOURCE | VENTILATION | SUP 13
Port_13878265_0 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13890081_1 | SINK | VENTILATION | SUP 13
OutPort_13878265_2 | SOURCE | VENTILATION | SUP 13
InPort_13890117_1 | SINK | VENTILATION | SUP 13
OutPort_13878265_3 | SOURCE | VENTILATION | SUP 13
InPort_13890141_1 | SINK | VENTILATION | SUP 13
OutPort_13878265_4 | SOURCE | VENTILATION | SUP 13
InPort_13878277_2 | SINK | VENTILATION | SUP 13
OutPort_13878279_1 | SOURCE | VENTILATION | SUP 13
InPort_13878419_0 | SINK | VENTILATION | SUP 13
OutPort_13878431_2 | SOURCE | VENTILATION | SUP 13
InPort_13878457_1 | SINK | VENTILATION | SUP 13
OutPort_13878419_1 | SOURCE | VENTILATION | SUP 13
InPort_13879616_1 | SINK | VENTILATION | SUP 18
OutPort_13879780_0 | SOURCE | VENTILATION | SUP 18
InPort_13879766_0 | SINK | VENTILATION | SUP 18
OutPort_13879779_3 | SOURCE | VENTILATION | SUP 18
InPort_13879787_2 | SINK | VENTILATION | SUP 18
OutPort_13879766_1 | SOURCE | VENTILATION | SUP 18
InPort_13879780_1 | SINK | VENTILATION | SUP 18
OutPort_13879779_2 | SOURCE | VENTILATION | SUP 18
InPort_13880569_2 | SINK | VENTILATION | SUP 24
OutPort_13880571_1 | SOURCE | VENTILATION | SUP 24
InPort_13882291_2 | SINK | VENTILATION | SUP 18
OutPort_13882279_1 | SOURCE | VENTILATION | SUP 18
InPort_13882311_1 | SINK | VENTILATION | SUP 18
OutPort_13882323_2 | SOURCE | VENTILATION | SUP 18
InPort_13883718_1 | SINK | VENTILATION | SUP 1
OutPort_13885647_4 | SOURCE | VENTILATION | SUP 1
InPort_13883753_1 | SINK | VENTILATION | SUP 1
OutPort_13885647_3 | SOURCE | VENTILATION | SUP 1
InPort_13883781_1 | SINK | VENTILATION | SUP 1
OutPort_13885647_2 | SOURCE | VENTILATION | SUP 1
InPort_13883809_1 | SINK | VENTILATION | SUP 1
OutPort_13885679_4 | SOURCE | VENTILATION | SUP 1
InPort_13883833_1 | SINK | VENTILATION | SUP 1
OutPort_13885679_3 | SOURCE | VENTILATION | SUP 1
InPort_13883869_1 | SINK | VENTILATION | SUP 1
OutPort_13885679_2 | SOURCE | VENTILATION | SUP 1
InPort_13884107_1 | SINK | VENTILATION | SUP 24
OutPort_13884376_1 | SOURCE | VENTILATION | SUP 24
InPort_13884378_1 | SINK | VENTILATION | SUP 24
OutPort_13884107_2 | SOURCE | VENTILATION | SUP 24
InPort_13884141_0 | SINK | VENTILATION | SUP 24
OutPort_13884374_2 | SOURCE | VENTILATION | SUP 24
InPort_13884376_2 | SINK | VENTILATION | SUP 24
OutPort_13884141_1 | SOURCE | VENTILATION | SUP 24
InPort_13884245_1 | SINK | VENTILATION | SUP 24
OutPort_13884460_1 | SOURCE | VENTILATION | SUP 24
InPort_13884462_1 | SINK | VENTILATION | SUP 24
OutPort_13884245_2 | SOURCE | VENTILATION | SUP 24
InPort_13884263_1 | SINK | VENTILATION | SUP 24
OutPort_13884462_2 | SOURCE | VENTILATION | SUP 24
InPort_13884402_1 | SINK | VENTILATION | SUP 24
OutPort_13884430_0 | SOURCE | VENTILATION | SUP 24
InPort_13884572_0 | SINK | VENTILATION | SUP 24
OutPort_13884402_2 | SOURCE | VENTILATION | SUP 24
InPort_13884428_1 | SINK | VENTILATION | SUP 24
OutPort_13884434_2 | SOURCE | VENTILATION | SUP 24
InPort_13884432_2 | SINK | VENTILATION | SUP 24
OutPort_13884428_2 | SOURCE | VENTILATION | SUP 24
InPort_13884430_1 | SINK | VENTILATION | SUP 24
OutPort_13884432_1 | SOURCE | VENTILATION | SUP 24
InPort_13884554_2 | SINK | VENTILATION | SUP 24
OutPort_13884548_1 | SOURCE | VENTILATION | SUP 24
InPort_13884548_2 | SINK | VENTILATION | SUP 24
OutPort_13884552_2 | SOURCE | VENTILATION | SUP 24
InPort_13884552_1 | SINK | VENTILATION | SUP 24
OutPort_13884550_1 | SOURCE | VENTILATION | SUP 24
InPort_13884576_2 | SINK | VENTILATION | SUP 24
OutPort_13884570_1 | SOURCE | VENTILATION | SUP 24
InPort_13884570_2 | SINK | VENTILATION | SUP 24
OutPort_13884574_2 | SOURCE | VENTILATION | SUP 24
InPort_13884574_1 | SINK | VENTILATION | SUP 24
OutPort_13884572_1 | SOURCE | VENTILATION | SUP 24
InPort_13884616_1 | SINK | VENTILATION | SUP 24
OutPort_13884652_2 | SOURCE | VENTILATION | SUP 24
InPort_13887690_1 | SINK | VENTILATION | SUP 24
OutPort_13884616_2 | SOURCE | VENTILATION | SUP 24
InPort_13884648_0 | SINK | VENTILATION | SUP 24
OutPort_13887690_2 | SOURCE | VENTILATION | SUP 24
Port_13884648_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13887720_1 | SINK | VENTILATION | SUP 24
OutPort_13884648_2 | SOURCE | VENTILATION | SUP 24
InPort_13887746_1 | SINK | VENTILATION | SUP 24
OutPort_13884648_3 | SOURCE | VENTILATION | SUP 24
InPort_13887766_1 | SINK | VENTILATION | SUP 24
OutPort_13884648_4 | SOURCE | VENTILATION | SUP 24
InPort_13884908_1 | SINK | VENTILATION | SUP 1
OutPort_13884914_2 | SOURCE | VENTILATION | SUP 1
InPort_13884912_2 | SINK | VENTILATION | SUP 1
OutPort_13884908_2 | SOURCE | VENTILATION | SUP 1
InPort_13884910_1 | SINK | VENTILATION | SUP 1
OutPort_13884912_1 | SOURCE | VENTILATION | SUP 1
InPort_13884951_2 | SINK | VENTILATION | SUP 1
OutPort_13884945_1 | SOURCE | VENTILATION | SUP 1
InPort_13884945_2 | SINK | VENTILATION | SUP 1
OutPort_13884949_2 | SOURCE | VENTILATION | SUP 1
InPort_13884949_1 | SINK | VENTILATION | SUP 1
OutPort_13884947_1 | SOURCE | VENTILATION | SUP 1
InPort_13885164_1 | SINK | VENTILATION | SUP 1
OutPort_13884987_1 | SOURCE | VENTILATION | SUP 1
InPort_13884987_2 | SINK | VENTILATION | SUP 1
OutPort_13885166_1 | SOURCE | VENTILATION | SUP 1
InPort_13885166_2 | SINK | VENTILATION | SUP 1
OutPort_13884989_1 | SOURCE | VENTILATION | SUP 1
InPort_13885011_1 | SINK | VENTILATION | SUP 1
OutPort_13885168_1 | SOURCE | VENTILATION | SUP 1
InPort_13885170_1 | SINK | VENTILATION | SUP 1
OutPort_13885011_2 | SOURCE | VENTILATION | SUP 1
InPort_13885013_1 | SINK | VENTILATION | SUP 1
OutPort_13885170_2 | SOURCE | VENTILATION | SUP 1
InPort_13885178_1 | SINK | VENTILATION | SUP 1
OutPort_13885064_1 | SOURCE | VENTILATION | SUP 1
InPort_13885064_2 | SINK | VENTILATION | SUP 1
OutPort_13885066_1 | SOURCE | VENTILATION | SUP 1
InPort_13885066_0 | SINK | VENTILATION | SUP 1
OutPort_13885176_2 | SOURCE | VENTILATION | SUP 1
InPort_13885111_1 | SINK | VENTILATION | SUP 1
OutPort_13885180_1 | SOURCE | VENTILATION | SUP 1
InPort_13885182_1 | SINK | VENTILATION | SUP 1
OutPort_13885111_2 | SOURCE | VENTILATION | SUP 1
InPort_13885113_1 | SINK | VENTILATION | SUP 1
OutPort_13885182_2 | SOURCE | VENTILATION | SUP 1
InPort_13885403_1 | SINK | VENTILATION | SUP 1
OutPort_13885409_2 | SOURCE | VENTILATION | SUP 1
InPort_13885407_2 | SINK | VENTILATION | SUP 1
OutPort_13885403_2 | SOURCE | VENTILATION | SUP 1
InPort_13885405_1 | SINK | VENTILATION | SUP 1
OutPort_13885407_1 | SOURCE | VENTILATION | SUP 1
InPort_13885439_1 | SINK | VENTILATION | SUP 1
OutPort_13885482_2 | SOURCE | VENTILATION | SUP 1
InPort_13885484_2 | SINK | VENTILATION | SUP 1
OutPort_13885439_2 | SOURCE | VENTILATION | SUP 1
InPort_13885443_1 | SINK | VENTILATION | SUP 1
OutPort_13885484_1 | SOURCE | VENTILATION | SUP 1
InPort_13885545_1 | SINK | VENTILATION | SUP 1
OutPort_13885575_1 | SOURCE | VENTILATION | SUP 1
InPort_13885577_1 | SINK | VENTILATION | SUP 1
OutPort_13885545_2 | SOURCE | VENTILATION | SUP 1
InPort_13885547_1 | SINK | VENTILATION | SUP 1
OutPort_13885577_2 | SOURCE | VENTILATION | SUP 1
InPort_13885621_2 | SINK | VENTILATION | SUP 1
OutPort_13885615_1 | SOURCE | VENTILATION | SUP 1
InPort_13885615_2 | SINK | VENTILATION | SUP 1
OutPort_13885619_2 | SOURCE | VENTILATION | SUP 1
InPort_13885619_1 | SINK | VENTILATION | SUP 1
OutPort_13885617_1 | SOURCE | VENTILATION | SUP 1
InPort_13885645_1 | SINK | VENTILATION | SUP 1
OutPort_13885651_2 | SOURCE | VENTILATION | SUP 1
InPort_13885649_2 | SINK | VENTILATION | SUP 1
OutPort_13885645_2 | SOURCE | VENTILATION | SUP 1
Port_13885647_0 | SOURCEANDSINK | VENTILATION | SUP 1
InPort_13885647_1 | SINK | VENTILATION | SUP 1
OutPort_13885649_1 | SOURCE | VENTILATION | SUP 1
InPort_13885677_1 | SINK | VENTILATION | SUP 1
OutPort_13885683_2 | SOURCE | VENTILATION | SUP 1
InPort_13885681_2 | SINK | VENTILATION | SUP 1
OutPort_13885677_2 | SOURCE | VENTILATION | SUP 1
Port_13885679_0 | SOURCEANDSINK | VENTILATION | SUP 1
InPort_13885679_1 | SINK | VENTILATION | SUP 1
OutPort_13885681_1 | SOURCE | VENTILATION | SUP 1
InPort_13885762_1 | SINK | VENTILATION | SUP 24
OutPort_13885760_2 | SOURCE | VENTILATION | SUP 24
Port_13885762_0 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13975944_1 | SINK | VENTILATION | SUP 24
OutPort_13885762_2 | SOURCE | VENTILATION | SUP 24
InPort_13975968_1 | SINK | VENTILATION | SUP 24
OutPort_13885762_3 | SOURCE | VENTILATION | SUP 24
InPort_13976008_1 | SINK | VENTILATION | SUP 24
OutPort_13885762_4 | SOURCE | VENTILATION | SUP 24
InPort_13885815_1 | SINK | VENTILATION | SUP 24
OutPort_13885838_2 | SOURCE | VENTILATION | SUP 24
InPort_13885840_2 | SINK | VENTILATION | SUP 24
OutPort_13885815_2 | SOURCE | VENTILATION | SUP 24
InPort_13885817_1 | SINK | VENTILATION | SUP 24
OutPort_13885840_1 | SOURCE | VENTILATION | SUP 24
InPort_13886096_2 | SINK | VENTILATION | SUP 13
OutPort_13886112_1 | SOURCE | VENTILATION | SUP 13
InPort_13886214_1 | SINK | VENTILATION | SUP 13
OutPort_13886376_4 | SOURCE | VENTILATION | SUP 13
InPort_13886238_1 | SINK | VENTILATION | SUP 13
OutPort_13886376_3 | SOURCE | VENTILATION | SUP 13
InPort_13886262_1 | SINK | VENTILATION | SUP 13
OutPort_13886376_2 | SOURCE | VENTILATION | SUP 13
InPort_13886376_1 | SINK | VENTILATION | SUP 13
OutPort_13886374_2 | SOURCE | VENTILATION | SUP 13
Port_13886376_0 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13886499_1 | SINK | VENTILATION | SUP 13
OutPort_13886519_1 | SOURCE | VENTILATION | SUP 13
InPort_13886709_1 | SINK | VENTILATION | SUP 13
OutPort_13886723_2 | SOURCE | VENTILATION | SUP 13
InPort_13886721_2 | SINK | VENTILATION | SUP 13
OutPort_13886709_2 | SOURCE | VENTILATION | SUP 13
InPort_13886719_1 | SINK | VENTILATION | SUP 13
OutPort_13886721_1 | SOURCE | VENTILATION | SUP 13
Port_13889966_0 | SOURCEANDSINK | VENTILATION | SUP 63
Port_13889966_1 | SOURCEANDSINK | VENTILATION | SUP 63
InPort_13889968_1 | SINK | VENTILATION | SUP 63
OutPort_13889966_3 | SOURCE | VENTILATION | SUP 63
InPort_13889969_1 | SINK | VENTILATION | SUP 63
OutPort_13889966_4 | SOURCE | VENTILATION | SUP 63
InPort_13891212_1 | SINK | VENTILATION | SUP 17
OutPort_13939464_3 | SOURCE | VENTILATION | SUP 17
InPort_13891281_1 | SINK | VENTILATION | SUP 17
OutPort_13939464_2 | SOURCE | VENTILATION | SUP 17
Port_13892878_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14084291_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13892878_3 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14121026_0 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_14084168_2 | SINK | VENTILATION | ETA 14
OutPort_13892879_0 | SOURCE | VENTILATION | ETA 14
Port_13892879_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14084289_2 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_13892879_2 | SINK | VENTILATION | ETA 14
OutPort_14076596_0 | SOURCE | VENTILATION | ETA 14
InPort_13894547_1 | SINK | VENTILATION | SUP 11
OutPort_14170728_1 | SOURCE | VENTILATION | SUP 11
InPort_13894548_1 | SINK | VENTILATION | SUP 11
OutPort_14170506_1 | SOURCE | VENTILATION | SUP 11
InPort_13894549_1 | SINK | VENTILATION | SUP 11
OutPort_14170622_1 | SOURCE | VENTILATION | SUP 11
InPort_13894565_1 | SINK | VENTILATION | SUP 11
OutPort_14170265_1 | SOURCE | VENTILATION | SUP 11
InPort_13894568_1 | SINK | VENTILATION | SUP 11
OutPort_14170426_1 | SOURCE | VENTILATION | SUP 11
Port_13895739_0 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13908080_1 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13895739_1 | SOURCEANDSINK | VENTILATION | SUP 12
InPort_13993944_1 | SINK | VENTILATION | SUP 12
OutPort_13895739_2 | SOURCE | VENTILATION | SUP 12
Port_13895906_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13895924_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13895906_2 | SINK | VENTILATION | ETA 7
OutPort_13907680_1 | SOURCE | VENTILATION | ETA 7
Port_13895916_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13895924_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13895916_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13895916_2 | SINK | VENTILATION | ETA 7
OutPort_13907714_1 | SOURCE | VENTILATION | ETA 7
Port_13895934_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13895952_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13895944_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13895952_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13895944_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13895961_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13895955_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13895961_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13895955_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13895955_2 | SINK | VENTILATION | ETA 7
OutPort_13907567_1 | SOURCE | VENTILATION | ETA 7
InPort_13895955_3 | SINK | VENTILATION | ETA 7
OutPort_13907591_1 | SOURCE | VENTILATION | ETA 7
InPort_13896278_0 | SINK | VENTILATION | ODA 7
OutPort_13896742_2 | SOURCE | VENTILATION | ODA 7
InPort_13896743_1 | SINK | VENTILATION | ODA 7
OutPort_13896278_1 | SOURCE | VENTILATION | ODA 7
InPort_13896742_1 | SINK | VENTILATION | ODA 7
OutPort_13896345_0 | SOURCE | VENTILATION | ODA 7
InPort_13896345_1 | SINK | VENTILATION | ODA 7
OutPort_14146225_1 | SOURCE | VENTILATION | ODA 7
InPort_13896608_1 | SINK | VENTILATION | ODA 7
OutPort_13896743_2 | SOURCE | VENTILATION | ODA 7
InPort_13896867_2 | SINK | VENTILATION | ODA 7
OutPort_13896852_0 | SOURCE | VENTILATION | ODA 7
InPort_13897049_1 | SINK | EXHAUST | EHA 5
OutPort_13897143_1 | SOURCE | EXHAUST | EHA 5
Port_13898590_1 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13898591_0 | SOURCEANDSINK | VENTILATION | ETA 97
InPort_13898590_2 | SINK | VENTILATION | ETA 97
OutPort_13946814_1 | SOURCE | VENTILATION | ETA 97
InPort_14104005_2 | SINK | VENTILATION | ETA 97
OutPort_13898654_0 | SOURCE | VENTILATION | ETA 97
InPort_13898654_1 | SINK | VENTILATION | ETA 97
OutPort_14120011_1 | SOURCE | VENTILATION | ETA 97
InPort_13898654_2 | SINK | VENTILATION | ETA 97
OutPort_13948485_1 | SOURCE | VENTILATION | ETA 97
InPort_13898654_3 | SINK | VENTILATION | ETA 97
OutPort_13948513_1 | SOURCE | VENTILATION | ETA 97
InPort_14066261_1 | SINK | VENTILATION | ODA 12
OutPort_13900352_0 | SOURCE | VENTILATION | ODA 12
InPort_13900352_1 | SINK | VENTILATION | ODA 12
OutPort_14067813_1 | SOURCE | VENTILATION | ODA 12
InPort_13900592_0 | SINK | VENTILATION | ODA 12
OutPort_13917256_2 | SOURCE | VENTILATION | ODA 12
InPort_13917391_1 | SINK | VENTILATION | ODA 12
OutPort_13900592_1 | SOURCE | VENTILATION | ODA 12
InPort_13901082_1 | SINK | VENTILATION | ETA 7
OutPort_13901080_2 | SOURCE | VENTILATION | ETA 7
Port_13901342_0 | SOURCEANDSINK | VENTILATION | SUP 5
Port_14121941_1 | SOURCEANDSINK | VENTILATION | SUP 5
Port_13901342_1 | SOURCEANDSINK | VENTILATION | SUP 5
InPort_13960324_1 | SINK | VENTILATION | SUP 5
OutPort_13901342_2 | SOURCE | VENTILATION | SUP 5
InPort_14003474_1 | SINK | VENTILATION | SUP 5
OutPort_13901342_4 | SOURCE | VENTILATION | SUP 5
InPort_14003534_1 | SINK | VENTILATION | SUP 5
OutPort_13901342_5 | SOURCE | VENTILATION | SUP 5
Port_13901342_7 | SOURCEANDSINK | VENTILATION | SUP 5
Port_14065154_1 | SOURCEANDSINK | VENTILATION | SUP 5
Port_13901527_0 | SOURCEANDSINK | VENTILATION | SUP 5
Port_14122086_2 | SOURCEANDSINK | VENTILATION | SUP 5
Port_13901527_1 | SOURCEANDSINK | VENTILATION | SUP 5
Port_14121952_1 | SOURCEANDSINK | VENTILATION | SUP 5
InPort_13901865_1 | SINK | VENTILATION | ETA 17
OutPort_13901674_0 | SOURCE | VENTILATION | ETA 17
InPort_13901674_1 | SINK | VENTILATION | ETA 17
OutPort_14005091_1 | SOURCE | VENTILATION | ETA 17
InPort_13901674_2 | SINK | VENTILATION | ETA 17
OutPort_14004907_1 | SOURCE | VENTILATION | ETA 17
InPort_13901865_3 | SINK | VENTILATION | ETA 17
OutPort_13901814_0 | SOURCE | VENTILATION | ETA 17
InPort_13901814_1 | SINK | VENTILATION | ETA 17
OutPort_14186850_3 | SOURCE | VENTILATION | ETA 17
InPort_13901814_2 | SINK | VENTILATION | ETA 17
OutPort_13902101_1 | SOURCE | VENTILATION | ETA 17
InPort_14186850_1 | SINK | VENTILATION | ETA 17
OutPort_13901823_0 | SOURCE | VENTILATION | ETA 17
InPort_13901823_1 | SINK | VENTILATION | ETA 17
OutPort_14003833_1 | SOURCE | VENTILATION | ETA 17
InPort_13901823_2 | SINK | VENTILATION | ETA 17
OutPort_13901899_1 | SOURCE | VENTILATION | ETA 17
InPort_13901823_3 | SINK | VENTILATION | ETA 17
OutPort_13902051_1 | SOURCE | VENTILATION | ETA 17
InPort_13901866_1 | SINK | VENTILATION | ETA 17
OutPort_13901865_2 | SOURCE | VENTILATION | ETA 17
InPort_14117734_1 | SINK | VENTILATION | ETA 17
OutPort_13901866_0 | SOURCE | VENTILATION | ETA 17
InPort_13902162_2 | SINK | VENTILATION | ETA 17
OutPort_13902154_0 | SOURCE | VENTILATION | ETA 17
InPort_13902154_1 | SINK | VENTILATION | ETA 17
OutPort_14065182_1 | SOURCE | VENTILATION | ETA 17
InPort_13902154_2 | SINK | VENTILATION | ETA 17
OutPort_13902222_1 | SOURCE | VENTILATION | ETA 17
InPort_13902154_3 | SINK | VENTILATION | ETA 17
OutPort_13960261_1 | SOURCE | VENTILATION | ETA 17
InPort_13902154_4 | SINK | VENTILATION | ETA 17
OutPort_14001007_1 | SOURCE | VENTILATION | ETA 17
InPort_13902222_2 | SINK | VENTILATION | ETA 17
OutPort_13902181_0 | SOURCE | VENTILATION | ETA 17
InPort_13902181_1 | SINK | VENTILATION | ETA 17
OutPort_14065331_1 | SOURCE | VENTILATION | ETA 17
InPort_13902891_1 | SINK | EXHAUST | ETA 8
OutPort_13902926_0 | SOURCE | EXHAUST | ETA 8
InPort_13902974_1 | SINK | VENTILATION | ETA 7
OutPort_13902975_1 | SOURCE | VENTILATION | ETA 7
InPort_14174483_0 | SINK | VENTILATION | ETA 7
OutPort_13902974_3 | SOURCE | VENTILATION | ETA 7
InPort_13902975_0 | SINK | VENTILATION | ETA 7
OutPort_14110297_2 | SOURCE | VENTILATION | ETA 7
Port_13903321_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14007247_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13903321_1 | SOURCEANDSINK | VENTILATION | ETA 17
InPort_13903321_3 | SINK | VENTILATION | ETA 17
OutPort_13903816_1 | SOURCE | VENTILATION | ETA 17
Port_13903321_4 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14135894_1 | SOURCEANDSINK | VENTILATION | ETA 17
InPort_13903908_1 | SINK | VENTILATION | ETA 6
OutPort_13903909_0 | SOURCE | VENTILATION | ETA 6
InPort_14068035_0 | SINK | VENTILATION | ETA 6
OutPort_13903908_2 | SOURCE | VENTILATION | ETA 6
InPort_13903909_1 | SINK | VENTILATION | ETA 6
OutPort_13973127_1 | SOURCE | VENTILATION | ETA 6
InPort_13903910_0 | SINK | VENTILATION | ETA 6
OutPort_14068033_1 | SOURCE | VENTILATION | ETA 6
OutPort_13903910_1 | SOURCE | VENTILATION | ETA 6
InPort_13981207_1 | SINK | VENTILATION | ETA 68
OutPort_13905480_0 | SOURCE | VENTILATION | ETA 68
InPort_13905480_1 | SINK | VENTILATION | ETA 68
OutPort_13981123_1 | SOURCE | VENTILATION | ETA 68
InPort_14129236_1 | SINK | VENTILATION | ETA 7
OutPort_13906442_1 | SOURCE | VENTILATION | ETA 7
InPort_14129237_1 | SINK | VENTILATION | ETA 7
OutPort_13906801_1 | SOURCE | VENTILATION | ETA 7
InPort_14129238_1 | SINK | VENTILATION | ETA 7
OutPort_13906985_1 | SOURCE | VENTILATION | ETA 7
InPort_14129239_1 | SINK | VENTILATION | ETA 7
OutPort_13907159_1 | SOURCE | VENTILATION | ETA 7
InPort_13907368_2 | SINK | VENTILATION | SUP 24
Port_13907371_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14180243_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13907371_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13908054_0 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13908072_3 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13908054_1 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13908080_2 | SOURCEANDSINK | VENTILATION | SUP 12
InPort_13908072_1 | SINK | VENTILATION | SUP 12
OutPort_13908664_0 | SOURCE | VENTILATION | SUP 12
Port_13908072_2 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13908073_1 | SOURCEANDSINK | VENTILATION | SUP 12
InPort_13908403_1 | SINK | VENTILATION | SUP 12
OutPort_13908401_2 | SOURCE | VENTILATION | SUP 12
InPort_13908662_1 | SINK | VENTILATION | SUP 12
OutPort_13908403_0 | SOURCE | VENTILATION | SUP 12
InPort_13908664_1 | SINK | VENTILATION | SUP 12
OutPort_13908662_2 | SOURCE | VENTILATION | SUP 12
InPort_13908744_2 | SINK | VENTILATION | SUP 12
OutPort_13908746_1 | SOURCE | VENTILATION | SUP 12
InPort_13908796_1 | SINK | VENTILATION | SUP 12
OutPort_13908802_2 | SOURCE | VENTILATION | SUP 12
InPort_13908800_2 | SINK | VENTILATION | SUP 12
OutPort_13908796_2 | SOURCE | VENTILATION | SUP 12
InPort_13908798_1 | SINK | VENTILATION | SUP 12
OutPort_13908800_1 | SOURCE | VENTILATION | SUP 12
InPort_13908802_1 | SINK | VENTILATION | SUP 12
OutPort_13914247_0 | SOURCE | VENTILATION | SUP 12
InPort_13908938_1 | SINK | VENTILATION | SUP 12
OutPort_13908906_1 | SOURCE | VENTILATION | SUP 12
InPort_13908924_0 | SINK | VENTILATION | SUP 12
OutPort_13909354_1 | SOURCE | VENTILATION | SUP 12
InPort_13908951_1 | SINK | VENTILATION | SUP 12
OutPort_13908924_1 | SOURCE | VENTILATION | SUP 12
InPort_13909451_0 | SINK | VENTILATION | SUP 12
OutPort_13908938_2 | SOURCE | VENTILATION | SUP 12
Port_13908941_0 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13909622_2 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13908941_1 | SOURCEANDSINK | VENTILATION | SUP 12
InPort_13911443_1 | SINK | VENTILATION | SUP 12
OutPort_13908941_2 | SOURCE | VENTILATION | SUP 12
InPort_13909082_0 | SINK | VENTILATION | SUP 12
OutPort_13908951_2 | SOURCE | VENTILATION | SUP 12
Port_13909082_1 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13909557_1 | SOURCEANDSINK | VENTILATION | SUP 12
InPort_13911260_1 | SINK | VENTILATION | SUP 12
OutPort_13909082_2 | SOURCE | VENTILATION | SUP 12
InPort_13911361_1 | SINK | VENTILATION | SUP 12
OutPort_13909082_3 | SOURCE | VENTILATION | SUP 12
InPort_13909354_2 | SINK | VENTILATION | SUP 12
OutPort_13909348_1 | SOURCE | VENTILATION | SUP 12
InPort_13909348_2 | SINK | VENTILATION | SUP 12
OutPort_13909352_2 | SOURCE | VENTILATION | SUP 12
InPort_13909350_0 | SINK | VENTILATION | SUP 12
OutPort_13909449_2 | SOURCE | VENTILATION | SUP 12
InPort_13909352_1 | SINK | VENTILATION | SUP 12
OutPort_13909350_1 | SOURCE | VENTILATION | SUP 12
InPort_13909449_1 | SINK | VENTILATION | SUP 12
OutPort_13909451_1 | SOURCE | VENTILATION | SUP 12
Port_13909557_2 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13909577_0 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13909577_1 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13909622_1 | SOURCEANDSINK | VENTILATION | SUP 12
InPort_13911391_1 | SINK | VENTILATION | SUP 12
OutPort_13909577_2 | SOURCE | VENTILATION | SUP 12
InPort_13911415_1 | SINK | VENTILATION | SUP 12
OutPort_13909577_3 | SOURCE | VENTILATION | SUP 12
InPort_13910116_0 | SINK | VENTILATION | ODA 21
OutPort_13912711_1 | SOURCE | VENTILATION | ODA 21
InPort_13912785_2 | SINK | VENTILATION | ODA 21
OutPort_13910116_1 | SOURCE | VENTILATION | ODA 21
InPort_13910357_1 | SINK | VENTILATION | ODA 21
OutPort_13912785_1 | SOURCE | VENTILATION | ODA 21
InPort_14127339_2 | SINK | VENTILATION | ODA 21
OutPort_13910652_0 | SOURCE | VENTILATION | ODA 21
InPort_13910652_1 | SINK | VENTILATION | ODA 21
OutPort_13918393_1 | SOURCE | VENTILATION | ODA 21
InPort_13910899_1 | SINK | VENTILATION | ODA 21
OutPort_13912999_1 | SOURCE | VENTILATION | ODA 21
InPort_13910933_1 | SINK | VENTILATION | ODA 21
OutPort_13913209_1 | SOURCE | VENTILATION | ODA 21
InPort_13910969_1 | SINK | VENTILATION | ODA 21
OutPort_14127339_1 | SOURCE | VENTILATION | ODA 21
InPort_13911018_2 | SINK | VENTILATION | SUP 24
OutPort_13911012_1 | SOURCE | VENTILATION | SUP 24
InPort_13911012_2 | SINK | VENTILATION | SUP 24
OutPort_13911016_2 | SOURCE | VENTILATION | SUP 24
InPort_13911016_1 | SINK | VENTILATION | SUP 24
OutPort_13911014_1 | SOURCE | VENTILATION | SUP 24
InPort_13911063_1 | SINK | VENTILATION | SUP 24
OutPort_13911065_1 | SOURCE | VENTILATION | SUP 24
InPort_13911116_2 | SINK | VENTILATION | SUP 24
OutPort_13911118_1 | SOURCE | VENTILATION | SUP 24
InPort_13911165_1 | SINK | VENTILATION | SUP 24
OutPort_13911211_1 | SOURCE | VENTILATION | SUP 24
InPort_13911213_1 | SINK | VENTILATION | SUP 24
OutPort_13911165_2 | SOURCE | VENTILATION | SUP 24
InPort_13911167_0 | SINK | VENTILATION | SUP 24
OutPort_13911201_2 | SOURCE | VENTILATION | SUP 24
InPort_13911211_2 | SINK | VENTILATION | SUP 24
OutPort_13911167_1 | SOURCE | VENTILATION | SUP 24
InPort_13911566_1 | SINK | VENTILATION | ETA 9
OutPort_13911566_2 | SOURCE | VENTILATION | ETA 9
Port_13911568_0 | SOURCEANDSINK | VENTILATION | ETA 10
Port_13911617_1 | SOURCEANDSINK | VENTILATION | ETA 10
Port_13911568_1 | SOURCEANDSINK | VENTILATION | ETA 10
Port_13911570_1 | SOURCEANDSINK | VENTILATION | ETA 10
Port_13911570_2 | SOURCEANDSINK | VENTILATION | ETA 10
Port_13911572_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13911617_2 | SOURCEANDSINK | VENTILATION | ETA 10
Port_13911619_0 | SOURCEANDSINK | VENTILATION | ETA 10
Port_13911619_1 | SOURCEANDSINK | VENTILATION | ETA 10
InPort_13911619_2 | SINK | VENTILATION | ETA 10
OutPort_13994248_1 | SOURCE | VENTILATION | ETA 10
InPort_13911619_3 | SINK | VENTILATION | ETA 10
OutPort_13994272_1 | SOURCE | VENTILATION | ETA 10
InPort_13911689_0 | SINK | VENTILATION | ETA 17
OutPort_13911663_1 | SOURCE | VENTILATION | ETA 17
InPort_13911663_2 | SINK | VENTILATION | ETA 17
OutPort_13911665_1 | SOURCE | VENTILATION | ETA 17
InPort_13911687_1 | SINK | VENTILATION | ETA 17
OutPort_13911689_1 | SOURCE | VENTILATION | ETA 17
InPort_13911856_1 | SINK | VENTILATION | SUP 12
OutPort_13911854_2 | SOURCE | VENTILATION | SUP 12
Port_13911996_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13911998_1 | SOURCEANDSINK | VENTILATION | ETA 17
InPort_13912111_2 | SINK | VENTILATION | ETA 17
OutPort_13914105_0 | SOURCE | VENTILATION | ETA 17
InPort_13912711_0 | SINK | VENTILATION | ODA 21
OutPort_13918301_4 | SOURCE | VENTILATION | ODA 21
InPort_13912983_0 | SINK | VENTILATION | ODA 21
OutPort_13912996_1 | SOURCE | VENTILATION | ODA 21
InPort_13912999_2 | SINK | VENTILATION | ODA 21
OutPort_13912983_1 | SOURCE | VENTILATION | ODA 21
InPort_13912996_0 | SINK | VENTILATION | ODA 21
OutPort_13918301_3 | SOURCE | VENTILATION | ODA 21
InPort_13913209_2 | SINK | VENTILATION | ODA 21
OutPort_13913199_0 | SOURCE | VENTILATION | ODA 21
InPort_13913199_1 | SINK | VENTILATION | ODA 21
OutPort_13913206_1 | SOURCE | VENTILATION | ODA 21
InPort_13913206_0 | SINK | VENTILATION | ODA 21
OutPort_13918301_2 | SOURCE | VENTILATION | ODA 21
InPort_13913701_1 | SINK | VENTILATION | SUP 12
OutPort_14176154_3 | SOURCE | VENTILATION | SUP 12
InPort_13913736_1 | SINK | VENTILATION | SUP 12
OutPort_14176154_2 | SOURCE | VENTILATION | SUP 12
InPort_13914103_1 | SINK | VENTILATION | ETA 17
OutPort_13914109_2 | SOURCE | VENTILATION | ETA 17
InPort_13914107_2 | SINK | VENTILATION | ETA 17
OutPort_13914103_2 | SOURCE | VENTILATION | ETA 17
InPort_13914105_1 | SINK | VENTILATION | ETA 17
OutPort_13914107_1 | SOURCE | VENTILATION | ETA 17
InPort_13914109_1 | SINK | VENTILATION | ETA 17
OutPort_13914135_0 | SOURCE | VENTILATION | ETA 17
InPort_13914133_1 | SINK | VENTILATION | ETA 17
OutPort_13914139_2 | SOURCE | VENTILATION | ETA 17
InPort_13914137_2 | SINK | VENTILATION | ETA 17
OutPort_13914133_2 | SOURCE | VENTILATION | ETA 17
InPort_13914135_1 | SINK | VENTILATION | ETA 17
OutPort_13914137_1 | SOURCE | VENTILATION | ETA 17
InPort_13914247_1 | SINK | VENTILATION | SUP 12
OutPort_13914386_2 | SOURCE | VENTILATION | SUP 12
InPort_13914374_0 | SINK | VENTILATION | SUP 12
OutPort_13914384_1 | SOURCE | VENTILATION | SUP 12
InPort_13914386_1 | SINK | VENTILATION | SUP 12
OutPort_13914374_1 | SOURCE | VENTILATION | SUP 12
Port_13914394_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914408_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914408_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914427_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914418_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914427_2 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914418_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914457_2 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914449_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914457_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914449_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914466_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914460_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914466_2 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914460_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914477_2 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914469_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914477_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914469_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914529_3 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914480_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914529_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13914480_1 | SOURCEANDSINK | VENTILATION | ETA 12
InPort_13914480_2 | SINK | VENTILATION | ETA 12
OutPort_13914724_1 | SOURCE | VENTILATION | ETA 12
InPort_13914529_2 | SINK | VENTILATION | ETA 12
OutPort_13914551_0 | SOURCE | VENTILATION | ETA 12
InPort_13914551_1 | SINK | VENTILATION | ETA 12
OutPort_14191867_1 | SOURCE | VENTILATION | ETA 12
InPort_13914551_2 | SINK | VENTILATION | ETA 12
OutPort_13914774_1 | SOURCE | VENTILATION | ETA 12
Port_13915145_1 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13915174_0 | SOURCEANDSINK | VENTILATION | SUP 17
InPort_13915162_0 | SINK | VENTILATION | SUP 17
OutPort_13915173_3 | SOURCE | VENTILATION | SUP 17
InPort_13915325_1 | SINK | VENTILATION | SUP 17
OutPort_13915162_1 | SOURCE | VENTILATION | SUP 17
