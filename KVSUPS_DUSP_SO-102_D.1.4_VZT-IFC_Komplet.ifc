Properties of the parts of a building model (IFC4), part 38 of 45

# IfcDuctSegment: Hranaté potrubí:POZINK/T spoj (368)
Name (Hranaté potrubí:POZINK/T spoj:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Reynoldsovo číslo | Dynamický tlak (Pa) | Průtok (m3/s) | Rychlost (m/s) | Tlaková ztráta (Pa) | Tření (kg/m2/s2) | Referenční podlaží | Sklon | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Koeficient ztrát | Ekvivaletní průměr (mm) | Hydraulický průměr (mm) | Klasifikace systému | Název systému | Plocha (m2) | Řez | Typ systému | Zkratka systému | Délka (mm) | Šířka (mm) | Velikost | Výška (mm) | Kód prvku | Označení | Páteřní trasa | Group
13639242 | -1.PP_SO-102 | 1120 | 0.0530203 | 1.75768 | 710 mm × 1120 mm | 0 | 710 mm × 1120 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 89 | -471 | -471 | -1031 | Fáze 1 | 0 | 968.564 | 869.071 | Odváděný vzduch | EHA 11 | 0.273316 | 3 | Znehodnocený | EHA | 74.6765 | 710 | 710 × 1120 | 1120 | PO02.03.0328 | 0328 | yes | EHA 11
13639700 | -1.PP_SO-102 | 1176 | 0.8875 | 4.60992 | 1250 mm × 710 mm | 0 | 1250 mm × 710 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 |  | 1790 | 614 | 1790 | 614 | Fáze 1 | 0 | 1019.73 | 905.612 | Odváděný vzduch | EHA 17 | 4.60992 | 15 | Znehodnocený | EHA | 1176 | 1250 | 1250 × 710 | 710 | PO02.03.0329 | 0329 | yes | EHA 17
13640119 | -1.PP_SO-102 | 560 | 1.53625 | 2.86738 | 1600 mm × 560 mm | 0 | 1600 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2380 | 2100 | 2100 | 1820 | Fáze 1 | 0 | 1001.2 | 829.63 | Zpětný vzduch | ETA 1 | 4.14788 | 69 | Odváděný | ETA | 960.158 | 1600 | 1600 × 560 | 560 | PO02.03.0330 | 0330 | yes | ETA 1
13640150 | -1.PP_SO-102 | 560 | 1.66197 | 2.92419 | 1100 mm × 560 mm | 0 | 1100 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2380 | 2100 | 2100 | 1820 | Fáze 1 | 0 | 846.066 | 742.169 | Zpětný vzduch | ETA 1 | 5.01613 | 150 | Odváděný | ETA | 1510.88 | 1100 | 1100 × 560 | 560 | PO02.03.0331 | 0331 | yes | ETA 1
13640410 | -1.PP_SO-102 | 560 | 1.48491 | 2.83143 | 1600 mm × 560 mm | 0 | 1600 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2685.78 | 2405.78 | 2405.78 | 2125.78 | Fáze 1 | 0 | 1001.2 | 829.63 | Zpětný vzduch | ETA 1 | 4.00924 | 69 | Odváděný | ETA | 928.066 | 1600 | 1600 × 560 | 560 | PO02.03.0332 | 0332 | yes | ETA 1
13640411 | -1.PP_SO-102 | 1600 | 0.166837 | 2.74536 | 1600 mm × 560 mm | 0 | 1600 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 57.735 | 2569.86 | 2178.41 | 2327.37 | 1935.92 | Fáze 1 | 0 | 1001.2 | 829.63 | Zpětný vzduch | ETA 1 | 1.28703 | 69 | Odváděný | ETA | 297.924 | 1600 | 1600 × 560 | 560 | PO02.03.0333 | 0333 | yes | ETA 1
13640455 | -1.PP_SO-102 | 1120 | 0.162059 | 1.80353 | 1120 mm × 400 mm | 0 | 1120 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 100 | 3034.66 | 2893.24 | 2606.76 | 2465.34 | Fáze 1 | 0 | 708.812 | 589.474 | Zpětný vzduch | ETA 21 | 1.23165 | 65 | Odváděný | ETA | 405.147 | 1120 | 1120 × 400 | 400 | PO02.03.0334 | 0334 | yes | ETA 21
13640876 | -1.PP_SO-102 | 560 | 0.111939 | 1.5003 | 1250 mm × 560 mm | 0 | 1250 mm × 560 mm | 292053 | 19.6346 | 4 | 5.71429 | 0.0369558 | 0.412679 | -1.PP_SO-102 | 0 | 2680 | 2400 | 2400 | 2120 | Fáze 1 | 0.00188218 | 896.83 | 773.481 | Přívod vzduchu | ODA 8 | 0.324174 | 4 | Čerstvý | ODA | 89.5508 | 1250 | 1250 × 560 | 560 | PO02.03.0335 | 0335 | yes | ODA 8
13640957 | -1.PP_SO-102 | 560 | 0.0176118 | 1.41578 | 1250 mm × 560 mm | 0 | 1250 mm × 560 mm | 292053 | 19.6346 | 4 | 5.71429 | 0.00581443 | 0.412679 | -1.PP_SO-102 | 0 | 2680 | 2400 | 2400 | 2120 | Fáze 1 | 0.000296132 | 896.83 | 773.481 | Přívod vzduchu | ODA 8 | 0.0510038 | 6 | Čerstvý | ODA | 14.0895 | 1250 | 1250 × 560 | 560 | PO02.03.0336 | 0336 | yes | ODA 8
13641173 | -1.PP_SO-102 | 560 | 2.81494 | 3.92218 | 1250 mm × 560 mm | 0 | 1250 mm × 560 mm | 292053 | 19.6346 | 4 | 5.71429 | 0.929333 | 0.412679 | -1.PP_SO-102 | 0 | 2063.91 | 1783.91 | 1783.91 | 1503.91 | Fáze 1 | 0.0473314 | 896.83 | 773.481 | Přívod vzduchu | ODA 8 | 8.15206 | 6 | Čerstvý | ODA | 2251.95 | 1250 | 1250 × 560 | 560 | PO02.03.0337 | 0337 | yes | ODA 8
13641274 | -1.PP_SO-102 | 1250 | 0.514382 | 3.69635 | 1250 mm × 560 mm | 0 | 1250 mm × 560 mm | 292053 | 19.6346 | 4 | 5.71429 | 0.379062 | 0.412679 | -1.PP_SO-102 | 57.735 | 2564.08 | 2321.59 | 1862.32 | 1619.83 | Fáze 1 | 0.0193059 | 896.83 | 773.481 | Přívod vzduchu | ODA 8 | 3.32511 | 6 | Čerstvý | ODA | 918.54 | 1250 | 1250 × 560 | 560 | PO02.03.0338 | 0338 | yes | ODA 8
13641298 | -1.PP_SO-102 | 710 | 0.808401 | 2.89529 | 1500 mm × 710 mm | 0 | 1500 mm × 710 mm | 239192 | 8.4824 | 4 | 3.75587 | 0.0777054 | 0.144184 | -1.PP_SO-102 | 0 | 2755 | 2400 | 2400 | 2045 | Fáze 1 | 0.00916078 | 1109.02 | 963.801 | Přívod vzduchu | ODA 8 | 2.38209 | 2 | Čerstvý | ODA | 538.934 | 1500 | 1500 × 710 | 710 | PO02.03.0339 | 0339 | yes | ODA 8
13641772 | -1.PP_SO-102 | 560 | 2.25949 | 3.37559 | 1400 mm × 560 mm | 0 | 1400 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2685.78 | 2405.78 | 2405.78 | 2125.78 | Fáze 1 | 0 | 943.685 | 800 | Zpětný vzduch | ETA 1 | 6.32657 | 152 | Odváděný | ETA | 1613.92 | 1400 | 1400 × 560 | 560 | PO02.03.0342 | 0342 | yes | ETA 1
13641976 | -1.PP_SO-102 | 560 | 1.69995 | 2.92315 | 1250 mm × 560 mm | 0 | 1250 mm × 560 mm | 292053 | 19.6346 | 4 | 5.71429 | 0.561227 | 0.412679 | -1.PP_SO-102 | 0 | 2680 | 2400 | 2400 | 2120 | Fáze 1 | 0.0285836 | 896.83 | 773.481 | Přívod vzduchu | ODA 8 | 4.92305 | 6 | Čerstvý | ODA | 1359.96 | 1250 | 1250 × 560 | 560 | PO02.03.0343 | 0343 | yes | ODA 8
13642097 | -1.PP_SO-102 | 710 | 0.96305 | 2.86902 | 1250 mm × 710 mm | 0 | 1250 mm × 710 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2655 | 2300 | 2300 | 1945 | Fáze 1 | 0 | 1019.73 | 905.612 | Odváděný vzduch | EHA 17 | 3.02012 | 15 | Znehodnocený | EHA | 770.44 | 1250 | 1250 × 710 | 710 | PO02.03.0344 | 0344 | yes | EHA 17
13644997 | 2.NP_SO-102 | 382.34 | 0.7 | 1.38407 | 1250 mm × 560 mm | 0 | 1250 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 2265 | 1882.66 | 2265 | 1882.66 | Fáze 1 | 0 | 896.83 | 773.481 | Přívod vzduchu | SUP 13 | 1.38407 | 305 | Přívodní | SUP | 382.34 | 1250 | 1250 × 560 | 560 | PO02.03.0345 | 0345 | yes | SUP 13
13696824 | 2.NP_SO-102 | 630 | 0.220234 | 1.65896 | 1120 mm × 630 mm | 0 | 1120 mm × 630 mm | 314652 | 20.9681 | 4.16667 | 5.90514 | 0.0820901 | 0.417469 | 2.NP_SO-102 | 0 | 1124 | 809 | 809 | 494 | Fáze 1 | 0.00391501 | 908.935 | 806.4 | Přívod vzduchu | ODA 6 | 0.688232 | 4 | Čerstvý | ODA | 196.638 | 1120 | 1120 × 630 | 630 | PO02.03.0378 | 0378 | yes | ODA 6
13697380 | 2.NP_SO-102 | 800 | 0.108103 | 2.13837 | 1250 mm × 800 mm | 0 | 1250 mm × 800 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 1209 | 809 | 809 | 409 | Fáze 1 | 0 | 1086.44 | 975.61 | Přívod vzduchu | SUP 11 | 0.354579 | 2 | Přívodní | SUP | 86.4827 | 1250 | 1250 × 800 | 800 | PO02.03.0379 | 0379 | yes | SUP 11
13697539 | 2.NP_SO-102 | 800 | 0.0995103 | 2.12737 | 1250 mm × 800 mm | 0 | 1250 mm × 800 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 1209 | 809 | 809 | 409 | Fáze 1 | 0 | 1086.44 | 975.61 | Přívod vzduchu | SUP 11 | 0.326394 | 2 | Přívodní | SUP | 79.6083 | 1250 | 1250 × 800 | 800 | PO02.03.0380 | 0380 | yes | SUP 11
13705864 | 1.NP_SO-102 | 3239.44 | 0.14 | 5.05352 | 500 mm × 280 mm | 0 | 500 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-102 |  | 14765 | 14765 | 11525.6 | 11525.6 | Fáze 2 | 0 | 404.809 | 358.974 | Zpětný vzduch | ETA 7 | 5.05352 | 402 | Odváděný | ETA | 3239.44 | 500 | 500 × 280 | 280 | PO02.03.0386 | 0386 | yes | ETA 7
13706535 | -1.PP_SO-102 | 500 | 0.558714 | 1.51685 | 630 mm × 500 mm | 0 | 630 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3330 | 3080 | 3080 | 2830 | Fáze 1 | 0 | 612.517 | 557.522 | Zpětný vzduch | ETA 7 | 2.00428 | 213 | Odváděný | ETA | 886.848 | 630 | 630 × 500 | 500 | PO02.03.0387 | 0387 | yes | ETA 7
13706605 | -1.PP_SO-102 | 500 | 1.08845 | 2.3577 | 630 mm × 500 mm | 0 | 630 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3330 | 3080 | 3080 | 2830 | Fáze 1 | 0 | 612.517 | 557.522 | Zpětný vzduch | ETA 7 | 3.9046 | 433 | Odváděný | ETA | 1727.7 | 630 | 630 × 500 | 500 | PO02.03.0388 | 0388 | yes | ETA 7
13707284 | -1.PP_SO-102 | 500 | 35.5366 | 23.8104 | 1600 mm × 500 mm | 0 | 1600 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3340 | 3090 | 3090 | 2840 | Fáze 1 | 0 | 939.333 | 761.905 | Přívod vzduchu | SUP 24 | 93.2837 | 422 | Přívodní | SUP | 22210.4 | 1600 | 1600 × 500 | 500 | PO02.03.0389 | 0389 | yes | SUP 24
13709186 | 2.NP_SO-102 | 710 | 0.5202 | 2.0486 | 710 mm × 710 mm | 0 | 710 mm × 710 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3155 | 2800 | 2800 | 2445 | Fáze 1 | 0 | 776.147 | 710 | Zpětný vzduch | ETA 3 | 2.0808 | 7 | Odváděný | ETA | 732.677 | 710 | 710 × 710 | 710 | PO02.03.0394 | 0394 | yes | ETA 3
13709198 | 2.NP_SO-102 | 710 | 2.59644 | 6.20109 | 710 mm × 710 mm | 0 | 710 mm × 710 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3155 | 2800 | 2800 | 2445 | Fáze 1 | 0 | 776.147 | 710 | Zpětný vzduch | ETA 3 | 10.3858 | 7 | Odváděný | ETA | 3656.96 | 710 | 710 × 710 | 710 | PO02.03.0395 | 0395 | yes | ETA 3
13710069 | 4.NP_SO-102 | 500 | 0.453443 | 1.34975 | 630 mm × 500 mm | 0 | 630 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 | 0 | 3077.52 | 2827.52 | 2827.52 | 2577.52 | Fáze 1 | 0 | 612.517 | 557.522 | Zpětný vzduch | ETA 3 | 1.62664 | 33 | Odváděný | ETA | 719.752 | 630 | 630 × 500 | 500 | PO02.03.0396 | 0396 | yes | ETA 3 | Identifikační data - Komentáře: VZT19
13710298 | 4.NP_SO-102 | 2712.04 | 0.1764 | 4.93591 | 280 mm × 630 mm | 0 | 280 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 |  | 2422.52 | 2422.52 | -289.521 | -289.521 | Fáze 1 | 0 | 450.033 | 387.692 | Zpětný vzduch | ETA 3 | 4.93591 | 32 | Odváděný | ETA | 2712.04 | 280 | 280 × 630 | 630 | PO02.03.0397 | 0397 | yes | ETA 3
13710946 | 1.NP_SO-102 | 500 | 0.400623 | 1.26591 | 630 mm × 500 mm | 0 | 630 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-102 | 0 | 2960.11 | 2710.11 | 2710.11 | 2460.11 | Fáze 1 | 0 | 612.517 | 557.522 | Zpětný vzduch | ETA 3 | 1.43716 | 5 | Odváděný | ETA | 635.91 | 630 | 630 × 500 | 500 | PO02.03.0398 | 0398 | yes | ETA 3
13711168 | 2.NP_SO-102 | 500 | 0.0486396 | 0.707206 | 630 mm × 500 mm | 0 | 630 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3050 | 2800 | 2800 | 2550 | Fáze 1 | 0 | 612.517 | 557.522 | Zpětný vzduch | ETA 3 | 0.174485 | 1 | Odváděný | ETA | 77.2057 | 630 | 630 × 500 | 500 | PO02.03.0399 | 0399 | yes | ETA 3 | Identifikační data - Komentáře: VZT19
13712369 | 4.NP_SO-102 | 2700.31 | 0.14 | 4.21248 | 280 mm × 500 mm | 0 | 280 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 |  | 2607.24 | 2607.24 | -93.0733 | -93.0733 | Fáze 1 | 0 | 404.809 | 358.974 | Zpětný vzduch | ETA 7 | 4.21248 | 126 | Odváděný | ETA | 2700.31 | 280 | 280 × 500 | 500 | PO02.03.0403 | 0403 | yes | ETA 7
13712463 | 3.NP_SO-102 | 280 | 0.0701773 | 0.41518 | 630 mm × 280 mm | 0 | 630 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 | 0 | 3190 | 3050 | 3050 | 2910 | Fáze 1 | 0 | 450.033 | 387.692 | Zpětný vzduch | ETA 7 | 0.202734 | 119 | Odváděný | ETA | 111.392 | 630 | 630 × 280 | 280 | PO02.03.0404 | 0404 | yes | ETA 7 | Identifikační data - Komentáře: VZT18
13742229 | -1.PP_SO-102 | 400 | 0.292775 | 0.932775 | 800 mm × 400 mm | 0 | 800 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3330 | 3130 | 3130 | 2930 | Fáze 2 | 0 | 609.35 | 533.333 | Přívod vzduchu | SUP 24 | 0.878326 | 555 | Přívodní | SUP | 365.969 | 800 | 800 × 400 | 400 | PO02.03.0433 | 0433 | yes | SUP 24
13744523 | 3.NP_SO-102 | 3413.4 | 0.2835 | 7.37294 | 450 mm × 630 mm | 0 | 450 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 |  | 2725 | -688.4 | 2725 | -688.4 | Fáze 1 | 0 | 580.007 | 525 | Zpětný vzduch | ETA 3 | 7.37294 | 28 | Odváděný | ETA | 3413.4 | 450 | 450 × 630 | 630 | PO02.03.0435 | 0435 | yes | ETA 3
13744744 | 3.NP_SO-102 | 500 | 0.0596047 | 0.724611 | 630 mm × 500 mm | 0 | 630 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 | 0 | 3250 | 3000 | 3000 | 2750 | Fáze 1 | 0 | 612.517 | 557.522 | Zpětný vzduch | ETA 3 | 0.21382 | 36 | Odváděný | ETA | 94.6107 | 630 | 630 × 500 | 500 | PO02.03.0436 | 0436 | yes | ETA 3 | Identifikační data - Komentáře: VZT19
13744807 | 3.NP_SO-102 | 230.271 | 0.2835 | 0.497385 | 450 mm × 630 mm | 0 | 450 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 |  | 3505.27 | 3275 | 3505.27 | 3275 | Fáze 1 | 0 | 580.007 | 525 | Zpětný vzduch | ETA 3 | 0.497385 | 31 | Odváděný | ETA | 230.271 | 450 | 450 × 630 | 630 | PO02.03.0437 | 0437 | yes | ETA 3
13745466 | 3.NP_SO-102 | 3176.49 | 0.2835 | 6.86122 | 450 mm × 630 mm | 0 | 450 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 |  | -1708.4 | -1708.4 | -4884.89 | -4884.89 | Fáze 1 | 0 | 580.007 | 525 | Zpětný vzduch | ETA 3 | 6.86122 | 6 | Odváděný | ETA | 3176.49 | 450 | 450 × 630 | 630 | PO02.03.0438 | 0438 | yes | ETA 3 | Identifikační data - Komentáře: VZT19
13746287 | 2.NP_SO-102 | 560 | 0.376676 | 1.38055 | 560 mm × 560 mm | 0 | 560 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2980 | 2700 | 2700 | 2420 | Fáze 1 | 0 | 612.173 | 560 | Přívod vzduchu | SUP 13 | 1.5067 | 47 | Přívodní | SUP | 672.635 | 560 | 560 × 560 | 560 | PO02.03.0440 | 0440 | yes | SUP 13
13746342 | 2.NP_SO-102 | 560 | 0.138397 | 0.903994 | 560 mm × 560 mm | 0 | 560 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2980 | 2700 | 2700 | 2420 | Fáze 1 | 0 | 612.173 | 560 | Přívod vzduchu | SUP 13 | 0.553588 | 48 | Přívodní | SUP | 247.138 | 560 | 560 × 560 | 560 | PO02.03.0441 | 0441 | yes | SUP 13
13747012 | 2.NP_SO-102 | 630 | 0.835818 | 2.3515 | 1120 mm × 630 mm | 0 | 1120 mm × 630 mm | 314652 | 20.9681 | 4.16667 | 5.90514 | 0.311543 | 0.417469 | 2.NP_SO-102 | 0 | 2858.58 | 2543.58 | 2543.58 | 2228.58 | Fáze 1 | 0.014858 | 908.935 | 806.4 | Přívod vzduchu | ODA 6 | 2.61193 | 4 | Čerstvý | ODA | 746.266 | 1120 | 1120 × 630 | 630 | PO02.03.0445 | 0445 | yes | ODA 6
13766745 | 2.NP_SO-102 | 280 | 0.269324 | 0.581643 | 500 mm × 280 mm | 0 | 500 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3140 | 3000 | 3000 | 2860 | Fáze 2 | 0 | 404.809 | 358.974 | Zpětný vzduch | ETA 7 | 0.840291 | 404 | Odváděný | ETA | 538.648 | 500 | 500 × 280 | 280 | PO02.03.0476 | 0476 | no | ETA 7
13766760 | 2.NP_SO-102 | 3641.92 | 0.315 | 8.23075 | 500 mm × 630 mm | 0 | 500 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 2835 | 2835 | -806.925 | -806.925 | Fáze 2 | 0 | 612.517 | 557.522 | Zpětný vzduch | ETA 7 | 8.23075 | 111 | Odváděný | ETA | 3641.92 | 500 | 500 × 630 | 630 | PO02.03.0477 | 0477 | yes | ETA 7
13766818 | 1.NP_SO-102 | 280 | 0.212809 | 0.518346 | 500 mm × 280 mm | 0 | 500 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-102 | 0 | 3168.08 | 3028.08 | 3028.08 | 2888.08 | Fáze 2 | 0 | 404.809 | 358.974 | Zpětný vzduch | ETA 7 | 0.663964 | 405 | Odváděný | ETA | 425.618 | 500 | 500 × 280 | 280 | PO02.03.0478 | 0478 | no | ETA 7
13766829 | 1.NP_SO-102 | 4008.37 | 0.315 | 9.05892 | 500 mm × 630 mm | 0 | 500 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-102 |  | 2863.08 | -1145.3 | 2863.08 | -1145.3 | Fáze 2 | 0 | 612.517 | 557.522 | Zpětný vzduch | ETA 7 | 9.05892 | 113 | Odváděný | ETA | 4008.37 | 500 | 500 × 630 | 630 | PO02.03.0479 | 0479 | yes | ETA 7
13766852 | 3.NP_SO-102 | 280 | 0.279581 | 0.59313 | 500 mm × 280 mm | 0 | 500 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 | 0 | 3235 | 3095 | 3095 | 2955 | Fáze 2 | 0 | 404.809 | 358.974 | Zpětný vzduch | ETA 7 | 0.872292 | 403 | Odváděný | ETA | 559.162 | 500 | 500 × 280 | 280 | PO02.03.0480 | 0480 | yes | ETA 7
13766860 | 2.NP_SO-102 | 3608.08 | 0.25 | 7.21615 | 500 mm × 500 mm | 0 | 500 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 6930 | 6930 | 3321.92 | 3321.92 | Fáze 2 | 0 | 546.583 | 500 | Zpětný vzduch | ETA 7 | 7.21615 | 168 | Odváděný | ETA | 3608.08 | 500 | 500 × 500 | 500 | PO02.03.0481 | 0481 | yes | ETA 7
13766901 | 4.NP_SO-102 | 280 | 0.264125 | 0.57582 | 500 mm × 280 mm | 0 | 500 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 | 0 | 3200 | 3060 | 3060 | 2920 | Fáze 2 | 0 | 404.809 | 358.974 | Zpětný vzduch | ETA 7 | 0.824071 | 402 | Odváděný | ETA | 528.251 | 500 | 500 × 280 | 280 | PO02.03.0482 | 0482 | no | ETA 7
13767014 | -1.PP_SO-102 | 400 | 0.418107 | 1.03911 | 710 mm × 400 mm | 0 | 710 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2699.7 | 2499.7 | 2499.7 | 2299.7 | Fáze 2 | 0 | 576.682 | 511.712 | Zpětný vzduch | ETA 7 | 1.30732 | 166 | Odváděný | ETA | 588.883 | 710 | 710 × 400 | 400 | PO02.03.0483 | 0483 | yes | ETA 7
13767591 | -1.PP_SO-102 | 400 | 0.262878 | 0.8642 | 710 mm × 400 mm | 0 | 710 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2699.7 | 2499.7 | 2499.7 | 2299.7 | Fáze 2 | 0 | 576.682 | 511.712 | Zpětný vzduch | ETA 7 | 0.821955 | 166 | Odváděný | ETA | 370.25 | 710 | 710 × 400 | 400 | PO02.03.0484 | 0484 | yes | ETA 7
13768028 | -1.PP_SO-102 | 710 | 0.224451 | 1.3648 | 710 mm × 400 mm | 0 | 710 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 100 | 3164.66 | 3023.24 | 2626.46 | 2485.04 | Fáze 2 | 0 | 576.682 | 511.712 | Zpětný vzduch | ETA 7 | 1.2457 | 166 | Odváděný | ETA | 561.128 | 710 | 710 × 400 | 400 | PO02.03.0485 | 0485 | yes | ETA 7
13768261 | -1.PP_SO-102 | 800 | 0.145424 | 1.22343 | 800 mm × 355 mm | 0 | 800 mm × 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 100 | 3085.34 | 2959.83 | 2670.17 | 2544.66 | Fáze 1 | 0 | 570.981 | 491.775 | Zpětný vzduch | ETA 7 | 0.946279 | 390 | Odváděný | ETA | 409.645 | 800 | 800 × 355 | 355 | PO02.03.0486 | 0486 | yes | ETA 7
13768877 | -1.PP_SO-102 | 500 | 1.00306 | 2.12276 | 710 mm × 500 mm | 0 | 710 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3330 | 3080 | 3080 | 2830 | Fáze 1 | 0 | 648.843 | 586.777 | Zpětný vzduch | ETA 7 | 3.41887 | 158 | Odváděný | ETA | 1412.76 | 710 | 710 × 500 | 500 | PO02.03.0487 | 0487 | yes | ETA 7
13770164 | 2.NP_SO-102 | 145.172 | 0.315 | 0.32809 | 630 mm × 500 mm | 0 | 630 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 3117.89 | 3117.89 | 2972.72 | 2972.72 | Fáze 1 | 0 | 612.517 | 557.522 | Zpětný vzduch | ETA 7 | 0.32809 | 128 | Odváděný | ETA | 145.172 | 630 | 630 × 500 | 500 | PO02.03.0516 | 0516 | yes | ETA 7
13770540 | 3.NP_SO-102 | 426.363 | 0.25 | 0.852726 | 500 mm × 500 mm | 0 | 500 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 |  | 3641.36 | 3641.36 | 3215 | 3215 | Fáze 1 | 0 | 546.583 | 500 | Zpětný vzduch | ETA 7 | 0.852726 | 123 | Odváděný | ETA | 426.363 | 500 | 500 × 500 | 500 | PO02.03.0517 | 0517 | yes | ETA 7
13786605 | -1.PP_SO-102 | 1100 | 0.393819 | 5.641 | 2400 mm × 1100 mm | 0 | 2400 mm × 1100 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 79 | -471 | -471 | -1021 | Fáze 1 | 0 | 1743.53 | 1508.57 | Přívod vzduchu | SUP 24 | 1.14864 | 423 | Přívodní | SUP | 164.091 | 2400 | 2400 × 1100 | 1100 | PO02.03.0518 | 0518 | yes | SUP 24
13786740 | -1.PP_SO-102 | 416.827 | 1.5625 | 2.08414 | 1250 mm × 1250 mm | 0 | 1250 mm × 1250 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 |  | 2039 | 2039 | 1622.17 | 1622.17 | Fáze 1 | 0 | 1366.46 | 1250 | Přívod vzduchu | SUP 24 | 2.08414 | 5 | Přívodní | SUP | 416.827 | 1250 | 1250 × 1250 | 1250 | PO02.03.0519 | 0519 | yes | SUP 24
13786811 | -1.PP_SO-102 | 1100 | 1.28155 | 6.45476 | 2400 mm × 1100 mm | 0 | 2400 mm × 1100 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 79 | -471 | -471 | -1021 | Fáze 1 | 0 | 1743.53 | 1508.57 | Odváděný vzduch | EHA 11 | 3.73787 | 1 | Znehodnocený | EHA | 533.981 | 2400 | 2400 × 1100 | 1100 | PO02.03.0520 | 0520 | yes | EHA 11
13788069 | -1.PP_SO-102 | 500 | 0.0594565 | 0.793741 | 710 mm × 500 mm | 0 | 710 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3330 | 3080 | 3080 | 2830 | Fáze 1 | 0 | 648.843 | 586.777 | Zpětný vzduch | ETA 7 | 0.202654 | 158 | Odváděný | ETA | 83.7415 | 710 | 710 × 500 | 500 | PO02.03.0521 | 0521 | yes | ETA 7
13788424 | -1.PP_SO-102 | 400 | 0.0501305 | 0.931807 | 1120 mm × 400 mm | 0 | 1120 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2685.78 | 2485.78 | 2485.78 | 2285.78 | Fáze 1 | 0 | 708.812 | 589.474 | Zpětný vzduch | ETA 1 | 0.136068 | 1 | Odváděný | ETA | 44.7594 | 1120 | 1120 × 400 | 400 | PO02.03.0522 | 0522 | yes | ETA 1
13788668 | -1.PP_SO-102 | 400 | 0.245156 | 1.07111 | 1120 mm × 400 mm | 0 | 1120 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2685.78 | 2485.78 | 2485.78 | 2285.78 | Fáze 1 | 0 | 708.812 | 589.474 | Zpětný vzduch | ETA 1 | 0.665423 | 1 | Odváděný | ETA | 218.889 | 1120 | 1120 × 400 | 400 | PO02.03.0523 | 0523 | yes | ETA 1
13788786 | -1.PP_SO-102 | 400 | 0.0645887 | 0.704589 | 800 mm × 400 mm | 0 | 800 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2600 | 2400 | 2400 | 2200 | Fáze 1 | 0 | 609.35 | 533.333 | Zpětný vzduch | ETA 1 | 0.193766 | 80 | Odváděný | ETA | 80.7359 | 800 | 800 × 400 | 400 | PO02.03.0524 | 0524 | yes | ETA 1
13789035 | -1.PP_SO-102 | 400 | 0.65788 | 1.36591 | 1120 mm × 400 mm | 0 | 1120 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3200 | 3000 | 3000 | 2800 | Fáze 1 | 0 | 708.812 | 589.474 | Zpětný vzduch | ETA 7 | 1.78567 | 177 | Odváděný | ETA | 587.393 | 1120 | 1120 × 400 | 400 | PO02.03.0525 | 0525 | yes | ETA 7
13789043 | -1.PP_SO-102 | 400 | 0.213766 | 1.04869 | 1120 mm × 400 mm | 0 | 1120 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3200 | 3000 | 3000 | 2800 | Fáze 1 | 0 | 708.812 | 589.474 | Zpětný vzduch | ETA 7 | 0.580223 | 177 | Odváděný | ETA | 190.863 | 1120 | 1120 × 400 | 400 | PO02.03.0526 | 0526 | yes | ETA 7
13789156 | -1.PP_SO-102 | 400 | 1.73254 | 2.13353 | 1120 mm × 400 mm | 0 | 1120 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3200 | 3000 | 3000 | 2800 | Fáze 1 | 0 | 708.812 | 589.474 | Zpětný vzduch | ETA 7 | 4.70261 | 177 | Odváděný | ETA | 1546.91 | 1120 | 1120 × 400 | 400 | PO02.03.0527 | 0527 | yes | ETA 7
13789465 | -1.PP_SO-102 | 400 | 0.559995 | 1.19999 | 800 mm × 400 mm | 0 | 800 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2600 | 2400 | 2400 | 2200 | Fáze 1 | 0 | 609.35 | 533.333 | Zpětný vzduch | ETA 1 | 1.67998 | 80 | Odváděný | ETA | 699.994 | 800 | 800 × 400 | 400 | PO02.03.0528 | 0528 | yes | ETA 1
13789605 | -1.PP_SO-102 | 400 | 1.15673 | 1.79673 | 800 mm × 400 mm | 0 | 800 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0.00738377 | 3180.11 | 2980.11 | 2980 | 2780 | Fáze 1 | 0 | 609.35 | 533.333 | Zpětný vzduch | ETA 1 | 3.47018 | 80 | Odváděný | ETA | 1445.91 | 800 | 800 × 400 | 400 | PO02.03.0529 | 0529 | yes | ETA 1
13789717 | -1.PP_SO-102 | 800 | 0.184749 | 1.379 | 800 mm × 400 mm | 0 | 800 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 100 | 2994.77 | 2853.35 | 2526.76 | 2385.34 | Fáze 1 | 0 | 609.35 | 533.333 | Zpětný vzduch | ETA 1 | 1.10849 | 80 | Odváděný | ETA | 461.872 | 800 | 800 × 400 | 400 | PO02.03.0530 | 0530 | yes | ETA 1
13791764 | 1.NP_SO-102 | 280 | 0.106476 | 0.399253 | 500 mm × 280 mm | 0 | 500 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-102 | 0 | 2940 | 2800 | 2800 | 2660 | Fáze 1 | 0 | 404.809 | 358.974 | Zpětný vzduch | ETA 7 | 0.332205 | 129 | Odváděný | ETA | 212.952 | 500 | 500 × 280 | 280 | PO02.03.0534 | 0534 | yes | ETA 7
13792026 | 3.NP_SO-102 | 40.299 | 0.25 | 0.080598 | 500 mm × 500 mm | 0 | 500 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 |  | 2885 | 2885 | 2844.7 | 2844.7 | Fáze 1 | 0 | 546.583 | 500 | Zpětný vzduch | ETA 7 | 0.080598 | 322 | Odváděný | ETA | 40.299 | 500 | 500 × 500 | 500 | PO02.03.0535 | 0535 | yes | ETA 7
13792243 | 2.NP_SO-102 | 280 | 0.0381502 | 0.386711 | 630 mm × 280 mm | 0 | 630 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2947.72 | 2807.72 | 2807.72 | 2667.72 | Fáze 1 | 0 | 450.033 | 387.692 | Zpětný vzduch | ETA 7 | 0.110212 | 1 | Odváděný | ETA | 60.5559 | 630 | 630 × 280 | 280 | PO02.03.0536 | 0536 | yes | ETA 7 | Identifikační data - Komentáře: VZT18
13792398 | 2.NP_SO-102 | 3677.72 | 0.315 | 8.31164 | 630 mm × 500 mm | 0 | 630 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 2642.72 | 2642.72 | -1035 | -1035 | Fáze 1 | 0 | 612.517 | 557.522 | Zpětný vzduch | ETA 7 | 8.31164 | 130 | Odváděný | ETA | 3677.72 | 630 | 630 × 500 | 500 | PO02.03.0537 | 0537 | yes | ETA 7 | Identifikační data - Komentáře: VZT19
13792458 | 1.NP_SO-102 | 3150 | 0.315 | 7.119 | 630 mm × 500 mm | 0 | 630 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-102 |  | 2635 | 2635 | -515 | -515 | Fáze 1 | 0 | 612.517 | 557.522 | Zpětný vzduch | ETA 7 | 7.119 | 213 | Odváděný | ETA | 3150 | 630 | 630 × 500 | 500 | PO02.03.0538 | 0538 | yes | ETA 7 | Identifikační data - Komentáře: VZT18
13792563 | -1.PP_SO-102 | 630 | 0.671845 | 2.25222 | 1250 mm × 630 mm | 15 | 1280 mm × 660 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3405 | 3090 | 3090 | 2775 | Fáze 1 | 0 | 956.226 | 837.766 | Přívod vzduchu | SUP 24 | 2.02091 | 152 | Přívodní | SUP | 537.476 | 1250 | 1250 × 630 | 630 | PO02.03.0539 | 0539 | yes | SUP 24 | Izolace - Typ izolace: Protipožární
13792751 | 1.NP_SO-102 | 3232.74 | 0.284 | 7.17668 | 710 mm × 400 mm | 15 | 740 mm × 430 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-102 |  | 2246.64 | -986.097 | 2246.64 | -986.097 | Fáze 1 | 0 | 576.682 | 511.712 | Přívod vzduchu | ODA 12 | 7.17668 | 11 | Čerstvý | ODA | 3232.74 | 710 | 710 × 400 | 400 | PO02.03.0540 | 0540 | yes | ODA 12 | Identifikační data - Komentáře: VZT29; Izolace - Typ izolace: Protipožární
13792771 | 2.NP_SO-102 | 4024.07 | 0.36 | 10.0602 | 800 mm × 450 mm | 15 | 830 mm × 480 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 2379.35 | 2379.35 | -1644.72 | -1644.72 | Fáze 1 | 0 | 649.239 | 576 | Přívod vzduchu | ODA 12 | 10.0602 | 12 | Čerstvý | ODA | 4024.07 | 800 | 800 × 450 | 450 | PO02.03.0541 | 0541 | yes | ODA 12 | Identifikační data - Komentáře: VZT29; Izolace - Typ izolace: Protipožární
13792850 | 3.NP_SO-102 | 3672.5 | 0.5 | 11.0175 | 1000 mm × 500 mm | 15 | 1030 mm × 530 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 |  | 2251.85 | 2251.85 | -1420.65 | -1420.65 | Fáze 1 | 0 | 761.687 | 666.667 | Přívod vzduchu | ODA 12 | 11.0175 | 14 | Čerstvý | ODA | 3672.5 | 1000 | 1000 × 500 | 500 | PO02.03.0542 | 0542 | yes | ODA 12 | Identifikační data - Komentáře: VZT29; Izolace - Typ izolace: Protipožární
13793387 | 4.NP_SO-102 | 280 | 0.18711 | 0.51912 | 630 mm × 280 mm | 0 | 630 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 | 0 | 3190 | 3050 | 3050 | 2910 | Fáze 1 | 0 | 450.033 | 387.692 | Zpětný vzduch | ETA 7 | 0.54054 | 132 | Odváděný | ETA | 297 | 630 | 630 × 280 | 280 | PO02.03.0544 | 0544 | yes | ETA 7 | Identifikační data - Komentáře: VZT18
13793886 | 4.NP_SO-102 | 1018.03 | 0.355 | 2.46362 | 500 mm × 710 mm | 0 | 500 mm × 710 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 |  | 363.028 | -655 | 363.026 | -655.002 | Fáze 1 | 0 | 648.843 | 586.777 | Přívod vzduchu | SUP 24 | 2.46362 | 137 | Přívodní | SUP | 1018.03 | 500 | 500 × 710 | 710 | PO02.03.0545 | 0545 | yes | SUP 24 | Identifikační data - Komentáře: VZT18
13793963 | 2.NP_SO-102 | 3364.68 | 0.625 | 11.7764 | 1250 mm × 500 mm | 0 | 1250 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 768721 | 2734.72 | 2734.68 | -630 | -630.033 | Fáze 1 | 0 | 842.576 | 714.286 | Přívod vzduchu | SUP 24 | 11.7764 | 156 | Přívodní | SUP | 3364.68 | 1250 | 1250 × 500 | 500 | PO02.03.0546 | 0546 | yes | SUP 24 | Identifikační data - Komentáře: VZT18
13794033 | 3.NP_SO-102 | 2160.19 | 0.355 | 5.22767 | 500 mm × 710 mm | 0 | 500 mm × 710 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 |  | 2735 | 574.808 | 2735 | 574.807 | Fáze 1 | 0 | 648.843 | 586.777 | Přívod vzduchu | SUP 24 | 5.22767 | 149 | Přívodní | SUP | 2160.19 | 500 | 500 × 710 | 710 | PO02.03.0547 | 0547 | yes | SUP 24
13794178 | 1.NP_SO-102 | 3260 | 0.625 | 11.41 | 1250 mm × 500 mm | 0 | 1250 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-102 | 802302 | 2820.03 | 2820 | -440 | -440.031 | Fáze 1 | 0 | 842.576 | 714.286 | Přívod vzduchu | SUP 24 | 11.41 | 151 | Přívodní | SUP | 3260 | 1250 | 1250 × 500 | 500 | PO02.03.0548 | 0548 | yes | SUP 24 | Identifikační data - Komentáře: VZT18
13794358 | 1.NP_SO-102 | 280 | 1.01842 | 1.51936 | 450 mm × 280 mm | 15 | 480 mm × 310 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-102 | 0 | 3130.01 | 2990.01 | 2990.01 | 2850.01 | Fáze 1 | 0 | 385.34 | 345.205 | Přívod vzduchu | ODA 25 | 3.30419 | 10 | Čerstvý | ODA | 2263.15 | 450 | 450 × 280 | 280 | PO02.03.0549 | 0549 | yes | ODA 25 | Izolace - Typ izolace: Protipožární; Fázování - Bouráno ve FÁZI 2: yes
13797487 | -1.PP_SO-102 | 560 | 2.09763 | 3.35203 | 1120 mm × 560 mm | 0 | 1120 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2685.78 | 2405.78 | 2405.78 | 2125.78 | Fáze 1 | 0 | 853.09 | 746.667 | Zpětný vzduch | ETA 1 | 6.2929 | 78 | Odváděný | ETA | 1872.89 | 1120 | 1120 × 560 | 560 | PO02.03.0560 | 0560 | yes | ETA 1
13801708 | 4.NP_SO-102 | 450 | 0.324277 | 1.0337 | 500 mm × 450 mm | 0 | 500 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 | 0 | 5550.5 | 5325.5 | 5325.5 | 5100.5 | Fáze 2 | 0 | 518.354 | 473.684 | Přívod vzduchu | ODA 21 | 1.23225 | 4 | Čerstvý | ODA | 648.554 | 500 | 500 × 450 | 450 | PO02.03.0562 | 0562 | yes | ODA 21
13801709 | 4.NP_SO-102 | 630 | 1.05909 | 2.77411 | 710 mm × 630 mm | 0 | 710 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 | 0 | 5640.5 | 5325.5 | 5325.5 | 5010.5 | Fáze 2 | 0 | 730.788 | 667.612 | Přívod vzduchu | ODA 21 | 3.99768 | 3 | Čerstvý | ODA | 1491.67 | 710 | 710 × 630 | 630 | PO02.03.0563 | 0563 | yes | ODA 21
13802119 | 4.NP_SO-102 | 450 | 1.30483 | 2.7987 | 500 mm × 450 mm | 0 | 500 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 | 0 | 5550.5 | 5325.5 | 5325.5 | 5100.5 | Fáze 2 | 0 | 518.354 | 473.684 | Přívod vzduchu | ODA 21 | 4.95837 | 4 | Čerstvý | ODA | 2609.67 | 500 | 500 × 450 | 450 | PO02.03.0564 | 0564 | yes | ODA 21 | Identifikační data - Komentáře: VZT31
13802203 | 4.NP_SO-102 | 450 | 0.739308 | 1.78076 | 500 mm × 450 mm | 0 | 500 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 | 0 | 5075 | 4850 | 4850 | 4625 | Fáze 1 | 0 | 518.354 | 473.684 | Přívod vzduchu | ODA 10 | 2.80937 | 2 | Čerstvý | ODA | 1478.62 | 500 | 500 × 450 | 450 | PO02.03.0565 | 0565 | yes | ODA 10
13802204 | 4.NP_SO-102 | 630 | 0.18948 | 1.23086 | 710 mm × 630 mm | 0 | 710 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 | 0 | 5165 | 4850 | 4850 | 4535 | Fáze 1 | 0 | 730.788 | 667.612 | Přívod vzduchu | ODA 4 | 0.71522 | 2 | Čerstvý | ODA | 266.873 | 710 | 710 × 630 | 630 | PO02.03.0566 | 0566 | yes | ODA 4
13802748 | 4.NP_SO-102 | 500 | 0.868855 | 2.14303 | 1600 mm × 500 mm | 0 | 1600 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 | 0 | 4829.33 | 4579.33 | 4579.33 | 4329.33 | Fáze 1 | 0 | 939.333 | 761.905 | Odváděný vzduch | EHA 1 | 2.28074 | 1 | Znehodnocený | EHA | 543.034 | 1600 | 1600 × 500 | 500 | PO02.03.0567 | 0567 | yes | EHA 1 | Identifikační data - Komentáře: VZT18
13802896 | 4.NP_SO-102 | 315 | 0.243185 | 0.684821 | 315 mm × 315 mm | 0 | 315 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 | 0 | 4722.99 | 4565.49 | 4565.49 | 4407.99 | Fáze 1 | 0 | 344.347 | 315 | Zpětný vzduch | ETA 97 | 0.972741 | 43 | Odváděný | ETA | 772.017 | 315 | 315 × 315 | 315 | PO02.03.0568 | 0568 | yes | ETA 97
13802899 | 4.NP_SO-102 | 630 | 0.914999 | 2.5184 | 710 mm × 630 mm | 0 | 710 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 | 0 | 5215 | 4900 | 4900 | 4585 | Fáze 1 | 0 | 730.788 | 667.612 | Odváděný vzduch | EHA 3 | 3.4538 | 2 | Znehodnocený | EHA | 1288.73 | 710 | 710 × 630 | 630 | PO02.03.0569 | 0569 | yes | EHA 3
13803523 | 3.NP_SO-102 | 280 | 1.09942 | 1.62016 | 450 mm × 280 mm | 15 | 480 mm × 310 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 | 0 | 3336.2 | 3196.2 | 3196.2 | 3056.2 | Fáze 1 | 0 | 385.34 | 345.205 | Přívod vzduchu | ODA 25 | 3.56699 | 13 | Čerstvý | ODA | 2443.15 | 450 | 450 × 280 | 280 | PO02.03.0573 | 0573 | yes | ODA 25 | Izolace - Typ izolace: Protipožární; Fázování - Bouráno ve FÁZI 2: yes
13803541 | 3.NP_SO-102 | 3770 | 0.225 | 7.163 | 450 mm × 500 mm | 15 | 480 mm × 530 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 |  | 3031.2 | 3031.2 | -738.796 | -738.796 | Fáze 1 | 0 | 518.354 | 473.684 | Přívod vzduchu | ODA 25 | 7.163 | 3 | Čerstvý | ODA | 3770 | 450 | 450 × 500 | 500 | PO02.03.0574 | 0574 | yes | ODA 25 | Identifikační data - Komentáře: Protipožární izolace; Izolace - Typ izolace: Protipožární; Fázování - Bouráno ve FÁZI 2: yes
13805111 | -1.PP_SO-102 | 500 | 4.46638 | 4.39149 | 1600 mm × 500 mm | 0 | 1600 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3340 | 3090 | 3090 | 2840 | Fáze 1 | 0 | 939.333 | 761.905 | Přívod vzduchu | SUP 24 | 11.7242 | 422 | Přívodní | SUP | 2791.49 | 1600 | 1600 × 500 | 500 | PO02.03.0576 | 0576 | yes | SUP 24
13805548 | -1.PP_SO-102 | 710 | 0.887145 | 2.7828 | 1250 mm × 710 mm | 0 | 1250 mm × 710 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2905 | 2550 | 2550 | 2195 | Fáze 1 | 0 | 1019.73 | 905.612 | Přívod vzduchu | SUP 24 | 2.78209 | 3 | Přívodní | SUP | 709.716 | 1250 | 1250 × 710 | 710 | PO02.03.0577 | 0577 | yes | SUP 24
13806063 | -1.PP_SO-102 | 355 | 0.2216 | 0.76467 | 800 mm × 355 mm | 0 | 800 mm × 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2727.5 | 2550 | 2550 | 2372.5 | Fáze 2 | 0 | 570.981 | 491.775 | Zpětný vzduch | ETA 7 | 0.63987 | 390 | Odváděný | ETA | 277 | 800 | 800 × 355 | 355 | PO02.03.0579 | 0579 | yes | ETA 7 | Identifikační data - Komentáře: ZASLEPENÁ ODBOČKA PŘÍPRAVA PRO NAPOJENÍ MÍSTNOSTÍ VE II.ETAPĚ VÝSTAVBY
13806114 | -1.PP_SO-102 | 400 | 2.58315 | 3.47859 | 710 mm × 400 mm | 0 | 710 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3350 | 3150 | 3150 | 2950 | Fáze 2 | 0 | 576.682 | 511.712 | Zpětný vzduch | ETA 7 | 8.0769 | 166 | Odváděný | ETA | 3638.24 | 710 | 710 × 400 | 400 | PO02.03.0580 | 0580 | yes | ETA 7
13806374 | -1.PP_SO-102 | 3399.17 | 0.04 | 2.71934 | 200 mm × 200 mm | 0 | 200 mm × 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 |  | 2728.4 | 2728.4 | -670.772 | -670.772 | Fáze 1 | 0 | 218.633 | 200 | Zpětný vzduch | ETA 7 | 2.71934 | 214 | Odváděný | ETA | 3399.17 | 200 | 200 × 200 | 200 | PO02.03.0584 | 0584 | no | ETA 7
13807816 | 4.NP_SO-102 | 450 | 0.382288 | 1.13812 | 500 mm × 450 mm | 0 | 500 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 | 0 | 5075 | 4850 | 4850 | 4625 | Fáze 1 | 0 | 518.354 | 473.684 | Přívod vzduchu | ODA 10 | 1.45269 | 135 | Čerstvý | ODA | 764.576 | 500 | 500 × 450 | 450 | PO02.03.0591 | 0591 | yes | ODA 10
13808637 | -1.PP_SO-102 | 500 | 0.109831 | 0.674578 | 400 mm × 500 mm | 15 | 430 mm × 530 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | -1200 | -1450 | -1450 | -1700 | Fáze 1 | 0 | 488.12 | 444.444 | Přívod vzduchu | ODA 12 | 0.494241 | 5 | Čerstvý | ODA | 274.578 | 400 | 400 × 500 | 500 | PO02.03.0593 | 0593 | yes | ODA 12 | Izolace - Typ izolace: Protipožární
13809266 | -1.PP_SO-102 | 500 | 1.96899 | 2.80642 | 1400 mm × 500 mm | 0 | 1400 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3300 | 3050 | 3050 | 2800 | Fáze 1 | 0 | 886.015 | 736.842 | Odváděný vzduch | EHA 1 | 5.3444 | 3 | Znehodnocený | EHA | 1406.42 | 1400 | 1400 × 500 | 500 | PO02.03.0594 | 0594 | yes | EHA 1
13809790 | -1.PP_SO-102 | 500 | 9.87661 | 7.77288 | 1600 mm × 500 mm | 0 | 1600 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3340 | 3090 | 3090 | 2840 | Fáze 1 | 0 | 939.333 | 761.905 | Přívod vzduchu | SUP 24 | 25.9261 | 422 | Přívodní | SUP | 6172.88 | 1600 | 1600 × 500 | 500 | PO02.03.0595 | 0595 | yes | SUP 24
13809872 | -1.PP_SO-102 | 710 | 3.25998 | 5.47833 | 1250 mm × 710 mm | 0 | 1250 mm × 710 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2655 | 2300 | 2300 | 1945 | Fáze 1 | 0 | 1019.73 | 905.612 | Odváděný vzduch | EHA 17 | 10.2233 | 15 | Znehodnocený | EHA | 2607.98 | 1250 | 1250 × 710 | 710 | PO02.03.0596 | 0596 | yes | EHA 17
13810242 | -1.PP_SO-102 | 500 | 14.042 | 10.3762 | 1600 mm × 500 mm | 15 | 1630 mm × 530 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3340 | 3090 | 3090 | 2840 | Fáze 1 | 0 | 939.333 | 761.905 | Přívod vzduchu | SUP 24 | 36.8602 | 422 | Přívodní | SUP | 8776.25 | 1600 | 1600 × 500 | 500 | PO02.03.0598 | 0598 | yes | SUP 24 | Izolace - Typ izolace: Protipožární
13810297 | -1.PP_SO-102 | 500 | 3.36413 | 5.96989 | 630 mm × 500 mm | 0 | 630 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3330 | 3080 | 3080 | 2830 | Fáze 1 | 0 | 612.517 | 557.522 | Zpětný vzduch | ETA 7 | 12.0682 | 433 | Odváděný | ETA | 5339.89 | 630 | 630 × 500 | 500 | PO02.03.0599 | 0599 | yes | ETA 7
13814132 | -1.PP_SO-102 | 500 | 1.11886 | 2.40597 | 630 mm × 500 mm | 0 | 630 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3330 | 3080 | 3080 | 2830 | Fáze 1 | 0 | 612.517 | 557.522 | Zpětný vzduch | ETA 7 | 4.01369 | 433 | Odváděný | ETA | 1775.97 | 630 | 630 × 500 | 500 | PO02.03.0607 | 0607 | yes | ETA 7
13817544 | -1.PP_SO-102 | 400 | 0.838752 | 1.47875 | 800 mm × 400 mm | 0 | 800 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3330 | 3130 | 3130 | 2930 | Fáze 2 | 0 | 609.35 | 533.333 | Přívod vzduchu | SUP 24 | 2.51626 | 555 | Přívodní | SUP | 1048.44 | 800 | 800 × 400 | 400 | PO02.03.0610 | 0610 | yes | SUP 24
13818909 | 2.NP_SO-102 | 280 | 0.0396662 | 0.301362 | 450 mm × 280 mm | 15 | 480 mm × 310 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3236.2 | 3096.2 | 3096.2 | 2956.2 | Fáze 1 | 0 | 385.34 | 345.205 | Přívod vzduchu | ODA 25 | 0.128695 | 2 | Čerstvý | ODA | 88.1472 | 450 | 450 × 280 | 280 | PO02.03.0620 | 0620 | yes | ODA 25 | Identifikační data - Komentáře: VZT32; Izolace - Typ izolace: Protipožární; Fázování - Bouráno ve FÁZI 2: yes
13819022 | 3.NP_SO-102 | 3646.19 | 0.225 | 6.92777 | 450 mm × 500 mm | 15 | 480 mm × 530 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 |  | -1068.8 | -1068.8 | -4714.99 | -4714.99 | Fáze 1 | 0 | 518.354 | 473.684 | Přívod vzduchu | ODA 25 | 6.92777 | 11 | Čerstvý | ODA | 3646.19 | 450 | 450 × 500 | 500 | PO02.03.0621 | 0621 | yes | ODA 25 | Identifikační data - Komentáře: VZT32; Izolace - Typ izolace: Protipožární; Fázování - Bouráno ve FÁZI 2: yes
13819538 | 4.NP_SO-102 | 400 | 0.08838 | 0.51712 | 450 mm × 400 mm | 15 | 480 mm × 430 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 | 0 | 3296.2 | 3096.2 | 3096.2 | 2896.2 | Fáze 1 | 0 | 463.59 | 423.529 | Přívod vzduchu | ODA 25 | 0.33388 | 14 | Čerstvý | ODA | 196.4 | 450 | 450 × 400 | 400 | PO02.03.0622 | 0622 | yes | ODA 25 | Identifikační data - Komentáře: Protipožární izolace; Izolace - Typ izolace: Protipožární; Fázování - Bouráno ve FÁZI 2: yes
13820449 | 2.NP_SO-102 | 400 | 0.439659 | 1.15173 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3120 | 2920 | 2920 | 2720 | Fáze 1 | 0 | 674.06 | 571.429 | Zpětný vzduch | ETA 14 | 1.23105 | 192 | Odváděný | ETA | 439.659 | 1000 | 1000 × 400 | 400 | PO02.03.0630 | 0630 | yes | ETA 14
13820647 | 2.NP_SO-102 | 400 | 0.259434 | 1.16604 | 1250 mm × 400 mm | 0 | 1250 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3120 | 2920 | 2920 | 2720 | Fáze 1 | 0 | 743.753 | 606.061 | Zpětný vzduch | ETA 14 | 0.684906 | 5 | Odváděný | ETA | 207.547 | 1250 | 1250 × 400 | 400 | PO02.03.0631 | 0631 | yes | ETA 14
13820676 | 2.NP_SO-102 | 400 | 1.03059 | 1.65957 | 1250 mm × 400 mm | 0 | 1250 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3080 | 2880 | 2880 | 2680 | Fáze 1 | 0 | 743.753 | 606.061 | Přívod vzduchu | SUP 9 | 2.72074 | 4 | Přívodní | SUP | 824.468 | 1250 | 1250 × 400 | 400 | PO02.03.0632 | 0632 | yes | SUP 9
13823917 | 2.NP_SO-102 | 600 | 0.0164476 | 1.51579 | 1250 mm × 600 mm | 0 | 1250 mm × 600 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3000 | 2700 | 2700 | 2400 | Fáze 1 | 0 | 931.244 | 810.811 | Odváděný vzduch | EHA 5 | 0.048685 | 4 | Znehodnocený | EHA | 13.1581 | 1250 | 1250 × 600 | 600 | PO02.03.0637 | 0637 | yes | EHA 5
13824854 | 2.NP_SO-102 | 400 | 1.13338 | 1.7067 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 277943 | 32.5825 | 2.94444 | 7.36111 | 1.0887 | 0.960578 | 2.NP_SO-102 | 0 | 2950 | 2750 | 2750 | 2550 | Fáze 1 | 0.0334136 | 674.06 | 571.429 | Přívod vzduchu | ODA 14 | 3.17346 | 2 | Čerstvý | ODA | 1133.38 | 1000 | 1000 × 400 | 400 | PO02.03.0642 | 0642 | yes | ODA 14
13824906 | 2.NP_SO-102 | 400 | 2.15484 | 2.52387 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 277943 | 32.5825 | 2.94444 | 7.36111 | 2.06989 | 0.960578 | 2.NP_SO-102 | 0 | 2950 | 2750 | 2750 | 2550 | Fáze 1 | 0.0635278 | 674.06 | 571.429 | Přívod vzduchu | ODA 14 | 6.03356 | 2 | Čerstvý | ODA | 2154.84 | 1000 | 1000 × 400 | 400 | PO02.03.0643 | 0643 | yes | ODA 14
13825193 | 2.NP_SO-102 | 560 | 1.37423 | 2.63131 | 1250 mm × 560 mm | 0 | 1250 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2980 | 2700 | 2700 | 2420 | Fáze 1 | 0 | 896.83 | 773.481 | Přívod vzduchu | SUP 13 | 3.97977 | 305 | Přívodní | SUP | 1099.38 | 1250 | 1250 × 560 | 560 | PO02.03.0644 | 0644 | yes | SUP 13
13825221 | 2.NP_SO-102 | 400 | 0.612677 | 1.7123 | 1800 mm × 400 mm | 0 | 1800 mm × 400 mm | 176873 | 10.0563 | 2.94444 | 4.08951 | 0.0918814 | 0.269941 | 2.NP_SO-102 | 0 | 2950 | 2750 | 2750 | 2550 | Fáze 1 | 0.00913667 | 869.302 | 654.545 | Přívod vzduchu | ODA 14 | 1.49765 | 3 | Čerstvý | ODA | 340.376 | 1800 | 1800 × 400 | 400 | PO02.03.0645 | 0645 | yes | ODA 14
13825707 | 2.NP_SO-102 | 600 | 0.937691 | 2.34867 | 1120 mm × 600 mm | 0 | 1120 mm × 600 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3000 | 2700 | 2700 | 2400 | Fáze 1 | 0 | 885.456 | 781.395 | Odváděný vzduch | EHA 5 | 2.88005 | 3 | Znehodnocený | EHA | 837.224 | 1120 | 1120 × 600 | 600 | PO02.03.0646 | 0646 | yes | EHA 5
13838386 | 3.NP_SO-102 | 300 | 1.0824 | 1.2918 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 | 0 | 3350 | 3200 | 3200 | 3050 | Fáze 1 | 0 | 520.268 | 436.364 | Zpětný vzduch | ETA 53 | 2.9766 | 2 | Odváděný | ETA | 1353 | 800 | 800 × 300 | 300 | PO02.03.0681 | 0681 | no | ETA 53
13840483 | -1.PP_SO-102 | 355 | 3.34864 | 3.53992 | 800 mm × 355 mm | 0 | 800 mm × 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3257.5 | 3080 | 3080 | 2902.5 | Fáze 1 | 0 | 570.981 | 491.775 | Zpětný vzduch | ETA 7 | 9.6692 | 390 | Odváděný | ETA | 4185.8 | 800 | 800 × 355 | 355 | PO02.03.0736 | 0736 | yes | ETA 7
13845460 | 2.NP_SO-102 | 31 | 0.72 | 0.1364 | 1800 mm × 400 mm | 0 | 1800 mm × 400 mm | 176873 | 10.0563 | 2.94444 | 4.08951 | 0.00836817 | 0.269941 | 2.NP_SO-102 |  | 2395 | 2364 | 2395 | 2364 | Fáze 1 | 0.000832129 | 869.302 | 654.545 | Přívod vzduchu | ODA 14 | 0.1364 | 3 | Čerstvý | ODA | 31 | 1800 | 1800 × 400 | 400 | PO02.03.0737 | 0737 | yes | ODA 14
13845474 | 2.NP_SO-102 | 900 | 0.0402824 | 3.63625 | 2000 mm × 900 mm | 0 | 2000 mm × 900 mm | 134179 | 1.60901 | 2.94444 | 1.6358 | 0.000461388 | 0.0229077 | 2.NP_SO-102 | 0 | 2259 | 1809 | 1809 | 1359 | Fáze 1 | 0.000286752 | 1438.43 | 1241.38 | Přívod vzduchu | ODA 14 | 0.116819 | 5 | Čerstvý | ODA | 20.1412 | 2000 | 2000 × 900 | 900 | PO02.03.0738 | 0738 | yes | ODA 14
13846045 | 2.NP_SO-102 | 710 | 0.0868475 | 2.62451 | 1800 mm × 710 mm | 0 | 1800 mm × 710 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 1064 | 709 | 709 | 354 | Fáze 1 | 0 | 1203.95 | 1018.33 | Přívod vzduchu | SUP 13 | 0.242208 | 2 | Přívodní | SUP | 48.2486 | 1800 | 1800 × 710 | 710 | PO02.03.0739 | 0739 | yes | SUP 13
13846246 | 2.NP_SO-102 | 710 | 0.0835712 | 2.62193 | 1800 mm × 710 mm | 0 | 1800 mm × 710 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 1064 | 709 | 709 | 354 | Fáze 1 | 0 | 1203.95 | 1018.33 | Přívod vzduchu | SUP 13 | 0.233071 | 2 | Přívodní | SUP | 46.4285 | 1800 | 1800 × 710 | 710 | PO02.03.0740 | 0740 | yes | SUP 13
13846541 | 2.NP_SO-102 | 560 | 0.410077 | 1.76743 | 1250 mm × 560 mm | 0 | 1250 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2980 | 2700 | 2700 | 2420 | Fáze 1 | 0 | 896.83 | 773.481 | Přívod vzduchu | SUP 13 | 1.18758 | 305 | Přívodní | SUP | 328.062 | 1250 | 1250 × 560 | 560 | PO02.03.0741 | 0741 | yes | SUP 13
13846672 | 2.NP_SO-102 | 560 | 0.366759 | 1.72862 | 1250 mm × 560 mm | 0 | 1250 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3080 | 2800 | 2800 | 2520 | Fáze 1 | 0 | 896.83 | 773.481 | Zpětný vzduch | ETA 3 | 1.06213 | 27 | Odváděný | ETA | 293.407 | 1250 | 1250 × 560 | 560 | PO02.03.0742 | 0742 | yes | ETA 3
13846867 | 2.NP_SO-102 | 560 | 0.0782346 | 1.4701 | 1250 mm × 560 mm | 0 | 1250 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3080 | 2800 | 2800 | 2520 | Fáze 1 | 0 | 896.83 | 773.481 | Zpětný vzduch | ETA 3 | 0.226567 | 27 | Odváděný | ETA | 62.5877 | 1250 | 1250 × 560 | 560 | PO02.03.0743 | 0743 | yes | ETA 3
13846927 | 2.NP_SO-102 | 560 | 0.221734 | 1.59867 | 1250 mm × 560 mm | 0 | 1250 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3080 | 2800 | 2800 | 2520 | Fáze 1 | 0 | 896.83 | 773.481 | Zpětný vzduch | ETA 3 | 0.642142 | 12 | Odváděný | ETA | 177.387 | 1250 | 1250 × 560 | 560 | PO02.03.0744 | 0744 | yes | ETA 3
13846941 | 2.NP_SO-102 | 560 | 0.376053 | 1.73694 | 1250 mm × 560 mm | 0 | 1250 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3080 | 2800 | 2800 | 2520 | Fáze 1 | 0 | 896.83 | 773.481 | Zpětný vzduch | ETA 3 | 1.08905 | 12 | Odváděný | ETA | 300.843 | 1250 | 1250 × 560 | 560 | PO02.03.0745 | 0745 | yes | ETA 3
13847076 | 2.NP_SO-102 | 46 | 2.25 | 0.2806 | 1800 mm × 1250 mm | 0 | 1800 mm × 1250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 2365 | 2365 | 2319 | 2319 | Fáze 1 | 0 | 1632.99 | 1475.41 | Zpětný vzduch | ETA 3 | 0.2806 | 13 | Odváděný | ETA | 46 | 1800 | 1800 × 1250 | 1250 | PO02.03.0746 | 0746 | yes | ETA 3
13850147 | 2.NP_SO-102 | 400 | 0.938061 | 1.60036 | 1250 mm × 400 mm | 0 | 1250 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3080 | 2880 | 2880 | 2680 | Fáze 1 | 0 | 743.753 | 606.061 | Přívod vzduchu | SUP 9 | 2.47648 | 4 | Přívodní | SUP | 750.449 | 1250 | 1250 × 400 | 400 | PO02.03.0760 | 0760 | yes | SUP 9
13850642 | -1.PP_SO-102 | 110 | 2.64 | 0.77 | 2400 mm × 1100 mm | 0 | 2400 mm × 1100 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 |  | 1665 | 1665 | 1555 | 1555 | Fáze 1 | 0 | 1743.53 | 1508.57 | Zpětný vzduch | ETA 1 | 0.77 | 71 | Odváděný | ETA | 110 | 2400 | 2400 × 1100 | 1100 | PO02.03.0763 | 0763 | yes | ETA 1
13853075 | -1.PP_SO-102 | 1100 | 0.102212 | 5.37369 | 2400 mm × 1100 mm | 0 | 2400 mm × 1100 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 79 | -471 | -471 | -1021 | Fáze 1 | 0 | 1743.53 | 1508.57 | Přívod vzduchu | SUP 24 | 0.298117 | 423 | Přívodní | SUP | 42.5882 | 2400 | 2400 × 1100 | 1100 | PO02.03.0764 | 0764 | yes | SUP 24
13854334 | -1.PP_SO-102 | 560 | 0.772166 | 2.33252 | 1600 mm × 560 mm | 0 | 1600 mm × 560 mm | 244729 | 11.984 | 4 | 4.46429 | 0.115142 | 0.238584 | -1.PP_SO-102 | 0 | 2063.91 | 1783.91 | 1783.91 | 1503.91 | Fáze 1 | 0.00960795 | 1001.2 | 829.63 | Přívod vzduchu | ODA 8 | 2.08485 | 7 | Čerstvý | ODA | 482.604 | 1600 | 1600 × 560 | 560 | PO02.03.0766 | 0766 | yes | ODA 8
13854620 | -1.PP_SO-102 | 560 | 0.968 | 2.4696 | 1600 mm × 560 mm | 0 | 1600 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 839 | 559 | 559 | 279 | Fáze 1 | 0 | 1001.2 | 829.63 | Přívod vzduchu | ODA 8 | 2.6136 | 9 | Čerstvý | ODA | 605 | 1600 | 1600 × 560 | 560 | PO02.03.0767 | 0767 | yes | ODA 8
13854744 | -1.PP_SO-102 | 560 | 0.241485 | 1.61637 | 1250 mm × 560 mm | 0 | 1250 mm × 560 mm | 292053 | 19.6346 | 4 | 5.71429 | 0.0797248 | 0.412679 | -1.PP_SO-102 | 0 | 2680 | 2400 | 2400 | 2120 | Fáze 1 | 0.00406043 | 896.83 | 773.481 | Přívod vzduchu | ODA 8 | 0.699341 | 4 | Čerstvý | ODA | 193.188 | 1250 | 1250 × 560 | 560 | PO02.03.0768 | 0768 | yes | ODA 8
13855113 | 2.NP_SO-102 | 400 | 0.790694 | 1.67535 | 1600 mm × 400 mm | 0 | 1600 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2850 | 2650 | 2650 | 2450 | Fáze 1 | 0 | 827.082 | 640 | Odváděný vzduch | EHA 8 | 1.97673 | 3 | Znehodnocený | EHA | 494.184 | 1600 | 1600 × 400 | 400 | PO02.03.0769 | 0769 | yes | EHA 8
13855468 | 2.NP_SO-102 | 800 | 0.313433 | 3.15861 | 1800 mm × 800 mm | 0 | 1800 mm × 800 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 959 | 559 | 559 | 159 | Fáze 1 | 0 | 1285.81 | 1107.69 | Odváděný vzduch | EHA 10 | 0.905474 | 3 | Znehodnocený | EHA | 174.13 | 1800 | 1800 × 800 | 800 | PO02.03.0770 | 0770 | yes | EHA 10
13855528 | 2.NP_SO-102 | 800 | 0.313433 | 3.15861 | 1800 mm × 800 mm | 0 | 1800 mm × 800 mm | 104481 | 1.22527 | 2.05556 | 1.42747 | 0.00357202 | 0.0205136 | 2.NP_SO-102 | 0 | 1959 | 1559 | 1559 | 1159 | Fáze 1 | 0.00291529 | 1285.81 | 1107.69 | Přívod vzduchu | ODA 3 | 0.905474 | 4 | Čerstvý | ODA | 174.13 | 1800 | 1800 × 800 | 800 | PO02.03.0771 | 0771 | yes | ODA 3
13855917 | 2.NP_SO-102 | 5006 | 0.405 | 13.5162 | 450 mm × 900 mm | 0 | 450 mm × 900 mm | 201222 | 15.4898 | 2.05556 | 5.07545 | 2.24911 | 0.449284 | 2.NP_SO-102 |  | 7120 | 7120 | 2114 | 2114 | Fáze 1 | 0.1452 | 685.519 | 600 | Přívod vzduchu | ODA 3 | 13.5162 | 2 | Čerstvý | ODA | 5006 | 450 | 450 × 900 | 900 | PO02.03.0772 | 0772 | yes | ODA 3
13863442 | 2.NP_SO-102 | 900 | 0.028352 | 3.62552 | 2000 mm × 900 mm | 0 | 2000 mm × 900 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 1159 | 709 | 709 | 259 | Fáze 1 | 0 | 1438.43 | 1241.38 | Přívod vzduchu | SUP 13 | 0.0822209 | 1 | Přívodní | SUP | 14.176 | 2000 | 2000 × 900 | 900 | PO02.03.0773 | 0773 | yes | SUP 13
13864021 | 1.NP_SO-102 | 17490.5 | 0.099225 | 22.038 | 315 mm × 315 mm | 0 | 315 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-102 |  | 16253 | -1237.5 | 16253 | -1237.5 | Fáze 1 | 0 | 344.347 | 315 | Zpětný vzduch | ETA 97 | 22.038 | 43 | Odváděný | ETA | 17490.5 | 315 | 315 × 315 | 315 | PO02.03.0774 | 0774 | yes | ETA 97 | Identifikační data - Komentáře: VZT27
13864192 | 4.NP_SO-102 | 315 | 0.401625 | 1.0017 | 315 mm × 315 mm | 0 | 315 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 | 0 | 4722.99 | 4565.49 | 4565.49 | 4407.99 | Fáze 1 | 0 | 344.347 | 315 | Zpětný vzduch | ETA 97 | 1.6065 | 43 | Odváděný | ETA | 1275 | 315 | 315 × 315 | 315 | PO02.03.0775 | 0775 | yes | ETA 97 | Identifikační data - Komentáře: VZT27
13865861 | -1.PP_SO-102 | 7150.45 | 0.0504 | 6.79293 | 315 mm × 160 mm | 0 | 315 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 1.11888 | 2659.99 | 2500 | 2580 | 2420.01 | Fáze 2 | 0 | 241.985 | 212.211 | Zpětný vzduch | ETA 4 | 6.79293 | 14 | Odváděný | ETA | 7150.45 | 315 | 315 × 160 | 160 | PO02.03.0791 | 0791 | yes | ETA 4 | Identifikační data - Komentáře: PŘIPOJENÍ PŘÍVODNÍHO A ODVODNÍHO POTRUBÍ V II.ETAPĚ VÝSTAVBY
13865985 | -1.PP_SO-102 | 160 | 0.379081 | 0.485898 | 315 mm × 160 mm | 0 | 315 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2660 | 2580 | 2580 | 2500 | Fáze 1 | 0 | 241.985 | 212.211 | Zpětný vzduch | ETA 97 | 1.14326 | 11 | Odváděný | ETA | 1203.43 | 315 | 315 × 160 | 160 | PO02.03.0792 | 0792 | yes | ETA 97
13866224 | -1.PP_SO-102 | 160 | 4.2525 | 4.4208 | 315 mm × 160 mm | 0 | 315 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2660 | 2580 | 2580 | 2500 | Fáze 2 | 0 | 241.985 | 212.211 | Zpětný vzduch | ETA 97 | 12.825 | 27 | Odváděný | ETA | 13500 | 315 | 315 × 160 | 160 | PO02.03.0793 | 0793 | yes | ETA 97 | Identifikační data - Komentáře: PŘIPOJENÍ ODVODNÍHO POTRUBÍ V II.ETAPĚ VÝSTAVBY
13866260 | -1.PP_SO-102 | 160 | 6.60505 | 6.81069 | 315 mm × 160 mm | 0 | 315 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2660 | 2580 | 2580 | 2500 | Fáze 1 | 0 | 241.985 | 212.211 | Zpětný vzduch | ETA 97 | 19.92 | 17 | Odváděný | ETA | 20968.4 | 315 | 315 × 160 | 160 | PO02.03.0794 | 0794 | yes | ETA 97
13873058 | 4.NP_SO-102 | 752.677 | 0.125 | 1.12901 | 250 mm × 500 mm | 0 | 250 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 |  | 122.837 | -629.839 | 122.837 | -629.839 | Fáze 1 | 0 | 380.844 | 333.333 | Přívod vzduchu | SUP 9 | 1.12901 | 201 | Přívodní | SUP | 752.677 | 250 | 250 × 500 | 500 | PO02.03.0843 | 0843 | yes | SUP 9
13892879 | 2.NP_SO-102 | 400 | 1.28087 | 1.81976 | 1250 mm × 400 mm | 0 | 1250 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3120 | 2920 | 2920 | 2720 | Fáze 1 | 0 | 743.753 | 606.061 | Zpětný vzduch | ETA 14 | 3.38149 | 485 | Odváděný | ETA | 1024.7 | 1250 | 1250 × 400 | 400 | PO02.03.0916 | 0916 | yes | ETA 14
13896278 | 2.NP_SO-102 | 315 | 0.892947 | 1.35736 | 560 mm × 315 mm | 0 | 560 mm × 315 mm | 146838 | 18.2655 | 0.972222 | 5.51146 | 1.35748 | 0.851325 | 2.NP_SO-102 | 0 | 2932.5 | 2775 | 2775 | 2617.5 | Fáze 1 | 0.0743192 | 454.468 | 403.2 | Přívod vzduchu | ODA 7 | 2.79046 | 5 | Čerstvý | ODA | 1594.55 | 560 | 560 × 315 | 315 | PO02.03.0923 | 0923 | yes | ODA 7
13896345 | 2.NP_SO-102 | 315 | 0.276946 | 0.664364 | 560 mm × 315 mm | 0 | 560 mm × 315 mm | 146838 | 18.2655 | 0.972222 | 5.51146 | 0.42102 | 0.851325 | 2.NP_SO-102 | 0 | 2932.5 | 2775 | 2775 | 2617.5 | Fáze 1 | 0.02305 | 454.468 | 403.2 | Přívod vzduchu | ODA 7 | 0.865457 | 5 | Čerstvý | ODA | 494.547 | 560 | 560 × 315 | 315 | PO02.03.0924 | 0924 | yes | ODA 7
13896608 | 2.NP_SO-102 | 630 | 0.0778953 | 1.49883 | 1120 mm × 630 mm | 0 | 1120 mm × 630 mm | 73418.8 | 1.14159 | 0.972222 | 1.37787 | 0.00197012 | 0.028327 | 2.NP_SO-102 | 0 | 3090 | 2775 | 2775 | 2460 | Fáze 1 | 0.00172577 | 908.935 | 806.4 | Přívod vzduchu | ODA 7 | 0.243423 | 4 | Čerstvý | ODA | 69.5494 | 1120 | 1120 × 630 | 630 | PO02.03.0925 | 0925 | yes | ODA 7
13896852 | 2.NP_SO-102 | 630 | 0.0424928 | 1.459 | 1120 mm × 630 mm | 0 | 1120 mm × 630 mm | 73418.8 | 1.14159 | 0.972222 | 1.37787 | 0.00107473 | 0.028327 | 2.NP_SO-102 | 0 | 3090 | 2775 | 2775 | 2460 | Fáze 1 | 0.000941425 | 908.935 | 806.4 | Přívod vzduchu | ODA 7 | 0.13279 | 4 | Čerstvý | ODA | 37.94 | 1120 | 1120 × 630 | 630 | PO02.03.0926 | 0926 | yes | ODA 7
13897049 | 2.NP_SO-102 | 600 | 0.015 | 1.5144 | 1250 mm × 600 mm | 0 | 1250 mm × 600 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3000 | 2700 | 2700 | 2400 | Fáze 1 | 0 | 931.244 | 810.811 | Odváděný vzduch | EHA 5 | 0.0444 | 4 | Znehodnocený | EHA | 12 | 1250 | 1250 × 600 | 600 | PO02.03.0927 | 0927 | yes | EHA 5
13898590 | -1.PP_SO-102 | 160 | 2.79361 | 2.93875 | 315 mm × 160 mm | 0 | 315 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2660 | 2580 | 2580 | 2500 | Fáze 1 | 0 | 241.985 | 212.211 | Zpětný vzduch | ETA 97 | 8.42517 | 25 | Odváděný | ETA | 8868.6 | 315 | 315 × 160 | 160 | PO02.03.0928 | 0928 | yes | ETA 97 | Identifikační data - Komentáře: ZASLEPENÁ ODBOČKA PŘÍPRAVA PRO NAPOJENÍ MÍSTNOSTÍ VE II.ETAPĚ VÝSTAVBY
13898654 | -1.PP_SO-102 | 160 | 2.6145 | 2.7568 | 315 mm × 160 mm | 0 | 315 mm × 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2660 | 2580 | 2580 | 2500 | Fáze 1 | 0 | 241.985 | 212.211 | Zpětný vzduch | ETA 97 | 7.885 | 37 | Odváděný | ETA | 8300 | 315 | 315 × 160 | 160 | PO02.03.0929 | 0929 | yes | ETA 97 | Identifikační data - Komentáře: ZASLEPENÁ ODBOČKA PŘÍPRAVA PRO NAPOJENÍ MÍSTNOSTÍ VE II.ETAPĚ VÝSTAVBY
13900352 | -1.PP_SO-102 | 400 | 0.0670339 | 0.479171 | 450 mm × 400 mm | 15 | 480 mm × 430 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2800 | 2600 | 2600 | 2400 | Fáze 1 | 0 | 463.59 | 423.529 | Přívod vzduchu | ODA 12 | 0.253239 | 9 | Čerstvý | ODA | 148.964 | 450 | 450 × 400 | 400 | PO02.03.0930 | 0930 | yes | ODA 12 | Izolace - Typ izolace: Protipožární
13900592 | -1.PP_SO-102 | 148.133 | 0.16 | 0.237014 | 400 mm × 400 mm | 0 | 400 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 |  | -896.867 | -1045 | -896.867 | -1045 | Fáze 1 | 0 | 437.266 | 400 | Přívod vzduchu | ODA 12 | 0.237014 | 6 | Čerstvý | ODA | 148.133 | 400 | 400 × 400 | 400 | PO02.03.0931 | 0931 | yes | ODA 12
13902975 | -1.PP_SO-102 | 400 | 0.158906 | 0.747049 | 710 mm × 400 mm | 0 | 710 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3350 | 3150 | 3150 | 2950 | Fáze 2 | 0 | 576.682 | 511.712 | Zpětný vzduch | ETA 7 | 0.496862 | 397 | Odváděný | ETA | 223.812 | 710 | 710 × 400 | 400 | PO02.03.0940 | 0940 | yes | ETA 7
13917221 | -1.PP_SO-102 | 2924.59 | 0.1 | 3.80196 | 250 mm × 400 mm | 15 | 280 mm × 430 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 |  | 2208.79 | -715.801 | 2208.79 | -715.801 | Fáze 1 | 0 | 343.333 | 307.692 | Přívod vzduchu | ODA 12 | 3.80196 | 7 | Čerstvý | ODA | 2924.59 | 250 | 250 × 400 | 400 | PO02.03.0987 | 0987 | yes | ODA 12 | Identifikační data - Komentáře: VZT29; Izolace - Typ izolace: Protipožární
13917535 | 1.NP_SO-102 | 280 | 0.121098 | 0.41563 | 500 mm × 280 mm | 0 | 500 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-102 | 0 | 3168.08 | 3028.08 | 3028.08 | 2888.08 | Fáze 2 | 0 | 404.809 | 358.974 | Zpětný vzduch | ETA 7 | 0.377826 | 405 | Odváděný | ETA | 242.196 | 500 | 500 × 280 | 280 | PO02.03.0988 | 0988 | yes | ETA 7 | Identifikační data - Komentáře: VZT18
13917767 | 2.NP_SO-102 | 280 | 0.071083 | 0.359613 | 500 mm × 280 mm | 0 | 500 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3140 | 3000 | 3000 | 2860 | Fáze 2 | 0 | 404.809 | 358.974 | Zpětný vzduch | ETA 7 | 0.221779 | 404 | Odváděný | ETA | 142.166 | 500 | 500 × 280 | 280 | PO02.03.0989 | 0989 | yes | ETA 7 | Identifikační data - Komentáře: VZT18
13917901 | 3.NP_SO-102 | 280 | 0.102897 | 0.395245 | 500 mm × 280 mm | 0 | 500 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 | 0 | 3235 | 3095 | 3095 | 2955 | Fáze 2 | 0 | 404.809 | 358.974 | Zpětný vzduch | ETA 7 | 0.321038 | 403 | Odváděný | ETA | 205.794 | 500 | 500 × 280 | 280 | PO02.03.0990 | 0990 | yes | ETA 7 | Identifikační data - Komentáře: VZT18
13917950 | 4.NP_SO-102 | 280 | 0.105053 | 0.397659 | 500 mm × 280 mm | 0 | 500 mm × 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 | 0 | 3200 | 3060 | 3060 | 2920 | Fáze 2 | 0 | 404.809 | 358.974 | Zpětný vzduch | ETA 7 | 0.327765 | 402 | Odváděný | ETA | 210.106 | 500 | 500 × 280 | 280 | PO02.03.0991 | 0991 | yes | ETA 7 | Identifikační data - Komentáře: VZT18
13918301 | 2.NP_SO-102 | 10548.9 | 0.3976 | 26.7943 | 710 mm × 560 mm | 15 | 740 mm × 590 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 12945.5 | 2396.57 | 12945.5 | 2396.57 | Fáze 2 | 0 | 688.092 | 626.142 | Přívod vzduchu | ODA 21 | 26.7943 | 6 | Čerstvý | ODA | 10548.9 | 710 | 710 × 560 | 560 | PO02.03.0992 | 0992 | yes | ODA 21 | Identifikační data - Komentáře: VZT31; Izolace - Typ izolace: Protipožární
13921635 | 4.NP_SO-102 | 450 | 3.28989 | 6.37181 | 500 mm × 450 mm | 0 | 500 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | STŘECHA_SO-102 | 0 | 1465 | 1240 | 1240 | 1015 | Fáze 1 | 0 | 518.354 | 473.684 | Přívod vzduchu | ODA 25 | 12.5016 | 6 | Čerstvý | ODA | 6579.79 | 500 | 500 × 450 | 450 | PO02.03.0997 | 0997 | yes | ODA 25 | Fázování - Bouráno ve FÁZI 2: yes
13921643 | 4.NP_SO-102 | 450 | 0.221009 | 0.847816 | 500 mm × 450 mm | 0 | 500 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | STŘECHA_SO-102 | 0 | 1465 | 1240 | 1240 | 1015 | Fáze 1 | 0 | 518.354 | 473.684 | Přívod vzduchu | ODA 25 | 0.839833 | 6 | Čerstvý | ODA | 442.017 | 500 | 500 × 450 | 450 | PO02.03.0998 | 0998 | yes | ODA 25 | Identifikační data - Komentáře: VZT32; Fázování - Bouráno ve FÁZI 2: yes
13921778 | 4.NP_SO-102 | 280 | 0.1764 | 0.5096 | 630 mm × 280 mm | 15 | 660 mm × 310 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 | 0 | 2940 | 2800 | 2800 | 2660 | Fáze 1 | 0 | 450.033 | 387.692 | Přívod vzduchu | ODA 12 | 0.5096 | 20 | Čerstvý | ODA | 280 | 630 | 630 × 280 | 280 | PO02.03.0999 | 0999 | yes | ODA 12 | Izolace - Typ izolace: Protipožární
13922245 | 3.NP_SO-102 | 280 | 0.129354 | 0.467782 | 630 mm × 280 mm | 15 | 660 mm × 310 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 | 0 | 3236.2 | 3096.2 | 3096.2 | 2956.2 | Fáze 1 | 0 | 450.033 | 387.692 | Přívod vzduchu | ODA 12 | 0.373691 | 21 | Čerstvý | ODA | 205.325 | 630 | 630 × 280 | 280 | PO02.03.1000 | 1000 | yes | ODA 12 | Izolace - Typ izolace: Protipožární
13934449 | 2.NP_SO-102 | 315 | 3.04997 | 2.32468 | 1250 mm × 315 mm | 0 | 1250 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3037.5 | 2880 | 2880 | 2722.5 | Fáze 1 | 0 | 649.124 | 503.195 | Přívod vzduchu | SUP 9 | 7.63712 | 449 | Přívodní | SUP | 2439.98 | 1250 | 1250 × 315 | 315 | PO02.03.1021 | 1021 | yes | SUP 9
