Properties of the parts of a building model (IFC4), part 37 of 45

# IfcDuctFitting: Pravoúhlý přechod, koleno, poloměr, přírubový:Standardní (78)
Name (Pravoúhlý přechod, koleno, poloměr, přírubový:Standardní:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | alfa (deg) = alfa 2 (deg) = alfa 3 (deg) = alfa 4 (deg) | a (mm) = c (mm) = Výš. (mm) | b (mm) | d (mm) | Objem (m3) | Příruba a (mm) = Příruba c (mm) | Příruba b (mm) | Příruba d (mm) | Velikost | Kód prvku | Označení | Páteřní trasa | Délka 5 (mm) | alfa 1 (deg) | Délka 1 (mm) | Délka 10 (mm) | Délka 11 (mm) | Délka 12 (mm) | Délka 13 (mm) | Délka 14 (mm) | Délka 15 (mm) | Délka 16 (mm) | Délka 18 (mm) = Délka 19 (mm) | Délka 2 (mm) | Délka 20 (mm) = Délka 21 (mm) = Posouzení 2 (mm) | Délka 22 (mm) | Délka 23 (mm) = r2 (mm) = r3 (mm) | Délka 24 (mm) | Délka 25 (mm) | Délka 3 (mm) | Délka 4 (mm) | Délka 6 (mm) | Délka 7 (mm) | Délka 8 (mm) | Délka 9 (mm) | Max ab (mm) | Max abcd (mm) | Max bd (mm) | Max cd (mm) | Polovina b (mm) | Posouzení 1 (mm) | r4 (mm) | Šířka 1 (mm) | Tlaková ztráta (Pa)
13847116 | 2.NP_SO-102 | 1800 | 0.03905 | 2.754 | 1250 mm × 1800 mm-710 mm × 1800 mm | 0 | 1250 mm × 1800 mm-710 mm × 1800 mm | 2.NP_SO-102 | 1809 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 90 | 1800 | 710 | 1250 | 1.89476 | 1860 | 770 | 1310 | 1250 × 1800-710 × 1800 | TA00.03.0418 | 0418 | yes | -270 | 90 | 10725 | 0 | 50 | 0 | 5 | 1400 | 860 | 1574.36 | 1350 | 455 | 0 | 810 | 810 | 710 | 1450 | 725 | 455 | 10000 | 0 | 455 | 775 | 1800 | 1800 | 1250 | 1800 | 355 | 1350 | 1310 | 1805 | 0
13847167 | 2.NP_SO-102 | 1250 | 0.099 | 4.6375 | 1800 mm × 1250 mm-560 mm × 1250 mm | 0 | 1800 mm × 1250 mm-560 mm × 1250 mm | 2.NP_SO-102 | 2800 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 90 | 1250 | 1800 | 560 | 1.60308 | 1310 | 1860 | 620 | 1800 × 1250-560 × 1250 | TA00.03.0420 | 0420 | yes | 620 | 90 | 10380 | 0 | 50 | 0 | 5 | 710 | 1950 | 2011.37 | 660 | 1000 | 0 | 660 | 660 | 560 | 760 | 380 | 1000 | 10000 | 0 | 1000 | 430 | 1800 | 1800 | 1800 | 1250 | 900 | 660 | 1160 | 2900 | 0
13850769 | -1.PP_SO-102 | 2400 | 0.0605 | 5.544 | 1100 mm × 2400 mm-1100 mm × 2400 mm | 0 | 1100 mm × 2400 mm-1100 mm × 2400 mm | -1.PP_SO-102 | 850 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 90 | 2400 | 1100 | 1100 | 2.9846 | 2460 | 1160 | 1160 | 1100 × 2400-1100 × 2400 | TA00.03.0435 | 0435 | yes | 0 | 90 | 10650 | 0 | 50 | 0 | 5 | 1250 | 1250 | 1697.06 | 1200 | 650 | 0 | 1200 | 1200 | 1100 | 1300 | 650 | 650 | 10000 | 0 | 650 | 700 | 2400 | 2400 | 1100 | 2400 | 550 | 1200 | 1700 | 1850
13850772 | -1.PP_SO-102 | 1100 | 0.0308 | 1.353 | 2400 mm × 1100 mm-560 mm × 1100 mm | 0 | 2400 mm × 1100 mm-560 mm × 1100 mm | -1.PP_SO-102 | 2100 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 90 | 1100 | 560 | 2400 | 1.88261 | 1160 | 620 | 2460 | 2400 × 1100-560 × 1100 | TA00.03.0436 | 0436 | yes | -920 | 90 | 11300 | 0 | 50 | 0 | 5 | 2550 | 710 | 2585.65 | 2500 | 380 | 0 | 660 | 660 | 560 | 2600 | 1300 | 380 | 10000 | 0 | 380 | 1350 | 1100 | 2400 | 2400 | 2400 | 280 | 2500 | 1160 | 2880
13850984 | -1.PP_SO-102 | 2400 | 0.0605 | 5.544 | 1100 mm × 2400 mm-1100 mm × 2400 mm | 0 | 1100 mm × 2400 mm-1100 mm × 2400 mm | -1.PP_SO-102 | -471 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 2400 | 1100 | 1100 | 2.9846 | 2460 | 1160 | 1160 | 1100 × 2400-1100 × 2400 | TA00.03.0437 | 0437 | yes | 0 | 90 | 10650 | 0 | 50 | 0 | 5 | 1250 | 1250 | 1697.06 | 1200 | 650 | 0 | 1200 | 1200 | 1100 | 1300 | 650 | 650 | 10000 | 0 | 650 | 700 | 2400 | 2400 | 1100 | 2400 | 550 | 1200 | 1700 | 1850 | 0
13864237 | 4.NP_SO-102 | 315 | 0.017325 | 0.2331 | 315 mm × 315 mm-315 mm × 315 mm | 0 | 315 mm × 315 mm-315 mm × 315 mm | STŘECHA_SO-102 | 715.494 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 97 | ETA | 90 | 315 | 315 | 315 | 0.0510487 | 375 | 375 | 375 | 315 × 315-315 × 315 | TA00.03.0451 | 0451 | yes | 0 | 90 | 10257.5 | 0 | 50 | 0 | 5 | 465 | 465 | 586.899 | 415 | 257.5 | 0 | 415 | 415 | 315 | 515 | 257.5 | 257.5 | 10000 | 0 | 257.5 | 307.5 | 315 | 315 | 315 | 315 | 157.5 | 415 | 915 | 672.5
13900082 | 1.NP_SO-102 | 630 | 0.0275 | 0.6993 | 500 mm × 630 mm-500 mm × 630 mm | 0 | 500 mm × 630 mm-500 mm × 630 mm | 1.NP_SO-102 | -920 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 630 | 500 | 500 | 0.207829 | 690 | 560 | 560 | 500 × 630-500 × 630 | TA00.03.0634 | 0634 | yes | 0 | 90 | 10350 | 0 | 50 | 0 | 5 | 650 | 650 | 848.528 | 600 | 350 | 0 | 600 | 600 | 500 | 700 | 350 | 350 | 10000 | 0 | 350 | 400 | 630 | 630 | 500 | 630 | 250 | 600 | 1100 | 950
13919002 | 4.NP_SO-102 | 630 | 0.0275 | 0.6993 | 500 mm × 630 mm-500 mm × 630 mm | 0 | 500 mm × 630 mm-500 mm × 630 mm | STŘECHA_SO-102 | 690.06 | Fáze 2 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | 90 | 630 | 500 | 500 | 0.207829 | 690 | 560 | 560 | 500 × 630-500 × 630 | TA00.03.0704 | 0704 | yes | 0 | 90 | 10350 | 0 | 50 | 0 | 5 | 650 | 650 | 848.528 | 600 | 350 | 0 | 600 | 600 | 500 | 700 | 350 | 350 | 10000 | 0 | 350 | 400 | 630 | 630 | 500 | 630 | 250 | 600 | 1100 | 950 | 0
13919409 | -1.PP_SO-102 | 630 | 0.0275 | 0.6993 | 500 mm × 630 mm-500 mm × 630 mm | 0 | 500 mm × 630 mm-500 mm × 630 mm | -1.PP_SO-102 | 2930 | Fáze 2 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | 90 | 630 | 500 | 500 | 0.207829 | 690 | 560 | 560 | 500 × 630-500 × 630 | TA00.03.0706 | 0706 | yes | 0 | 90 | 10350 | 0 | 50 | 0 | 5 | 650 | 650 | 848.528 | 600 | 350 | 0 | 600 | 600 | 500 | 700 | 350 | 350 | 10000 | 0 | 350 | 400 | 630 | 630 | 500 | 630 | 250 | 600 | 1100 | 950 | 0
13957037 | -1.PP_SO-102 | 560 | 0.088 | 1.8536 | 1600 mm × 560 mm-1100 mm × 560 mm | 0 | 1600 mm × 560 mm-1100 mm × 560 mm | -1.PP_SO-102 | 2100 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 90 | 560 | 1600 | 1100 | 1.04814 | 620 | 1660 | 1160 | 1600 × 560-1100 × 560 | TA00.03.0811 | 0811 | yes | 250 | 90 | 10650 | 0 | 50 | 0 | 5 | 1250 | 1750 | 2080.87 | 1200 | 900 | 0 | 1200 | 1200 | 1100 | 1300 | 650 | 900 | 10000 | 0 | 900 | 700 | 1600 | 1600 | 1600 | 1100 | 800 | 1200 | 1700 | 2600
13979909 | 3.NP_SO-102 | 300 | 0.0275 | 0.333 | 500 mm × 300 mm-500 mm × 300 mm | 0 | 500 mm × 300 mm-500 mm × 300 mm | 3.NP_SO-102 | 3200 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 33 | ETA | 90 | 300 | 500 | 500 | 0.0989663 | 360 | 560 | 560 | 500 × 300-500 × 300 | TA00.03.0863 | 0863 | no | 0 | 90 | 10350 | 0 | 50 | 0 | 5 | 650 | 650 | 848.528 | 600 | 350 | 0 | 600 | 600 | 500 | 700 | 350 | 350 | 10000 | 0 | 350 | 400 | 500 | 500 | 500 | 500 | 250 | 600 | 1100 | 950 | 0
13980604 | 4.NP_SO-102 | 200 | 0.0275 | 0.222 | 500 mm × 200 mm-500 mm × 200 mm | 0 | 500 mm × 200 mm-500 mm × 200 mm | 4.NP_SO-102 | 3200 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 67 | ETA | 90 | 200 | 500 | 500 | 0.0659775 | 260 | 560 | 560 | 500 × 200-500 × 200 | TA00.03.0864 | 0864 | no | 0 | 90 | 10350 | 0 | 50 | 0 | 5 | 650 | 650 | 848.528 | 600 | 350 | 0 | 600 | 600 | 500 | 700 | 350 | 350 | 10000 | 0 | 350 | 400 | 500 | 500 | 500 | 500 | 250 | 600 | 1100 | 950 | 0
14006810 | -1.PP_SO-102 | 500 | 0.044 | 0.855 | 800 mm × 500 mm-800 mm × 500 mm | 0 | 800 mm × 500 mm-800 mm × 500 mm | -1.PP_SO-102 | 3070 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 90 | 500 | 800 | 800 | 0.358157 | 560 | 860 | 860 | 800 × 500-800 × 500 | TA00.03.0942 | 0942 | yes | 0 | 90 | 10500 | 0 | 50 | 0 | 5 | 950 | 950 | 1272.79 | 900 | 500 | 0 | 900 | 900 | 800 | 1000 | 500 | 500 | 10000 | 0 | 500 | 550 | 800 | 800 | 800 | 800 | 400 | 900 | 1400 | 1400
14006836 | -1.PP_SO-102 | 500 | 0.044 | 0.855 | 800 mm × 500 mm-800 mm × 500 mm | 0 | 800 mm × 500 mm-800 mm × 500 mm | -1.PP_SO-102 | 3070 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 90 | 500 | 800 | 800 | 0.358157 | 560 | 860 | 860 | 800 × 500-800 × 500 | TA00.03.0944 | 0944 | yes | 0 | 90 | 10500 | 0 | 50 | 0 | 5 | 950 | 950 | 1272.79 | 900 | 500 | 0 | 900 | 900 | 800 | 1000 | 500 | 500 | 10000 | 0 | 500 | 550 | 800 | 800 | 800 | 800 | 400 | 900 | 1400 | 1400 | 0
14012970 | 2.NP_SO-102 | 450 | 0.055 | 0.9495 | 1000 mm × 450 mm-1000 mm × 450 mm | 0 | 1000 mm × 450 mm-1000 mm × 450 mm | 2.NP_SO-102 | 2159 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 11 | ETA | 90 | 450 | 1000 | 1000 | 0.473612 | 510 | 1060 | 1060 | 1000 × 450-1000 × 450 | TA00.03.0957 | 0957 | yes | 0 | 90 | 10600 | 0 | 50 | 0 | 5 | 1150 | 1150 | 1555.63 | 1100 | 600 | 0 | 1100 | 1100 | 1000 | 1200 | 600 | 600 | 10000 | 0 | 600 | 650 | 1000 | 1000 | 1000 | 1000 | 500 | 1100 | 1600 | 1700 | 0
14016684 | 2.NP_SO-102 | 1000 | 0.017325 | 0.74 | 400 mm × 1000 mm-315 mm × 1000 mm | 0 | 400 mm × 1000 mm-315 mm × 1000 mm | 2.NP_SO-102 | 2920 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 1000 | 315 | 400 | 0.202011 | 1060 | 375 | 460 | 400 × 1000-315 × 1000 | TA00.03.0960 | 0960 | yes | -42.5 | 90 | 10300 | 0 | 50 | 0 | 5 | 550 | 465 | 649.788 | 500 | 257.5 | 0 | 415 | 415 | 315 | 600 | 300 | 257.5 | 10000 | 0 | 257.5 | 350 | 1000 | 1000 | 400 | 1000 | 157.5 | 500 | 915 | 757.5 | 0
14033571 | 2.NP_SO-102 | 500 | 0.012375 | 0.28 | 225 mm × 500 mm-225 mm × 500 mm | 0 | 225 mm × 500 mm-225 mm × 500 mm | 2.NP_SO-102 | 2925 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 500 | 225 | 225 | 0.0499265 | 560 | 285 | 285 | 225 × 500-225 × 500 | TA00.03.0993 | 0993 | yes | 0 | 90 | 10212.5 | 0 | 50 | 0 | 5 | 375 | 375 | 459.619 | 325 | 212.5 | 0 | 325 | 325 | 225 | 425 | 212.5 | 212.5 | 10000 | 0 | 212.5 | 262.5 | 500 | 500 | 225 | 500 | 112.5 | 325 | 825 | 537.5 | 0
14033654 | 2.NP_SO-102 | 500 | 0.012375 | 0.28 | 225 mm × 500 mm-225 mm × 500 mm | 0 | 225 mm × 500 mm-225 mm × 500 mm | 2.NP_SO-102 | 3890 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 45 | 500 | 225 | 225 | 0.0311507 | 560 | 285 | 285 | 225 × 500-225 × 500 | TA00.03.0994 | 0994 | yes | 0 | 135 | 10088 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 375 | 279.81 | 248.744 | 229.81 | 212.5 | 95.1903 | 134.619 | 325 | 225 | 425 | 212.5 | 88.0204 | 9937.76 | 150.26 | 88.0204 | 138.02 | 500 | 500 | 225 | 500 | 112.5 | 134.619 | 825 | 537.5 | 0
14033691 | 3.NP_SO-102 | 500 | 0.012375 | 0.28 | 225 mm × 500 mm-225 mm × 500 mm | 0 | 225 mm × 500 mm-225 mm × 500 mm | 3.NP_SO-102 | 121.692 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 45 | 500 | 225 | 225 | 0.0311507 | 560 | 285 | 285 | 225 × 500-225 × 500 | TA00.03.0995 | 0995 | yes | 0 | 135 | 10088 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 375 | 279.81 | 248.744 | 229.81 | 212.5 | 95.1903 | 134.619 | 325 | 225 | 425 | 212.5 | 88.0204 | 9937.76 | 150.26 | 88.0204 | 138.02 | 500 | 500 | 225 | 500 | 112.5 | 134.619 | 825 | 537.5 | 0
14076906 | 2.NP_SO-102 | 1250 | 0.0275 | 1.3875 | 500 mm × 1250 mm-500 mm × 1250 mm | 0 | 500 mm × 1250 mm-500 mm × 1250 mm | 2.NP_SO-102 | 2870 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 1250 | 500 | 500 | 0.41236 | 1310 | 560 | 560 | 500 × 1250-500 × 1250 | TA00.03.1136 | 1136 | yes | 0 | 90 | 10350 | 0 | 50 | 0 | 5 | 650 | 650 | 848.528 | 600 | 350 | 0 | 600 | 600 | 500 | 700 | 350 | 350 | 10000 | 0 | 350 | 400 | 1250 | 1250 | 500 | 1250 | 250 | 600 | 1100 | 950 | 0
14077672 | 2.NP_SO-102 | 450 | 0.06875 | 1.1745 | 1250 mm × 450 mm-1250 mm × 450 mm | 0 | 1250 mm × 450 mm-1250 mm × 450 mm | 2.NP_SO-102 | 2895 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 450 | 1250 | 1250 | 0.7025 | 510 | 1310 | 1310 | 1250 × 450-1250 × 450 | TA00.03.1137 | 1137 | yes | 0 | 90 | 10725 | 0 | 50 | 0 | 5 | 1400 | 1400 | 1909.19 | 1350 | 725 | 0 | 1350 | 1350 | 1250 | 1450 | 725 | 725 | 10000 | 0 | 725 | 775 | 1250 | 1250 | 1250 | 1250 | 625 | 1350 | 1850 | 2075
14077783 | 2.NP_SO-102 | 1250 | 0.0275 | 1.3875 | 500 mm × 1250 mm-500 mm × 1250 mm | 0 | 500 mm × 1250 mm-500 mm × 1250 mm | 2.NP_SO-102 | 1559 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 1250 | 500 | 500 | 0.41236 | 1310 | 560 | 560 | 500 × 1250-500 × 1250 | TA00.03.1138 | 1138 | yes | 0 | 90 | 10350 | 0 | 50 | 0 | 5 | 650 | 650 | 848.528 | 600 | 350 | 0 | 600 | 600 | 500 | 700 | 350 | 350 | 10000 | 0 | 350 | 400 | 1250 | 1250 | 500 | 1250 | 250 | 600 | 1100 | 950 | 0
14083781 | 2.NP_SO-102 | 1000 | 0.02475 | 1.01 | 1000 mm × 1000 mm-450 mm × 1000 mm | 0 | 1000 mm × 1000 mm-450 mm × 1000 mm | 2.NP_SO-102 | 2159 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 11 | ETA | 90 | 1000 | 450 | 1000 | 0.611981 | 1060 | 510 | 1060 | 1000 × 1000-450 × 1000 | TA00.03.1177 | 1177 | yes | -275 | 90 | 10600 | 0 | 50 | 0 | 5 | 1150 | 600 | 1229.84 | 1100 | 325 | 0 | 550 | 550 | 450 | 1200 | 600 | 325 | 10000 | 0 | 325 | 650 | 1000 | 1000 | 1000 | 1000 | 225 | 1100 | 1050 | 1425 | 0
14084289 | 2.NP_SO-102 | 400 | 0.06875 | 1.044 | 1250 mm × 400 mm-1250 mm × 400 mm | 0 | 1250 mm × 400 mm-1250 mm × 400 mm | 2.NP_SO-102 | 2920 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 45 | 400 | 1250 | 1250 | 0.339706 | 460 | 1310 | 1310 | 1250 × 400-1250 × 400 | TA00.03.1180 | 1180 | yes | 0 | 135 | 10300.3 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 1400 | 1004.59 | 1033.25 | 954.594 | 725 | 395.406 | 559.188 | 1350 | 1250 | 1450 | 725 | 300.305 | 9787.65 | 512.652 | 300.305 | 350.305 | 1250 | 1250 | 1250 | 1250 | 625 | 559.188 | 1850 | 2075
14084353 | 2.NP_SO-102 | 400 | 0.06875 | 1.044 | 1250 mm × 400 mm-1250 mm × 400 mm | 0 | 1250 mm × 400 mm-1250 mm × 400 mm | 2.NP_SO-102 | 2920 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 45 | 400 | 1250 | 1250 | 0.339706 | 460 | 1310 | 1310 | 1250 × 400-1250 × 400 | TA00.03.1181 | 1181 | yes | 0 | 135 | 10300.3 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 1400 | 1004.59 | 1033.25 | 954.594 | 725 | 395.406 | 559.188 | 1350 | 1250 | 1450 | 725 | 300.305 | 9787.65 | 512.652 | 300.305 | 350.305 | 1250 | 1250 | 1250 | 1250 | 625 | 559.188 | 1850 | 2075
14106592 | 4.NP_SO-102 | 315 | 0.017325 | 0.2331 | 315 mm × 315 mm-315 mm × 315 mm | 0 | 315 mm × 315 mm-315 mm × 315 mm | STŘECHA_SO-102 | 715.494 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 97 | ETA | 90 | 315 | 315 | 315 | 0.0510487 | 375 | 375 | 375 | 315 × 315-315 × 315 | TA00.03.1185 | 1185 | yes | 0 | 90 | 10257.5 | 0 | 50 | 0 | 5 | 465 | 465 | 586.899 | 415 | 257.5 | 0 | 415 | 415 | 315 | 515 | 257.5 | 257.5 | 10000 | 0 | 257.5 | 307.5 | 315 | 315 | 315 | 315 | 157.5 | 415 | 915 | 672.5
14109686 | -1.PP_SO-102 | 355 | 0.044 | 0.60705 | 800 mm × 355 mm-800 mm × 355 mm | 0 | 800 mm × 355 mm-800 mm × 355 mm | -1.PP_SO-102 | 3080 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 355 | 800 | 800 | 0.254291 | 415 | 860 | 860 | 800 × 355-800 × 355 | TA00.03.1188 | 1188 | yes | 0 | 90 | 10500 | 0 | 50 | 0 | 5 | 950 | 950 | 1272.79 | 900 | 500 | 0 | 900 | 900 | 800 | 1000 | 500 | 500 | 10000 | 0 | 500 | 550 | 800 | 800 | 800 | 800 | 400 | 900 | 1400 | 1400
14109688 | -1.PP_SO-102 | 800 | 0.019525 | 0.656 | 355 mm × 800 mm-355 mm × 800 mm | 0 | 355 mm × 800 mm-355 mm × 800 mm | -1.PP_SO-102 | 3080 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 45 | 800 | 355 | 355 | 0.0931369 | 860 | 415 | 415 | 355 × 800-355 × 800 | TA00.03.1189 | 1189 | yes | 0 | 135 | 10114.9 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 505 | 371.734 | 348.242 | 321.734 | 277.5 | 133.266 | 188.467 | 455 | 355 | 555 | 277.5 | 114.944 | 9918.72 | 196.222 | 114.944 | 164.944 | 800 | 800 | 355 | 800 | 177.5 | 188.467 | 955 | 732.5
14110069 | -1.PP_SO-102 | 800 | 0.019525 | 0.656 | 355 mm × 800 mm-355 mm × 800 mm | 0 | 355 mm × 800 mm-355 mm × 800 mm | -1.PP_SO-102 | 2550 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 45 | 800 | 355 | 355 | 0.0931369 | 860 | 415 | 415 | 355 × 800-355 × 800 | TA00.03.1193 | 1193 | yes | 0 | 135 | 10114.9 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 505 | 371.734 | 348.242 | 321.734 | 277.5 | 133.266 | 188.467 | 455 | 355 | 555 | 277.5 | 114.944 | 9918.72 | 196.222 | 114.944 | 164.944 | 800 | 800 | 355 | 800 | 177.5 | 188.467 | 955 | 732.5
14110275 | -1.PP_SO-102 | 800 | 0.019525 | 0.656 | 355 mm × 800 mm-355 mm × 800 mm | 0 | 355 mm × 800 mm-355 mm × 800 mm | -1.PP_SO-102 | 2550 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 45 | 800 | 355 | 355 | 0.0931369 | 860 | 415 | 415 | 355 × 800-355 × 800 | TA00.03.1196 | 1196 | yes | 0 | 135 | 10114.9 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 505 | 371.734 | 348.242 | 321.734 | 277.5 | 133.266 | 188.467 | 455 | 355 | 555 | 277.5 | 114.944 | 9918.72 | 196.222 | 114.944 | 164.944 | 800 | 800 | 355 | 800 | 177.5 | 188.467 | 955 | 732.5
14110287 | -1.PP_SO-102 | 800 | 0.019525 | 0.656 | 355 mm × 800 mm-355 mm × 800 mm | 0 | 355 mm × 800 mm-355 mm × 800 mm | -1.PP_SO-102 | 3150 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 45 | 800 | 355 | 355 | 0.0931369 | 860 | 415 | 415 | 355 × 800-355 × 800 | TA00.03.1197 | 1197 | yes | 0 | 135 | 10114.9 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 505 | 371.734 | 348.242 | 321.734 | 277.5 | 133.266 | 188.467 | 455 | 355 | 555 | 277.5 | 114.944 | 9918.72 | 196.222 | 114.944 | 164.944 | 800 | 800 | 355 | 800 | 177.5 | 188.467 | 955 | 732.5
14116060 | -1.PP_SO-102 | 355 | 0.044 | 0.60705 | 800 mm × 355 mm-800 mm × 355 mm | 15 | 830 mm × 385 mm-830 mm × 385 mm | -1.PP_SO-102 | 2930 | Fáze 2 | Znehodnocený | Odváděný vzduch | EHA 7 | EHA | 90 | 355 | 800 | 800 | 0.254291 | 415 | 860 | 860 | 800 × 355-800 × 355 | TA00.03.1227 | 1227 | yes | 0 | 90 | 10500 | 0 | 50 | 0 | 5 | 950 | 950 | 1272.79 | 900 | 500 | 0 | 900 | 900 | 800 | 1000 | 500 | 500 | 10000 | 0 | 500 | 550 | 800 | 800 | 800 | 800 | 400 | 900 | 1400 | 1400 | 0 | Izolace - Typ izolace: Protipožární
14116331 | -1.PP_SO-102 | 800 | 0.0275 | 0.888 | 500 mm × 800 mm-500 mm × 800 mm | 0 | 500 mm × 800 mm-500 mm × 800 mm | -1.PP_SO-102 | 3070 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 90 | 800 | 500 | 500 | 0.26391 | 860 | 560 | 560 | 500 × 800-500 × 800 | TA00.03.1232 | 1232 | yes | 0 | 90 | 10350 | 0 | 50 | 0 | 5 | 650 | 650 | 848.528 | 600 | 350 | 0 | 600 | 600 | 500 | 700 | 350 | 350 | 10000 | 0 | 350 | 400 | 800 | 800 | 500 | 800 | 250 | 600 | 1100 | 950 | 0
14122509 | -1.PP_SO-102 | 800 | 0.022 | 0.728 | 400 mm × 800 mm-400 mm × 800 mm | 0 | 400 mm × 800 mm-400 mm × 800 mm | -1.PP_SO-102 | 2980.12 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 45.0042 | 800 | 400 | 400 | 0.110605 | 860 | 460 | 460 | 400 × 800-400 × 800 | TA00.03.1279 | 1279 | yes | 0 | 134.996 | 10124.3 | 35.3527 | 35.3579 | 3.53527 | 3.53579 | 550.074 | 403.579 | 382.718 | 353.579 | 300 | 146.451 | 207.128 | 500 | 400 | 600 | 300 | 124.277 | 9912.13 | 212.116 | 124.277 | 174.277 | 800 | 800 | 400 | 800 | 200 | 207.128 | 1000 | 800
14138694 | -1.PP_SO-102 | 400 | 0.011 | 0.204 | 200 mm × 400 mm-200 mm × 400 mm | 0 | 200 mm × 400 mm-200 mm × 400 mm | -1.PP_SO-102 | 2404.86 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 45 | 400 | 200 | 200 | 0.0213662 | 460 | 260 | 260 | 200 × 400-200 × 400 | TA00.03.1331 | 1331 | yes | 0 | 135 | 10082.8 | 35.3553 | 35.3554 | 3.53553 | 3.53554 | 350 | 262.132 | 229.61 | 212.132 | 200 | 87.868 | 124.264 | 300 | 200 | 400 | 200 | 82.8428 | 9941.42 | 141.421 | 82.8428 | 132.843 | 400 | 400 | 200 | 400 | 100 | 124.264 | 800 | 500 | 0
14149806 | 2.NP_SO-102 | 630 | 0.0154 | 0.4221 | 450 mm × 630 mm-280 mm × 630 mm | 0 | 450 mm × 630 mm-280 mm × 630 mm | 2.NP_SO-102 | 1349.64 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 90 | 630 | 280 | 450 | 0.132493 | 690 | 340 | 510 | 450 × 630-280 × 630 | TA00.03.1353 | 1353 | yes | -85 | 90 | 10325 | 0 | 50 | 0 | 5 | 600 | 430 | 668.506 | 550 | 240 | 0 | 380 | 380 | 280 | 650 | 325 | 240 | 10000 | 0 | 240 | 375 | 630 | 630 | 450 | 630 | 140 | 550 | 880 | 790 | 0
14149874 | 2.NP_SO-102 | 630 | 0.0154 | 0.4221 | 500 mm × 630 mm-280 mm × 630 mm | 0 | 500 mm × 630 mm-280 mm × 630 mm | 2.NP_SO-102 | 2800 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 90 | 630 | 280 | 500 | 0.146196 | 690 | 340 | 560 | 500 × 630-280 × 630 | TA00.03.1354 | 1354 | yes | -110 | 90 | 10350 | 0 | 50 | 0 | 5 | 650 | 430 | 710.211 | 600 | 240 | 0 | 380 | 380 | 280 | 700 | 350 | 240 | 10000 | 0 | 240 | 400 | 630 | 630 | 500 | 630 | 140 | 600 | 880 | 840 | 0
14149953 | 1.NP_SO-102 | 630 | 0.0275 | 0.6993 | 500 mm × 630 mm-450 mm × 630 mm | 0 | 500 mm × 630 mm-450 mm × 630 mm | 1.NP_SO-102 | 2710.11 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 90 | 630 | 500 | 450 | 0.194971 | 690 | 560 | 510 | 500 × 630-450 × 630 | TA00.03.1355 | 1355 | yes | 25 | 90 | 10325 | 0 | 50 | 0 | 5 | 600 | 650 | 813.941 | 550 | 350 | 0 | 550 | 550 | 450 | 650 | 325 | 350 | 10000 | 0 | 350 | 375 | 630 | 630 | 500 | 630 | 250 | 550 | 1050 | 950 | 0
14155750 | 4.NP_SO-102 | 315 | 0.017325 | 0.2331 | 315 mm × 315 mm-315 mm × 315 mm | 0 | 315 mm × 315 mm-315 mm × 315 mm | 4.NP_SO-102 | 4565.49 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 97 | ETA | 90 | 315 | 315 | 315 | 0.0510487 | 375 | 375 | 375 | 315 × 315-315 × 315 | TA00.03.1373 | 1373 | yes | 0 | 90 | 10257.5 | 0 | 50 | 0 | 5 | 465 | 465 | 586.899 | 415 | 257.5 | 0 | 415 | 415 | 315 | 515 | 257.5 | 257.5 | 10000 | 0 | 257.5 | 307.5 | 315 | 315 | 315 | 315 | 157.5 | 415 | 915 | 672.5
14165918 | 1.NP_SO-102 | 450 | 0.055 | 0.9495 | 1000 mm × 450 mm-1000 mm × 450 mm | 0 | 1000 mm × 450 mm-1000 mm × 450 mm | 1.NP_SO-102 | 3200 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 11 | ETA | 90 | 450 | 1000 | 1000 | 0.473612 | 510 | 1060 | 1060 | 1000 × 450-1000 × 450 | TA00.03.1393 | 1393 | yes | 0 | 90 | 10600 | 0 | 50 | 0 | 5 | 1150 | 1150 | 1555.63 | 1100 | 600 | 0 | 1100 | 1100 | 1000 | 1200 | 600 | 600 | 10000 | 0 | 600 | 650 | 1000 | 1000 | 1000 | 1000 | 500 | 1100 | 1600 | 1700 | 0
14165931 | 1.NP_SO-102 | 450 | 0.055 | 0.9495 | 1000 mm × 450 mm-1000 mm × 450 mm | 0 | 1000 mm × 450 mm-1000 mm × 450 mm | 1.NP_SO-102 | 3200 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 11 | ETA | 90 | 450 | 1000 | 1000 | 0.473612 | 510 | 1060 | 1060 | 1000 × 450-1000 × 450 | TA00.03.1394 | 1394 | yes | 0 | 90 | 10600 | 0 | 50 | 0 | 5 | 1150 | 1150 | 1555.63 | 1100 | 600 | 0 | 1100 | 1100 | 1000 | 1200 | 600 | 600 | 10000 | 0 | 600 | 650 | 1000 | 1000 | 1000 | 1000 | 500 | 1100 | 1600 | 1700 | 0
14173288 | -1.PP_SO-102 | 315 | 0.0088 | 0.13545 | 160 mm × 315 mm-160 mm × 315 mm | 0 | 160 mm × 315 mm-160 mm × 315 mm | -1.PP_SO-102 | 2580 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 97 | ETA | 45 | 315 | 160 | 160 | 0.0126691 | 375 | 220 | 220 | 160 × 315-160 × 315 | TA00.03.1427 | 1427 |  | 0 | 135 | 10074.6 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 310 | 233.848 | 198.995 | 183.848 | 180 | 76.1522 | 107.696 | 260 | 160 | 360 | 180 | 74.5584 | 9947.28 | 127.279 | 74.5584 | 124.558 | 315 | 315 | 160 | 315 | 80 | 107.696 | 760 | 440
14173301 | -1.PP_SO-102 | 315 | 0.0088 | 0.13545 | 160 mm × 315 mm-160 mm × 315 mm | 0 | 160 mm × 315 mm-160 mm × 315 mm | -1.PP_SO-102 | 2891.13 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 97 | ETA | 45 | 315 | 160 | 160 | 0.0126691 | 375 | 220 | 220 | 160 × 315-160 × 315 | TA00.03.1428 | 1428 |  | 0 | 135 | 10074.6 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 310 | 233.848 | 198.995 | 183.848 | 180 | 76.1522 | 107.696 | 260 | 160 | 360 | 180 | 74.5584 | 9947.28 | 127.279 | 74.5584 | 124.558 | 315 | 315 | 160 | 315 | 80 | 107.696 | 760 | 440
14173315 | -1.PP_SO-102 | 315 | 0.0088 | 0.13545 | 160 mm × 315 mm-160 mm × 315 mm | 0 | 160 mm × 315 mm-160 mm × 315 mm | -1.PP_SO-102 | 2891.13 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 97 | ETA | 45 | 315 | 160 | 160 | 0.0126691 | 375 | 220 | 220 | 160 × 315-160 × 315 | TA00.03.1429 | 1429 |  | 0 | 135 | 10074.6 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 310 | 233.848 | 198.995 | 183.848 | 180 | 76.1522 | 107.696 | 260 | 160 | 360 | 180 | 74.5584 | 9947.28 | 127.279 | 74.5584 | 124.558 | 315 | 315 | 160 | 315 | 80 | 107.696 | 760 | 440
14173339 | -1.PP_SO-102 | 315 | 0.0088 | 0.13545 | 160 mm × 315 mm-160 mm × 315 mm | 0 | 160 mm × 315 mm-160 mm × 315 mm | -1.PP_SO-102 | 2580 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 97 | ETA | 45 | 315 | 160 | 160 | 0.0126691 | 375 | 220 | 220 | 160 × 315-160 × 315 | TA00.03.1431 | 1431 |  | 0 | 135 | 10074.6 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 310 | 233.848 | 198.995 | 183.848 | 180 | 76.1522 | 107.696 | 260 | 160 | 360 | 180 | 74.5584 | 9947.28 | 127.279 | 74.5584 | 124.558 | 315 | 315 | 160 | 315 | 80 | 107.696 | 760 | 440
14174911 | -1.PP_SO-102 | 280 | 0.019525 | 0.2296 | 355 mm × 280 mm-355 mm × 280 mm | 0 | 355 mm × 280 mm-355 mm × 280 mm | -1.PP_SO-102 | 3172.5 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 280 | 355 | 355 | 0.0542618 | 340 | 415 | 415 | 355 × 280-355 × 280 | TA00.03.1435 | 1435 | yes | 0 | 90 | 10277.5 | 0 | 50 | 0 | 5 | 505 | 505 | 643.467 | 455 | 277.5 | 0 | 455 | 455 | 355 | 555 | 277.5 | 277.5 | 10000 | 0 | 277.5 | 327.5 | 355 | 355 | 355 | 355 | 177.5 | 455 | 955 | 732.5 | 0
14174963 | -1.PP_SO-102 | 355 | 0.0154 | 0.23785 | 280 mm × 355 mm-280 mm × 355 mm | 0 | 280 mm × 355 mm-280 mm × 355 mm | -1.PP_SO-102 | 3172.5 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 45 | 355 | 280 | 280 | 0.0296704 | 415 | 340 | 340 | 280 × 355-280 × 355 | TA00.03.1436 | 1436 | yes | 0 | 135 | 10099.4 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 430 | 318.701 | 290.839 | 268.701 | 240 | 111.299 | 157.401 | 380 | 280 | 480 | 240 | 99.4113 | 9929.71 | 169.706 | 99.4113 | 149.411 | 355 | 355 | 280 | 355 | 140 | 157.401 | 880 | 620 | 0
14174972 | -1.PP_SO-102 | 355 | 0.0154 | 0.23785 | 280 mm × 355 mm-280 mm × 355 mm | 0 | 280 mm × 355 mm-280 mm × 355 mm | -1.PP_SO-102 | 2900 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 45 | 355 | 280 | 280 | 0.0296704 | 415 | 340 | 340 | 280 × 355-280 × 355 | TA00.03.1437 | 1437 | yes | 0 | 135 | 10099.4 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 430 | 318.701 | 290.839 | 268.701 | 240 | 111.299 | 157.401 | 380 | 280 | 480 | 240 | 99.4113 | 9929.71 | 169.706 | 99.4113 | 149.411 | 355 | 355 | 280 | 355 | 140 | 157.401 | 880 | 620 | 0
14176746 | -1.PP_SO-102 | 800 | 0.022 | 0.728 | 400 mm × 800 mm-400 mm × 800 mm | 0 | 400 mm × 800 mm-400 mm × 800 mm | -1.PP_SO-102 | 3130 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 45 | 800 | 400 | 400 | 0.110598 | 860 | 460 | 460 | 400 × 800-400 × 800 | TA00.03.1441 | 1441 | yes | 0 | 135 | 10124.3 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 550 | 403.553 | 382.683 | 353.553 | 300 | 146.447 | 207.107 | 500 | 400 | 600 | 300 | 124.264 | 9912.13 | 212.132 | 124.264 | 174.264 | 800 | 800 | 400 | 800 | 200 | 207.107 | 1000 | 800
14176829 | -1.PP_SO-102 | 800 | 0.022 | 0.728 | 400 mm × 800 mm-400 mm × 800 mm | 0 | 400 mm × 800 mm-400 mm × 800 mm | -1.PP_SO-102 | 2500 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 45 | 800 | 400 | 400 | 0.110598 | 860 | 460 | 460 | 400 × 800-400 × 800 | TA00.03.1442 | 1442 | yes | 0 | 135 | 10124.3 | 35.3553 | 35.3553 | 3.53553 | 3.53553 | 550 | 403.553 | 382.683 | 353.553 | 300 | 146.447 | 207.107 | 500 | 400 | 600 | 300 | 124.264 | 9912.13 | 212.132 | 124.264 | 174.264 | 800 | 800 | 400 | 800 | 200 | 207.107 | 1000 | 800
14177471 | 1.NP_SO-102 | 1000 | 0.022 | 0.91 | 400 mm × 1000 mm-400 mm × 1000 mm | 0 | 400 mm × 1000 mm-400 mm × 1000 mm | 1.NP_SO-102 | 3250 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 11 | ETA | 30 | 1000 | 400 | 400 | 0.106832 | 1060 | 460 | 460 | 400 × 1000-400 × 1000 | TA00.03.1444 | 1444 | yes | 0 | 150 | 10080.4 | 43.3013 | 25 | 4.33013 | 2.5 | 338.675 | 300 | 258.819 | 250 | 300 | 116.025 | 133.975 | 500 | 400 | 600 | 300 | 80.3848 | 9930.38 | 259.808 | 80.3848 | 130.385 | 1000 | 1000 | 400 | 1000 | 200 | 133.975 | 1000 | 800 | 0
14177487 | 1.NP_SO-102 | 1000 | 0.022 | 0.91 | 400 mm × 1000 mm-400 mm × 1000 mm | 0 | 400 mm × 1000 mm-400 mm × 1000 mm | 1.NP_SO-102 | 3050 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 11 | ETA | 30 | 1000 | 400 | 400 | 0.106832 | 1060 | 460 | 460 | 400 × 1000-400 × 1000 | TA00.03.1445 | 1445 | yes | 0 | 150 | 10080.4 | 43.3013 | 25 | 4.33013 | 2.5 | 338.675 | 300 | 258.819 | 250 | 300 | 116.025 | 133.975 | 500 | 400 | 600 | 300 | 80.3848 | 9930.38 | 259.808 | 80.3848 | 130.385 | 1000 | 1000 | 400 | 1000 | 200 | 133.975 | 1000 | 800 | 0
14182999 | 1.NP_SO-102 | 450 | 0.055 | 0.9495 | 1000 mm × 450 mm-1000 mm × 450 mm | 0 | 1000 mm × 450 mm-1000 mm × 450 mm | 1.NP_SO-102 | 3250 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 15 | SUP | 90 | 450 | 1000 | 1000 | 0.473612 | 510 | 1060 | 1060 | 1000 × 450-1000 × 450 | TA00.03.1490 | 1490 |  | 0 | 90 | 10600 | 0 | 50 | 0 | 5 | 1150 | 1150 | 1555.63 | 1100 | 600 | 0 | 1100 | 1100 | 1000 | 1200 | 600 | 600 | 10000 | 0 | 600 | 650 | 1000 | 1000 | 1000 | 1000 | 500 | 1100 | 1600 | 1700
14188786 | -1.PP_SO-102 | 1250 | 0.0275 | 1.3875 | 500 mm × 1250 mm-500 mm × 1250 mm | 0 | 500 mm × 1250 mm-500 mm × 1250 mm | -1.PP_SO-102 | 3050 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 1 | EHA | 90 | 1250 | 500 | 500 | 0.41236 | 1310 | 560 | 560 | 500 × 1250-500 × 1250 | TA00.03.1512 | 1512 |  | 0 | 90 | 10350 | 0 | 50 | 0 | 5 | 650 | 650 | 848.528 | 600 | 350 | 0 | 600 | 600 | 500 | 700 | 350 | 350 | 10000 | 0 | 350 | 400 | 1250 | 1250 | 500 | 1250 | 250 | 600 | 1100 | 950 | 0

# IfcDuctFitting: Pravoúhlý spoj T, přímý, přírubový:Standardní (4)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - ID kategorie: O; Kód sestavy: TA00; Název typu: Standardní; Označení typu: 08; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: Pravoúhlý spoj T, přímý, přírubový
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes
Kóty - e: 0 mm; f: 0 mm; l: 0 mm; r: 0 mm; Rozšíření příruby: 30 mm; Tloušťka příruby: 5 mm; x: 0 mm
Jiné - Páteřní trasa: yes; Typ: Standardní; Viditelnost 1: yes; Viditelnost 2: no; Délka 1: 50 mm; Délka x3: 55 mm; e1: 151 mm; e2: 0 mm; e3: 0 mm; e4: 0 mm; f1: 151.6 mm; Id typu: 1170298; m: 0 mm; m1: 2000 mm; r1: 100 mm; Rodina: Pravoúhlý spoj T, přímý, přírubový; Rodina a typ: Pravoúhlý spoj T, přímý, přírubový: Standardní; x1: 50 mm; x2: 150 mm
Name (Pravoúhlý spoj T, přímý, přírubový:Standardní:...) | In | Length (mm) = Příruba a (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Název systému = Group | a (mm) | b (mm) = Min bh (mm) | d (mm) = d12 (mm) = Min dh (mm) = Odsazení 2 (mm) | h (mm) = l1 (mm) = Max abdh (mm) = Max bdh (mm) | Objem (m3) | Příruba b (mm) | Příruba d (mm) | Příruba h (mm) | Velikost | Kód prvku | Označení | f2 (mm) | l2 (mm) | m2 (mm) | Min abdh (mm) | Min bdh (mm) | Odsazení 1 (mm) | Viditelnost 3 | Viditelnost 4
13635395 | 3.NP_SO-102 | 620 | 0.0031 | 0.775 | 560 mm × 560 mm-560 mm × 560 mm-560 mm × 560 mm | 3.NP_SO-102 | 3040 | SUP 24 | 560 | 560 | 560 | 560 | 0.324158 | 620 | 620 | 620 | 560 × 560-560 × 560-560 × 560 | TA00.08.0143 | 0143 | 433.632 | 860 | 2280 | 560 | 560 | 280 | yes | no
13746317 | 2.NP_SO-102 | 620 | 0.0031 | 0.775 | 1250 mm × 560 mm-560 mm × 560 mm-560 mm × 560 mm | 2.NP_SO-102 | 2700 | SUP 13 | 560 | 560 | 560 | 1250 | 0.60082 | 620 | 620 | 1310 | 1250 × 560-560 × 560-560 × 560 | TA00.08.0232 | 0232 | 1069.95 | 1550 | 2280 | 560 | 1250 | 280 | yes | no
14037805 | 2.NP_SO-102 | 375 | 0.00655 | 0.98625 | 1250 mm × 315 mm-1250 mm × 315 mm-1250 mm × 315 mm | 2.NP_SO-102 | 2880 | SUP 9 | 315 | 1250 | 1250 | 1250 | 0.677027 | 1310 | 1310 | 1310 | 1250 × 315-1250 × 315-1250 × 315 | TA00.08.1012 | 1012 | 1069.95 | 1550 | 2625 | 315 | 1250 | 625 | yes | no
14138062 | -1.PP_SO-102 | 1310 | 0.001875 | 0.9956 | 1250 mm × 1250 mm-710 mm × 1250 mm-315 mm × 1250 mm | -1.PP_SO-102 | 2648.75 | SUP 24 | 1250 | 315 | 710 | 1250 | 1.55629 | 375 | 770 | 1310 | 1250 × 1250-710 × 1250-315 × 1250 | TA00.08.1327 | 1327 | 207.693 | 1550 | 2256.25 | 315 | 315 | 256.25 | no | yes

# IfcDuctFitting: Pravoúhlý spoj T, přímý, přírubový:Standardní, Pravoúhlý spoj T, přímý, přírubový:Standardní:13807808
In: 4.NP_SO-102
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - ID kategorie: O; Kód sestavy: TA00; Název typu: Standardní; Označení typu: 08; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: Pravoúhlý spoj T, přímý, přírubový
Classification: TA00 Uniformat (Uniformat); Group: ODA 10
Qto_DuctFittingBaseQuantities - Length: 510 mm; GrossCrossSectionArea: 0.0028 m2; NetCrossSectionArea: 0.0028 m2; OuterSurfaceArea: 0.5763 m2
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 500 mm × 450 mm-500 mm × 450 mm-500 mm × 450 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 500 mm × 450 mm-500 mm × 450 mm-500 mm × 450 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Vazby - Podlaží: STŘECHA_SO-102; Výška od podlaží: 1000 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Název systému: ODA 10; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes
Kóty - e: 0 mm; f: 0 mm; l: 0 mm; r: 0 mm; x: 0 mm; a: 450 mm; b: 500 mm; d: 500 mm; h: 500 mm; Objem: 0.219282 m3; Příruba a: 510 mm; Příruba b: 560 mm; Příruba d: 560 mm; Příruba h: 560 mm; Rozšíření příruby: 30 mm; Tloušťka příruby: 5 mm; Velikost: 500 × 450-500 × 450-500 × 450
Identifikační data - Kód prvku: TA00.08.0365; Označení: 0365
Jiné - Páteřní trasa: yes; Typ: Standardní; Viditelnost 1: yes; Viditelnost 2: no; e2: 0 mm; e3: 0 mm; e4: 0 mm; Id typu: 1170298; m: 0 mm; Rodina: Pravoúhlý spoj T, přímý, přírubový; Rodina a typ: Pravoúhlý spoj T, přímý, přírubový: Standardní; Viditelnost 3: yes; Viditelnost 4: no; d12: 500 mm; Délka 1: 50 mm; Délka x3: 55 mm; e1: 151 mm; f1: 151.6 mm; f2: 378.3 mm; l1: 500 mm; l2: 800 mm; m1: 2000 mm; m2: 2250 mm; Max abdh: 500 mm; Max bdh: 500 mm; Min abdh: 450 mm; Min bdh: 500 mm; Min bh: 500 mm; Min dh: 500 mm; Odsazení 1: 250 mm; Odsazení 2: 500 mm; r1: 100 mm; x1: 50 mm; x2: 150 mm

# IfcDuctFitting: Pravoúhlý spoj T, přímý, přírubový:Standardní (9)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - ID kategorie: O; Kód sestavy: TA00; Název typu: Standardní; Označení typu: 08; Popis: T kus; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: Pravoúhlý spoj T, přímý, přírubový
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes
Kóty - e: 0 mm; f: 0 mm; l: 0 mm; r: 0 mm; x: 0 mm; Rozšíření příruby: 30 mm; Tloušťka příruby: 5 mm
Jiné - Páteřní trasa: yes; Typ: Standardní; Viditelnost 1: yes; Viditelnost 2: no; e2: 0 mm; e3: 0 mm; e4: 0 mm; Id typu: 1170298; m: 0 mm; Rodina: Pravoúhlý spoj T, přímý, přírubový; Rodina a typ: Pravoúhlý spoj T, přímý, přírubový: Standardní; Délka 1: 50 mm; Délka x3: 55 mm; f1: 151.6 mm; m1: 2000 mm; r1: 100 mm; x1: 50 mm
Name (Pravoúhlý spoj T, přímý, přírubový:Standardní:...) | In | Length (mm) = Příruba a (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | a (mm) | b (mm) | d (mm) | h (mm) | Objem (m3) | Příruba b (mm) | Příruba d (mm) | Příruba h (mm) | Velikost | Kód prvku | Označení | d12 (mm) = Odsazení 2 (mm) | e1 (mm) | f2 (mm) | l1 (mm) = Max abdh (mm) = Max bdh (mm) | l2 (mm) | m2 (mm) | Min abdh (mm) | Min bdh (mm) | Min bh (mm) | Min dh (mm) | Odsazení 1 (mm) | Viditelnost 3 | Viditelnost 4 | x2 (mm)
13768876 | -1.PP_SO-102 | 560 | 0.00385 | 0.868 | 800 mm × 500 mm-710 mm × 500 mm-315 mm × 500 mm | -1.PP_SO-102 | 3080 | Fáze 1 | ETA 7 | 500 | 710 | 800 | 315 | 0.269669 | 770 | 860 | 375 | 800 × 500-710 × 500-315 × 500 | TA00.08.0273 | 0273 | 800 | 151 | 207.693 | 800 | 615 | 2377.5 | 315 | 315 | 315 | 315 | 377.5 | no | yes | 150
13866250 | -1.PP_SO-102 | 220 | 0.001875 | 0.1672 | 315 mm × 160 mm-315 mm × 160 mm-315 mm × 160 mm | -1.PP_SO-102 | 2580 | Fáze 1 | ETA 97 | 160 | 315 | 315 | 315 | 0.0400492 | 375 | 375 | 375 | 315 × 160-315 × 160-315 × 160 | TA00.08.0456 | 0456 | 315 | 151 | 207.693 | 315 | 615 | 2157.5 | 160 | 315 | 315 | 315 | 157.5 | yes | no | 75
13892878 | 2.NP_SO-102 | 460 | 0.00655 | 1.2098 | 1250 mm × 400 mm-1250 mm × 400 mm-355 mm × 400 mm | 2.NP_SO-102 | 2920 | Fáze 1 | ETA 14 | 400 | 1250 | 1250 | 355 | 0.356369 | 1310 | 1310 | 415 | 1250 × 400-1250 × 400-355 × 400 | TA00.08.0622 | 0622 | 1250 | 151 | 244.581 | 1250 | 655 | 2625 | 355 | 355 | 355 | 355 | 625 | yes | no | 150
13902974 | -1.PP_SO-102 | 460 | 0.00385 | 0.713 | 710 mm × 400 mm-710 mm × 400 mm-355 mm × 400 mm | -1.PP_SO-102 | 3150 | Fáze 2 | ETA 7 | 400 | 710 | 710 | 355 | 0.212729 | 770 | 770 | 415 | 710 × 400-710 × 400-355 × 400 | TA00.08.0643 | 0643 | 710 | 151 | 244.581 | 710 | 655 | 2355 | 355 | 355 | 355 | 355 | 355 | yes | no | 150
13944601 | -1.PP_SO-102 | 460 | 0.0028 | 0.5198 | 710 mm × 400 mm-500 mm × 400 mm-400 mm × 400 mm | -1.PP_SO-102 | 2980 | Fáze 1 | ETA 1 | 400 | 500 | 400 | 710 | 0.243885 | 560 | 460 | 770 | 710 × 400-500 × 400-400 × 400 | TA00.08.0769 | 0769 | 500 | 251 | 286.08 | 710 | 1010 | 2225 | 400 | 400 | 500 | 400 | 225 | yes | no | 150
13945050 | -1.PP_SO-102 | 460 | 0.00385 | 0.713 | 800 mm × 400 mm-710 mm × 400 mm-500 mm × 400 mm | -1.PP_SO-102 | 2980 | Fáze 1 | ETA 1 | 400 | 710 | 800 | 500 | 0.28648 | 770 | 860 | 560 | 800 × 400-710 × 400-500 × 400 | TA00.08.0770 | 0770 | 800 | 151 | 378.3 | 800 | 800 | 2377.5 | 400 | 500 | 500 | 500 | 377.5 | no | yes | 150
14059950 | -1.PP_SO-102 | 560 | 0.0059 | 1.3272 | 1120 mm × 500 mm-1120 mm × 500 mm-630 mm × 500 mm | -1.PP_SO-102 | 3080 | Fáze 1 | ETA 7 | 500 | 1120 | 1120 | 630 | 0.577686 | 1180 | 1180 | 690 | 1120 × 500-1120 × 500-630 × 500 | TA00.08.1104 | 1104 | 1120 | 151 | 498.186 | 1120 | 930 | 2560 | 500 | 630 | 630 | 630 | 560 | yes | no | 150
14065957 | -1.PP_SO-102 | 415 | 0.00385 | 0.64325 | 710 mm × 355 mm-710 mm × 355 mm-180 mm × 355 mm | -1.PP_SO-102 | 3150 | Fáze 2 | ETA 7 | 355 | 710 | 710 | 180 | 0.134997 | 770 | 770 | 240 | 710 × 355-710 × 355-180 × 355 | TA00.08.1122 | 1122 | 710 | 151 | 83.196 | 710 | 480 | 2355 | 180 | 180 | 180 | 180 | 355 | yes | no | 100
14150045 | 2.NP_SO-102 | 510 | 0.00345 | 0.7089 | 710 mm × 450 mm-630 mm × 450 mm-630 mm × 450 mm | 2.NP_SO-102 | 2800 | Fáze 1 | ETA 3 | 450 | 630 | 630 | 710 | 0.340944 | 690 | 690 | 770 | 710 × 450-630 × 450-630 × 450 | TA00.08.1356 | 1356 | 630 | 151 | 571.962 | 710 | 1010 | 2315 | 450 | 710 | 630 | 630 | 315 | yes | no | 150

# IfcDuctSegment: Hranaté potrubí:POZINK/T spoj (368)
Type - Material: 128-64-0
Type - Požární ochrana - Požární odolnost: A1
Type - Materiály a povrchové úpravy - Materiál: Kov, pozink
Type - Stavba - Drsnost: 0.15 mm
Type - Identifikační data - ID kategorie: PO; Kód sestavy: PO02; Komentáře k typům: POZINK; Název typu: POZINK/T spoj; Označení typu: 03; Popis: Potrubí hranaté pozink; Popis sestavy: Pozinkované
Type - Jiné - Kategorie: Potrubí; MJ: m; Název rodiny: Hranaté potrubí
Classification: PO02 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Mechanické – tok - Doplňkový průtok: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Mechanické - Uzamknutí velikosti: no
Jiné - Rodina: Hranaté potrubí; Id typu: 352284; Rodina a typ: Hranaté potrubí: POZINK/T spoj; Typ: POZINK/T spoj
Name (Hranaté potrubí:POZINK/T spoj:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Reynoldsovo číslo | Dynamický tlak (Pa) | Průtok (m3/s) | Rychlost (m/s) | Tlaková ztráta (Pa) | Tření (kg/m2/s2) | Referenční podlaží | Sklon | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Fáze vytvoření | Koeficient ztrát | Ekvivaletní průměr (mm) | Hydraulický průměr (mm) | Klasifikace systému | Název systému | Plocha (m2) | Řez | Typ systému | Zkratka systému | Délka (mm) | Šířka (mm) | Velikost | Výška (mm) | Kód prvku | Označení | Páteřní trasa | Group
12928524 | 2.NP_SO-102 | 630 | 2.34173 | 4.04565 | 1120 mm × 630 mm | 0 | 1120 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3074 | 2759 | 2759 | 2444 | Fáze 1 | 0 | 908.935 | 806.4 | Odváděný vzduch | EHA 10 | 7.31791 | 1 | Znehodnocený | EHA | 2090.83 | 1120 | 1120 × 630 | 630 | PO02.03.0018 | 0018 | yes | EHA 10 | Identifikační data - Komentáře: VÝFUK POD STROPEM
12928681 | 2.NP_SO-102 | 800 | 0.0979603 | 2.96708 | 1800 mm × 800 mm | 0 | 1800 mm × 800 mm | 104481 | 1.22527 | 2.05556 | 1.42747 | 0.0011164 | 0.0205136 | 2.NP_SO-102 | 0 | 1959 | 1559 | 1559 | 1159 | Fáze 1 | 0.000911145 | 1285.81 | 1107.69 | Přívod vzduchu | ODA 3 | 0.282996 | 4 | Čerstvý | ODA | 54.4224 | 1800 | 1800 × 800 | 800 | PO02.03.0019 | 0019 | yes | ODA 3
12930435 | 2.NP_SO-102 | 400 | 0.00893751 | 1.00572 | 1250 mm × 400 mm | 0 | 1250 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3120 | 2920 | 2920 | 2720 | Fáze 1 | 0 | 743.753 | 606.061 | Zpětný vzduch | ETA 14 | 0.023595 | 5 | Odváděný | ETA | 7.15 | 1250 | 1250 × 400 | 400 | PO02.03.0020 | 0020 | yes | ETA 14
12930744 | 2.NP_SO-102 | 655.816 | 0.625 | 2.29536 | 500 mm × 1250 mm | 0 | 500 mm × 1250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 216040 | 2525.44 | 1869.33 | 2525.15 | 1869.04 | Fáze 1 | 0 | 842.576 | 714.286 | Přívod vzduchu | SUP 9 | 2.29536 | 485 | Přívodní | SUP | 655.816 | 500 | 500 × 1250 | 1250 | PO02.03.0021 | 0021 | yes | SUP 9
12931474 | 2.NP_SO-102 | 400 | 0.528853 | 1.19009 | 900 mm × 400 mm | 0 | 900 mm × 400 mm | 208961 | 19.6043 | 2.05556 | 5.70988 | 0.362996 | 0.617745 | 2.NP_SO-102 | 0 | 1959 | 1759 | 1759 | 1559 | Fáze 1 | 0.0185162 | 642.905 | 553.846 | Přívod vzduchu | ODA 3 | 1.5278 | 3 | Čerstvý | ODA | 587.615 | 900 | 900 × 400 | 400 | PO02.03.0022 | 0022 | yes | ODA 3
12931586 | 2.NP_SO-102 | 1554 | 0.4 | 4.3512 | 400 mm × 1000 mm | 0 | 400 mm × 1000 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 1804 | 1804 | 250 | 250 | Fáze 1 | 0 | 674.06 | 571.429 | Zpětný vzduch | ETA 11 | 4.3512 | 63 | Odváděný | ETA | 1554 | 400 | 400 × 1000 | 1000 | PO02.03.0023 | 0023 | yes | ETA 11
13088964 | 2.NP_SO-102 | 1000 | 0.106944 | 2.03765 | 900 mm × 1000 mm | 0 | 900 mm × 1000 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2659 | 2159 | 2159 | 1659 | Fáze 1 | 0 | 1036.71 | 947.368 | Zpětný vzduch | ETA 11 | 0.45154 | 17 | Odváděný | ETA | 118.826 | 900 | 900 × 1000 | 1000 | PO02.03.0027 | 0027 | yes | ETA 11
13089207 | 2.NP_SO-102 | 794.581 | 0.7056 | 2.78103 | 1120 mm × 630 mm | 0 | 1120 mm × 630 mm | 314652 | 20.9681 | 4.16667 | 5.90514 | 0.331713 | 0.417469 | 2.NP_SO-102 |  | 2073.58 | 2073.58 | 1279 | 1279 | Fáze 1 | 0.0158199 | 908.935 | 806.4 | Přívod vzduchu | ODA 6 | 2.78103 | 4 | Čerstvý | ODA | 794.581 | 1120 | 1120 × 630 | 630 | PO02.03.0028 | 0028 | yes | ODA 6
13094719 | 2.NP_SO-102 | 500 | 3.71314 | 3.92071 | 1600 mm × 500 mm | 0 | 1600 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2900 | 2650 | 2650 | 2400 | Fáze 1 | 0 | 939.333 | 761.905 | Odváděný vzduch | EHA 8 | 9.74698 | 1 | Znehodnocený | EHA | 2320.71 | 1600 | 1600 × 500 | 500 | PO02.03.0029 | 0029 | yes | EHA 8 | Identifikační data - Komentáře: VÝFUK POD STROPEM
13095338 | 2.NP_SO-102 | 450 | 2.12878 | 2.73173 | 1100 mm × 450 mm | 0 | 1100 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 609 | 384 | 384 | 159 | Fáze 1 | 0 | 750.738 | 638.71 | Přívod vzduchu | SUP 17 | 5.99928 | 1 | Přívodní | SUP | 1935.25 | 1100 | 1100 × 450 | 450 | PO02.03.0030 | 0030 | yes | SUP 17
13095403 | 2.NP_SO-102 | 553.21 | 0.495 | 1.71495 | 1100 mm × 450 mm | 0 | 1100 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 1317.21 | 1317.21 | 764 | 764 | Fáze 1 | 0 | 750.738 | 638.71 | Přívod vzduchu | SUP 17 | 1.71495 | 1 | Přívodní | SUP | 553.21 | 1100 | 1100 × 450 | 450 | PO02.03.0031 | 0031 | yes | SUP 17
13096663 | 2.NP_SO-102 | 450 | 2.16943 | 2.76499 | 1100 mm × 450 mm | 0 | 1100 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 1259 | 1034 | 1034 | 809 | Fáze 1 | 0 | 750.738 | 638.71 | Zpětný vzduch | ETA 12 | 6.11384 | 1 | Odváděný | ETA | 1972.21 | 1100 | 1100 × 450 | 450 | PO02.03.0038 | 0038 | yes | ETA 12
13097284 | 2.NP_SO-102 | 466.79 | 0.225 | 0.886902 | 450 mm × 500 mm | 0 | 450 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 2384 | 1917.21 | 2384 | 1917.21 | Fáze 1 | 0 | 518.354 | 473.684 | Přívod vzduchu | SUP 17 | 0.886902 | 2 | Přívodní | SUP | 466.79 | 450 | 450 × 500 | 500 | PO02.03.0039 | 0039 | yes | SUP 17
13097632 | 2.NP_SO-102 | 370 | 0.225 | 0.703 | 450 mm × 500 mm | 0 | 450 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 2384 | 2384 | 2014 | 2014 | Fáze 1 | 0 | 518.354 | 473.684 | Zpětný vzduch | ETA 12 | 0.703 | 2 | Odváděný | ETA | 370 | 450 | 450 × 500 | 500 | PO02.03.0040 | 0040 | yes | ETA 12
13097672 | 2.NP_SO-102 | 450 | 0.36 | 1.098 | 500 mm × 450 mm | 0 | 500 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2989 | 2764 | 2764 | 2539 | Fáze 1 | 0 | 518.354 | 473.684 | Zpětný vzduch | ETA 12 | 1.368 | 2 | Odváděný | ETA | 720 | 500 | 500 × 450 | 450 | PO02.03.0041 | 0041 | yes | ETA 12
13104332 | 2.NP_SO-102 | 500 | 0.2221 | 1.42768 | 1250 mm × 500 mm | 0 | 1250 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3120 | 2870 | 2870 | 2620 | Fáze 1 | 0 | 842.576 | 714.286 | Zpětný vzduch | ETA 14 | 0.621879 | 487 | Odváděný | ETA | 177.68 | 1250 | 1250 × 500 | 500 | PO02.03.0047 | 0047 | yes | ETA 14
13105917 | 2.NP_SO-102 | 450 | 0.230146 | 1.29071 | 1250 mm × 450 mm | 0 | 1250 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3120 | 2895 | 2895 | 2670 | Fáze 1 | 0 | 794.617 | 661.765 | Zpětný vzduch | ETA 14 | 0.625998 | 4 | Odváděný | ETA | 184.117 | 1250 | 1250 × 450 | 450 | PO02.03.0048 | 0048 | yes | ETA 14
13106058 | 2.NP_SO-102 | 450 | 0.093223 | 1.19212 | 1250 mm × 450 mm | 0 | 1250 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3120 | 2895 | 2895 | 2670 | Fáze 1 | 0 | 794.617 | 661.765 | Zpětný vzduch | ETA 14 | 0.253567 | 4 | Odváděný | ETA | 74.5784 | 1250 | 1250 × 450 | 450 | PO02.03.0049 | 0049 | yes | ETA 14
13107198 | 2.NP_SO-102 | 315 | 0.768694 | 1.17492 | 1250 mm × 315 mm | 0 | 1250 mm × 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3037.5 | 2880 | 2880 | 2722.5 | Fáze 1 | 0 | 649.124 | 503.195 | Přívod vzduchu | SUP 9 | 1.92481 | 450 | Přívodní | SUP | 614.955 | 1250 | 1250 × 315 | 315 | PO02.03.0051 | 0051 | yes | SUP 9
13109732 | 2.NP_SO-102 | 225 | 0.0844895 | 0.301041 | 500 mm × 225 mm | 0 | 500 mm × 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2992.5 | 2880 | 2880 | 2767.5 | Fáze 1 | 0 | 359.608 | 310.345 | Přívod vzduchu | SUP 9 | 0.245019 | 436 | Přívodní | SUP | 168.979 | 500 | 500 × 225 | 225 | PO02.03.0053 | 0053 | yes | SUP 9
13110419 | 3.NP_SO-102 | 500 | 0.0348574 | 0.38943 | 500 mm × 250 mm | 0 | 500 mm × 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 | 173.205 | 156.907 | 94.4073 | -26.3422 | -88.8422 | Fáze 1 | 0 | 380.844 | 333.333 | Přívod vzduchu | SUP 9 | 0.209144 | 428 | Přívodní | SUP | 139.43 | 500 | 500 × 250 | 250 | PO02.03.0054 | 0054 | yes | SUP 9
13113178 | 2.NP_SO-102 | 981 | 0.495 | 3.0411 | 1100 mm × 450 mm | 0 | 1100 mm × 450 mm | 82892.2 | 2.31963 | 0.972222 | 1.96409 | 0.0704852 | 0.0718504 | 2.NP_SO-102 |  | 2395 | 2395 | 1414 | 1414 | Fáze 1 | 0.0303864 | 750.738 | 638.71 | Přívod vzduchu | ODA 7 | 3.0411 | 1 | Čerstvý | ODA | 981 | 1100 | 1100 × 450 | 450 | PO02.03.0056 | 0056 | yes | ODA 7
13113353 | 2.NP_SO-102 | 450 | 0.00213021 | 0.40926 | 450 mm × 450 mm | 0 | 450 mm × 450 mm | 142759 | 13.8605 | 0.972222 | 4.8011 | 0.0027212 | 0.574845 | 2.NP_SO-102 | 0 | 3000 | 2775 | 2775 | 2550 | Fáze 1 | 0.000196328 | 491.924 | 450 | Přívod vzduchu | ODA 7 | 0.00852083 | 2 | Čerstvý | ODA | 4.7338 | 450 | 450 × 450 | 450 | PO02.03.0057 | 0057 | yes | ODA 7
13113542 | 2.NP_SO-102 | 450 | 0.834475 | 1.67856 | 1120 mm × 450 mm | 0 | 1120 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 609 | 384 | 384 | 159 | Fáze 1 | 0 | 756.811 | 642.038 | Odváděný vzduch | EHA 5 | 2.33951 | 2 | Znehodnocený | EHA | 745.067 | 1120 | 1120 × 450 | 450 | PO02.03.0058 | 0058 | yes | EHA 5
13113593 | 2.NP_SO-102 | 1481 | 0.504 | 4.65034 | 1120 mm × 450 mm | 0 | 1120 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 2245 | 2245 | 764 | 764 | Fáze 1 | 0 | 756.811 | 642.038 | Odváděný vzduch | EHA 5 | 4.65034 | 2 | Znehodnocený | EHA | 1481 | 1120 | 1120 × 450 | 450 | PO02.03.0059 | 0059 | yes | EHA 5
13115087 | 2.NP_SO-102 | 630 | 0.3864 | 1.8459 | 1120 mm × 630 mm | 0 | 1120 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2965 | 2650 | 2650 | 2335 | Fáze 1 | 0 | 908.935 | 806.4 | Odváděný vzduch | EHA 8 | 1.2075 | 5 | Znehodnocený | EHA | 345 | 1120 | 1120 × 630 | 630 | PO02.03.0060 | 0060 | yes | EHA 8
13152090 | 3.NP_SO-102 | 2610.62 | 0.125 | 3.91593 | 250 mm × 500 mm | 0 | 250 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 |  | 2920.16 | 309.539 | 2920.16 | 309.539 | Fáze 1 | 0 | 380.844 | 333.333 | Přívod vzduchu | SUP 9 | 3.91593 | 428 | Přívodní | SUP | 2610.62 | 250 | 250 × 500 | 500 | PO02.03.0066 | 0066 | yes | SUP 9
13152511 | 2.NP_SO-102 | 400 | 0.150436 | 0.920349 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 3120 | 2920 | 2920 | 2720 | Fáze 1 | 0 | 674.06 | 571.429 | Zpětný vzduch | ETA 14 | 0.421222 | 192 | Odváděný | ETA | 150.436 | 1000 | 1000 × 400 | 400 | PO02.03.0068 | 0068 | yes | ETA 14 | Identifikační data - Komentáře: VZT25
13219373 | -1.PP_SO-102 | 250 | 2.39667 | 3.19584 | 400 mm × 250 mm | 0 | 400 mm × 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3105 | 2980 | 2980 | 2855 | Fáze 1 | 0 | 343.333 | 307.692 | Zpětný vzduch | ETA 1 | 7.78917 | 138 | Odváděný | ETA | 5991.67 | 400 | 400 × 250 | 250 | PO02.03.0222 | 0222 | yes | ETA 1
13221690 | 2.NP_SO-102 | 497.5 | 0.1764 | 0.90545 | 280 mm × 630 mm | 0 | 280 mm × 630 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 7795 | 7795 | 7297.5 | 7297.5 | Fáze 2 | 0 | 450.033 | 387.692 | Přívod vzduchu | SUP 24 | 0.90545 | 469 | Přívodní | SUP | 497.5 | 280 | 280 × 630 | 630 | PO02.03.0224 | 0224 | yes | SUP 24
13221798 | 2.NP_SO-102 | 7681.95 | 0.32 | 18.4367 | 400 mm × 800 mm | 0 | 400 mm × 800 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 461921 | 3649.88 | 3649.79 | -4032.16 | -4032.24 | Fáze 2 | 0 | 609.35 | 533.333 | Přívod vzduchu | SUP 24 | 18.4367 | 479 | Přívodní | SUP | 7681.95 | 400 | 400 × 800 | 800 | PO02.03.0225 | 0225 | yes | SUP 24 | Identifikační data - Komentáře: VZT18
13223136 | 2.NP_SO-102 | 560 | 0.413897 | 1.77085 | 1250 mm × 560 mm | 0 | 1250 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 | 0 | 2980 | 2700 | 2700 | 2420 | Fáze 1 | 0 | 896.83 | 773.481 | Přívod vzduchu | SUP 13 | 1.19864 | 305 | Přívodní | SUP | 331.117 | 1250 | 1250 × 560 | 560 | PO02.03.0226 | 0226 | yes | SUP 13
13225596 | -1.PP_SO-102 | 400 | 5.55699 | 6.19699 | 800 mm × 400 mm | 15 | 830 mm × 430 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3330 | 3130 | 3130 | 2930 | Fáze 2 | 0 | 609.35 | 533.333 | Přívod vzduchu | SUP 24 | 16.671 | 555 | Přívodní | SUP | 6946.24 | 800 | 800 × 400 | 400 | PO02.03.0227 | 0227 | yes | SUP 24 | Identifikační data - Komentáře: VZT18; Izolace - Typ izolace: Protipožární
13226308 | -1.PP_SO-102 | 400 | 0.619182 | 1.25918 | 800 mm × 400 mm | 0 | 800 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3330 | 3130 | 3130 | 2930 | Fáze 2 | 0 | 609.35 | 533.333 | Přívod vzduchu | SUP 24 | 1.85754 | 555 | Přívodní | SUP | 773.977 | 800 | 800 × 400 | 400 | PO02.03.0232 | 0232 | yes | SUP 24
13227170 | -1.PP_SO-102 | 400 | 0.165504 | 1.01422 | 1120 mm × 400 mm | 0 | 1120 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3280 | 3080 | 3080 | 2880 | Fáze 1 | 0 | 708.812 | 589.474 | Zpětný vzduch | ETA 7 | 0.449224 | 306 | Odváděný | ETA | 147.771 | 1120 | 1120 × 400 | 400 | PO02.03.0233 | 0233 | yes | ETA 7
13391133 | -1.PP_SO-102 | 515.837 | 0.32 | 1.23801 | 800 mm × 400 mm | 0 | 800 mm × 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 |  | 2207.84 | 2207.84 | 1692 | 1692 | Fáze 1 | 0 | 609.35 | 533.333 | Odváděný vzduch | EHA 2 | 1.23801 | 1 | Znehodnocený | EHA | 515.837 | 800 | 800 × 400 | 400 | PO02.03.0259 | 0259 | yes | EHA 2
13391172 | -1.PP_SO-102 | 515.837 | 0.32 | 1.23801 | 800 mm × 400 mm | 0 | 800 mm × 400 mm | 67300.6 | 2.193 | 0.611111 | 1.90972 | 0.0439194 | 0.085142 | -1.PP_SO-102 |  | 2207.84 | 2207.84 | 1692 | 1692 | Fáze 1 | 0.0200271 | 609.35 | 533.333 | Přívod vzduchu | ODA 2 | 1.23801 | 1 | Čerstvý | ODA | 515.837 | 800 | 800 × 400 | 400 | PO02.03.0260 | 0260 | yes | ODA 2
13429106 | -1.PP_SO-102 | 500 | 0.95979 | 2.19987 | 1600 mm × 500 mm | 0 | 1600 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3340 | 3090 | 3090 | 2840 | Fáze 1 | 0 | 939.333 | 761.905 | Přívod vzduchu | SUP 24 | 2.51945 | 422 | Přívodní | SUP | 599.868 | 1600 | 1600 × 500 | 500 | PO02.03.0261 | 0261 | yes | SUP 24
13429111 | -1.PP_SO-102 | 630 | 0.604459 | 2.18429 | 1250 mm × 630 mm | 15 | 1280 mm × 660 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3405 | 3090 | 3090 | 2775 | Fáze 1 | 0 | 956.226 | 837.766 | Přívod vzduchu | SUP 24 | 1.81821 | 152 | Přívodní | SUP | 483.567 | 1250 | 1250 × 630 | 630 | PO02.03.0262 | 0262 | yes | SUP 24 | Izolace - Typ izolace: Protipožární
13440194 | 2.NP_SO-102 | 95 | 0.252 | 0.1919 | 560 mm × 450 mm | 0 | 560 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 2830 | 2735 | 2830 | 2735 | Fáze 1 | 0 | 547.947 | 499.01 | Přívod vzduchu | SUP 13 | 0.1919 | 78 | Přívodní | SUP | 95 | 560 | 560 × 450 | 450 | PO02.03.0273 | 0273 | yes | SUP 13
13458454 | 3.NP_SO-102 | 3519.91 | 0.252 | 7.11022 | 560 mm × 450 mm | 0 | 560 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 |  | 2849.91 | -670 | 2849.91 | -670 | Fáze 1 | 0 | 547.947 | 499.01 | Přívod vzduchu | SUP 13 | 7.11022 | 70 | Přívodní | SUP | 3519.91 | 560 | 560 × 450 | 450 | PO02.03.0276 | 0276 | yes | SUP 13 | Identifikační data - Komentáře: VZT19
13459243 | -1.PP_SO-102 | 355 | 1.28073 | 1.70465 | 800 mm × 355 mm | 0 | 800 mm × 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3257.5 | 3080 | 3080 | 2902.5 | Fáze 1 | 0 | 570.981 | 491.775 | Zpětný vzduch | ETA 7 | 3.6981 | 387 | Odváděný | ETA | 1600.91 | 800 | 800 × 355 | 355 | PO02.03.0278 | 0278 | yes | ETA 7
13459752 | -1.PP_SO-102 | 710 | 0.757035 | 2.63499 | 1250 mm × 710 mm | 0 | 1250 mm × 710 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2905 | 2550 | 2550 | 2195 | Fáze 1 | 0 | 1019.73 | 905.612 | Přívod vzduchu | SUP 24 | 2.37406 | 3 | Přívodní | SUP | 605.628 | 1250 | 1250 × 710 | 710 | PO02.03.0279 | 0279 | yes | SUP 24
13459856 | -1.PP_SO-102 | 1250 | 0.301916 | 2.83808 | 1250 mm × 710 mm | 0 | 1250 mm × 710 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 100 | 3273.87 | 3022.84 | 2722.16 | 2471.13 | Fáze 1 | 0 | 1019.73 | 905.612 | Přívod vzduchu | SUP 24 | 1.66691 | 3 | Přívodní | SUP | 425.233 | 1250 | 1250 × 710 | 710 | PO02.03.0280 | 0280 | yes | SUP 24
13460055 | -1.PP_SO-102 | 500 | 13.3077 | 9.91733 | 1600 mm × 500 mm | 0 | 1600 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3340 | 3090 | 3090 | 2840 | Fáze 1 | 0 | 939.333 | 761.905 | Přívod vzduchu | SUP 24 | 34.9328 | 422 | Přívodní | SUP | 8317.33 | 1600 | 1600 × 500 | 500 | PO02.03.0281 | 0281 | yes | SUP 24
13632980 | -1.PP_SO-102 | 1100 | 3.41165 | 8.40734 | 2400 mm × 1100 mm | 0 | 2400 mm × 1100 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 1400 | 850 | 850 | 300 | Fáze 1 | 0 | 1743.53 | 1508.57 | Zpětný vzduch | ETA 1 | 9.95064 | 71 | Odváděný | ETA | 1421.52 | 2400 | 2400 × 1100 | 1100 | PO02.03.0304 | 0304 | yes | ETA 1
13633170 | -1.PP_SO-102 | 560 | 3.64595 | 4.48476 | 1400 mm × 560 mm | 0 | 1400 mm × 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2685.78 | 2405.78 | 2405.78 | 2125.78 | Fáze 1 | 0 | 943.685 | 800 | Zpětný vzduch | ETA 1 | 10.2087 | 152 | Odváděný | ETA | 2604.25 | 1400 | 1400 × 560 | 560 | PO02.03.0305 | 0305 | yes | ETA 1
13635304 | 3.NP_SO-102 | 578.285 | 0.625 | 2.024 | 1250 mm × 500 mm | 0 | 1250 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 | 768721 | -76.9975 | -77.03 | -655.315 | -655.348 | Fáze 1 | 0 | 842.576 | 714.286 | Přívod vzduchu | SUP 24 | 2.024 | 138 | Přívodní | SUP | 578.285 | 1250 | 1250 × 500 | 500 | PO02.03.0315 | 0315 | yes | SUP 24
13635586 | 2.NP_SO-102 | 6444.76 | 0.1764 | 11.2783 | 315 mm × 560 mm | 15 | 345 mm × 590 mm | 0 | 0 | 0 | 0 | 0 | 0 | 2.NP_SO-102 |  | 1919.76 | -4525 | 1919.76 | -4525 | Fáze 2 | 0 | 454.468 | 403.2 | Přívod vzduchu | ODA 21 | 11.2783 | 17 | Čerstvý | ODA | 6444.76 | 315 | 315 × 560 | 560 | PO02.03.0317 | 0317 | yes | ODA 21 | Identifikační data - Komentáře: VZT31; Izolace - Typ izolace: Protipožární
13635646 | 4.NP_SO-102 | 3017.56 | 0.56 | 9.41479 | 1000 mm × 560 mm | 15 | 1030 mm × 590 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 |  | 4191.86 | 4191.86 | 1174.3 | 1174.3 | Fáze 1 | 0 | 809.617 | 717.949 | Přívod vzduchu | ODA 12 | 9.41479 | 17 | Čerstvý | ODA | 3017.56 | 1000 | 1000 × 560 | 560 | PO02.03.0318 | 0318 | yes | ODA 12 | Identifikační data - Komentáře: VZT29; Izolace - Typ izolace: Protipožární
13635721 | 4.NP_SO-102 | 5323.8 | 0.225 | 10.1152 | 450 mm × 500 mm | 15 | 480 mm × 530 mm | 0 | 0 | 0 | 0 | 0 | 0 | 4.NP_SO-102 |  | 4685 | 4685 | -638.796 | -638.796 | Fáze 1 | 0 | 518.354 | 473.684 | Přívod vzduchu | ODA 25 | 10.1152 | 4 | Čerstvý | ODA | 5323.8 | 450 | 450 × 500 | 500 | PO02.03.0319 | 0319 | yes | ODA 25 | Identifikační data - Komentáře: VZT32; Izolace - Typ izolace: Protipožární; Fázování - Bouráno ve FÁZI 2: yes
13636309 | 3.NP_SO-102 | 139.163 | 0.252 | 0.28111 | 560 mm × 450 mm | 0 | 560 mm × 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 3.NP_SO-102 |  | 3489.07 | 3349.91 | 3489.07 | 3349.91 | Fáze 1 | 0 | 547.947 | 499.01 | Přívod vzduchu | SUP 13 | 0.28111 | 147 | Přívodní | SUP | 139.163 | 560 | 560 × 450 | 450 | PO02.03.0322 | 0322 | yes | SUP 13
13637849 | 1.NP_SO-102 | 16369.3 | 0.625 | 57.2927 | 500 mm × 1250 mm | 0 | 500 mm × 1250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 1.NP_SO-102 |  | 15824.3 | 15824.3 | -545 | -545 | Fáze 1 | 0 | 842.576 | 714.286 | Odváděný vzduch | EHA 1 | 57.2927 | 2 | Znehodnocený | EHA | 16369.3 | 500 | 500 × 1250 | 1250 | PO02.03.0323 | 0323 | yes | EHA 1 | Identifikační data - Komentáře: VZT18
13638073 | -1.PP_SO-102 | 500 | 3.225 | 3.83 | 1250 mm × 500 mm | 0 | 1250 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3300 | 3050 | 3050 | 2800 | Fáze 1 | 0 | 842.576 | 714.286 | Odváděný vzduch | EHA 1 | 9.03 | 2 | Znehodnocený | EHA | 2580 | 1250 | 1250 × 500 | 500 | PO02.03.0324 | 0324 | yes | EHA 1
13638466 | -1.PP_SO-102 | 500 | 13.1626 | 10.8019 | 1400 mm × 500 mm | 0 | 1400 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 3300 | 3050 | 3050 | 2800 | Fáze 1 | 0 | 886.015 | 736.842 | Odváděný vzduch | EHA 1 | 35.7271 | 3 | Znehodnocený | EHA | 9401.86 | 1400 | 1400 × 500 | 500 | PO02.03.0325 | 0325 | yes | EHA 1
13638467 | -1.PP_SO-102 | 1400 | 0.330355 | 3.24999 | 1400 mm × 500 mm | 0 | 1400 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 100 | 3085.37 | 2441.4 | 2908.6 | 2264.63 | Fáze 1 | 0 | 886.015 | 736.842 | Odváděný vzduch | EHA 1 | 2.5107 | 3 | Znehodnocený | EHA | 660.711 | 1400 | 1400 × 500 | 500 | PO02.03.0326 | 0326 | yes | EHA 1
13638499 | -1.PP_SO-102 | 500 | 0.116937 | 1.48353 | 1400 mm × 500 mm | 0 | 1400 mm × 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | -1.PP_SO-102 | 0 | 2550 | 2300 | 2300 | 2050 | Fáze 1 | 0 | 886.015 | 736.842 | Odváděný vzduch | EHA 17 | 0.317402 | 7 | Znehodnocený | EHA | 83.5267 | 1400 | 1400 × 500 | 500 | PO02.03.0327 | 0327 | yes | EHA 17
