Properties of the parts of a building model (IFC4), part 40 of 45

# IfcDuctSegment: Hranaté potrubí:POZINK/vývod (238)
Name (Hranaté potrubí:POZINK/vývod:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Sklon | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Spodní výška (mm) | Fáze vytvoření | Typ systému | Ekvivaletní průměr (mm) | Hydraulický průměr (mm) | Klasifikace systému | Název systému = Group | Plocha (m2) | Řez | Zkratka systému | Délka (mm) | Šířka (mm) | Velikost | Výška (mm) | Kód prvku | Označení | Páteřní trasa
13806217 | -1.PP_SO-102 | 280 | 0.703874 | 0.978466 | 630 mm × 280 mm | 0 | 630 mm × 280 mm | 0 | 3140 | 3000 | 3000 | -1.PP_SO-102 | 2860 | Fáze 2 | Čerstvý | 450.033 | 387.692 | Přívod vzduchu | ODA 17 | 2.03341 | 2 | ODA | 1117.26 | 630 | 630 × 280 | 280 | PO02.02.0583 | 0583 | yes
13817285 | -1.PP_SO-102 | 280 | 0.938929 | 1.1874 | 630 mm × 280 mm | 0 | 630 mm × 280 mm | 0 | 3140 | 3000 | 3000 | -1.PP_SO-102 | 2860 | Fáze 2 | Čerstvý | 450.033 | 387.692 | Přívod vzduchu | ODA 17 | 2.71246 | 2 | ODA | 1490.36 | 630 | 630 × 280 | 280 | PO02.02.0608 | 0608 | yes
13817362 | -1.PP_SO-102 | 280 | 2.25488 | 2.35714 | 630 mm × 280 mm | 0 | 630 mm × 280 mm | 0 | 3140 | 3000 | 3000 | -1.PP_SO-102 | 2860 | Fáze 2 | Čerstvý | 450.033 | 387.692 | Přívod vzduchu | ODA 17 | 6.51411 | 2 | ODA | 3579.18 | 630 | 630 × 280 | 280 | PO02.02.0609 | 0609 | yes
13821879 | 2.NP_SO-102 | 500 | 3.98628 | 4.09142 | 1600 mm × 500 mm | 0 | 1600 mm × 500 mm | 0 | 2900 | 2650 | 2650 | 2.NP_SO-102 | 2400 | Fáze 1 | Znehodnocený | 939.333 | 761.905 | Odváděný vzduch | EHA 13 | 10.464 | 5 | EHA | 2491.42 | 1600 | 1600 × 500 | 500 | PO02.02.0635 | 0635 | yes | Identifikační data - Komentáře: VÝFUK POD STROPEM
13822147 | 2.NP_SO-102 | 800 | 0.0195387 | 2.89737 | 1800 mm × 800 mm | 0 | 1800 mm × 800 mm | 0 | 3050 | 2650 | 2650 | 2.NP_SO-102 | 2250 | Fáze 1 | Znehodnocený | 1285.81 | 1107.69 | Odváděný vzduch | EHA 13 | 0.056445 | 3 | EHA | 10.8548 | 1800 | 1800 × 800 | 800 | PO02.02.0636 | 0636 | yes
13824306 | 2.NP_SO-102 | 800 | 0.505779 | 2.27578 | 710 mm × 800 mm | 0 | 710 mm × 800 mm | 0 | 3050 | 2650 | 2650 | 2.NP_SO-102 | 2250 | Fáze 1 | Znehodnocený | 823.506 | 752.318 | Odváděný vzduch | EHA 13 | 2.15134 | 2 | EHA | 712.365 | 710 | 710 × 800 | 800 | PO02.02.0638 | 0638 | yes
13824365 | 2.NP_SO-102 | 800 | 0.340281 | 1.90283 | 710 mm × 800 mm | 0 | 710 mm × 800 mm | 0 | 1109 | 709 | 709 | 2.NP_SO-102 | 309 | Fáze 1 | Znehodnocený | 823.506 | 752.318 | Odváděný vzduch | EHA 13 | 1.44739 | 2 | EHA | 479.269 | 710 | 710 × 800 | 800 | PO02.02.0639 | 0639 | yes
13824373 | 2.NP_SO-102 | 831 | 0.568 | 2.50962 | 710 mm × 800 mm | 0 | 710 mm × 800 mm |  | 2095 | 1264 | 2095 | 2.NP_SO-102 | 1264 | Fáze 1 | Znehodnocený | 823.506 | 752.318 | Odváděný vzduch | EHA 13 | 2.50962 | 2 | EHA | 831 | 710 | 710 × 800 | 800 | PO02.02.0640 | 0640 | yes
13824409 | 2.NP_SO-102 | 900 | 1.52722 | 4.97449 | 2000 mm × 900 mm | 0 | 2000 mm × 900 mm | 0 | 1159 | 709 | 709 | 2.NP_SO-102 | 259 | Fáze 1 | Znehodnocený | 1438.43 | 1241.38 | Odváděný vzduch | EHA 13 | 4.42893 | 1 | EHA | 763.608 | 2000 | 2000 × 900 | 900 | PO02.02.0641 | 0641 | yes
13837023 | 4.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 39 | 0.176 | 1 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0647 | 0647 | no
13837198 | 4.NP_SO-102 | 300 | 0.0104 | 0.4878 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 39 | 0.0286 | 1 | ETA | 13 | 800 | 800 × 300 | 300 | PO02.02.0648 | 0648 | no
13837341 | 4.NP_SO-102 | 300 | 0.0566647 | 0.522499 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 38 | 0.155828 | 1 | ETA | 70.8309 | 800 | 800 × 300 | 300 | PO02.02.0649 | 0649 | no
13837342 | 4.NP_SO-102 | 300 | 0.0177353 | 0.493301 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 38 | 0.0487721 | 1 | ETA | 22.1691 | 800 | 800 × 300 | 300 | PO02.02.0650 | 0650 | no
13837358 | 4.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 40 | 0.176 | 1 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0651 | 0651 | no
13837359 | 4.NP_SO-102 | 300 | 0.0104 | 0.4878 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 40 | 0.0286 | 1 | ETA | 13 | 800 | 800 × 300 | 300 | PO02.02.0652 | 0652 | no
13837373 | 4.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 41 | 0.176 | 1 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0653 | 0653 | no
13837374 | 4.NP_SO-102 | 300 | 0.0104 | 0.4878 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 41 | 0.0286 | 1 | ETA | 13 | 800 | 800 × 300 | 300 | PO02.02.0654 | 0654 | no
13837435 | 3.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 42 | 0.176 | 1 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0655 | 0655 | no
13837436 | 3.NP_SO-102 | 300 | 0.0104 | 0.4878 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 42 | 0.0286 | 1 | ETA | 13 | 800 | 800 × 300 | 300 | PO02.02.0656 | 0656 | no
13837438 | 3.NP_SO-102 | 300 | 0.0566647 | 0.522499 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 44 | 0.155828 | 1 | ETA | 70.8309 | 800 | 800 × 300 | 300 | PO02.02.0657 | 0657 | no
13837439 | 3.NP_SO-102 | 300 | 0.0177353 | 0.493301 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 44 | 0.0487721 | 1 | ETA | 22.1691 | 800 | 800 × 300 | 300 | PO02.02.0658 | 0658 | no
13837441 | 3.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 46 | 0.176 | 1 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0659 | 0659 | no
13837442 | 3.NP_SO-102 | 300 | 0.0104 | 0.4878 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 46 | 0.0286 | 1 | ETA | 13 | 800 | 800 × 300 | 300 | PO02.02.0660 | 0660 | no
13837444 | 3.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 48 | 0.176 | 1 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0661 | 0661 | no
13837445 | 3.NP_SO-102 | 300 | 0.0104 | 0.4878 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 48 | 0.0286 | 1 | ETA | 13 | 800 | 800 × 300 | 300 | PO02.02.0662 | 0662 | no
13837536 | 3.NP_SO-102 | 300 | 0.0566647 | 0.522499 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 43 | 0.155828 | 1 | ETA | 70.8309 | 800 | 800 × 300 | 300 | PO02.02.0663 | 0663 | no
13837537 | 3.NP_SO-102 | 300 | 0.0177353 | 0.493301 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 43 | 0.0487721 | 1 | ETA | 22.1691 | 800 | 800 × 300 | 300 | PO02.02.0664 | 0664 | no
13837585 | 3.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 45 | 0.176 | 1 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0665 | 0665 | no
13837586 | 3.NP_SO-102 | 300 | 0.0104 | 0.4878 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 45 | 0.0286 | 1 | ETA | 13 | 800 | 800 × 300 | 300 | PO02.02.0666 | 0666 | no
13837598 | 3.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 47 | 0.176 | 1 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0667 | 0667 | no
13837599 | 3.NP_SO-102 | 300 | 0.0104 | 0.4878 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 47 | 0.0286 | 1 | ETA | 13 | 800 | 800 × 300 | 300 | PO02.02.0668 | 0668 | no
13838017 | 3.NP_SO-102 | 300 | 0.07 | 0.384 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 49 | 0.224 | 1 | ETA | 140 | 500 | 500 × 300 | 300 | PO02.02.0675 | 0675 | no
13838145 | 3.NP_SO-102 | 300 | 0.07 | 0.384 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3250 | 3100 | 3100 | 3.NP_SO-102 | 2950 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 50 | 0.224 | 1 | ETA | 140 | 500 | 500 × 300 | 300 | PO02.02.0678 | 0678 | no
13838250 | 3.NP_SO-102 | 200 | 0.03 | 0.224 | 500 mm × 200 mm | 0 | 500 mm × 200 mm | 0 | 3300 | 3200 | 3200 | 3.NP_SO-102 | 3100 | Fáze 1 | Odváděný | 337.03 | 285.714 | Zpětný vzduch | ETA 51 | 0.084 | 1 | ETA | 60 | 500 | 500 × 200 | 200 | PO02.02.0679 | 0679 | no
13838353 | 3.NP_SO-102 | 200 | 0.04 | 0.232 | 500 mm × 200 mm | 0 | 500 mm × 200 mm | 0 | 3300 | 3200 | 3200 | 3.NP_SO-102 | 3100 | Fáze 1 | Odváděný | 337.03 | 285.714 | Zpětný vzduch | ETA 64 | 0.112 | 1 | ETA | 80 | 500 | 500 × 200 | 200 | PO02.02.0680 | 0680 | no
13838387 | 3.NP_SO-102 | 300 | 0.08 | 0.54 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 53 | 0.22 | 2 | ETA | 100 | 800 | 800 × 300 | 300 | PO02.02.0682 | 0682 | no
13838402 | 3.NP_SO-102 | 300 | 0.08 | 0.54 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 54 | 0.22 | 1 | ETA | 100 | 800 | 800 × 300 | 300 | PO02.02.0683 | 0683 | no
13838436 | 4.NP_SO-102 | 300 | 0.05 | 0.36 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 55 | 0.16 | 1 | ETA | 100 | 500 | 500 × 300 | 300 | PO02.02.0684 | 0684 | no
13838478 | 2.NP_SO-102 | 300 | 0.0449771 | 0.513733 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 57 | 0.123687 | 1 | ETA | 56.2214 | 800 | 800 × 300 | 300 | PO02.02.0685 | 0685 | no
13838479 | 2.NP_SO-102 | 300 | 0.0294229 | 0.502067 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 57 | 0.080913 | 1 | ETA | 36.7786 | 800 | 800 × 300 | 300 | PO02.02.0686 | 0686 | no
13838490 | 2.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 58 | 0.176 | 1 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0687 | 0687 | no
13838491 | 2.NP_SO-102 | 300 | 0.0104 | 0.4878 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 58 | 0.0286 | 1 | ETA | 13 | 800 | 800 × 300 | 300 | PO02.02.0688 | 0688 | no
13838512 | 2.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 59 | 0.176 | 1 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0689 | 0689 | no
13838513 | 2.NP_SO-102 | 300 | 0.0104 | 0.4878 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 59 | 0.0286 | 1 | ETA | 13 | 800 | 800 × 300 | 300 | PO02.02.0690 | 0690 | no
13838537 | 2.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 60 | 0.176 | 1 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0691 | 0691 | no
13838538 | 2.NP_SO-102 | 300 | 0.0104 | 0.4878 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 60 | 0.0286 | 1 | ETA | 13 | 800 | 800 × 300 | 300 | PO02.02.0692 | 0692 | no
13838564 | 2.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 61 | 0.176 | 1 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0693 | 0693 | no
13838565 | 2.NP_SO-102 | 300 | 0.0104 | 0.4878 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 61 | 0.0286 | 1 | ETA | 13 | 800 | 800 × 300 | 300 | PO02.02.0694 | 0694 | no
13838576 | 2.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 62 | 0.176 | 1 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0695 | 0695 | no
13838577 | 2.NP_SO-102 | 300 | 0.0104 | 0.4878 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 62 | 0.0286 | 1 | ETA | 13 | 800 | 800 × 300 | 300 | PO02.02.0696 | 0696 | no
13838588 | 2.NP_SO-102 | 300 | 0.0424 | 0.5118 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 63 | 0.1166 | 1 | ETA | 53 | 800 | 800 × 300 | 300 | PO02.02.0697 | 0697 | no
13838589 | 2.NP_SO-102 | 300 | 0.08 | 0.54 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 63 | 0.22 | 1 | ETA | 100 | 800 | 800 × 300 | 300 | PO02.02.0698 | 0698 | no
13838623 | 2.NP_SO-102 | 300 | 0.0554101 | 0.366492 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 90 | 0.177312 | 1 | ETA | 110.82 | 500 | 500 × 300 | 300 | PO02.02.0699 | 0699 | no
13838624 | 2.NP_SO-102 | 300 | 0.00738233 | 0.308859 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 90 | 0.0236235 | 1 | ETA | 14.7647 | 500 | 500 × 300 | 300 | PO02.02.0700 | 0700 | no
13838635 | 2.NP_SO-102 | 300 | 0.0211955 | 0.325435 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 65 | 0.0678256 | 1 | ETA | 42.391 | 500 | 500 × 300 | 300 | PO02.02.0701 | 0701 | no
13838636 | 2.NP_SO-102 | 300 | 0.04 | 0.348 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 65 | 0.128 | 1 | ETA | 80 | 500 | 500 × 300 | 300 | PO02.02.0702 | 0702 | no
13838814 | 4.NP_SO-102 | 300 | 0.143879 | 0.472655 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 66 | 0.460413 | 1 | ETA | 287.758 | 500 | 500 × 300 | 300 | PO02.02.0703 | 0703 | no
13838815 | 4.NP_SO-102 | 300 | 0.425 | 0.81 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 66 | 1.36 | 1 | ETA | 850 | 500 | 500 × 300 | 300 | PO02.02.0704 | 0704 | no
13838912 | 4.NP_SO-102 | 200 | 0.0575 | 0.246 | 500 mm × 200 mm | 0 | 500 mm × 200 mm | 0 | 3300 | 3200 | 3200 | 4.NP_SO-102 | 3100 | Fáze 2 | Odváděný | 337.03 | 285.714 | Zpětný vzduch | ETA 67 | 0.161 | 1 | ETA | 115 | 500 | 500 × 200 | 200 | PO02.02.0705 | 0705 | no
13838936 | 4.NP_SO-102 | 200 | 0.04 | 0.232 | 500 mm × 200 mm | 0 | 500 mm × 200 mm | 0 | 3300 | 3200 | 3200 | 4.NP_SO-102 | 3100 | Fáze 2 | Odváděný | 337.03 | 285.714 | Zpětný vzduch | ETA 67 | 0.112 | 1 | ETA | 80 | 500 | 500 × 200 | 200 | PO02.02.0706 | 0706 | no
13839005 | 4.NP_SO-102 | 300 | 0.048 | 0.516 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 69 | 0.132 | 1 | ETA | 60 | 800 | 800 × 300 | 300 | PO02.02.0707 | 0707 | no
13839039 | 4.NP_SO-102 | 300 | 0.06 | 0.525 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 70 | 0.165 | 1 | ETA | 75 | 800 | 800 × 300 | 300 | PO02.02.0708 | 0708 | no
13839101 | 4.NP_SO-102 | 300 | 0.0768509 | 0.392221 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 71 | 0.245923 | 1 | ETA | 153.702 | 500 | 500 × 300 | 300 | PO02.02.0709 | 0709 | no
13839102 | 4.NP_SO-102 | 300 | 0.00439204 | 0.30527 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 71 | 0.0140545 | 1 | ETA | 8.78409 | 500 | 500 × 300 | 300 | PO02.02.0710 | 0710 | no
13839116 | 4.NP_SO-102 | 300 | 0.06 | 0.372 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 72 | 0.192 | 1 | ETA | 120 | 500 | 500 × 300 | 300 | PO02.02.0711 | 0711 | no
13839232 | 3.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 73 | 0.176 | 1 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0712 | 0712 | no
13839233 | 3.NP_SO-102 | 300 | 0.0104 | 0.4878 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 73 | 0.0286 | 1 | ETA | 13 | 800 | 800 × 300 | 300 | PO02.02.0713 | 0713 | no
13839368 | 3.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 74 | 0.176 | 1 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0714 | 0714 | no
13839369 | 3.NP_SO-102 | 300 | 0.0104 | 0.4878 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 74 | 0.0286 | 1 | ETA | 13 | 800 | 800 × 300 | 300 | PO02.02.0715 | 0715 | no
13839548 | 3.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 75 | 0.176 | 1 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0716 | 0716 | no
13839549 | 3.NP_SO-102 | 300 | 0.0104 | 0.4878 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 75 | 0.0286 | 1 | ETA | 13 | 800 | 800 × 300 | 300 | PO02.02.0717 | 0717 | no
13839561 | 3.NP_SO-102 | 300 | 0.314953 | 0.716215 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 76 | 0.866121 | 1 | ETA | 393.691 | 800 | 800 × 300 | 300 | PO02.02.0718 | 0718 | no
13839562 | 3.NP_SO-102 | 300 | 1.53117 | 1.62838 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 76 | 4.21072 | 1 | ETA | 1913.96 | 800 | 800 × 300 | 300 | PO02.02.0719 | 0719 | no
13839677 | 3.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 78 | 0.176 | 1 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0720 | 0720 | no
13839692 | 3.NP_SO-102 | 300 | 0.048 | 0.516 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 79 | 0.132 | 1 | ETA | 60 | 800 | 800 × 300 | 300 | PO02.02.0721 | 0721 | no
13839719 | 2.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 80 | 0.176 | 5 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0722 | 0722 | no
13839720 | 2.NP_SO-102 | 300 | 0.08 | 0.54 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 80 | 0.22 | 5 | ETA | 100 | 800 | 800 × 300 | 300 | PO02.02.0723 | 0723 | no
13839752 | 2.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 81 | 0.176 | 5 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0724 | 0724 | no
13839753 | 2.NP_SO-102 | 300 | 0.08 | 0.54 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 81 | 0.22 | 5 | ETA | 100 | 800 | 800 × 300 | 300 | PO02.02.0725 | 0725 | no
13839765 | 2.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 82 | 0.176 | 5 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0726 | 0726 | no
13839766 | 2.NP_SO-102 | 300 | 0.08 | 0.54 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 82 | 0.22 | 5 | ETA | 100 | 800 | 800 × 300 | 300 | PO02.02.0727 | 0727 | no
13839778 | 2.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 83 | 0.176 | 5 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0728 | 0728 | no
13839779 | 2.NP_SO-102 | 300 | 0.08 | 0.54 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 83 | 0.22 | 5 | ETA | 100 | 800 | 800 × 300 | 300 | PO02.02.0729 | 0729 | no
13839811 | 2.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 84 | 0.176 | 5 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0730 | 0730 | no
13839812 | 2.NP_SO-102 | 300 | 0.08 | 0.54 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 84 | 0.22 | 5 | ETA | 100 | 800 | 800 × 300 | 300 | PO02.02.0731 | 0731 | no
13839824 | 2.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 85 | 0.176 | 5 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.0732 | 0732 | no
13839825 | 2.NP_SO-102 | 300 | 0.08 | 0.54 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 2.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 85 | 0.22 | 5 | ETA | 100 | 800 | 800 × 300 | 300 | PO02.02.0733 | 0733 | no
13840028 | 1.NP_SO-102 | 300 | 0.0368 | 0.5076 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 1.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 29 | 0.1012 | 1 | ETA | 46 | 800 | 800 × 300 | 300 | PO02.02.0734 | 0734 | no
13840029 | 1.NP_SO-102 | 300 | 0.0897548 | 0.547316 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 1.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 29 | 0.246826 | 1 | ETA | 112.193 | 800 | 800 × 300 | 300 | PO02.02.0735 | 0735 | no
13865064 | 1.NP_SO-102 | 300 | 0.0165 | 0.3198 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 1.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 92 | 0.0528 | 1 | ETA | 33 | 500 | 500 × 300 | 300 | PO02.02.0779 | 0779 | no
13865065 | 1.NP_SO-102 | 300 | 0.04 | 0.348 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 1.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 92 | 0.128 | 1 | ETA | 80 | 500 | 500 × 300 | 300 | PO02.02.0780 | 0780 | no
13865148 | 1.NP_SO-102 | 300 | 0.0235666 | 0.32828 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 1.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 93 | 0.0754132 | 1 | ETA | 47.1332 | 500 | 500 × 300 | 300 | PO02.02.0781 | 0781 | no
13865149 | 1.NP_SO-102 | 300 | 0.04 | 0.348 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 1.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 93 | 0.128 | 1 | ETA | 80 | 500 | 500 × 300 | 300 | PO02.02.0782 | 0782 | no
13865165 | 1.NP_SO-102 | 300 | 0.0165 | 0.3198 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 1.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 94 | 0.0528 | 1 | ETA | 33 | 500 | 500 × 300 | 300 | PO02.02.0783 | 0783 | no
13865166 | 1.NP_SO-102 | 300 | 0.04 | 0.348 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 1.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 94 | 0.128 | 1 | ETA | 80 | 500 | 500 × 300 | 300 | PO02.02.0784 | 0784 | no
13865180 | 1.NP_SO-102 | 300 | 0.0265 | 0.3318 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 1.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 95 | 0.0848 | 1 | ETA | 53 | 500 | 500 × 300 | 300 | PO02.02.0785 | 0785 | no
13865181 | 1.NP_SO-102 | 300 | 0.04 | 0.348 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 1.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 95 | 0.128 | 1 | ETA | 80 | 500 | 500 × 300 | 300 | PO02.02.0786 | 0786 | no
13865827 | -1.PP_SO-102 | 160 | 1.47436 | 1.96718 | 250 mm × 160 mm | 0 | 250 mm × 160 mm | 0 | 2660 | 2580 | 2580 | -1.PP_SO-102 | 2500 | Fáze 1 | Odváděný | 217.288 | 195.122 | Zpětný vzduch | ETA 97 | 4.8359 | 33 | ETA | 5897.44 | 250 | 250 × 160 | 160 | PO02.02.0790 | 0790 | yes
13903909 | 1.NP_SO-102 | 300 | 0.0688 | 0.5316 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 1.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 6 | 0.1892 | 1 | ETA | 86 | 800 | 800 × 300 | 300 | PO02.02.0942 | 0942 | no | Fázování - Bouráno ve FÁZI 2: yes
13903910 | 1.NP_SO-102 | 300 | 0.017484 | 0.493113 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 1.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 6 | 0.048081 | 1 | ETA | 21.855 | 800 | 800 × 300 | 300 | PO02.02.0943 | 0943 | no | Fázování - Bouráno ve FÁZI 2: yes
13905480 | 4.NP_SO-102 | 300 | 0.0604767 | 0.525358 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 68 | 0.166311 | 1 | ETA | 75.5959 | 800 | 800 × 300 | 300 | PO02.02.0944 | 0944 | no
13910116 | 4.NP_SO-102 | 400 | 0.0818845 | 0.564978 | 560 mm × 400 mm | 15 | 590 mm × 430 mm | 0 | 3300 | 3100 | 3100 | 4.NP_SO-102 | 2900 | Fáze 2 | Čerstvý | 515.562 | 466.667 | Přívod vzduchu | ODA 21 | 0.280747 | 8 | ODA | 146.222 | 560 | 560 × 400 | 400 | PO02.02.0958 | 0958 | yes | Izolace - Typ izolace: Protipožární; Identifikační data - Komentáře: VZT31
13910652 | 1.NP_SO-102 | 400 | 0.189685 | 0.718978 | 560 mm × 400 mm | 15 | 590 mm × 430 mm | 0 | 3320 | 3120 | 3120 | 1.NP_SO-102 | 2920 | Fáze 2 | Čerstvý | 515.562 | 466.667 | Přívod vzduchu | ODA 21 | 0.650347 | 16 | ODA | 338.722 | 560 | 560 × 400 | 400 | PO02.02.0959 | 0959 | yes | Izolace - Typ izolace: Protipožární
13912983 | 3.NP_SO-102 | 400 | 0.0790845 | 0.560978 | 560 mm × 400 mm | 15 | 590 mm × 430 mm | 0 | 3295 | 3095 | 3095 | 3.NP_SO-102 | 2895 | Fáze 2 | Čerstvý | 515.562 | 466.667 | Přívod vzduchu | ODA 21 | 0.271147 | 10 | ODA | 141.222 | 560 | 560 × 400 | 400 | PO02.02.0970 | 0970 | yes | Izolace - Typ izolace: Protipožární
13913199 | 2.NP_SO-102 | 400 | 0.0790845 | 0.560978 | 560 mm × 400 mm | 15 | 590 mm × 430 mm | 0 | 2975 | 2775 | 2775 | 2.NP_SO-102 | 2575 | Fáze 2 | Čerstvý | 515.562 | 466.667 | Přívod vzduchu | ODA 21 | 0.271147 | 13 | ODA | 141.222 | 560 | 560 × 400 | 400 | PO02.02.0971 | 0971 | yes | Izolace - Typ izolace: Protipožární
13918457 | -1.PP_SO-102 | 400 | 0.159781 | 0.676258 | 560 mm × 400 mm | 15 | 590 mm × 430 mm | 0 | 3320 | 3120 | 3120 | -1.PP_SO-102 | 2920 | Fáze 2 | Čerstvý | 515.562 | 466.667 | Přívod vzduchu | ODA 21 | 0.547819 | 20 | ODA | 285.322 | 560 | 560 × 400 | 400 | PO02.02.0993 | 0993 | yes | Izolace - Typ izolace: Protipožární
13918743 | 2.NP_SO-102 | 690.049 | 0.315 | 1.55951 | 500 mm × 630 mm | 0 | 500 mm × 630 mm |  | 12135.1 | 11445 | 12135.1 | 2.NP_SO-102 | 11445 | Fáze 2 | Znehodnocený | 612.517 | 557.522 | Odváděný vzduch | EHA 7 | 1.55951 | 1 | EHA | 690.049 | 500 | 500 × 630 | 630 | PO02.02.0994 | 0994 | yes
13918765 | 2.NP_SO-102 | 630 | 0.150857 | 1.01016 | 630 mm × 500 mm | 0 | 630 mm × 500 mm | 173.205 | 11292.4 | 10906.1 | 11167.4 | 2.NP_SO-102 | 10781.1 | Fáze 2 | Znehodnocený | 612.517 | 557.522 | Odváděný vzduch | EHA 7 | 0.681876 | 1 | EHA | 301.715 | 630 | 630 × 500 | 500 | PO02.02.0995 | 0995 | yes | Identifikační data - Komentáře: VZT20
13918946 | 2.NP_SO-102 | 500 | 0.71505 | 1.765 | 630 mm × 500 mm | 0 | 630 mm × 500 mm | 0 | 12790.1 | 12540.1 | 12540.1 | 2.NP_SO-102 | 12290.1 | Fáze 2 | Znehodnocený | 612.517 | 557.522 | Odváděný vzduch | EHA 7 | 2.5651 | 1 | EHA | 1135 | 630 | 630 × 500 | 500 | PO02.02.0996 | 0996 | yes | Identifikační data - Komentáře: VZT20
13928480 | 1.NP_SO-102 | 280 | 2.87051 | 2.90437 | 630 mm × 280 mm | 0 | 630 mm × 280 mm | 0 | 3425 | 3285 | 3285 | 1.NP_SO-102 | 3145 | Fáze 1 | Odváděný | 450.033 | 387.692 | Zpětný vzduch | ETA 11 | 8.29259 | 81 | ETA | 4556.37 | 630 | 630 × 280 | 280 | PO02.02.1014 | 1014 | yes
13937664 | 2.NP_SO-102 | 180 | 0.150832 | 0.279749 | 400 mm × 180 mm | 0 | 400 mm × 180 mm | 0 | 2940 | 2850 | 2850 | 2.NP_SO-102 | 2760 | Fáze 1 | Odváděný | 287.686 | 248.276 | Zpětný vzduch | ETA 12 | 0.437413 | 95 | ETA | 377.08 | 400 | 400 × 180 | 180 | PO02.02.1041 | 1041 | yes
13937731 | 2.NP_SO-102 | 180 | 0.137845 | 0.26806 | 400 mm × 180 mm | 0 | 400 mm × 180 mm | 0 | 2940 | 2850 | 2850 | 2.NP_SO-102 | 2760 | Fáze 1 | Odváděný | 287.686 | 248.276 | Zpětný vzduch | ETA 12 | 0.39975 | 108 | ETA | 344.612 | 400 | 400 × 180 | 180 | PO02.02.1042 | 1042 | yes
13937754 | 2.NP_SO-102 | 180 | 0.121608 | 0.253448 | 400 mm × 180 mm | 0 | 400 mm × 180 mm | 0 | 2992.86 | 2902.86 | 2902.86 | 2.NP_SO-102 | 2812.86 | Fáze 1 | Odváděný | 287.686 | 248.276 | Zpětný vzduch | ETA 12 | 0.352664 | 110 | ETA | 304.021 | 400 | 400 × 180 | 180 | PO02.02.1043 | 1043 | yes
13937781 | 2.NP_SO-102 | 180 | 0.135272 | 0.265744 | 400 mm × 180 mm | 0 | 400 mm × 180 mm | 0 | 2991.43 | 2901.43 | 2901.43 | 2.NP_SO-102 | 2811.43 | Fáze 1 | Odváděný | 287.686 | 248.276 | Zpětný vzduch | ETA 12 | 0.392288 | 109 | ETA | 338.179 | 400 | 400 × 180 | 180 | PO02.02.1044 | 1044 | yes
13937974 | 2.NP_SO-102 | 180 | 0.142845 | 0.27256 | 400 mm × 180 mm | 0 | 400 mm × 180 mm | 0 | 2940 | 2850 | 2850 | 2.NP_SO-102 | 2760 | Fáze 1 | Odváděný | 287.686 | 248.276 | Zpětný vzduch | ETA 12 | 0.41425 | 111 | ETA | 357.112 | 400 | 400 × 180 | 180 | PO02.02.1046 | 1046 | yes
13945967 | -1.PP_SO-102 | 500 | 3.84147 | 6.72757 | 630 mm × 500 mm | 0 | 630 mm × 500 mm | 0 | 3330 | 3080 | 3080 | -1.PP_SO-102 | 2830 | Fáze 1 | Odváděný | 612.517 | 557.522 | Zpětný vzduch | ETA 7 | 13.7805 | 384 | ETA | 6097.57 | 630 | 630 × 500 | 500 | PO02.02.1060 | 1060 | yes
13971995 | 1.NP_SO-102 | 300 | 0.064 | 0.528 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 1.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 29 | 0.176 | 1 | ETA | 80 | 800 | 800 × 300 | 300 | PO02.02.1138 | 1138 | no
13979811 | 3.NP_SO-102 | 300 | 0.0075 | 0.309 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 33 | 0.024 | 1 | ETA | 15 | 500 | 500 × 300 | 300 | PO02.02.1144 | 1144 | no
13979904 | 3.NP_SO-102 | 300 | 0.2675 | 0.621 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 33 | 0.856 | 1 | ETA | 535 | 500 | 500 × 300 | 300 | PO02.02.1145 | 1145 | no
13980599 | 4.NP_SO-102 | 200 | 0.054 | 0.2432 | 500 mm × 200 mm | 0 | 500 mm × 200 mm | 0 | 3300 | 3200 | 3200 | 4.NP_SO-102 | 3100 | Fáze 2 | Odváděný | 337.03 | 285.714 | Zpětný vzduch | ETA 67 | 0.1512 | 1 | ETA | 108 | 500 | 500 × 200 | 200 | PO02.02.1146 | 1146 | no
13981245 | 4.NP_SO-102 | 300 | 0.192 | 0.624 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 68 | 0.528 | 1 | ETA | 240 | 800 | 800 × 300 | 300 | PO02.02.1147 | 1147 | no
13982426 | 4.NP_SO-102 | 300 | 0.06 | 0.372 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 56 | 0.192 | 1 | ETA | 120 | 500 | 500 × 300 | 300 | PO02.02.1152 | 1152 | no
13985598 | 3.NP_SO-102 | 300 | 0.05 | 0.36 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 89 | 0.16 | 1 | ETA | 100 | 500 | 500 × 300 | 300 | PO02.02.1168 | 1168 | yes
13990588 | 3.NP_SO-102 | 200 | 0.025 | 0.22 | 500 mm × 200 mm | 0 | 500 mm × 200 mm | 0 | 3300 | 3200 | 3200 | 3.NP_SO-102 | 3100 | Fáze 1 | Odváděný | 337.03 | 285.714 | Zpětný vzduch | ETA 64 | 0.07 | 1 | ETA | 50 | 500 | 500 × 200 | 200 | PO02.02.1184 | 1184 | no
14034420 | 2.NP_SO-102 | 3664.79 | 0.1125 | 5.31394 | 225 mm × 500 mm | 0 | 225 mm × 500 mm |  | 7929.5 | 7929.5 | 4264.71 | 2.NP_SO-102 | 4264.71 | Fáze 1 | Odváděný | 359.608 | 310.345 | Zpětný vzduch | ETA 14 | 5.31394 | 270 | ETA | 3664.79 | 225 | 225 × 500 | 500 | PO02.02.1293 | 1293 | yes | Identifikační data - Komentáře: VZT25
14034684 | 3.NP_SO-102 | 250 | 0.00880978 | 0.132077 | 225 mm × 250 mm | 0 | 225 mm × 250 mm | 0 | 3225 | 3100 | 3100 | 3.NP_SO-102 | 2975 | Fáze 1 | Odváděný | 259.177 | 236.842 | Zpětný vzduch | ETA 14 | 0.0371968 | 269 | ETA | 39.1546 | 225 | 225 × 250 | 250 | PO02.02.1294 | 1294 | no
14037417 | 2.NP_SO-102 | 225 | 0.0403487 | 0.261314 | 500 mm × 225 mm | 0 | 500 mm × 225 mm | 0 | 2992.5 | 2880 | 2880 | 2.NP_SO-102 | 2767.5 | Fáze 1 | Přívodní | 359.608 | 310.345 | Přívod vzduchu | SUP 9 | 0.117011 | 453 | SUP | 80.6973 | 500 | 500 × 225 | 225 | PO02.02.1299 | 1299 | yes
14037549 | 2.NP_SO-102 | 225 | 0.355212 | 0.544691 | 500 mm × 225 mm | 0 | 500 mm × 225 mm | 0 | 2992.5 | 2880 | 2880 | 2.NP_SO-102 | 2767.5 | Fáze 1 | Přívodní | 359.608 | 310.345 | Přívod vzduchu | SUP 9 | 1.03012 | 453 | SUP | 710.424 | 500 | 500 × 225 | 225 | PO02.02.1300 | 1300 | yes
14037636 | 2.NP_SO-102 | 225 | 0.499218 | 0.674296 | 500 mm × 225 mm | 0 | 500 mm × 225 mm | 0 | 2992.5 | 2880 | 2880 | 2.NP_SO-102 | 2767.5 | Fáze 1 | Přívodní | 359.608 | 310.345 | Přívod vzduchu | SUP 9 | 1.44773 | 447 | SUP | 998.436 | 500 | 500 × 225 | 225 | PO02.02.1301 | 1301 | yes
14037774 | 2.NP_SO-102 | 315 | 0.137803 | 0.856953 | 1250 mm × 315 mm | 0 | 1250 mm × 315 mm | 0 | 3037.5 | 2880 | 2880 | 2.NP_SO-102 | 2722.5 | Fáze 1 | Přívodní | 649.124 | 503.195 | Přívod vzduchu | SUP 9 | 0.345058 | 451 | SUP | 110.242 | 1250 | 1250 × 315 | 315 | PO02.02.1302 | 1302 | yes
14038032 | 2.NP_SO-102 | 225 | 0.198741 | 0.403867 | 500 mm × 225 mm | 0 | 500 mm × 225 mm | 0 | 2992.5 | 2880 | 2880 | 2.NP_SO-102 | 2767.5 | Fáze 1 | Přívodní | 359.608 | 310.345 | Přívod vzduchu | SUP 9 | 0.576349 | 447 | SUP | 397.482 | 500 | 500 × 225 | 225 | PO02.02.1303 | 1303 | yes
14038115 | 2.NP_SO-102 | 225 | 0.128413 | 0.340572 | 500 mm × 225 mm | 0 | 500 mm × 225 mm | 0 | 2992.5 | 2880 | 2880 | 2.NP_SO-102 | 2767.5 | Fáze 1 | Přívodní | 359.608 | 310.345 | Přívod vzduchu | SUP 9 | 0.372398 | 453 | SUP | 256.826 | 500 | 500 × 225 | 225 | PO02.02.1304 | 1304 | yes
14039387 | 1.NP_SO-102 | 160 | 0.0107761 | 0.0937934 | 250 mm × 160 mm | 0 | 250 mm × 160 mm | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 3015 | Fáze 1 | Přívodní | 217.288 | 195.122 | Přívod vzduchu | SUP 14 | 0.0353455 | 11 | SUP | 43.1042 | 250 | 250 × 160 | 160 | PO02.02.1309 | 1309 | yes
14039429 | 1.NP_SO-102 | 160 | 0.0107761 | 0.0937934 | 250 mm × 160 mm | 0 | 250 mm × 160 mm | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 3015 | Fáze 1 | Přívodní | 217.288 | 195.122 | Přívod vzduchu | SUP 14 | 0.0353455 | 13 | SUP | 43.1042 | 250 | 250 × 160 | 160 | PO02.02.1310 | 1310 | yes
14039738 | 1.NP_SO-102 | 300 | 0.0665 | 0.3798 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 1.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 98 | 0.2128 | 1 | ETA | 133 | 500 | 500 × 300 | 300 | PO02.02.1311 | 1311 | no
14039739 | 1.NP_SO-102 | 300 | 2.24 | 2.988 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 1.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 98 | 7.168 | 1 | ETA | 4480 | 500 | 500 × 300 | 300 | PO02.02.1312 | 1312 | no
14040158 | 1.NP_SO-102 | 300 | 0.029691 | 0.335629 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 1.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 98 | 0.0950113 | 3 | ETA | 59.3821 | 500 | 500 × 300 | 300 | PO02.02.1314 | 1314 | no
14040449 | 1.NP_SO-102 | 300 | 0.324309 | 0.689171 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 1.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 98 | 1.03779 | 3 | ETA | 648.618 | 500 | 500 × 300 | 300 | PO02.02.1316 | 1316 | no
14059536 | -1.PP_SO-102 | 300 | 0.0165 | 0.3198 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | -1.PP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 99 | 0.0528 | 1 | ETA | 33 | 500 | 500 × 300 | 300 | PO02.02.1381 | 1381 | no
14059537 | -1.PP_SO-102 | 300 | 0.04 | 0.348 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | -1.PP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 99 | 0.128 | 1 | ETA | 80 | 500 | 500 × 300 | 300 | PO02.02.1382 | 1382 | no
14059628 | -1.PP_SO-102 | 500 | 0.122567 | 1.22943 | 1120 mm × 500 mm | 0 | 1120 mm × 500 mm | 0 | 3330 | 3080 | 3080 | -1.PP_SO-102 | 2830 | Fáze 1 | Odváděný | 802.014 | 691.358 | Zpětný vzduch | ETA 7 | 0.354568 | 73 | ETA | 109.435 | 1120 | 1120 × 500 | 500 | PO02.02.1384 | 1384 | yes
14060388 | -1.PP_SO-102 | 500 | 0.400391 | 1.47749 | 1120 mm × 500 mm | 0 | 1120 mm × 500 mm | 0 | 3330 | 3080 | 3080 | -1.PP_SO-102 | 2830 | Fáze 1 | Odváděný | 802.014 | 691.358 | Zpětný vzduch | ETA 7 | 1.15827 | 358 | ETA | 357.492 | 1120 | 1120 × 500 | 500 | PO02.02.1385 | 1385 | yes
14068035 | 1.NP_SO-102 | 300 | 0.078516 | 0.538887 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 1.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 6 | 0.215919 | 1 | ETA | 98.145 | 800 | 800 × 300 | 300 | PO02.02.1418 | 1418 | no | Fázování - Bouráno ve FÁZI 2: yes
14112914 | 1.NP_SO-102 | 400 | 2.61333 | 2.89066 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 0 | 3450 | 3250 | 3250 | 1.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 674.06 | 571.429 | Zpětný vzduch | ETA 11 | 7.31731 | 87 | ETA | 2613.33 | 1000 | 1000 × 400 | 400 | PO02.02.1474 | 1474 | yes
14114084 | -1.PP_SO-102 | 500 | 0.354762 | 1.43675 | 1120 mm × 500 mm | 0 | 1120 mm × 500 mm | 0 | 3330 | 3080 | 3080 | -1.PP_SO-102 | 2830 | Fáze 1 | Odváděný | 802.014 | 691.358 | Zpětný vzduch | ETA 7 | 1.02628 | 400 | ETA | 316.752 | 1120 | 1120 × 500 | 500 | PO02.02.1477 | 1477 | yes
14115933 | -1.PP_SO-102 | 355 | 0.779535 | 1.25984 | 800 mm × 355 mm | 15 | 830 mm × 385 mm | 0 | 3107.5 | 2930 | 2930 | -1.PP_SO-102 | 2752.5 | Fáze 2 | Znehodnocený | 570.981 | 491.775 | Odváděný vzduch | EHA 7 | 2.25091 | 3 | EHA | 974.419 | 800 | 800 × 355 | 355 | PO02.02.1485 | 1485 | yes | Izolace - Typ izolace: Protipožární
14116145 | -1.PP_SO-102 | 355 | 2.8776 | 3.12187 | 800 mm × 355 mm | 0 | 800 mm × 355 mm | 0 | 3107.5 | 2930 | 2930 | -1.PP_SO-102 | 2752.5 | Fáze 2 | Znehodnocený | 570.981 | 491.775 | Odváděný vzduch | EHA 7 | 8.30907 | 3 | EHA | 3597 | 800 | 800 × 355 | 355 | PO02.02.1486 | 1486 | yes
14116782 | -1.PP_SO-102 | 500 | 0.727418 | 1.70927 | 800 mm × 500 mm | 0 | 800 mm × 500 mm | 0 | 3320 | 3070 | 3070 | -1.PP_SO-102 | 2820 | Fáze 2 | Přívodní | 686.665 | 615.385 | Přívod vzduchu | SUP 12 | 2.36411 | 54 | SUP | 909.273 | 800 | 800 × 500 | 500 | PO02.02.1494 | 1494 | yes
14117244 | -1.PP_SO-102 | 630 | 0.354802 | 1.50391 | 560 mm × 630 mm | 0 | 560 mm × 630 mm | 0 | 3385 | 3070 | 3070 | -1.PP_SO-102 | 2755 | Fáze 2 | Přívodní | 649.026 | 592.941 | Přívod vzduchu | SUP 12 | 1.50791 | 240 | SUP | 633.576 | 560 | 560 × 630 | 630 | PO02.02.1499 | 1499 | yes
14118227 | 1.NP_SO-102 | 315 | 2.90924 | 2.60347 | 900 mm × 315 mm | 0 | 900 mm × 315 mm | 0 | 3419.94 | 3262.44 | 3262.44 | 1.NP_SO-102 | 3104.94 | Fáze 1 | Přívodní | 563.177 | 466.667 | Přívod vzduchu | SUP 11 | 7.85494 | 182 | SUP | 3232.49 | 900 | 900 × 315 | 315 | PO02.02.1502 | 1502 | yes
14125321 | 2.NP_SO-102 | 167.571 | 0.4 | 0.469199 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm |  | -162.486 | -330.057 | -162.486 | 2.NP_SO-102 | -330.057 | Fáze 1 | Přívodní | 674.06 | 571.429 | Přívod vzduchu | SUP 11 | 0.469199 | 113 | SUP | 167.571 | 1000 | 1000 × 400 | 400 | PO02.02.1519 | 1519 | yes
14132276 | 1.NP_SO-102 | 85.1 | 0.099225 | 0.107226 | 315 mm × 315 mm | 0 | 315 mm × 315 mm |  | 3068.34 | 3068.34 | 2983.24 | 1.NP_SO-102 | 2983.24 | Fáze 1 | Přívodní | 344.347 | 315 | Přívod vzduchu | SUP 11 | 0.107226 | 163 | SUP | 85.1 | 315 | 315 × 315 | 315 | PO02.02.1521 | 1521 | yes
14132306 | 1.NP_SO-102 | 10.1 | 0.099225 | 0.012726 | 315 mm × 315 mm | 0 | 315 mm × 315 mm |  | 3003.34 | 3003.34 | 2993.24 | 1.NP_SO-102 | 2993.24 | Fáze 1 | Přívodní | 344.347 | 315 | Přívod vzduchu | SUP 11 | 0.012726 | 195 | SUP | 10.1 | 315 | 315 × 315 | 315 | PO02.02.1522 | 1522 | yes
14132337 | 1.NP_SO-102 | 10.1 | 0.099225 | 0.012726 | 315 mm × 315 mm | 0 | 315 mm × 315 mm |  | 3003.34 | 3003.34 | 2993.24 | 1.NP_SO-102 | 2993.24 | Fáze 1 | Přívodní | 344.347 | 315 | Přívod vzduchu | SUP 11 | 0.012726 | 192 | SUP | 10.1 | 315 | 315 × 315 | 315 | PO02.02.1523 | 1523 | yes
14132363 | 1.NP_SO-102 | 5.1 | 0.099225 | 0.006426 | 315 mm × 315 mm | 0 | 315 mm × 315 mm |  | 2963.34 | 2963.34 | 2958.24 | 1.NP_SO-102 | 2958.24 | Fáze 1 | Přívodní | 344.347 | 315 | Přívod vzduchu | SUP 11 | 0.006426 | 189 | SUP | 5.1 | 315 | 315 × 315 | 315 | PO02.02.1524 | 1524 | yes
14132455 | 1.NP_SO-102 | 5.1 | 0.099225 | 0.006426 | 315 mm × 315 mm | 0 | 315 mm × 315 mm |  | 3003.34 | 3003.34 | 2998.24 | 1.NP_SO-102 | 2998.24 | Fáze 1 | Přívodní | 344.347 | 315 | Přívod vzduchu | SUP 11 | 0.006426 | 181 | SUP | 5.1 | 315 | 315 × 315 | 315 | PO02.02.1526 | 1526 | yes
14132512 | 1.NP_SO-102 | 28.6545 | 0.099225 | 0.0361047 | 315 mm × 315 mm | 0 | 315 mm × 315 mm |  | 3068.34 | 3068.34 | 3039.69 | 1.NP_SO-102 | 3039.69 | Fáze 1 | Přívodní | 344.347 | 315 | Přívod vzduchu | SUP 11 | 0.0361047 | 177 | SUP | 28.6545 | 315 | 315 × 315 | 315 | PO02.02.1527 | 1527 | yes
14148347 | 3.NP_SO-102 | 300 | 0.0065 | 0.3078 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3250 | 3100 | 3100 | 3.NP_SO-102 | 2950 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 50 | 0.0208 | 1 | ETA | 13 | 500 | 500 × 300 | 300 | PO02.02.1553 | 1553 | no
14148423 | 3.NP_SO-102 | 300 | 0.0065 | 0.3078 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 49 | 0.0208 | 1 | ETA | 13 | 500 | 500 × 300 | 300 | PO02.02.1554 | 1554 | no
14148458 | 3.NP_SO-102 | 200 | 0.0065 | 0.2052 | 500 mm × 200 mm | 0 | 500 mm × 200 mm | 0 | 3300 | 3200 | 3200 | 3.NP_SO-102 | 3100 | Fáze 1 | Odváděný | 337.03 | 285.714 | Zpětný vzduch | ETA 51 | 0.0182 | 1 | ETA | 13 | 500 | 500 × 200 | 200 | PO02.02.1555 | 1555 | no
14148528 | 3.NP_SO-102 | 300 | 0.0264 | 0.4998 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 54 | 0.0726 | 1 | ETA | 33 | 800 | 800 × 300 | 300 | PO02.02.1556 | 1556 | no
14148586 | 4.NP_SO-102 | 300 | 0.0165 | 0.3198 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 55 | 0.0528 | 1 | ETA | 33 | 500 | 500 × 300 | 300 | PO02.02.1557 | 1557 | yes
14148617 | 4.NP_SO-102 | 300 | 0.0165 | 0.3198 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 1 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 56 | 0.0528 | 1 | ETA | 33 | 500 | 500 × 300 | 300 | PO02.02.1558 | 1558 | no
14148649 | 4.NP_SO-102 | 300 | 0.0264 | 0.4998 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 69 | 0.0726 | 1 | ETA | 33 | 800 | 800 × 300 | 300 | PO02.02.1559 | 1559 | no
14148753 | 3.NP_SO-102 | 300 | 0.0264 | 0.4998 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 78 | 0.0726 | 1 | ETA | 33 | 800 | 800 × 300 | 300 | PO02.02.1560 | 1560 | no
14148812 | 4.NP_SO-102 | 300 | 0.0144 | 0.4908 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 70 | 0.0396 | 1 | ETA | 18 | 800 | 800 × 300 | 300 | PO02.02.1561 | 1561 | no
14148860 | 4.NP_SO-102 | 300 | 0.0065 | 0.3078 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 4.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 72 | 0.0208 | 1 | ETA | 13 | 500 | 500 × 300 | 300 | PO02.02.1562 | 1562 | no
14148892 | 3.NP_SO-102 | 300 | 0.0165 | 0.3198 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 89 | 0.0528 | 1 | ETA | 33 | 500 | 500 × 300 | 300 | PO02.02.1563 | 1563 | yes
14148993 | 3.NP_SO-102 | 300 | 0.0165 | 0.3198 | 500 mm × 300 mm | 0 | 500 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 419.979 | 375 | Zpětný vzduch | ETA 33 | 0.0528 | 1 | ETA | 33 | 500 | 500 × 300 | 300 | PO02.02.1564 | 1564 | no
14149024 | 3.NP_SO-102 | 300 | 0.0264 | 0.4998 | 800 mm × 300 mm | 0 | 800 mm × 300 mm | 0 | 3350 | 3200 | 3200 | 3.NP_SO-102 | 3050 | Fáze 2 | Odváděný | 520.268 | 436.364 | Zpětný vzduch | ETA 79 | 0.0726 | 1 | ETA | 33 | 800 | 800 × 300 | 300 | PO02.02.1565 | 1565 | no
14165648 | 1.NP_SO-102 | 450 | 7.17856 | 7.36071 | 1000 mm × 450 mm | 0 | 1000 mm × 450 mm | 0 | 3425 | 3200 | 3200 | 1.NP_SO-102 | 2975 | Fáze 1 | Odváděný | 719.216 | 620.69 | Zpětný vzduch | ETA 11 | 20.8178 | 30 | ETA | 7178.56 | 1000 | 1000 × 450 | 450 | PO02.02.1582 | 1582 | yes
14165846 | 1.NP_SO-102 | 450 | 2.27885 | 2.95096 | 1000 mm × 450 mm | 0 | 1000 mm × 450 mm | 0 | 3425 | 3200 | 3200 | 1.NP_SO-102 | 2975 | Fáze 1 | Odváděný | 719.216 | 620.69 | Zpětný vzduch | ETA 11 | 6.60866 | 84 | ETA | 2278.85 | 1000 | 1000 × 450 | 450 | PO02.02.1583 | 1583 | yes
14165921 | 1.NP_SO-102 | 450 | 1.82654 | 2.54389 | 1000 mm × 450 mm | 0 | 1000 mm × 450 mm | 0 | 3425 | 3200 | 3200 | 1.NP_SO-102 | 2975 | Fáze 1 | Odváděný | 719.216 | 620.69 | Zpětný vzduch | ETA 11 | 5.29697 | 84 | ETA | 1826.54 | 1000 | 1000 × 450 | 450 | PO02.02.1584 | 1584 | yes
14166803 | 1.NP_SO-102 | 250 | 2.34465 | 2.17584 | 630 mm × 250 mm | 0 | 630 mm × 250 mm | 0 | 3419.94 | 3294.94 | 3294.94 | 1.NP_SO-102 | 3169.94 | Fáze 1 | Přívodní | 422.788 | 357.955 | Přívod vzduchu | SUP 11 | 6.55015 | 161 | SUP | 3721.67 | 630 | 630 × 250 | 250 | PO02.02.1585 | 1585 | yes
14166989 | 1.NP_SO-102 | 355 | 6.56486 | 4.95685 | 1120 mm × 355 mm | 0 | 1120 mm × 355 mm | 0 | 3419.94 | 3242.44 | 3242.44 | 1.NP_SO-102 | 3064.94 | Fáze 1 | Přívodní | 662.826 | 539.119 | Přívod vzduchu | SUP 11 | 17.2914 | 187 | SUP | 5861.48 | 1120 | 1120 × 355 | 355 | PO02.02.1586 | 1586 | yes
14167138 | 1.NP_SO-102 | 315 | 2.88306 | 3.00551 | 710 mm × 315 mm | 0 | 710 mm × 315 mm | 0 | 3419.94 | 3262.44 | 3262.44 | 1.NP_SO-102 | 3104.94 | Fáze 1 | Přívodní | 506.691 | 436.39 | Přívod vzduchu | SUP 11 | 8.32433 | 193 | SUP | 4060.65 | 710 | 710 × 315 | 315 | PO02.02.1587 | 1587 | yes
14167710 | 1.NP_SO-102 | 400 | 2.12125 | 2.3576 | 1250 mm × 400 mm | 0 | 1250 mm × 400 mm | 0 | 3419.94 | 3219.94 | 3219.94 | 1.NP_SO-102 | 3019.94 | Fáze 1 | Přívodní | 743.753 | 606.061 | Přívod vzduchu | SUP 11 | 5.6001 | 112 | SUP | 1697 | 1250 | 1250 × 400 | 400 | PO02.02.1588 | 1588 | yes
14169233 | 1.NP_SO-102 | 250 | 3.02616 | 2.71672 | 630 mm × 250 mm | 0 | 630 mm × 250 mm | 0 | 3419.94 | 3294.94 | 3294.94 | 1.NP_SO-102 | 3169.94 | Fáze 1 | Přívodní | 422.788 | 357.955 | Přívod vzduchu | SUP 11 | 8.45404 | 157 | SUP | 4803.43 | 630 | 630 × 250 | 250 | PO02.02.1589 | 1589 | yes
14169773 | 1.NP_SO-102 | 6.7 | 0.099225 | 0.008442 | 315 mm × 315 mm | 0 | 315 mm × 315 mm |  | 2963.34 | 2963.34 | 2956.64 | 1.NP_SO-102 | 2956.64 | Fáze 1 | Přívodní | 344.347 | 315 | Přívod vzduchu | SUP 11 | 0.008442 | 186 | SUP | 6.7 | 315 | 315 × 315 | 315 | PO02.02.1590 | 1590
14174483 | -1.PP_SO-102 | 400 | 0.00880411 | 0.30384 | 355 mm × 400 mm | 0 | 355 mm × 400 mm | 0 | 3350 | 3150 | 3150 | -1.PP_SO-102 | 2950 | Fáze 2 | Odváděný | 411.753 | 376.159 | Zpětný vzduch | ETA 7 | 0.0374485 | 237 | ETA | 24.8003 | 355 | 355 × 400 | 400 | PO02.02.1598 | 1598 | yes
14174528 | -1.PP_SO-102 | 280 | 0.275021 | 0.632636 | 355 mm × 280 mm | 0 | 355 mm × 280 mm | 0 | 3312.5 | 3172.5 | 3172.5 | -1.PP_SO-102 | 3032.5 | Fáze 2 | Odváděný | 344.046 | 313.071 | Zpětný vzduch | ETA 7 | 0.983877 | 431 | ETA | 774.707 | 355 | 355 × 280 | 280 | PO02.02.1599 | 1599 | yes
14174818 | -1.PP_SO-102 | 280 | 0.0791965 | 0.32373 | 355 mm × 280 mm | 0 | 355 mm × 280 mm | 0 | 3312.5 | 3172.5 | 3172.5 | -1.PP_SO-102 | 3032.5 | Fáze 2 | Odváděný | 344.046 | 313.071 | Zpětný vzduch | ETA 7 | 0.283323 | 431 | ETA | 223.089 | 355 | 355 × 280 | 280 | PO02.02.1600 | 1600 | yes
14174954 | -1.PP_SO-102 | 355 | 0.0214342 | 0.253151 | 355 mm × 280 mm | 0 | 355 mm × 280 mm | 100 | 3162.31 | 3009.19 | 3063.31 | -1.PP_SO-102 | 2910.19 | Fáze 2 | Odváděný | 344.046 | 313.071 | Zpětný vzduch | ETA 7 | 0.0972194 | 431 | ETA | 76.5507 | 355 | 355 × 280 | 280 | PO02.02.1601 | 1601 | yes
14174967 | -1.PP_SO-102 | 280 | 0.103228 | 0.361639 | 355 mm × 280 mm | 0 | 355 mm × 280 mm | 0 | 3040 | 2900 | 2900 | -1.PP_SO-102 | 2760 | Fáze 2 | Odváděný | 344.046 | 313.071 | Zpětný vzduch | ETA 7 | 0.369296 | 431 | ETA | 290.784 | 355 | 355 × 280 | 280 | PO02.02.1602 | 1602 | yes
14177460 | 1.NP_SO-102 | 1000 | 0.0516922 | 1.05846 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 57.735 | 3355.51 | 3117.69 | 3182.31 | 1.NP_SO-102 | 2944.49 | Fáze 1 | Odváděný | 674.06 | 571.429 | Zpětný vzduch | ETA 11 | 0.361845 | 87 | ETA | 129.23 | 1000 | 1000 × 400 | 400 | PO02.02.1609 | 1609 | yes
14177474 | 1.NP_SO-102 | 400 | 0.521205 | 1.21696 | 1000 mm × 400 mm | 0 | 1000 mm × 400 mm | 0 | 3250 | 3050 | 3050 | 1.NP_SO-102 | 2850 | Fáze 1 | Odváděný | 674.06 | 571.429 | Zpětný vzduch | ETA 11 | 1.45937 | 87 | ETA | 521.205 | 1000 | 1000 × 400 | 400 | PO02.02.1610 | 1610 | yes
14181640 | 1.NP_SO-102 | 32.6 | 0.099225 | 0.041076 | 315 mm × 315 mm | 0 | 315 mm × 315 mm |  | 3055.9 | 3055.9 | 3023.3 | 1.NP_SO-102 | 3023.3 | Fáze 1 | Přívodní | 344.347 | 315 | Přívod vzduchu | SUP 15 | 0.041076 | 163 | SUP | 32.6 | 315 | 315 × 315 | 315 | PO02.02.1622 | 1622 | yes
14181641 | 1.NP_SO-102 | 7.6 | 0.099225 | 0.009576 | 315 mm × 315 mm | 0 | 315 mm × 315 mm |  | 2990.9 | 2990.9 | 2983.3 | 1.NP_SO-102 | 2983.3 | Fáze 1 | Přívodní | 344.347 | 315 | Přívod vzduchu | SUP 15 | 0.009576 | 195 | SUP | 7.6 | 315 | 315 × 315 | 315 | PO02.02.1623 | 1623 | yes
14181642 | 1.NP_SO-102 | 7.6 | 0.099225 | 0.009576 | 315 mm × 315 mm | 0 | 315 mm × 315 mm |  | 2990.9 | 2990.9 | 2983.3 | 1.NP_SO-102 | 2983.3 | Fáze 1 | Přívodní | 344.347 | 315 | Přívod vzduchu | SUP 15 | 0.009576 | 192 | SUP | 7.6 | 315 | 315 × 315 | 315 | PO02.02.1624 | 1624 | yes
14181643 | 1.NP_SO-102 | 315 | 2.52096 | 2.68421 | 710 mm × 315 mm | 0 | 710 mm × 315 mm | 0 | 3407.5 | 3250 | 3250 | 1.NP_SO-102 | 3092.5 | Fáze 1 | Přívodní | 506.691 | 436.39 | Přívod vzduchu | SUP 15 | 7.27883 | 193 | SUP | 3550.65 | 710 | 710 × 315 | 315 | PO02.02.1625 | 1625 | yes
14181646 | 1.NP_SO-102 | 250 | 3.02616 | 2.71672 | 630 mm × 250 mm | 0 | 630 mm × 250 mm | 0 | 3407.5 | 3282.5 | 3282.5 | 1.NP_SO-102 | 3157.5 | Fáze 1 | Přívodní | 422.788 | 357.955 | Přívod vzduchu | SUP 15 | 8.45404 | 157 | SUP | 4803.43 | 630 | 630 × 250 | 250 | PO02.02.1626 | 1626 | yes
14181678 | 1.NP_SO-102 | 315 | 2.82034 | 2.94985 | 710 mm × 315 mm | 0 | 710 mm × 315 mm | 0 | 3407.5 | 3250 | 3250 | 1.NP_SO-102 | 3092.5 | Fáze 1 | Přívodní | 506.691 | 436.39 | Přívod vzduchu | SUP 15 | 8.14323 | 222 | SUP | 3972.31 | 710 | 710 × 315 | 315 | PO02.02.1627 | 1627
14181760 | 1.NP_SO-102 | 450 | 6.68158 | 6.91342 | 1000 mm × 450 mm | 0 | 1000 mm × 450 mm | 0 | 3475 | 3250 | 3250 | 1.NP_SO-102 | 3025 | Fáze 1 | Přívodní | 719.216 | 620.69 | Přívod vzduchu | SUP 15 | 19.3766 | 229 | SUP | 6681.58 | 1000 | 1000 × 450 | 450 | PO02.02.1628 | 1628 | yes
14181811 | 1.NP_SO-102 | 10.1 | 0.099225 | 0.012726 | 315 mm × 315 mm | 0 | 315 mm × 315 mm |  | 3123.4 | 3123.4 | 3113.3 | 1.NP_SO-102 | 3113.3 | Fáze 1 | Přívodní | 344.347 | 315 | Přívod vzduchu | SUP 15 | 0.012726 | 205 | SUP | 10.1 | 315 | 315 × 315 | 315 | PO02.02.1630 | 1630 | yes
14181813 | 1.NP_SO-102 | 315 | 0.647615 | 1.02194 | 710 mm × 315 mm | 0 | 710 mm × 315 mm | 0 | 3475 | 3317.5 | 3317.5 | 1.NP_SO-102 | 3160 | Fáze 1 | Přívodní | 506.691 | 436.39 | Přívod vzduchu | SUP 15 | 1.86987 | 202 | SUP | 912.134 | 710 | 710 × 315 | 315 | PO02.02.1631 | 1631 | yes
14181816 | 1.NP_SO-102 | 250 | 2.09376 | 1.97672 | 630 mm × 250 mm | 0 | 630 mm × 250 mm | 0 | 3475 | 3350 | 3350 | 1.NP_SO-102 | 3225 | Fáze 1 | Přívodní | 422.788 | 357.955 | Přívod vzduchu | SUP 15 | 5.84924 | 203 | SUP | 3323.43 | 630 | 630 × 250 | 250 | PO02.02.1632 | 1632 | yes
14182359 | 1.NP_SO-102 | 315 | 2.93582 | 3.05232 | 710 mm × 315 mm | 0 | 710 mm × 315 mm | 0 | 3407.5 | 3250 | 3250 | 1.NP_SO-102 | 3092.5 | Fáze 1 | Přívodní | 506.691 | 436.39 | Přívod vzduchu | SUP 15 | 8.47665 | 211 | SUP | 4134.95 | 710 | 710 × 315 | 315 | PO02.02.1633 | 1633 | yes
14182364 | 1.NP_SO-102 | 10 | 0.099225 | 0.0126 | 315 mm × 315 mm | 0 | 315 mm × 315 mm |  | 3055.9 | 3055.9 | 3045.9 | 1.NP_SO-102 | 3045.9 | Fáze 1 | Přívodní | 344.347 | 315 | Přívod vzduchu | SUP 15 | 0.0126 | 215 | SUP | 10 | 315 | 315 × 315 | 315 | PO02.02.1635 | 1635 | yes
14182365 | 1.NP_SO-102 | 315 | 0.647615 | 1.02194 | 710 mm × 315 mm | 0 | 710 mm × 315 mm | 0 | 3407.5 | 3250 | 3250 | 1.NP_SO-102 | 3092.5 | Fáze 1 | Přívodní | 506.691 | 436.39 | Přívod vzduchu | SUP 15 | 1.86987 | 212 | SUP | 912.134 | 710 | 710 × 315 | 315 | PO02.02.1636 | 1636 | yes
14182368 | 1.NP_SO-102 | 250 | 2.09376 | 1.97672 | 630 mm × 250 mm | 0 | 630 mm × 250 mm | 0 | 3407.5 | 3282.5 | 3282.5 | 1.NP_SO-102 | 3157.5 | Fáze 1 | Přívodní | 422.788 | 357.955 | Přívod vzduchu | SUP 15 | 5.84924 | 213 | SUP | 3323.43 | 630 | 630 × 250 | 250 | PO02.02.1637 | 1637 | yes
14182436 | 1.NP_SO-102 | 315 | 5.20486 | 5.0657 | 710 mm × 315 mm | 0 | 710 mm × 315 mm | 0 | 3407.5 | 3250 | 3250 | 1.NP_SO-102 | 3092.5 | Fáze 1 | Přívodní | 506.691 | 436.39 | Přívod vzduchu | SUP 15 | 15.0281 | 211 | SUP | 7330.79 | 710 | 710 × 315 | 315 | PO02.02.1638 | 1638
14182515 | 1.NP_SO-102 | 315 | 2.81721 | 2.94708 | 710 mm × 315 mm | 0 | 710 mm × 315 mm | 0 | 3407.5 | 3250 | 3250 | 1.NP_SO-102 | 3092.5 | Fáze 1 | Přívodní | 506.691 | 436.39 | Přívod vzduchu | SUP 15 | 8.13421 | 222 | SUP | 3967.91 | 710 | 710 × 315 | 315 | PO02.02.1639 | 1639
14183088 | 1.NP_SO-102 | 7.5 | 0.099225 | 0.00945 | 315 mm × 315 mm | 0 | 315 mm × 315 mm |  | 3058.4 | 3050.9 | 3058.4 | 1.NP_SO-102 | 3050.9 | Fáze 1 | Přívodní | 344.347 | 315 | Přívod vzduchu | SUP 15 | 0.00945 | 209 | SUP | 7.5 | 315 | 315 × 315 | 315 | PO02.02.1640 | 1640

# IfcDuctSegment: Kulaté potrubí:HLADKÉ POZINK/vývod (10)
Type - Material: 128-64-0
Type - Požární ochrana - Požární odolnost: A1
Type - Materiály a povrchové úpravy - Materiál: Kov, pozink
Type - Stavba - Drsnost: 0.15 mm
Type - Identifikační data - ID kategorie: PO; Kód sestavy: PO02; Komentáře k typům: POZINK; Název typu: HLADKÉ POZINK/vývod; Označení typu: 05; Popis: Potrubí kulaté pozink; Popis sestavy: Pozinkované
Type - Jiné - Kategorie: Potrubí; MJ: m; Název rodiny: Kulaté potrubí
Classification: PO02 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Reynoldsovo číslo: 0; Doplňkový průtok: 0 m3/s; Dynamický tlak: 0 Pa; Průtok: 0 m3/s; Rychlost: 0 m/s; Tlaková ztráta: 0 Pa; Tření: 0 kg/m2/s2
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Horizontální zarovnání: Na střed; Vertikální zarovnání: Střed
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Koeficient ztrát: 0; Uzamknutí velikosti: no; Typ systému: Znehodnocený; Klasifikace systému: Odváděný vzduch; Zkratka systému: EHA
Jiné - Páteřní trasa: yes; Rodina: Kulaté potrubí; Id typu: 9070530; Rodina a typ: Kulaté potrubí: HLADKÉ POZINK/vývod; Typ: HLADKÉ POZINK/vývod
Name (Kulaté potrubí:HLADKÉ POZINK/vývod:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Volná velikost = Celková velikost | Sklon | Referenční podlaží | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Spodní výška (mm) | Řez | Ekvivaletní průměr (mm) = Hydraulický průměr (mm) = Průměr (mm) = Velikost | Název systému = Group | Kód prvku | Označení
13631351 | -1.PP_SO-102 | 22.6336 | 0.0989649 | 0.0252425 | 355 mm | 0 | -1.PP_SO-102 | 3253.97 | 3076.47 | 3076.47 | 2898.97 | 2 | 355 | EHA 9 | PO02.05.0300 | 0300
