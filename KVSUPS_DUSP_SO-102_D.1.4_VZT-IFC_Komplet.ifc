Properties of the parts of a building model (IFC4), part 23 of 45

# IfcDistributionPort (8507)
Name | FlowDirection | SystemType | Group
InPort_13629073_2 | SINK | EXHAUST | ETA 8
OutPort_13629077_2 | SOURCE | EXHAUST | ETA 8
InPort_13629075_0 | SINK | EXHAUST | ETA 8
OutPort_13810138_1 | SOURCE | EXHAUST | ETA 8
InPort_13629077_1 | SINK | EXHAUST | ETA 8
OutPort_13629075_1 | SOURCE | EXHAUST | ETA 8
InPort_13629092_1 | SINK | EXHAUST | ETA 8
OutPort_13629098_2 | SOURCE | EXHAUST | ETA 8
InPort_13629096_2 | SINK | EXHAUST | ETA 8
OutPort_13629092_2 | SOURCE | EXHAUST | ETA 8
InPort_13629094_1 | SINK | EXHAUST | ETA 8
OutPort_13629096_1 | SOURCE | EXHAUST | ETA 8
InPort_13629310_0 | SINK | EXHAUST | ETA 8
OutPort_13902833_2 | SOURCE | EXHAUST | ETA 8
InPort_13902926_1 | SINK | EXHAUST | ETA 8
OutPort_13629310_1 | SOURCE | EXHAUST | ETA 8
InPort_13792986_4 | SINK | VENTILATION | ETA 8
OutPort_13629460_1 | SOURCE | VENTILATION | ETA 8
InPort_13792986_3 | SINK | VENTILATION | ETA 8
OutPort_13629484_1 | SOURCE | VENTILATION | ETA 8
InPort_13792986_2 | SINK | VENTILATION | ETA 8
OutPort_13629568_1 | SOURCE | VENTILATION | ETA 8
InPort_13629669_0 | SINK | EXHAUST | ETA 8
OutPort_13629667_1 | SOURCE | VENTILATION | ETA 8
InPort_13629832_1 | SINK | VENTILATION | ETA 18
OutPort_13629830_0 | SOURCE | VENTILATION | ETA 18
InPort_13629830_1 | SINK | VENTILATION | ETA 18
OutPort_13950844_1 | SOURCE | VENTILATION | ETA 18
Port_13629968_0 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13794995_1 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13629968_1 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13955582_2 | SOURCEANDSINK | VENTILATION | SUP 7
InPort_13629978_0 | SINK | VENTILATION | SUP 7
OutPort_13629980_1 | SOURCE | VENTILATION | SUP 7
InPort_13950316_1 | SINK | VENTILATION | SUP 7
OutPort_13629978_1 | SOURCE | VENTILATION | SUP 7
InPort_13631351_0 | SINK | EXHAUST | EHA 9
OutPort_13951647_1 | SOURCE | EXHAUST | EHA 9
InPort_13951851_2 | SINK | EXHAUST | EHA 9
OutPort_13631351_1 | SOURCE | EXHAUST | EHA 9
InPort_13810965_1 | SINK | VENTILATION | SUP 4
OutPort_13631603_0 | SOURCE | VENTILATION | SUP 4
InPort_13631603_1 | SINK | VENTILATION | SUP 4
OutPort_13631784_1 | SOURCE | VENTILATION | SUP 4
InPort_13631907_0 | SINK | VENTILATION | ODA 2
OutPort_13810664_1 | SOURCE | VENTILATION | ODA 2
InPort_13810479_2 | SINK | VENTILATION | ODA 2
OutPort_13631907_1 | SOURCE | VENTILATION | ODA 2
InPort_13810644_1 | SINK | EXHAUST | EHA 2
OutPort_13631998_0 | SOURCE | EXHAUST | EHA 2
InPort_13631998_1 | SINK | EXHAUST | EHA 2
OutPort_13810505_2 | SOURCE | EXHAUST | EHA 2
Port_13632980_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13968226_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13632980_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13850769_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13633170_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13640126_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13633170_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13797498_1 | SOURCEANDSINK | VENTILATION | ETA 1
InPort_13633170_3 | SINK | VENTILATION | ETA 1
OutPort_14138973_0 | SOURCE | VENTILATION | ETA 1
Port_13633538_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14081190_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13633538_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769616_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13633890_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13997247_3 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13633890_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14038190_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13634147_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13850051_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13634147_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13636245_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13634196_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13850037_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13634196_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13793967_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13634268_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13848948_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13634268_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13793894_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13634296_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13848914_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13634296_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13848486_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13634309_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13848916_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13634389_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13848825_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13634389_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13847737_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13634445_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13848764_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13634445_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14147992_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13634590_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14105796_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13634590_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13794186_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13635158_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13848766_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13635304_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13793962_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13635304_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13794143_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13849011_0 | SINK | VENTILATION | SUP 24
OutPort_13635395_1 | SOURCE | VENTILATION | SUP 24
Port_13635395_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13635433_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13635395_3 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13793893_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13635396_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13635433_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13635586_0 | SINK | VENTILATION | ODA 21
OutPort_13918531_1 | SOURCE | VENTILATION | ODA 21
InPort_13918509_2 | SINK | VENTILATION | ODA 21
OutPort_13635586_1 | SOURCE | VENTILATION | ODA 21
InPort_13918393_0 | SINK | VENTILATION | ODA 21
OutPort_13635586_2 | SOURCE | VENTILATION | ODA 21
InPort_14158267_1 | SINK | VENTILATION | ODA 12
OutPort_13635646_0 | SOURCE | VENTILATION | ODA 12
InPort_13635646_1 | SINK | VENTILATION | ODA 12
OutPort_14158271_2 | SOURCE | VENTILATION | ODA 12
InPort_13803540_2 | SINK | VENTILATION | ODA 25
OutPort_13635721_0 | SOURCE | VENTILATION | ODA 25
InPort_13635721_1 | SINK | VENTILATION | ODA 25
OutPort_14155816_1 | SOURCE | VENTILATION | ODA 25
InPort_14151945_0 | SINK | VENTILATION | ODA 25
OutPort_13635721_2 | SOURCE | VENTILATION | ODA 25
Port_13635760_0 | SOURCEANDSINK | VENTILATION | ODA 13
Port_13807359_2 | SOURCEANDSINK | VENTILATION | ODA 13
Port_13635760_1 | SOURCEANDSINK | VENTILATION | ODA 13
Port_13807542_1 | SOURCEANDSINK | VENTILATION | ODA 13
Port_13636089_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14124647_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13636089_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13636107_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13636103_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14124649_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13636234_3 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13636245_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13636300_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13636309_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13636308_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13636309_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13636308_3 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13848486_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13636392_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13848800_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13636392_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13848827_0 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13637849_0 | SINK | EXHAUST | EHA 1
OutPort_14188786_2 | SOURCE | EXHAUST | EHA 1
InPort_14188788_2 | SINK | EXHAUST | EHA 1
OutPort_13637849_1 | SOURCE | EXHAUST | EHA 1
InPort_14188786_1 | SINK | EXHAUST | EHA 1
OutPort_13638073_0 | SOURCE | EXHAUST | EHA 1
InPort_13638073_1 | SINK | EXHAUST | EHA 1
OutPort_13638087_2 | SOURCE | EXHAUST | EHA 1
InPort_13638087_1 | SINK | EXHAUST | EHA 1
OutPort_13809266_0 | SOURCE | EXHAUST | EHA 1
InPort_13638357_1 | SINK | EXHAUST | EHA 1
InPort_13638467_1 | SINK | EXHAUST | EHA 1
OutPort_13638357_2 | SOURCE | EXHAUST | EHA 1
InPort_13809264_2 | SINK | EXHAUST | EHA 1
OutPort_13638466_0 | SOURCE | EXHAUST | EHA 1
InPort_13638466_1 | SINK | EXHAUST | EHA 1
OutPort_13638468_1 | SOURCE | EXHAUST | EHA 1
InPort_13638468_2 | SINK | EXHAUST | EHA 1
OutPort_13638467_0 | SOURCE | EXHAUST | EHA 1
Port_13638499_0 | SOURCEANDSINK | EXHAUST | EHA 17
Port_13809870_1 | SOURCEANDSINK | EXHAUST | EHA 17
Port_13638499_1 | SOURCEANDSINK | EXHAUST | EHA 17
OutPort_13639242_0 | SOURCE | EXHAUST | EHA 11
InPort_13639242_1 | SINK | EXHAUST | EHA 11
OutPort_13787065_2 | SOURCE | EXHAUST | EHA 11
Port_13639700_0 | SOURCEANDSINK | EXHAUST | EHA 17
Port_13965751_1 | SOURCEANDSINK | EXHAUST | EHA 17
Port_13639700_1 | SOURCEANDSINK | EXHAUST | EHA 17
Port_13639771_1 | SOURCEANDSINK | EXHAUST | EHA 17
Port_13639771_2 | SOURCEANDSINK | EXHAUST | EHA 17
Port_13640119_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13957037_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13640119_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13640422_2 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13640126_2 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13641772_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13640150_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13957037_2 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13640150_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13850772_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13640410_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13641770_3 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13640410_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13640412_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13640411_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13640412_2 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13640411_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13640422_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13640455_0 | SOURCEANDSINK | VENTILATION | ETA 21
Port_13640555_2 | SOURCEANDSINK | VENTILATION | ETA 21
Port_13640455_1 | SOURCEANDSINK | VENTILATION | ETA 21
Port_13640586_1 | SOURCEANDSINK | VENTILATION | ETA 21
Port_13640555_1 | SOURCEANDSINK | VENTILATION | ETA 21
Port_13640586_2 | SOURCEANDSINK | VENTILATION | ETA 21
InPort_13854742_2 | SINK | VENTILATION | ODA 8
OutPort_13640876_0 | SOURCE | VENTILATION | ODA 8
InPort_13640876_1 | SINK | VENTILATION | ODA 8
OutPort_13641305_2 | SOURCE | VENTILATION | ODA 8
InPort_13640957_0 | SINK | VENTILATION | ODA 8
OutPort_13641284_1 | SOURCE | VENTILATION | ODA 8
InPort_13641285_2 | SINK | VENTILATION | ODA 8
OutPort_13640957_1 | SOURCE | VENTILATION | ODA 8
InPort_13641173_0 | SINK | VENTILATION | ODA 8
OutPort_13854331_2 | SOURCE | VENTILATION | ODA 8
InPort_13855999_2 | SINK | VENTILATION | ODA 8
OutPort_13641173_1 | SOURCE | VENTILATION | ODA 8
InPort_13854331_1 | SINK | VENTILATION | ODA 8
OutPort_13641274_0 | SOURCE | VENTILATION | ODA 8
InPort_13641274_1 | SINK | VENTILATION | ODA 8
OutPort_13641285_1 | SOURCE | VENTILATION | ODA 8
InPort_13641284_2 | SINK | VENTILATION | ODA 8
OutPort_13641976_0 | SOURCE | VENTILATION | ODA 8
InPort_13853630_2 | SINK | VENTILATION | ODA 8
OutPort_13641298_0 | SOURCE | VENTILATION | ODA 8
InPort_13641298_1 | SINK | VENTILATION | ODA 8
OutPort_13758660_1 | SOURCE | VENTILATION | ODA 8
InPort_13641305_1 | SINK | VENTILATION | ODA 8
OutPort_13853630_1 | SOURCE | VENTILATION | ODA 8
InPort_13951987_1 | SINK | VENTILATION | ODA 1
OutPort_13641510_0 | SOURCE | VENTILATION | ODA 1
InPort_13641510_1 | SINK | VENTILATION | ODA 1
OutPort_13951999_1 | SOURCE | VENTILATION | ODA 1
InPort_13641523_0 | SINK | VENTILATION | ODA 1
OutPort_13952256_2 | SOURCE | VENTILATION | ODA 1
InPort_13952422_1 | SINK | VENTILATION | ODA 1
OutPort_13641523_1 | SOURCE | VENTILATION | ODA 1
Port_13641770_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13788846_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13641772_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13788846_2 | SOURCEANDSINK | VENTILATION | ETA 1
InPort_13853631_1 | SINK | VENTILATION | ODA 8
OutPort_13641974_1 | SOURCE | VENTILATION | ODA 8
InPort_13641974_3 | SINK | VENTILATION | ODA 8
OutPort_13853632_1 | SOURCE | VENTILATION | ODA 8
InPort_13641976_1 | SINK | VENTILATION | ODA 8
OutPort_13853631_2 | SOURCE | VENTILATION | ODA 8
Port_13642097_0 | SOURCEANDSINK | EXHAUST | EHA 17
Port_13965826_3 | SOURCEANDSINK | EXHAUST | EHA 17
Port_13642097_1 | SOURCEANDSINK | EXHAUST | EHA 17
Port_13965751_2 | SOURCEANDSINK | EXHAUST | EHA 17
InPort_13846522_2 | SINK | VENTILATION | SUP 13
OutPort_13644997_0 | SOURCE | VENTILATION | SUP 13
InPort_13644997_1 | SINK | VENTILATION | SUP 13
OutPort_13846526_2 | SOURCE | VENTILATION | SUP 13
Port_13646879_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13702597_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13646879_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13702571_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13647672_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13911938_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13647672_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14005515_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13647690_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13650201_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13647690_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13647842_1 | SOURCEANDSINK | VENTILATION | ETA 17
InPort_13647690_2 | SINK | VENTILATION | ETA 17
OutPort_14116536_1 | SOURCE | VENTILATION | ETA 17
InPort_13650265_2 | SINK | VENTILATION | SUP 12
OutPort_13647789_0 | SOURCE | VENTILATION | SUP 12
InPort_13647789_1 | SINK | VENTILATION | SUP 12
OutPort_14116331_2 | SOURCE | VENTILATION | SUP 12
Port_13647835_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13648391_3 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13647835_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13648026_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13647842_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13648393_0 | SOURCEANDSINK | VENTILATION | ETA 17
InPort_13647943_0 | SINK | VENTILATION | SUP 12
InPort_13647955_1 | SINK | VENTILATION | SUP 12
OutPort_13647943_1 | SOURCE | VENTILATION | SUP 12
InPort_13647950_0 | SINK | VENTILATION | SUP 12
OutPort_13648890_3 | SOURCE | VENTILATION | SUP 12
InPort_13798277_1 | SINK | VENTILATION | SUP 12
OutPort_13647950_1 | SOURCE | VENTILATION | SUP 12
InPort_13648892_0 | SINK | VENTILATION | SUP 12
OutPort_13647955_2 | SOURCE | VENTILATION | SUP 12
InPort_13647991_0 | SINK | VENTILATION | SUP 12
OutPort_13648916_3 | SOURCE | VENTILATION | SUP 12
InPort_14116331_1 | SINK | VENTILATION | SUP 12
OutPort_13647991_1 | SOURCE | VENTILATION | SUP 12
Port_13648010_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13648813_3 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13648010_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13648026_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13648025_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13648025_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13648815_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13648391_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13648393_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13648813_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13648815_1 | SOURCEANDSINK | VENTILATION | ETA 17
InPort_13648890_1 | SINK | VENTILATION | SUP 12
OutPort_13648892_1 | SOURCE | VENTILATION | SUP 12
InPort_13648916_1 | SINK | VENTILATION | SUP 12
OutPort_13648918_1 | SOURCE | VENTILATION | SUP 12
InPort_13648918_0 | SINK | VENTILATION | SUP 12
OutPort_13798279_2 | SOURCE | VENTILATION | SUP 12
Port_13650201_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13650203_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13650203_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14006810_1 | SOURCEANDSINK | VENTILATION | ETA 17
InPort_13650267_1 | SINK | VENTILATION | SUP 12
OutPort_13650265_1 | SOURCE | VENTILATION | SUP 12
InPort_14006836_1 | SINK | VENTILATION | SUP 12
OutPort_13650267_0 | SOURCE | VENTILATION | SUP 12
InPort_13650410_0 | SINK | VENTILATION | ODA 17
OutPort_13697871_2 | SOURCE | VENTILATION | ODA 17
OutPort_13650410_1 | SOURCE | VENTILATION | ODA 17
InPort_13697872_1 | SINK | VENTILATION | ODA 17
OutPort_13650476_0 | SOURCE | VENTILATION | ODA 17
InPort_13650476_1 | SINK | VENTILATION | ODA 17
OutPort_13650490_1 | SOURCE | VENTILATION | ODA 17
InPort_13650779_3 | SINK | VENTILATION | ODA 17
OutPort_13650485_0 | SOURCE | VENTILATION | ODA 17
InPort_13650485_1 | SINK | VENTILATION | ODA 17
OutPort_13806182_2 | SOURCE | VENTILATION | ODA 17
InPort_13650490_2 | SINK | VENTILATION | ODA 17
OutPort_13650781_0 | SOURCE | VENTILATION | ODA 17
InPort_13697843_2 | SINK | EXHAUST | EHA 7
OutPort_13650522_0 | SOURCE | EXHAUST | EHA 7
InPort_13650522_1 | SINK | EXHAUST | EHA 7
InPort_13650540_0 | SINK | EXHAUST | EHA 7
OutPort_13650692_3 | SOURCE | EXHAUST | EHA 7
InPort_13650910_1 | SINK | EXHAUST | EHA 7
OutPort_13650540_1 | SOURCE | EXHAUST | EHA 7
InPort_13650692_1 | SINK | EXHAUST | EHA 7
OutPort_13650694_1 | SOURCE | EXHAUST | EHA 7
InPort_13650694_0 | SINK | EXHAUST | EHA 7
OutPort_13697844_1 | SOURCE | EXHAUST | EHA 7
InPort_13650781_1 | SINK | VENTILATION | ODA 17
OutPort_13650779_1 | SOURCE | VENTILATION | ODA 17
InPort_13650905_0 | SINK | EXHAUST | EHA 7
OutPort_13650910_2 | SOURCE | EXHAUST | EHA 7
InPort_13650977_2 | SINK | EXHAUST | EHA 7
OutPort_13650905_1 | SOURCE | EXHAUST | EHA 7
InPort_13650970_0 | SINK | EXHAUST | EHA 7
OutPort_13651152_2 | SOURCE | EXHAUST | EHA 7
InPort_14116058_1 | SINK | EXHAUST | EHA 7
OutPort_13650970_1 | SOURCE | EXHAUST | EHA 7
InPort_13651049_0 | SINK | EXHAUST | EHA 7
OutPort_13650977_1 | SOURCE | EXHAUST | EHA 7
InPort_13651047_1 | SINK | EXHAUST | EHA 7
OutPort_13651049_1 | SOURCE | EXHAUST | EHA 7
InPort_13651152_1 | SINK | EXHAUST | EHA 7
OutPort_13651047_3 | SOURCE | EXHAUST | EHA 7
InPort_13651162_0 | SINK | EXHAUST | EHA 7
OutPort_14115957_2 | SOURCE | EXHAUST | EHA 7
InPort_13919409_1 | SINK | EXHAUST | EHA 7
OutPort_13651162_1 | SOURCE | EXHAUST | EHA 7
InPort_13651195_0 | SINK | EXHAUST | EHA 7
OutPort_13919410_2 | SOURCE | EXHAUST | EHA 7
InPort_13919411_2 | SINK | EXHAUST | EHA 7
OutPort_13651195_1 | SOURCE | EXHAUST | EHA 7
Port_13651361_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13911996_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13651361_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13911979_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13651374_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13912084_1 | SOURCEANDSINK | VENTILATION | ETA 17
InPort_13651374_2 | SINK | VENTILATION | ETA 17
OutPort_13911942_1 | SOURCE | VENTILATION | ETA 17
Port_13651374_3 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13911998_0 | SOURCEANDSINK | VENTILATION | ETA 17
InPort_13651375_0 | SINK | VENTILATION | ETA 17
OutPort_13911687_2 | SOURCE | VENTILATION | ETA 17
InPort_13911942_2 | SINK | VENTILATION | ETA 17
OutPort_13651375_1 | SOURCE | VENTILATION | ETA 17
InPort_13908906_2 | SINK | VENTILATION | SUP 12
OutPort_13651528_0 | SOURCE | VENTILATION | SUP 12
InPort_13651528_1 | SINK | VENTILATION | SUP 12
OutPort_13651802_3 | SOURCE | VENTILATION | SUP 12
InPort_13806182_1 | SINK | VENTILATION | ODA 17
OutPort_13651746_0 | SOURCE | VENTILATION | ODA 17
InPort_13651746_1 | SINK | VENTILATION | ODA 17
OutPort_13806198_1 | SOURCE | VENTILATION | ODA 17
InPort_13911795_1 | SINK | VENTILATION | SUP 12
OutPort_13651802_1 | SOURCE | VENTILATION | SUP 12
InPort_13651802_2 | SINK | VENTILATION | SUP 12
OutPort_13911856_0 | SOURCE | VENTILATION | SUP 12
InPort_13911854_1 | SINK | VENTILATION | SUP 12
OutPort_13651810_0 | SOURCE | VENTILATION | SUP 12
InPort_13651810_1 | SINK | VENTILATION | SUP 12
OutPort_13911838_2 | SOURCE | VENTILATION | SUP 12
InPort_13651920_0 | SINK | EXHAUST | EHA 7
OutPort_14116147_1 | SOURCE | EXHAUST | EHA 7
InPort_14116060_2 | SINK | EXHAUST | EHA 7
OutPort_13651920_1 | SOURCE | EXHAUST | EHA 7
InPort_14010766_0 | SINK | VENTILATION | SUP 11
OutPort_13689832_1 | SOURCE | VENTILATION | SUP 11
InPort_13689832_2 | SINK | VENTILATION
InPort_13689832_3 | SINK | VENTILATION | ETA 11
OutPort_14010667_0 | SOURCE | VENTILATION | ETA 11
OutPort_13689832_4 | SOURCE | EXHAUST
InPort_14148090_1 | SINK | VENTILATION | SUP 9
OutPort_13695937_1 | SOURCE | VENTILATION | SUP 9
InPort_13695937_2 | SINK | VENTILATION
InPort_13695937_3 | SINK | VENTILATION | ETA 14
OutPort_14078018_1 | SOURCE | VENTILATION | ETA 14
OutPort_13695937_4 | SOURCE | EXHAUST
InPort_13696824_0 | SINK | VENTILATION | ODA 6
OutPort_13746983_2 | SOURCE | VENTILATION | ODA 6
InPort_13746986_2 | SINK | VENTILATION | ODA 6
OutPort_13696824_1 | SOURCE | VENTILATION | ODA 6
InPort_13697215_1 | SINK | VENTILATION | ETA 11
OutPort_14030524_0 | SOURCE | VENTILATION | ETA 11
InPort_13697380_0 | SINK | VENTILATION | SUP 11
OutPort_13697537_3 | SOURCE | VENTILATION | SUP 11
InPort_14032671_3 | SINK | VENTILATION | SUP 11
OutPort_13697380_1 | SOURCE | VENTILATION | SUP 11
InPort_13697537_1 | SINK | VENTILATION | SUP 11
OutPort_13697539_0 | SOURCE | VENTILATION | SUP 11
InPort_13697539_1 | SINK | VENTILATION | SUP 11
OutPort_14013227_2 | SOURCE | VENTILATION | SUP 11
OutPort_13697620_1 | SOURCE | VENTILATION
InPort_13697620_2 | SINK | VENTILATION
InPort_13697620_3 | SINK | VENTILATION
OutPort_13697620_4 | SOURCE | EXHAUST
InPort_13697844_2 | SINK | EXHAUST | EHA 7
OutPort_13697843_1 | SOURCE | EXHAUST | EHA 7
InPort_13697871_1 | SINK | VENTILATION | ODA 17
OutPort_13697872_2 | SOURCE | VENTILATION | ODA 17
Port_13702456_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13702597_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13702456_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13702823_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13702563_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13702571_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13702563_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13702580_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13702574_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13702580_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13702574_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13702574_2 | SINK | VENTILATION | ETA 7
OutPort_13913438_1 | SOURCE | VENTILATION | ETA 7
InPort_13702574_3 | SINK | VENTILATION | ETA 7
OutPort_13913462_1 | SOURCE | VENTILATION | ETA 7
Port_13702597_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13702605_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13702605_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13702605_2 | SINK | VENTILATION | ETA 7
OutPort_13913490_1 | SOURCE | VENTILATION | ETA 7
InPort_13702823_2 | SINK | VENTILATION | ETA 7
OutPort_13702824_1 | SOURCE | VENTILATION | ETA 7
InPort_13702824_0 | SINK | VENTILATION | ETA 7
OutPort_14171801_1 | SOURCE | VENTILATION | ETA 7
InPort_13766964_2 | SINK | VENTILATION | ETA 7
OutPort_13705864_0 | SOURCE | VENTILATION | ETA 7
InPort_13705864_1 | SINK | VENTILATION | ETA 7
OutPort_13766916_1 | SOURCE | VENTILATION | ETA 7
Port_13706018_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868421_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13706098_2 | SOURCEANDSINK | VENTILATION | SUP 21
Port_13868529_0 | SOURCEANDSINK | VENTILATION | SUP 21
Port_13706535_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13900082_2 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13791701_2 | SINK | VENTILATION | ETA 7
OutPort_13706535_1 | SOURCE | VENTILATION | ETA 7
InPort_13706535_2 | SINK | VENTILATION | ETA 7
OutPort_13901084_0 | SOURCE | VENTILATION | ETA 7
InPort_13706605_0 | SINK | VENTILATION | ETA 7
OutPort_13791701_1 | SOURCE | VENTILATION | ETA 7
InPort_13706621_1 | SINK | VENTILATION | ETA 7
OutPort_13706605_1 | SOURCE | VENTILATION | ETA 7
InPort_13810297_0 | SINK | VENTILATION | ETA 7
OutPort_13706621_2 | SOURCE | VENTILATION | ETA 7
Port_13707284_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13809352_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13707284_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13805163_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13707529_1 | SINK | VENTILATION | SUP 24
OutPort_13875844_0 | SOURCE | VENTILATION | SUP 24
InPort_13875505_1 | SINK | VENTILATION | SUP 24
OutPort_13707529_2 | SOURCE | VENTILATION | SUP 24
Port_13707770_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14147777_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13707770_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14147727_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13707787_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13707788_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13875484_1 | SINK | VENTILATION | SUP 24
OutPort_13707787_2 | SOURCE | VENTILATION | SUP 24
Port_13707787_3 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13849903_0 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13707944_1 | SINK | VENTILATION | SUP 24
OutPort_13875796_0 | SOURCE | VENTILATION | SUP 24
InPort_13875400_0 | SINK | VENTILATION | SUP 24
OutPort_13707944_2 | SOURCE | VENTILATION | SUP 24
Port_13708172_1 | SOURCEANDSINK | VENTILATION | SUP 22
Port_13875623_0 | SOURCEANDSINK | VENTILATION | SUP 22
Port_13708371_0 | SOURCEANDSINK | VENTILATION | SUP 50
Port_13876227_1 | SOURCEANDSINK | VENTILATION | SUP 50
Port_13708371_1 | SOURCEANDSINK | VENTILATION | SUP 50
Port_13713939_2 | SOURCEANDSINK | VENTILATION | SUP 50
Port_13708506_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13708514_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13708514_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14195706_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13709186_0 | SINK | VENTILATION | ETA 3
OutPort_14040833_1 | SOURCE | VENTILATION | ETA 3
InPort_13745587_2 | SINK | VENTILATION | ETA 3
OutPort_13709186_1 | SOURCE | VENTILATION | ETA 3
InPort_13709197_1 | SINK | VENTILATION | ETA 3
OutPort_14041517_0 | SOURCE | VENTILATION | ETA 3
InPort_13745242_1 | SINK | VENTILATION | ETA 3
OutPort_13709197_2 | SOURCE | VENTILATION | ETA 3
InPort_14150119_2 | SINK | VENTILATION | ETA 3
OutPort_13709198_0 | SOURCE | VENTILATION | ETA 3
InPort_13709198_1 | SINK | VENTILATION | ETA 3
OutPort_13745587_1 | SOURCE | VENTILATION | ETA 3
InPort_13710611_2 | SINK | VENTILATION | ETA 3
OutPort_13710069_0 | SOURCE | VENTILATION | ETA 3
InPort_13710069_1 | SINK | VENTILATION | ETA 3
OutPort_13743397_1 | SOURCE | VENTILATION | ETA 3
InPort_13710069_2 | SINK | VENTILATION | ETA 3
OutPort_13978671_0 | SOURCE | VENTILATION | ETA 3
InPort_13744705_1 | SINK | VENTILATION | ETA 3
OutPort_13710298_0 | SOURCE | VENTILATION | ETA 3
InPort_13710298_1 | SINK | VENTILATION | ETA 3
OutPort_13710611_1 | SOURCE | VENTILATION | ETA 3
InPort_14149953_1 | SINK | VENTILATION | ETA 3
OutPort_13710946_0 | SOURCE | VENTILATION | ETA 3
InPort_13710946_1 | SINK | VENTILATION | ETA 3
OutPort_13743893_1 | SOURCE | VENTILATION | ETA 3
InPort_14149874_2 | SINK | VENTILATION | ETA 3
OutPort_13711168_0 | SOURCE | VENTILATION | ETA 3
InPort_13711168_1 | SINK | VENTILATION | ETA 3
OutPort_13712068_1 | SOURCE | VENTILATION | ETA 3
InPort_13711722_3 | SINK | VENTILATION | ETA 27
OutPort_13711714_0 | SOURCE | VENTILATION | ETA 27
InPort_13711714_1 | SINK | VENTILATION | ETA 27
OutPort_13711737_1 | SOURCE | VENTILATION | ETA 27
InPort_13943500_0 | SINK | VENTILATION | ETA 27
OutPort_13711722_1 | SOURCE | VENTILATION | ETA 27
InPort_13967122_2 | SINK | VENTILATION | ETA 27
OutPort_13711723_0 | SOURCE | VENTILATION | ETA 27
InPort_13711723_1 | SINK | VENTILATION | ETA 27
OutPort_14189404_1 | SOURCE | VENTILATION | ETA 27
InPort_13711737_2 | SINK | VENTILATION | ETA 27
OutPort_14136703_0 | SOURCE | VENTILATION | ETA 27
InPort_13796966_1 | SINK | EXHAUST | EHA 12
OutPort_13711821_0 | SOURCE | EXHAUST | EHA 12
InPort_13711821_1 | SINK | EXHAUST | EHA 12
OutPort_14029902_2 | SOURCE | EXHAUST | EHA 12
Port_13712369_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13792182_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13712369_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13792184_2 | SOURCEANDSINK | VENTILATION | ETA 7
OutPort_13712413_1 | SOURCE | VENTILATION | ETA 7
InPort_13712463_0 | SINK | VENTILATION | ETA 7
OutPort_13712464_1 | SOURCE | VENTILATION | ETA 7
InPort_13792035_1 | SINK | VENTILATION | ETA 7
OutPort_13712463_1 | SOURCE | VENTILATION | ETA 7
Port_13712965_2 | SOURCEANDSINK | VENTILATION | SUP 57
Port_13877893_0 | SOURCEANDSINK | VENTILATION | SUP 57
Port_13713072_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877721_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13713074_2 | SOURCEANDSINK | VENTILATION | SUP 59
Port_13877921_0 | SOURCEANDSINK | VENTILATION | SUP 59
InPort_13713259_2 | SINK | VENTILATION | SUP 24
OutPort_13713179_1 | SOURCE | VENTILATION | SUP 24
Port_13713179_3 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13850039_0 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13877783_1 | SINK | VENTILATION | SUP 24
OutPort_13713209_0 | SOURCE | VENTILATION | SUP 24
InPort_13713209_1 | SINK | VENTILATION | SUP 24
OutPort_13713259_1 | SOURCE | VENTILATION | SUP 24
InPort_13877944_0 | SINK | VENTILATION | SUP 24
OutPort_13713257_1 | SOURCE | VENTILATION | SUP 24
InPort_13713257_2 | SINK | VENTILATION | SUP 24
OutPort_13877785_0 | SOURCE | VENTILATION | SUP 24
InPort_13878151_1 | SINK | VENTILATION | SUP 13
OutPort_13713516_0 | SOURCE | VENTILATION | SUP 13
InPort_13713516_1 | SINK | VENTILATION | SUP 13
OutPort_13713541_2 | SOURCE | VENTILATION | SUP 13
InPort_13878279_0 | SINK | VENTILATION | SUP 13
OutPort_13713526_1 | SOURCE | VENTILATION | SUP 13
InPort_13713526_2 | SINK | VENTILATION | SUP 13
OutPort_13878159_0 | SOURCE | VENTILATION | SUP 13
InPort_13713541_1 | SINK | VENTILATION | SUP 13
OutPort_13713529_1 | SOURCE | VENTILATION | SUP 13
InPort_13878389_2 | SINK | VENTILATION | SUP 13
OutPort_13713635_0 | SOURCE | VENTILATION | SUP 13
InPort_13713635_1 | SINK | VENTILATION | SUP 13
OutPort_13713662_1 | SOURCE | VENTILATION | SUP 13
InPort_13713641_1 | SINK | VENTILATION | SUP 13
OutPort_13878211_0 | SOURCE | VENTILATION | SUP 13
InPort_13878431_1 | SINK | VENTILATION | SUP 13
OutPort_13713641_2 | SOURCE | VENTILATION | SUP 13
InPort_13713644_0 | SINK | VENTILATION | SUP 13
OutPort_13713656_3 | SOURCE | VENTILATION | SUP 13
InPort_13713662_2 | SINK | VENTILATION | SUP 13
OutPort_13713644_1 | SOURCE | VENTILATION | SUP 13
Port_13713656_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14147413_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13713656_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13713963_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13713657_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14147413_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13713939_1 | SOURCEANDSINK | VENTILATION | SUP 50
Port_13875085_0 | SOURCEANDSINK | VENTILATION | SUP 50
Port_13713955_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14179203_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13713963_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_14196687_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13714025_0 | SOURCEANDSINK | VENTILATION | SUP 48
Port_13876235_1 | SOURCEANDSINK | VENTILATION | SUP 48
Port_13714025_1 | SOURCEANDSINK | VENTILATION | SUP 48
Port_13714042_1 | SOURCEANDSINK | VENTILATION | SUP 48
Port_13714031_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13876166_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13714034_0 | SOURCEANDSINK | VENTILATION | SUP 48
Port_13875266_1 | SOURCEANDSINK | VENTILATION | SUP 48
Port_13714034_1 | SOURCEANDSINK | VENTILATION | SUP 48
InPort_13969570_1 | SINK | VENTILATION | SUP 48
OutPort_13714034_2 | SOURCE | VENTILATION | SUP 48
InPort_13969598_1 | SINK | VENTILATION | SUP 48
OutPort_13714034_3 | SOURCE | VENTILATION | SUP 48
InPort_13969622_1 | SINK | VENTILATION | SUP 48
OutPort_13714034_4 | SOURCE | VENTILATION | SUP 48
Port_13714042_2 | SOURCEANDSINK | VENTILATION | SUP 48
Port_13875284_0 | SOURCEANDSINK | VENTILATION | SUP 48
InPort_13848860_1 | SINK | VENTILATION | SUP 24
OutPort_13714171_0 | SOURCE | VENTILATION | SUP 24
InPort_13714171_1 | SINK | VENTILATION | SUP 24
OutPort_14124017_1 | SOURCE | VENTILATION | SUP 24
InPort_13714189_1 | SINK | VENTILATION | SUP 24
OutPort_13714188_1 | SOURCE | VENTILATION | SUP 24
InPort_13884374_1 | SINK | VENTILATION | SUP 24
OutPort_13714188_2 | SOURCE | VENTILATION | SUP 24
InPort_13714188_3 | SINK | VENTILATION | SUP 24
OutPort_13848862_0 | SOURCE | VENTILATION | SUP 24
InPort_13714618_1 | SINK | VENTILATION | SUP 18
OutPort_13714619_1 | SOURCE | VENTILATION | SUP 18
InPort_13866987_1 | SINK | VENTILATION | SUP 18
OutPort_13714618_2 | SOURCE | VENTILATION | SUP 18
InPort_13882279_0 | SINK | VENTILATION | SUP 18
OutPort_13714618_3 | SOURCE | VENTILATION | SUP 18
InPort_13714619_0 | SINK | VENTILATION | SUP 18
OutPort_13879616_2 | SOURCE | VENTILATION | SUP 18
InPort_13847807_1 | SINK | VENTILATION | SUP 18
OutPort_13714714_0 | SOURCE | VENTILATION | SUP 18
InPort_13714714_1 | SINK | VENTILATION | SUP 18
InPort_13714819_1 | SINK | VENTILATION | SUP 24
OutPort_13714846_0 | SOURCE | VENTILATION | SUP 24
InPort_13714820_1 | SINK | VENTILATION | SUP 24
OutPort_13714819_2 | SOURCE | VENTILATION | SUP 24
InPort_13868092_0 | SINK | VENTILATION | SUP 24
OutPort_13714819_3 | SOURCE | VENTILATION | SUP 24
InPort_13868046_1 | SINK | VENTILATION | SUP 24
OutPort_13714820_0 | SOURCE | VENTILATION | SUP 24
InPort_13848715_1 | SINK | VENTILATION | SUP 24
OutPort_13714835_0 | SOURCE | VENTILATION | SUP 24
InPort_13714835_1 | SINK | VENTILATION | SUP 24
OutPort_14123975_1 | SOURCE | VENTILATION | SUP 24
InPort_13714846_1 | SINK | VENTILATION | SUP 24
OutPort_13714845_1 | SOURCE | VENTILATION | SUP 24
InPort_13714845_3 | SINK | VENTILATION | SUP 24
OutPort_13848717_0 | SOURCE | VENTILATION | SUP 24
InPort_13871010_0 | SINK | VENTILATION | SUP 13
OutPort_13715136_1 | SOURCE | VENTILATION | SUP 13
InPort_13715136_2 | SINK | VENTILATION | SUP 13
OutPort_13871207_0 | SOURCE | VENTILATION | SUP 13
InPort_14036733_1 | SINK | VENTILATION | SUP 9
OutPort_13717385_0 | SOURCE | VENTILATION | SUP 9
InPort_13717385_1 | SINK | VENTILATION | SUP 9
OutPort_13717452_1 | SOURCE | VENTILATION | SUP 9
Port_13717403_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717572_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717403_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717444_3 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717444_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717445_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717445_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13915916_1 | SINK | VENTILATION | SUP 9
OutPort_13717445_2 | SOURCE | VENTILATION | SUP 9
InPort_13915936_1 | SINK | VENTILATION | SUP 9
OutPort_13717445_3 | SOURCE | VENTILATION | SUP 9
InPort_13717452_2 | SINK | VENTILATION | SUP 9
OutPort_13717463_0 | SOURCE | VENTILATION | SUP 9
InPort_13717463_1 | SINK | VENTILATION | SUP 9
OutPort_13717467_2 | SOURCE | VENTILATION | SUP 9
Port_13717465_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717467_4 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717465_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13915655_1 | SINK | VENTILATION | SUP 9
OutPort_13717465_3 | SOURCE | VENTILATION | SUP 9
InPort_13916113_1 | SINK | VENTILATION | SUP 9
OutPort_13717465_4 | SOURCE | VENTILATION | SUP 9
Port_13717467_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717562_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717467_3 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717471_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717473_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717562_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717473_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717564_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717475_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717477_4 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717475_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13915814_1 | SINK | VENTILATION | SUP 9
OutPort_13717475_2 | SOURCE | VENTILATION | SUP 9
InPort_13916039_1 | SINK | VENTILATION | SUP 9
OutPort_13717475_3 | SOURCE | VENTILATION | SUP 9
Port_13717477_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717572_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717477_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13717564_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13718730_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13718777_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13718730_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14154909_3 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13718777_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13718778_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13718777_3 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13718852_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13718778_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13820356_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13718852_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13718901_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13718965_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13818065_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13718965_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14057421_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13742229_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13742239_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13742229_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14123795_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13742632_1 | SOURCEANDSINK | VENTILATION | SUP 5
Port_14006291_0 | SOURCEANDSINK | VENTILATION | SUP 5
Port_13742632_2 | SOURCEANDSINK | VENTILATION | SUP 5
Port_13960179_0 | SOURCEANDSINK | VENTILATION | SUP 5
InPort_13960151_1 | SINK | VENTILATION | SUP 5
OutPort_13742634_0 | SOURCE | VENTILATION | SUP 5
InPort_13742634_1 | SINK | VENTILATION | SUP 5
InPort_13744806_2 | SINK | VENTILATION | ETA 3
OutPort_13744523_0 | SOURCE | VENTILATION | ETA 3
InPort_13744523_1 | SINK | VENTILATION | ETA 3
OutPort_14150045_1 | SOURCE | VENTILATION | ETA 3
InPort_13744807_0 | SINK | VENTILATION | ETA 3
OutPort_13744705_2 | SOURCE | VENTILATION | ETA 3
InPort_14055982_2 | SINK | VENTILATION | ETA 3
OutPort_13744744_0 | SOURCE | VENTILATION | ETA 3
InPort_13744744_1 | SINK | VENTILATION | ETA 3
OutPort_13744806_3 | SOURCE | VENTILATION | ETA 3
InPort_14055983_0 | SINK | VENTILATION | ETA 3
OutPort_13744745_1 | SOURCE | VENTILATION | ETA 3
InPort_13744806_1 | SINK | VENTILATION | ETA 3
OutPort_13744807_1 | SOURCE | VENTILATION | ETA 3
InPort_14040834_0 | SINK | VENTILATION | ETA 3
OutPort_13745242_2 | SOURCE | VENTILATION | ETA 3
InPort_13745466_0 | SINK | VENTILATION | ETA 3
OutPort_14149953_2 | SOURCE | VENTILATION | ETA 3
InPort_14150045_2 | SINK | VENTILATION | ETA 3
OutPort_13745466_1 | SOURCE | VENTILATION | ETA 3
InPort_13745466_2 | SINK | VENTILATION | ETA 3
OutPort_14149805_0 | SOURCE | VENTILATION | ETA 3
Port_13745943_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13847383_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13745943_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746798_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746287_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746317_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746287_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746804_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746317_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746342_0 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13746317_3 | SINK | VENTILATION | SUP 13
OutPort_13825193_1 | SOURCE | VENTILATION | SUP 13
Port_13746342_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746714_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746580_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13850053_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746587_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746629_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746587_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746710_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746701_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746710_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746701_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746714_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746755_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746798_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746755_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746802_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746802_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746804_1 | SOURCEANDSINK | VENTILATION | SUP 13
OutPort_13746986_1 | SOURCE | VENTILATION | ODA 6
InPort_13757108_2 | SINK | VENTILATION | ODA 6
OutPort_13747010_1 | SOURCE | VENTILATION | ODA 6
InPort_13747010_3 | SINK | VENTILATION | ODA 6
OutPort_14145808_1 | SOURCE | VENTILATION | ODA 6
InPort_13747012_1 | SINK | VENTILATION | ODA 6
OutPort_13757108_1 | SOURCE | VENTILATION | ODA 6
Port_13747846_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13747875_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13747846_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13747846_2 | SINK | VENTILATION | ETA 7
OutPort_13869828_1 | SOURCE | VENTILATION | ETA 7
Port_13747875_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13747885_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13747885_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13747912_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13747893_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13747912_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13747893_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13747921_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13747915_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13747921_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13747915_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13747915_2 | SINK | VENTILATION | ETA 7
OutPort_13869772_1 | SOURCE | VENTILATION | ETA 7
InPort_13747915_3 | SINK | VENTILATION | ETA 7
OutPort_13869800_1 | SOURCE | VENTILATION | ETA 7
Port_13747948_0 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13747974_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13747948_1 | SOURCEANDSINK | VENTILATION | ETA 34
InPort_13747948_2 | SINK | VENTILATION | ETA 34
OutPort_13869895_1 | SOURCE | VENTILATION | ETA 34
Port_13747974_2 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748005_0 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748005_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748023_2 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748015_0 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748023_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748015_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748032_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748026_0 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748032_2 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748026_1 | SOURCEANDSINK | VENTILATION | ETA 34
InPort_13748026_2 | SINK | VENTILATION | ETA 34
OutPort_13869919_1 | SOURCE | VENTILATION | ETA 34
InPort_13748026_3 | SINK | VENTILATION | ETA 34
OutPort_13869943_1 | SOURCE | VENTILATION | ETA 34
Port_13748110_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13748163_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13748110_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13748127_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13748119_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13748127_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13748119_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13748136_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13748130_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13748136_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13748130_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13748130_2 | SINK | VENTILATION | ETA 7
OutPort_13872761_1 | SOURCE | VENTILATION | ETA 7
InPort_13748130_3 | SINK | VENTILATION | ETA 7
OutPort_13872781_1 | SOURCE | VENTILATION | ETA 7
Port_13748163_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13748171_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13748171_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13748171_2 | SINK | VENTILATION | ETA 7
OutPort_13872737_1 | SOURCE | VENTILATION | ETA 7
Port_13748211_0 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748236_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748211_1 | SOURCEANDSINK | VENTILATION | ETA 34
InPort_13748211_2 | SINK | VENTILATION | ETA 34
OutPort_13872664_1 | SOURCE | VENTILATION | ETA 34
Port_13748236_2 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748246_0 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748246_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748264_2 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748256_0 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748264_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748256_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748273_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748267_0 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748273_2 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748267_1 | SOURCEANDSINK | VENTILATION | ETA 34
InPort_13748267_2 | SINK | VENTILATION | ETA 34
OutPort_13872493_1 | SOURCE | VENTILATION | ETA 34
InPort_13748267_3 | SINK | VENTILATION | ETA 34
OutPort_13872571_1 | SOURCE | VENTILATION | ETA 34
InPort_13823015_1 | SINK | EXHAUST | EHA 8
OutPort_13759152_2 | SOURCE | EXHAUST | EHA 8
InPort_13765295_0 | SINK | EXHAUST | EHA 2
OutPort_13810503_2 | SOURCE | EXHAUST | EHA 2
InPort_13795256_1 | SINK | EXHAUST | EHA 2
OutPort_13765295_1 | SOURCE | EXHAUST | EHA 2
InPort_13765445_2 | SINK | VENTILATION | ODA 2
OutPort_13765427_0 | SOURCE | VENTILATION | ODA 2
InPort_13765427_1 | SINK | VENTILATION | ODA 2
OutPort_13765488_1 | SOURCE | VENTILATION | ODA 2
InPort_13810475_1 | SINK | VENTILATION | ODA 2
OutPort_13765438_0 | SOURCE | VENTILATION | ODA 2
InPort_13765438_1 | SINK | VENTILATION | ODA 2
OutPort_13765445_1 | SOURCE | VENTILATION | ODA 2
InPort_13765492_2 | SINK | VENTILATION | ODA 2
OutPort_13765451_0 | SOURCE | VENTILATION | ODA 2
InPort_13765451_1 | SINK | VENTILATION | ODA 2
OutPort_13794617_1 | SOURCE | VENTILATION | ODA 2
InPort_13765488_2 | SINK | VENTILATION | ODA 2
OutPort_13765486_0 | SOURCE | VENTILATION | ODA 2
InPort_13765486_1 | SINK | VENTILATION | ODA 2
OutPort_13765492_1 | SOURCE | VENTILATION | ODA 2
Port_13765731_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13765763_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13765731_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13765731_2 | SINK | VENTILATION | ETA 7
OutPort_13909703_1 | SOURCE | VENTILATION | ETA 7
Port_13765763_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13765773_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13765773_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13765791_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13765783_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13765791_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13765783_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13765800_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13765794_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13765800_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13765794_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13765794_2 | SINK | VENTILATION | ETA 7
OutPort_13909834_1 | SOURCE | VENTILATION | ETA 7
InPort_13765794_3 | SINK | VENTILATION | ETA 7
OutPort_13909891_1 | SOURCE | VENTILATION | ETA 7
InPort_13952256_1 | SINK | VENTILATION | ODA 1
OutPort_13765921_0 | SOURCE | VENTILATION | ODA 1
InPort_13765921_1 | SINK | VENTILATION | ODA 1
OutPort_13765966_0 | SOURCE | VENTILATION | ODA 1
InPort_13765966_1 | SINK | VENTILATION | ODA 1
OutPort_13766018_1 | SOURCE | VENTILATION | ODA 1
InPort_13766007_0 | SINK | VENTILATION | ODA 1
OutPort_13952289_1 | SOURCE | VENTILATION | ODA 1
InPort_13952291_1 | SINK | VENTILATION | ODA 1
OutPort_13766007_1 | SOURCE | VENTILATION | ODA 1
InPort_13766018_2 | SINK | VENTILATION | ODA 1
OutPort_13766016_0 | SOURCE | VENTILATION | ODA 1
InPort_13766016_1 | SINK | VENTILATION | ODA 1
OutPort_13952291_2 | SOURCE | VENTILATION | ODA 1
Port_13766152_0 | SOURCEANDSINK | VENTILATION | ETA 18
Port_14110484_1 | SOURCEANDSINK | VENTILATION | ETA 18
Port_13766152_1 | SOURCEANDSINK | VENTILATION | ETA 18
Port_14110455_1 | SOURCEANDSINK | VENTILATION | ETA 18
InPort_13766152_4 | SINK | VENTILATION | ETA 18
OutPort_13924344_1 | SOURCE | VENTILATION | ETA 18
InPort_13766152_5 | SINK | VENTILATION | ETA 18
OutPort_13947019_1 | SOURCE | VENTILATION | ETA 18
InPort_13917765_2 | SINK | VENTILATION | ETA 7
OutPort_13766745_0 | SOURCE | VENTILATION | ETA 7
InPort_13766745_1 | SINK | VENTILATION | ETA 7
OutPort_14129238_2 | SOURCE | VENTILATION | ETA 7
InPort_13766946_1 | SINK | VENTILATION | ETA 7
OutPort_13766759_1 | SOURCE | VENTILATION | ETA 7
InPort_13766759_2 | SINK | VENTILATION | ETA 7
OutPort_13766760_1 | SOURCE | VENTILATION | ETA 7
InPort_13766759_3 | SINK | VENTILATION | ETA 7
OutPort_13917767_0 | SOURCE | VENTILATION | ETA 7
InPort_13766760_0 | SINK | VENTILATION | ETA 7
OutPort_13766828_1 | SOURCE | VENTILATION | ETA 7
InPort_13917533_2 | SINK | VENTILATION | ETA 7
OutPort_13766818_0 | SOURCE | VENTILATION | ETA 7
InPort_13766818_1 | SINK | VENTILATION | ETA 7
OutPort_14129239_2 | SOURCE | VENTILATION | ETA 7
InPort_13766828_2 | SINK | VENTILATION | ETA 7
OutPort_13766829_0 | SOURCE | VENTILATION | ETA 7
InPort_13766828_3 | SINK | VENTILATION | ETA 7
OutPort_13917535_0 | SOURCE | VENTILATION | ETA 7
InPort_13766829_1 | SINK | VENTILATION | ETA 7
OutPort_13767568_1 | SOURCE | VENTILATION | ETA 7
InPort_13917899_2 | SINK | VENTILATION | ETA 7
OutPort_13766852_0 | SOURCE | VENTILATION | ETA 7
InPort_13766852_1 | SINK | VENTILATION | ETA 7
OutPort_14129237_2 | SOURCE | VENTILATION | ETA 7
InPort_13766859_1 | SINK | VENTILATION | ETA 7
OutPort_13766964_1 | SOURCE | VENTILATION | ETA 7
InPort_13766859_2 | SINK | VENTILATION | ETA 7
OutPort_13766860_1 | SOURCE | VENTILATION | ETA 7
InPort_13766859_3 | SINK | VENTILATION | ETA 7
OutPort_13917901_0 | SOURCE | VENTILATION | ETA 7
InPort_13766860_0 | SINK | VENTILATION | ETA 7
OutPort_13766946_2 | SOURCE | VENTILATION | ETA 7
InPort_13917948_2 | SINK | VENTILATION | ETA 7
OutPort_13766901_0 | SOURCE | VENTILATION | ETA 7
InPort_13766901_1 | SINK | VENTILATION | ETA 7
OutPort_14129236_2 | SOURCE | VENTILATION | ETA 7
InPort_13766916_2 | SINK | VENTILATION | ETA 7
OutPort_13917950_0 | SOURCE | VENTILATION | ETA 7
InPort_13959961_2 | SINK | VENTILATION | ETA 7
OutPort_13767014_0 | SOURCE | VENTILATION | ETA 7
InPort_13767014_1 | SINK | VENTILATION | ETA 7
OutPort_13767598_1 | SOURCE | VENTILATION | ETA 7
InPort_13767568_2 | SINK | VENTILATION | ETA 7
OutPort_13767569_1 | SOURCE | VENTILATION | ETA 7
InPort_13767569_2 | SINK | VENTILATION | ETA 7
OutPort_13959963_0 | SOURCE | VENTILATION | ETA 7
InPort_13767598_2 | SINK | VENTILATION | ETA 7
OutPort_13767591_0 | SOURCE | VENTILATION | ETA 7
InPort_13767591_1 | SINK | VENTILATION | ETA 7
OutPort_13768029_1 | SOURCE | VENTILATION | ETA 7
InPort_13768029_2 | SINK | VENTILATION | ETA 7
OutPort_13768028_0 | SOURCE | VENTILATION | ETA 7
InPort_13768028_1 | SINK | VENTILATION | ETA 7
OutPort_13805219_1 | SOURCE | VENTILATION | ETA 7
Port_13768261_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14110069_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13768261_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14109688_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13768876_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13768877_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13768876_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14109452_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13818255_0 | SINK | VENTILATION | ETA 7
OutPort_13768876_3 | SOURCE | VENTILATION | ETA 7
Port_13768877_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13810018_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769061_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769078_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769061_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13769061_2 | SINK | VENTILATION | ETA 7
OutPort_13873931_1 | SOURCE | VENTILATION | ETA 7
InPort_13769061_4 | SINK | VENTILATION | ETA 7
OutPort_13874039_1 | SOURCE | VENTILATION | ETA 7
Port_13769070_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769078_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769070_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769087_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769081_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769087_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769081_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769141_2 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13769081_2 | SINK | VENTILATION | ETA 7
OutPort_13873856_1 | SOURCE | VENTILATION | ETA 7
Port_13769090_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769141_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769090_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769305_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769141_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769149_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769149_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769169_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13769149_2 | SINK | VENTILATION | ETA 7
OutPort_13873814_1 | SOURCE | VENTILATION | ETA 7
Port_13769161_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769169_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769161_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13769161_2 | SINK | VENTILATION | ETA 7
OutPort_13873758_1 | SOURCE | VENTILATION | ETA 7
Port_13769305_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769306_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769354_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769356_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769354_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769400_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769356_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13895906_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769356_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13895934_0 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13769400_2 | SINK | VENTILATION | ETA 7
OutPort_13769401_1 | SOURCE | VENTILATION | ETA 7
InPort_13769401_0 | SINK | VENTILATION | ETA 7
OutPort_14172563_1 | SOURCE | VENTILATION | ETA 7
Port_13769474_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769476_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769474_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769505_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769476_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769677_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769476_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769705_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769505_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769506_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769561_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769616_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769561_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769580_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13769561_2 | SINK | VENTILATION | ETA 7
OutPort_13869684_1 | SOURCE | VENTILATION | ETA 7
Port_13769572_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769580_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769572_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13769572_2 | SINK | VENTILATION | ETA 7
OutPort_13869660_1 | SOURCE | VENTILATION | ETA 7
InPort_13769616_2 | SINK | VENTILATION | ETA 7
OutPort_13769624_0 | SOURCE | VENTILATION | ETA 7
InPort_13769624_1 | SINK | VENTILATION | ETA 7
OutPort_13769642_2 | SOURCE | VENTILATION | ETA 7
InPort_13769642_1 | SINK | VENTILATION | ETA 7
OutPort_13769634_0 | SOURCE | VENTILATION | ETA 7
InPort_13769634_1 | SINK | VENTILATION | ETA 7
OutPort_14081092_1 | SOURCE | VENTILATION | ETA 7
InPort_14081092_2 | SINK | VENTILATION | ETA 7
OutPort_13769645_0 | SOURCE | VENTILATION | ETA 7
InPort_13769645_1 | SINK | VENTILATION | ETA 7
OutPort_14017623_2 | SOURCE | VENTILATION | ETA 7
InPort_13769645_2 | SINK | VENTILATION | ETA 7
OutPort_13869453_1 | SOURCE | VENTILATION | ETA 7
InPort_13769645_3 | SINK | VENTILATION | ETA 7
OutPort_13869489_1 | SOURCE | VENTILATION | ETA 7
Port_13769677_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14082137_2 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13769677_2 | SINK | VENTILATION | ETA 7
OutPort_13872203_1 | SOURCE | VENTILATION | ETA 7
Port_13769687_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14082137_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769687_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13769687_2 | SINK | VENTILATION | ETA 7
OutPort_13872261_1 | SOURCE | VENTILATION | ETA 7
Port_13769705_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769723_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769715_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769723_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769715_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769734_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769726_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769734_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769726_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13769726_2 | SINK | VENTILATION | ETA 7
OutPort_13871945_1 | SOURCE | VENTILATION | ETA 7
InPort_13769726_3 | SINK | VENTILATION | ETA 7
OutPort_13871989_1 | SOURCE | VENTILATION | ETA 7
Port_13769763_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769801_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769763_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13769763_2 | SINK | VENTILATION | ETA 7
OutPort_13874728_1 | SOURCE | VENTILATION | ETA 7
Port_13769801_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769811_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769811_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769834_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769823_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769834_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769823_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769843_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769837_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769843_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769837_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13769837_2 | SINK | VENTILATION | ETA 7
OutPort_13874598_1 | SOURCE | VENTILATION | ETA 7
InPort_13769837_3 | SINK | VENTILATION | ETA 7
OutPort_13874634_1 | SOURCE | VENTILATION | ETA 7
Port_13769863_0 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13769873_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13769863_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13769884_2 | SOURCEANDSINK | VENTILATION | ETA 34
InPort_13769863_2 | SINK | VENTILATION | ETA 34
OutPort_13874453_1 | SOURCE | VENTILATION | ETA 34
Port_13769876_0 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13769884_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13769876_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13769893_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13769887_0 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13769893_2 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13769887_1 | SOURCEANDSINK | VENTILATION | ETA 34
InPort_13769887_2 | SINK | VENTILATION | ETA 34
OutPort_13874320_1 | SOURCE | VENTILATION | ETA 34
InPort_13769887_3 | SINK | VENTILATION | ETA 34
OutPort_13874398_1 | SOURCE | VENTILATION | ETA 34
InPort_13792243_0 | SINK | VENTILATION | ETA 7
OutPort_13769955_1 | SOURCE | VENTILATION | ETA 7
Port_13770164_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13792397_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13770164_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13792333_2 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13791764_0 | SINK | VENTILATION | ETA 7
OutPort_13770336_1 | SOURCE | VENTILATION | ETA 7
Port_13770540_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13792025_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13770540_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13792182_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13853075_0 | SINK | VENTILATION | SUP 24
OutPort_13786471_1 | SOURCE | VENTILATION | SUP 24
InPort_13786471_2 | SINK | VENTILATION | ODA 8
OutPort_13968405_0 | SOURCE | VENTILATION | ODA 8
InPort_13786471_3 | SINK | VENTILATION
InPort_13786811_0 | SINK | EXHAUST | EHA 11
OutPort_13786471_4 | SOURCE | EXHAUST | EHA 11
