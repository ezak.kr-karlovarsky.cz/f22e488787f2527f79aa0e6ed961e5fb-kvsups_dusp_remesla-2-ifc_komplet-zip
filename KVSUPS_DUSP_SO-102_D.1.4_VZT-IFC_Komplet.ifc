Properties of the parts of a building model (IFC4), part 42 of 45

# IfcDuctSegment: Kulaté potrubí:SPIRO POZINK/T spoj (978)
Name (Kulaté potrubí:SPIRO POZINK/T spoj:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Volná velikost | Celková velikost | Tloušťka izolace (mm) | Dynamický tlak (Pa) | Průtok (m3/s) | Reynoldsovo číslo | Rychlost (m/s) | Tlaková ztráta (Pa) | Tření (kg/m2/s2) | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Sklon | Spodní výška (mm) | Fáze vytvoření | Ekvivaletní průměr (mm) = Hydraulický průměr (mm) = Průměr (mm) = Velikost | Klasifikace systému | Koeficient ztrát | Název systému | Řez | Typ systému | Zkratka systému | Kód prvku | Označení | Páteřní trasa | Group
13429774 | 1.NP_SO-102 | 7288.82 | 0.0201032 | 3.66376 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 24 | 484 | Přívodní | SUP | PO02.01.0267 | 0267 | no | SUP 24
13429794 | 1.NP_SO-102 | 7264.67 | 0.0201032 | 3.65162 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 24 | 451 | Přívodní | SUP | PO02.01.0268 | 0268 | no | SUP 24
13429803 | 1.NP_SO-102 | 912.374 | 0.0201032 | 0.458609 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 24 | 1 | Přívodní | SUP | PO02.01.0269 | 0269 | no | SUP 24
13429814 | 1.NP_SO-102 | 65 | 0.0201032 | 0.0326726 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 24 | 1 | Přívodní | SUP | PO02.01.0270 | 0270 | no | SUP 24
13429829 | 1.NP_SO-102 | 106.877 | 0.04908 | 0.083941 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2775 | 2650 | 2650 | 1.NP_SO-102 | 0 | 2525 | Fáze 2 | 250 | Přívod vzduchu | 0 | SUP 24 | 85 | Přívodní | SUP | PO02.01.0271 | 0271 | yes | SUP 24 | Identifikační data - Komentáře: PŘIPOJENÍ PŘÍVODNÍHO POTRUBÍ V II.ETAPĚ VÝSTAVBY
13440181 | 2.NP_SO-102 | 2974.26 | 0.0779194 | 2.94333 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2439.26 | -535 | 2439.26 | 2.NP_SO-102 |  | -535 | Fáze 1 | 315 | Přívod vzduchu | 0 | SUP 13 | 77 | Přívodní | SUP | PO02.01.0272 | 0272 | yes | SUP 13
13440195 | 4.NP_SO-102 | 2792.08 | 0.125636 | 3.50863 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2474.29 | -317.788 | 2474.29 | 4.NP_SO-102 |  | -317.788 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 13 | 68 | Přívodní | SUP | PO02.01.0274 | 0274 | yes | SUP 13 | Identifikační data - Komentáře: VZT19
13459207 | 2.NP_SO-102 | 7178.11 | 0.246291 | 12.6284 | 560 mm | 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3360 | 3080 | 3080 | 2.NP_SO-102 | 0 | 2800 | Fáze 1 | 560 | Přívod vzduchu | 0 | SUP 13 | 99 | Přívodní | SUP | PO02.01.0277 | 0277 | yes | SUP 13
13479475 | 4.NP_SO-102 | 2035.39 | 0.159008 | 2.87747 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3320 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2870 | Fáze 1 | 450 | Přívod vzduchu | 0 | SUP 24 | 443 | Přívodní | SUP | PO02.01.0282 | 0282 | yes | SUP 24
13479482 | 4.NP_SO-102 | 1968.13 | 0.159008 | 2.78237 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2645 | 676.874 | 2645 | 4.NP_SO-102 |  | 676.873 | Fáze 1 | 450 | Přívod vzduchu | 0 | SUP 24 | 443 | Přívodní | SUP | PO02.01.0283 | 0283 | yes | SUP 24
13628020 | 1.NP_SO-102 | 292.289 | 0.01227 | 0.114782 | 125 mm | 125 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2802.5 | 2740 | 2740 | 1.NP_SO-102 | 0 | 2677.5 | Fáze 2 | 125 | Zpětný vzduch | 0 | ETA 17 | 15 | Odváděný | ETA | PO02.01.0284 | 0284 | yes | ETA 17
13628036 | 1.NP_SO-102 | 9929.52 | 0.0254431 | 5.61501 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2830 | 2740 | 2740 | 1.NP_SO-102 | 0 | 2650 | Fáze 2 | 180 | Zpětný vzduch | 0 | ETA 17 | 80 | Odváděný | ETA | PO02.01.0285 | 0285 | yes | ETA 17
13628395 | 1.NP_SO-102 | 17206.9 | 0.0397548 | 12.1628 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 16591.9 | 16591.9 | -615 | 1.NP_SO-102 |  | -615 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 8 | 57 | Odváděný | ETA | PO02.01.0286 | 0286 | yes | ETA 8 | Identifikační data - Komentáře: VZT 28
13628554 | -1.PP_SO-102 | 1513.23 | 0.0397548 | 1.06964 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.5 | 3160 | 3160 | -1.PP_SO-102 | 0 | 3047.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 8 | 74 | Odváděný | ETA | PO02.01.0287 | 0287 | no | ETA 8 | Identifikační data - Komentáře: VZT 28
13628596 | -1.PP_SO-102 | 1653.67 | 0.0201032 | 0.831227 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3240.03 | 3160.03 | 3160.03 | -1.PP_SO-102 | 0 | 3080.03 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 8 | 69 | Odváděný | ETA | PO02.01.0288 | 0288 | no | ETA 8 | Identifikační data - Komentáře: VZT 28
13628696 | -1.PP_SO-102 | 603.481 | 0.0397548 | 0.426575 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.5 | 3160 | 3160 | -1.PP_SO-102 | 0 | 3047.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 8 | 57 | Odváděný | ETA | PO02.01.0289 | 0289 | yes | ETA 8 | Identifikační data - Komentáře: VZT 28
13628705 | -1.PP_SO-102 | 1620.75 | 0.0397548 | 1.14564 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.5 | 3160 | 3160 | -1.PP_SO-102 | 0 | 3047.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 8 | 57 | Odváděný | ETA | PO02.01.0290 | 0290 | yes | ETA 8 | Identifikační data - Komentáře: VZT 28
13628812 | -1.PP_SO-102 | 140.965 | 0.0397548 | 0.0996423 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.5 | 3160 | 3160 | -1.PP_SO-102 | 0 | 3047.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 8 | 55 | Odváděný | ETA | PO02.01.0291 | 0291 | yes | ETA 8 | Identifikační data - Komentáře: VZT 28
13628857 | -1.PP_SO-102 | 60.1514 | 0.0397548 | 0.0425186 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.5 | 3160 | 3160 | -1.PP_SO-102 | 0 | 3047.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 8 | 56 | Odváděný | ETA | PO02.01.0292 | 0292 | no | ETA 8 | Identifikační data - Komentáře: VZT 28
13628864 | -1.PP_SO-102 | 645.021 | 0.0397548 | 0.455938 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.5 | 3160 | 3160 | -1.PP_SO-102 | 0 | 3047.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 8 | 50 | Odváděný | ETA | PO02.01.0293 | 0293 | no | ETA 8 | Identifikační data - Komentáře: VZT 28
13629075 | -1.PP_SO-102 | 100.962 | 0.0397548 | 0.0713658 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.5 | 3160 | 3160 | -1.PP_SO-102 | 0 | 3047.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 8 | 52 | Odváděný | ETA | PO02.01.0294 | 0294 | yes | ETA 8 | Identifikační data - Komentáře: VZT 28
13629094 | -1.PP_SO-102 | 30.2475 | 0.0397548 | 0.0213807 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.5 | 3160 | 3160 | -1.PP_SO-102 | 0 | 3047.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 8 | 59 | Odváděný | ETA | PO02.01.0295 | 0295 | no | ETA 8 | Identifikační data - Komentáře: VZT 28
13629310 | 4.NP_SO-102 | 3563.76 | 0.0397548 | 2.51907 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4929.39 | 4816.89 | 4816.89 | 4.NP_SO-102 | 0 | 4704.39 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 8 | 57 | Odváděný | ETA | PO02.01.0296 | 0296 | yes | ETA 8 | Identifikační data - Komentáře: VZT 28
13629830 | -1.PP_SO-102 | 575.157 | 0.125636 | 0.722764 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2750 | 2750 | 2174.84 | -1.PP_SO-102 |  | 2174.84 | Fáze 1 | 400 | Zpětný vzduch | 0 | ETA 18 | 36 | Odváděný | ETA | PO02.01.0297 | 0297 | yes | ETA 18
13629968 | -1.PP_SO-102 | 14.2286 | 0.125636 | 0.0178802 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 2880 | 2880 | -1.PP_SO-102 | 0 | 2680 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 7 | 30 | Přívodní | SUP | PO02.01.0298 | 0298 | yes | SUP 7
13629978 | -1.PP_SO-102 | 305.157 | 0.125636 | 0.383472 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2480 | 2480 | 2174.84 | -1.PP_SO-102 |  | 2174.84 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 7 | 22 | Přívodní | SUP | PO02.01.0299 | 0299 | yes | SUP 7
13631603 | -1.PP_SO-102 | 14.5398 | 0.0989649 | 0.0162157 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3254.64 | 3077.14 | 3077.14 | -1.PP_SO-102 | 0 | 2899.64 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 4 | 2 | Přívodní | SUP | PO02.01.0301 | 0301 | yes | SUP 4
13631907 | -1.PP_SO-102 | 212.919 | 0.0989649 | 0.237461 | 355 mm | 355 mm | 0 | 22.9216 | 0.611111 | 144828 | 6.1741 | 0.271243 | 1.27392 | 3277.5 | 3100 | 3100 | -1.PP_SO-102 | 0 | 2922.5 | Fáze 1 | 355 | Přívod vzduchu | 0.0118335 | ODA 2 | 2 | Čerstvý | ODA | PO02.01.0302 | 0302 | yes | ODA 2
13631998 | -1.PP_SO-102 | 312.919 | 0.0989649 | 0.348988 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3277.5 | 3100 | 3100 | -1.PP_SO-102 | 0 | 2922.5 | Fáze 1 | 355 | Odváděný vzduch | 0 | EHA 2 | 2 | Znehodnocený | EHA | PO02.01.0303 | 0303 | yes | EHA 2
13633538 | 4.NP_SO-102 | 540.528 | 0.0201024 | 0.271699 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3030 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2870 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 151 | Odváděný | ETA | PO02.01.0306 | 0306 | no | ETA 7 | Identifikační data - Komentáře: VZT18
13633890 | 3.NP_SO-102 | 6585.39 | 0.0989649 | 7.34446 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3322.66 | 3145.16 | 3145.16 | 3.NP_SO-102 | 0 | 2967.66 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 9 | 409 | Přívodní | SUP | PO02.01.0307 | 0307 | no | SUP 9 | Identifikační data - Komentáře: VZT25
13634147 | 2.NP_SO-102 | 148.149 | 0.159008 | 0.20944 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3305 | 3080 | 3080 | 2.NP_SO-102 | 0 | 2855 | Fáze 1 | 450 | Přívod vzduchu | 0 | SUP 13 | 80 | Přívodní | SUP | PO02.01.0308 | 0308 | yes | SUP 13
13634196 | 2.NP_SO-102 | 98.0788 | 0.246291 | 0.172549 | 560 mm | 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3319.79 | 3039.78 | 3039.79 | 2.NP_SO-102 | 0 | 2759.78 | Fáze 1 | 560 | Přívod vzduchu | 0 | SUP 24 | 14 | Přívodní | SUP | PO02.01.0309 | 0309 | yes | SUP 24
13634268 | 3.NP_SO-102 | 283.071 | 0.246291 | 0.498005 | 560 mm | 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3320 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2760 | Fáze 1 | 560 | Přívod vzduchu | 0 | SUP 24 | 147 | Přívodní | SUP | PO02.01.0310 | 0310 | yes | SUP 24
13634296 | 3.NP_SO-102 | 216.293 | 0.196306 | 0.339752 | 500 mm | 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3349.91 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 2849.91 | Fáze 1 | 500 | Přívod vzduchu | 0 | SUP 13 | 143 | Přívodní | SUP | PO02.01.0311 | 0311 | yes | SUP 13
13634389 | 4.NP_SO-102 | 1343.87 | 0.196306 | 2.11095 | 500 mm | 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3345 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2845 | Fáze 1 | 500 | Přívod vzduchu | 0 | SUP 13 | 148 | Přívodní | SUP | PO02.01.0312 | 0312 | yes | SUP 13
13634445 | 4.NP_SO-102 | 351.401 | 0.159008 | 0.496781 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3320 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2870 | Fáze 1 | 450 | Přívod vzduchu | 0 | SUP 24 | 443 | Přívodní | SUP | PO02.01.0313 | 0313 | yes | SUP 24
13634590 | 1.NP_SO-102 | 41.4653 | 0.196306 | 0.0651336 | 500 mm | 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3345.02 | 3095.02 | 3095.02 | 1.NP_SO-102 | 0 | 2845.02 | Fáze 1 | 500 | Přívod vzduchu | 0 | SUP 24 | 450 | Přívodní | SUP | PO02.01.0314 | 0314 | yes | SUP 24
13635396 | 3.NP_SO-102 | 33.6784 | 0.246291 | 0.0592501 | 560 mm | 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3320 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2760 | Fáze 1 | 560 | Přívod vzduchu | 0 | SUP 24 | 447 | Přívodní | SUP | PO02.01.0316 | 0316 | yes | SUP 24
13636089 | 1.NP_SO-102 | 1555.54 | 0.0779194 | 1.53936 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3307.5 | 3150 | 3150 | 1.NP_SO-102 | 0 | 2992.5 | Fáze 1 | 315 | Přívod vzduchu | 0 | SUP 13 | 77 | Přívodní | SUP | PO02.01.0321 | 0321 | yes | SUP 13 | Identifikační data - Komentáře: VZT19
13641510 | -1.PP_SO-102 | 890 | 0.0989649 | 0.992586 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3253.97 | 3076.47 | 3076.47 | -1.PP_SO-102 | 0 | 2898.97 | Fáze 1 | 355 | Přívod vzduchu | 0 | ODA 1 | 2 | Čerstvý | ODA | PO02.01.0340 | 0340 | yes | ODA 1
13641523 | -1.PP_SO-102 | 198.622 | 0.0989649 | 0.221516 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2877.5 | 2700 | 2700 | -1.PP_SO-102 | 0 | 2522.5 | Fáze 1 | 355 | Přívod vzduchu | 0 | ODA 1 | 4 | Čerstvý | ODA | PO02.01.0341 | 0341 | yes | ODA 1
13646879 | 1.NP_SO-102 | 796.344 | 0.0201032 | 0.400286 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3330 | 3250 | 3250 | 1.NP_SO-102 | 0 | 3170 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 261 | Odváděný | ETA | PO02.01.0346 | 0346 | no | ETA 7
13651361 | 1.NP_SO-102 | 26.5353 | 0.159008 | 0.0375134 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2965 | 2740 | 2740 | 1.NP_SO-102 | 0 | 2515 | Fáze 2 | 450 | Zpětný vzduch | 0 | ETA 17 | 58 | Odváděný | ETA | PO02.01.0372 | 0372 | yes | ETA 17 | Identifikační data - Komentáře: VZT20
13651375 | 1.NP_SO-102 | 2900.68 | 0.0989649 | 3.23503 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2917.5 | 2740 | 2740 | 1.NP_SO-102 | 0 | 2562.5 | Fáze 2 | 355 | Zpětný vzduch | 0 | ETA 17 | 21 | Odváděný | ETA | PO02.01.0373 | 0373 | yes | ETA 17
13651528 | 1.NP_SO-102 | 1558.74 | 0.0989649 | 1.7384 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3277.5 | 3100 | 3100 | 1.NP_SO-102 | 0 | 2922.5 | Fáze 2 | 355 | Přívod vzduchu | 0 | SUP 12 | 200 | Přívodní | SUP | PO02.01.0374 | 0374 | yes | SUP 12
13651810 | 1.NP_SO-102 | 59.1684 | 0.159008 | 0.0836474 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3325 | 3100 | 3100 | 1.NP_SO-102 | 0 | 2875 | Fáze 2 | 450 | Přívod vzduchu | 0 | SUP 12 | 239 | Přívodní | SUP | PO02.01.0376 | 0376 | yes | SUP 12
13702456 | 1.NP_SO-102 | 445.464 | 0.0201032 | 0.223915 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3330 | 3250 | 3250 | 1.NP_SO-102 | 0 | 3170 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 57 | Odváděný | ETA | PO02.01.0381 | 0381 | no | ETA 7 | Identifikační data - Komentáře: VZT18
13702563 | 1.NP_SO-102 | 500 | 0.0201032 | 0.251327 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3330 | 3250 | 3250 | 1.NP_SO-102 | 0 | 3170 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 261 | Odváděný | ETA | PO02.01.0382 | 0382 | no | ETA 7
13702574 | 1.NP_SO-102 | 3740 | 0.0201032 | 1.87993 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3330 | 3250 | 3250 | 1.NP_SO-102 | 0 | 3170 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 261 | Odváděný | ETA | PO02.01.0383 | 0383 | no | ETA 7
13702605 | 1.NP_SO-102 | 1513.66 | 0.0201032 | 0.760847 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3330 | 3250 | 3250 | 1.NP_SO-102 | 0 | 3170 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 265 | Odváděný | ETA | PO02.01.0384 | 0384 | no | ETA 7
13702824 | 1.NP_SO-102 | 3725 | 0.0779194 | 3.68627 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3120 | 3120 | -605 | 1.NP_SO-102 |  | -605 | Fáze 1 | 315 | Zpětný vzduch | 0 | ETA 7 | 62 | Odváděný | ETA | PO02.01.0385 | 0385 | no | ETA 7 | Identifikační data - Komentáře: VZT18
13707788 | 2.NP_SO-102 | 3723.7 | 0.125636 | 4.67934 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3295 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2895 | Fáze 2 | 400 | Přívod vzduchu | 0 | SUP 24 | 79 | Přívodní | SUP | PO02.01.0391 | 0391 | yes | SUP 24
13708371 | 2.NP_SO-102 | 801.98 | 0.0397548 | 0.566887 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 50 | 153 | Přívodní | SUP | PO02.01.0392 | 0392 | yes | SUP 50
13708514 | 3.NP_SO-102 | 1819.73 | 0.125636 | 2.28674 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3299.91 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 2899.91 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 13 | 328 | Přívodní | SUP | PO02.01.0393 | 0393 | yes | SUP 13 | Identifikační data - Komentáře: ZASLEPENÁ ODBOČKA PŘÍPRAVA PRO NAPOJENÍ MÍSTNOSTÍ VE II.ETAPĚ VÝSTAVBY
13711714 | -1.PP_SO-102 | 2742.5 | 0.0201032 | 1.37853 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2430 | 2350 | 2350 | -1.PP_SO-102 | 0 | 2270 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 27 | 54 | Odváděný | ETA | PO02.01.0400 | 0400 | no | ETA 27
13711723 | -1.PP_SO-102 | 760.355 | 0.0314112 | 0.477745 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2450 | 2350 | 2350 | -1.PP_SO-102 | 0 | 2250 | Fáze 1 | 200 | Zpětný vzduch | 0 | ETA 27 | 147 | Odváděný | ETA | PO02.01.0401 | 0401 | no | ETA 27
13713209 | 2.NP_SO-102 | 3313.95 | 0.0201032 | 1.66577 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3120 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2960 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 11 | Přívodní | SUP | PO02.01.0405 | 0405 | yes | SUP 24
13713516 | 2.NP_SO-102 | 332.779 | 0.0254431 | 0.188182 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3170 | 3080 | 3080 | 2.NP_SO-102 | 0 | 2990 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 13 | 216 | Přívodní | SUP | PO02.01.0406 | 0406 | no | SUP 13
13713529 | 2.NP_SO-102 | 201.025 | 0.0254431 | 0.113677 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3170 | 3080 | 3080 | 2.NP_SO-102 | 0 | 2990 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 13 | 216 | Přívodní | SUP | PO02.01.0407 | 0407 | no | SUP 13
13713635 | 2.NP_SO-102 | 375.795 | 0.04908 | 0.295149 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3205 | 3080 | 3080 | 2.NP_SO-102 | 0 | 2955 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 13 | 90 | Přívodní | SUP | PO02.01.0408 | 0408 | no | SUP 13
13713644 | 2.NP_SO-102 | 107.224 | 0.04908 | 0.0842135 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3205 | 3080 | 3080 | 2.NP_SO-102 | 0 | 2955 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 13 | 90 | Přívodní | SUP | PO02.01.0409 | 0409 | no | SUP 13
13713657 | 2.NP_SO-102 | 5655.65 | 0.159008 | 7.99549 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3305 | 3080 | 3080 | 2.NP_SO-102 | 0 | 2855 | Fáze 1 | 450 | Přívod vzduchu | 0 | SUP 13 | 21 | Přívodní | SUP | PO02.01.0410 | 0410 | yes | SUP 13
13713963 | 2.NP_SO-102 | 2021.77 | 0.125636 | 2.54063 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3280 | 3079.98 | 3080 | 2.NP_SO-102 | 0 | 2879.98 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 13 | 304 | Přívodní | SUP | PO02.01.0411 | 0411 | yes | SUP 13 | Identifikační data - Komentáře: ZASLEPENÁ ODBOČKA PŘÍPRAVA PRO NAPOJENÍ MÍSTNOSTÍ VE II.ETAPĚ VÝSTAVBY
13714025 | 2.NP_SO-102 | 1073.4 | 0.0397548 | 0.758743 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 48 | 151 | Přívodní | SUP | PO02.01.0412 | 0412 | no | SUP 48
13714034 | 2.NP_SO-102 | 6474.73 | 0.0397548 | 4.57672 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 48 | 151 | Přívodní | SUP | PO02.01.0413 | 0413 | no | SUP 48
13714171 | 3.NP_SO-102 | 139.949 | 0.0989649 | 0.15608 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.5 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2917.5 | Fáze 2 | 355 | Přívod vzduchu | 0 | SUP 24 | 488 | Přívodní | SUP | PO02.01.0414 | 0414 | yes | SUP 24 | Identifikační data - Komentáře: VZT18
13714189 | 3.NP_SO-102 | 3842.3 | 0.0779194 | 3.80234 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3252.5 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2937.5 | Fáze 2 | 315 | Přívod vzduchu | 0 | SUP 24 | 489 | Přívodní | SUP | PO02.01.0415 | 0415 | yes | SUP 24
13714619 | 4.NP_SO-102 | 7101.75 | 0.0314112 | 4.46216 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3195 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2995 | Fáze 2 | 200 | Přívod vzduchu | 0 | SUP 18 | 126 | Přívodní | SUP | PO02.01.0416 | 0416 | yes | SUP 18
13714714 | 4.NP_SO-102 | 333.254 | 0.0989649 | 0.371666 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2917.5 | Fáze 2 | 355 | Přívod vzduchu | 0 | SUP 18 | 132 | Přívodní | SUP | PO02.01.0417 | 0417 | yes | SUP 18
13714820 | 4.NP_SO-102 | 20.9194 | 0.0397548 | 0.0147871 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 24 | 184 | Přívodní | SUP | PO02.01.0418 | 0418 | yes | SUP 24
13714835 | 4.NP_SO-102 | 326.996 | 0.0397548 | 0.23114 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 24 | 164 | Přívodní | SUP | PO02.01.0419 | 0419 | yes | SUP 24 | Identifikační data - Komentáře: VZT18
13714846 | 4.NP_SO-102 | 37.354 | 0.0397548 | 0.026404 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 24 | 165 | Přívodní | SUP | PO02.01.0420 | 0420 | yes | SUP 24
13717385 | 2.NP_SO-102 | 804.447 | 0.159008 | 1.13726 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3162.5 | 2937.5 | 2937.5 | 2.NP_SO-102 | 0 | 2712.5 | Fáze 1 | 450 | Přívod vzduchu | 0 | SUP 9 | 215 | Přívodní | SUP | PO02.01.0421 | 0421 | yes | SUP 9
13717403 | 2.NP_SO-102 | 3763.53 | 0.04908 | 2.95587 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3062.5 | 2937.5 | 2937.5 | 2.NP_SO-102 | 0 | 2812.5 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 9 | 278 | Přívodní | SUP | PO02.01.0422 | 0422 | yes | SUP 9
13717445 | 2.NP_SO-102 | 2493.44 | 0.0397548 | 1.76251 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3050 | 2937.5 | 2937.5 | 2.NP_SO-102 | 0 | 2825 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 9 | 340 | Přívodní | SUP | PO02.01.0423 | 0423 | yes | SUP 9
13717463 | 2.NP_SO-102 | 967.833 | 0.159008 | 1.36824 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3162.5 | 2937.5 | 2937.5 | 2.NP_SO-102 | 0 | 2712.5 | Fáze 1 | 450 | Přívod vzduchu | 0 | SUP 9 | 215 | Přívodní | SUP | PO02.01.0424 | 0424 | yes | SUP 9
13717465 | 2.NP_SO-102 | 2368.44 | 0.0397548 | 1.67415 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3050 | 2937.5 | 2937.5 | 2.NP_SO-102 | 0 | 2825 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 9 | 324 | Přívodní | SUP | PO02.01.0425 | 0425 | yes | SUP 9
13717473 | 2.NP_SO-102 | 3392.64 | 0.0989649 | 3.7837 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3115 | 2937.5 | 2937.5 | 2.NP_SO-102 | 0 | 2760 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 9 | 277 | Přívodní | SUP | PO02.01.0426 | 0426 | yes | SUP 9
13717475 | 2.NP_SO-102 | 2368.44 | 0.0397548 | 1.67415 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3050 | 2937.5 | 2937.5 | 2.NP_SO-102 | 0 | 2825 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 9 | 332 | Přívodní | SUP | PO02.01.0427 | 0427 | yes | SUP 9
13718730 | 2.NP_SO-102 | 4940.57 | 0.0989649 | 5.51004 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3117.5 | 2940 | 2940 | 2.NP_SO-102 | 0 | 2762.5 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 9 | 293 | Přívodní | SUP | PO02.01.0429 | 0429 | no | SUP 9
13718778 | 2.NP_SO-102 | 665.207 | 0.0989649 | 0.741883 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3117.5 | 2940 | 2940 | 2.NP_SO-102 | 0 | 2762.5 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 9 | 383 | Přívodní | SUP | PO02.01.0430 | 0430 | yes | SUP 9
13718852 | 2.NP_SO-102 | 699.703 | 0.04908 | 0.549546 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3065 | 2939.57 | 2940 | 2.NP_SO-102 | 0.0618622 | 2814.57 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 9 | 477 | Přívodní | SUP | PO02.01.0431 | 0431 | no | SUP 9 | Identifikační data - Komentáře: VZT25
13718965 | 1.NP_SO-102 | 86.1907 | 0.04908 | 0.067694 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3325 | 3200 | 3200 | 1.NP_SO-102 | 0 | 3075 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 9 | 364 | Přívodní | SUP | PO02.01.0432 | 0432 | no | SUP 9
13745943 | 2.NP_SO-102 | 2424.75 | 0.246291 | 4.26584 | 560 mm | 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3360 | 3080 | 3080 | 2.NP_SO-102 | 0 | 2800 | Fáze 1 | 560 | Přívod vzduchu | 0 | SUP 13 | 98 | Přívodní | SUP | PO02.01.0439 | 0439 | yes | SUP 13
13746587 | 2.NP_SO-102 | 459.897 | 0.246291 | 0.809093 | 560 mm | 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3247.46 | 2775.03 | 3004.97 | 2.NP_SO-102 | 57.735 | 2532.54 | Fáze 1 | 560 | Přívod vzduchu | 0 | SUP 13 | 99 | Přívodní | SUP | PO02.01.0442 | 0442 | yes | SUP 13
13746701 | 2.NP_SO-102 | 222.519 | 0.246291 | 0.391476 | 560 mm | 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2980 | 2700 | 2700 | 2.NP_SO-102 | 0 | 2420 | Fáze 1 | 560 | Přívod vzduchu | 0 | SUP 13 | 99 | Přívodní | SUP | PO02.01.0443 | 0443 | yes | SUP 13
13746755 | 2.NP_SO-102 | 459.897 | 0.246291 | 0.809093 | 560 mm | 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3247.46 | 2775.03 | 3004.97 | 2.NP_SO-102 | 57.735 | 2532.54 | Fáze 1 | 560 | Přívod vzduchu | 0 | SUP 13 | 98 | Přívodní | SUP | PO02.01.0444 | 0444 | yes | SUP 13
13747846 | 4.NP_SO-102 | 780 | 0.0201032 | 0.392071 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3230 | 3150 | 3150 | 4.NP_SO-102 | 0 | 3070 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 192 | Odváděný | ETA | PO02.01.0446 | 0446 | no | ETA 7
13747885 | 4.NP_SO-102 | 876.688 | 0.0201032 | 0.440672 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3230 | 3150 | 3150 | 4.NP_SO-102 | 0 | 3070 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 188 | Odváděný | ETA | PO02.01.0447 | 0447 | no | ETA 7
13747893 | 4.NP_SO-102 | 400 | 0.0201032 | 0.201062 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3230 | 3150 | 3150 | 4.NP_SO-102 | 0 | 3070 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 188 | Odváděný | ETA | PO02.01.0448 | 0448 | no | ETA 7
13747915 | 4.NP_SO-102 | 3420 | 0.0201032 | 1.71908 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3230 | 3150 | 3150 | 4.NP_SO-102 | 0 | 3070 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 188 | Odváděný | ETA | PO02.01.0449 | 0449 | no | ETA 7
13747948 | 4.NP_SO-102 | 397.627 | 0.0201032 | 0.199869 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2920 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 34 | 87 | Odváděný | ETA | PO02.01.0450 | 0450 | no | ETA 34
13748005 | 4.NP_SO-102 | 1312.37 | 0.0201032 | 0.659671 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2920 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 34 | 89 | Odváděný | ETA | PO02.01.0451 | 0451 | no | ETA 34
13748015 | 4.NP_SO-102 | 451.329 | 0.0201032 | 0.226863 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2920 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 34 | 89 | Odváděný | ETA | PO02.01.0452 | 0452 | no | ETA 34
13748026 | 4.NP_SO-102 | 3740 | 0.0201032 | 1.87993 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2920 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 34 | 89 | Odváděný | ETA | PO02.01.0453 | 0453 | no | ETA 34
13748110 | 3.NP_SO-102 | 906.688 | 0.0201032 | 0.455751 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3100 | 3020 | 3020 | 3.NP_SO-102 | 0 | 2940 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 196 | Odváděný | ETA | PO02.01.0454 | 0454 | no | ETA 7
13748119 | 3.NP_SO-102 | 379.452 | 0.0201032 | 0.190734 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3100 | 3020 | 3020 | 3.NP_SO-102 | 0 | 2940 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 196 | Odváděný | ETA | PO02.01.0455 | 0455 | no | ETA 7
13748130 | 3.NP_SO-102 | 3360 | 0.0201032 | 1.68892 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3100 | 3020 | 3020 | 3.NP_SO-102 | 0 | 2940 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 196 | Odváděný | ETA | PO02.01.0456 | 0456 | no | ETA 7
13748171 | 3.NP_SO-102 | 900 | 0.0201032 | 0.452389 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3100 | 3020 | 3020 | 3.NP_SO-102 | 0 | 2940 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 194 | Odváděný | ETA | PO02.01.0457 | 0457 | no | ETA 7
13748211 | 3.NP_SO-102 | 580 | 0.0201032 | 0.29154 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3075.73 | 2995.73 | 2995.73 | 3.NP_SO-102 | 0 | 2915.73 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 34 | 97 | Odváděný | ETA | PO02.01.0458 | 0458 | no | ETA 34
13748246 | 3.NP_SO-102 | 1332.37 | 0.0201032 | 0.669724 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3075.73 | 2995.73 | 2995.73 | 3.NP_SO-102 | 0 | 2915.73 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 34 | 93 | Odváděný | ETA | PO02.01.0459 | 0459 | no | ETA 34
13748256 | 3.NP_SO-102 | 460 | 0.0201032 | 0.231221 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3075.73 | 2995.73 | 2995.73 | 3.NP_SO-102 | 0 | 2915.73 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 34 | 93 | Odváděný | ETA | PO02.01.0460 | 0460 | no | ETA 34
13748267 | 3.NP_SO-102 | 3440 | 0.0201032 | 1.72913 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3075.73 | 2995.73 | 2995.73 | 3.NP_SO-102 | 0 | 2915.73 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 34 | 93 | Odváděný | ETA | PO02.01.0461 | 0461 | no | ETA 34
13765295 | -1.PP_SO-102 | 820.602 | 0.0989649 | 0.915189 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3277.5 | 3100 | 3100 | -1.PP_SO-102 | 0 | 2922.5 | Fáze 1 | 355 | Odváděný vzduch | 0 | EHA 2 | 4 | Znehodnocený | EHA | PO02.01.0462 | 0462 | yes | EHA 2
13765427 | -1.PP_SO-102 | 645.908 | 0.0989649 | 0.720359 | 355 mm | 355 mm | 0 | 22.9216 | 0.611111 | 144828 | 6.1741 | 0.822838 | 1.27392 | 2877.5 | 2700 | 2700 | -1.PP_SO-102 | 0 | 2522.5 | Fáze 1 | 355 | Přívod vzduchu | 0.0358979 | ODA 2 | 4 | Čerstvý | ODA | PO02.01.0463 | 0463 | yes | ODA 2
13765438 | -1.PP_SO-102 | 271.594 | 0.0989649 | 0.302899 | 355 mm | 355 mm | 0 | 22.9216 | 0.611111 | 144828 | 6.1741 | 0.34599 | 1.27392 | 3121.53 | 2803.98 | 2996.02 | -1.PP_SO-102 | 100 | 2678.47 | Fáze 1 | 355 | Přívod vzduchu | 0.0150945 | ODA 2 | 4 | Čerstvý | ODA | PO02.01.0464 | 0464 | yes | ODA 2
13765451 | -1.PP_SO-102 | 65.983 | 0.0989649 | 0.0735885 | 355 mm | 355 mm | 0 | 22.9216 | 0.611111 | 144828 | 6.1741 | 0.0840573 | 1.27392 | 3277.5 | 3100 | 3100 | -1.PP_SO-102 | 0 | 2922.5 | Fáze 1 | 355 | Přívod vzduchu | 0.00366717 | ODA 2 | 4 | Čerstvý | ODA | PO02.01.0465 | 0465 | yes | ODA 2
13765486 | -1.PP_SO-102 | 271.594 | 0.0989649 | 0.302899 | 355 mm | 355 mm | 0 | 22.9216 | 0.611111 | 144828 | 6.1741 | 0.34599 | 1.27392 | 3121.53 | 2996.02 | 2803.98 | -1.PP_SO-102 | 100 | 2678.47 | Fáze 1 | 355 | Přívod vzduchu | 0.0150945 | ODA 2 | 4 | Čerstvý | ODA | PO02.01.0466 | 0466 | yes | ODA 2
13765731 | 1.NP_SO-102 | 997.39 | 0.0201032 | 0.501343 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3330 | 3250 | 3250 | 1.NP_SO-102 | 0 | 3170 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 255 | Odváděný | ETA | PO02.01.0467 | 0467 | no | ETA 7
13765773 | 1.NP_SO-102 | 1332.61 | 0.0201032 | 0.669843 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3330 | 3250 | 3250 | 1.NP_SO-102 | 0 | 3170 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 257 | Odváděný | ETA | PO02.01.0468 | 0468 | no | ETA 7
13765783 | 1.NP_SO-102 | 423.124 | 0.0201032 | 0.212685 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3330 | 3250 | 3250 | 1.NP_SO-102 | 0 | 3170 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 257 | Odváděný | ETA | PO02.01.0469 | 0469 | no | ETA 7
13765794 | 1.NP_SO-102 | 3440 | 0.0201032 | 1.72913 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3330 | 3250 | 3250 | 1.NP_SO-102 | 0 | 3170 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 257 | Odváděný | ETA | PO02.01.0470 | 0470 | no | ETA 7
13765921 | -1.PP_SO-102 | 129.732 | 0.0989649 | 0.144685 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2877.5 | 2700 | 2700 | -1.PP_SO-102 | 0 | 2522.5 | Fáze 1 | 355 | Přívod vzduchu | 0 | ODA 1 | 4 | Čerstvý | ODA | PO02.01.0471 | 0471 | yes | ODA 1
13765966 | -1.PP_SO-102 | 567.908 | 0.0989649 | 0.633369 | 355 mm | 355 mm | 0 | 13.6867 | 0.472222 | 111912 | 4.77089 | 0.444525 | 0.78274 | 2877.5 | 2700 | 2700 | -1.PP_SO-102 | 0 | 2522.5 | Fáze 1 | 355 | Přívod vzduchu | 0.0324787 | ODA 1 | 6 | Čerstvý | ODA | PO02.01.0472 | 0472 | yes | ODA 1
13766007 | -1.PP_SO-102 | 650.081 | 0.0989649 | 0.725013 | 355 mm | 355 mm | 0 | 13.6867 | 0.472222 | 111912 | 4.77089 | 0.508845 | 0.78274 | 3255.5 | 3078 | 3078 | -1.PP_SO-102 | 0 | 2900.5 | Fáze 1 | 355 | Přívod vzduchu | 0.0371781 | ODA 1 | 6 | Čerstvý | ODA | PO02.01.0473 | 0473 | yes | ODA 1
13766016 | -1.PP_SO-102 | 240.48 | 0.0989649 | 0.2682 | 355 mm | 355 mm | 0 | 13.6867 | 0.472222 | 111912 | 4.77089 | 0.188234 | 0.78274 | 3099.53 | 2974.02 | 2803.98 | -1.PP_SO-102 | 100 | 2678.47 | Fáze 1 | 355 | Přívod vzduchu | 0.0137531 | ODA 1 | 6 | Čerstvý | ODA | PO02.01.0474 | 0474 | yes | ODA 1
13766152 | -1.PP_SO-102 | 5905.53 | 0.04908 | 4.63819 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3275 | 3150 | 3150 | -1.PP_SO-102 | 0 | 3025 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 18 | 21 | Odváděný | ETA | PO02.01.0475 | 0475 | yes | ETA 18
13769061 | 2.NP_SO-102 | 4320 | 0.0201032 | 2.17147 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 210 | Odváděný | ETA | PO02.01.0488 | 0488 | no | ETA 7
13769070 | 2.NP_SO-102 | 440 | 0.0201032 | 0.221168 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 210 | Odváděný | ETA | PO02.01.0489 | 0489 | no | ETA 7
13769081 | 2.NP_SO-102 | 442.368 | 0.0201032 | 0.222359 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 210 | Odváděný | ETA | PO02.01.0490 | 0490 | no | ETA 7
13769090 | 2.NP_SO-102 | 466.215 | 0.0201032 | 0.234345 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 172 | Odváděný | ETA | PO02.01.0491 | 0491 | no | ETA 7 | Identifikační data - Komentáře: VZT18
13769149 | 2.NP_SO-102 | 1330.67 | 0.0201032 | 0.668868 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 228 | Odváděný | ETA | PO02.01.0492 | 0492 | no | ETA 7
13769161 | 2.NP_SO-102 | 600 | 0.0201032 | 0.301593 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 2.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 229 | Odváděný | ETA | PO02.01.0493 | 0493 | no | ETA 7
13769306 | 2.NP_SO-102 | 3065.25 | 0.061566 | 2.69634 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2970 | 2970 | -95.2513 | 2.NP_SO-102 |  | -95.2513 | Fáze 2 | 280 | Zpětný vzduch | 0 | ETA 7 | 30 | Odváděný | ETA | PO02.01.0494 | 0494 | yes | ETA 7
13769354 | 1.NP_SO-102 | 448.682 | 0.0201032 | 0.225532 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 1.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 146 | Odváděný | ETA | PO02.01.0495 | 0495 | no | ETA 7 | Identifikační data - Komentáře: VZT18
13769401 | 1.NP_SO-102 | 3755 | 0.0779194 | 3.71595 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2970 | 2970 | -785 | 1.NP_SO-102 |  | -785 | Fáze 2 | 315 | Zpětný vzduch | 0 | ETA 7 | 422 | Odváděný | ETA | PO02.01.0496 | 0496 | yes | ETA 7
13769474 | 3.NP_SO-102 | 481.216 | 0.0201032 | 0.241885 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 3.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 149 | Odváděný | ETA | PO02.01.0497 | 0497 | no | ETA 7 | Identifikační data - Komentáře: VZT18
13769506 | 2.NP_SO-102 | 3591.29 | 0.04908 | 2.82059 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6970 | 6970 | 3378.71 | 2.NP_SO-102 |  | 3378.71 | Fáze 2 | 250 | Zpětný vzduch | 0 | ETA 7 | 31 | Odváděný | ETA | PO02.01.0498 | 0498 | yes | ETA 7
13769561 | 4.NP_SO-102 | 1221.6 | 0.0201032 | 0.614044 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3030 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2870 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 215 | Odváděný | ETA | PO02.01.0499 | 0499 | no | ETA 7
13769572 | 4.NP_SO-102 | 740 | 0.0201032 | 0.371965 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3030 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2870 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 216 | Odváděný | ETA | PO02.01.0500 | 0500 | no | ETA 7
13769624 | 4.NP_SO-102 | 407.819 | 0.0201032 | 0.204992 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3030 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2870 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 370 | Odváděný | ETA | PO02.01.0501 | 0501 | no | ETA 7
13769634 | 4.NP_SO-102 | 480 | 0.0201032 | 0.241274 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3030 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2870 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 370 | Odváděný | ETA | PO02.01.0502 | 0502 | no | ETA 7
13769645 | 4.NP_SO-102 | 4026.95 | 0.0201032 | 2.02417 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3030 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2870 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 370 | Odváděný | ETA | PO02.01.0503 | 0503 | no | ETA 7
13769677 | 3.NP_SO-102 | 1241.24 | 0.0201032 | 0.623914 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 3.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 222 | Odváděný | ETA | PO02.01.0504 | 0504 | no | ETA 7
13769687 | 3.NP_SO-102 | 750 | 0.0201032 | 0.376991 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 3.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 377 | Odváděný | ETA | PO02.01.0505 | 0505 | no | ETA 7
13769705 | 3.NP_SO-102 | 448.762 | 0.0201032 | 0.225572 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 3.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 225 | Odváděný | ETA | PO02.01.0506 | 0506 | no | ETA 7
13769715 | 3.NP_SO-102 | 460 | 0.0201032 | 0.231221 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 3.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 225 | Odváděný | ETA | PO02.01.0507 | 0507 | no | ETA 7
13769726 | 3.NP_SO-102 | 4340 | 0.0201032 | 2.18152 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 3.NP_SO-102 | 0 | 3020 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 225 | Odváděný | ETA | PO02.01.0508 | 0508 | no | ETA 7
13769763 | 2.NP_SO-102 | 840 | 0.0201032 | 0.42223 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2920 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 204 | Odváděný | ETA | PO02.01.0509 | 0509 | no | ETA 7
13769811 | 2.NP_SO-102 | 860 | 0.0201032 | 0.432283 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2920 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 200 | Odváděný | ETA | PO02.01.0510 | 0510 | no | ETA 7
13769823 | 2.NP_SO-102 | 520 | 0.0201032 | 0.261381 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2920 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 200 | Odváděný | ETA | PO02.01.0511 | 0511 | no | ETA 7
13769837 | 2.NP_SO-102 | 3540 | 0.0201032 | 1.7794 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2920 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 200 | Odváděný | ETA | PO02.01.0512 | 0512 | no | ETA 7
13769863 | 2.NP_SO-102 | 1272.37 | 0.0201032 | 0.639564 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2920 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 34 | 103 | Odváděný | ETA | PO02.01.0513 | 0513 | no | ETA 34
13769876 | 2.NP_SO-102 | 484.087 | 0.0201032 | 0.243329 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2920 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 34 | 99 | Odváděný | ETA | PO02.01.0514 | 0514 | no | ETA 34
13769887 | 2.NP_SO-102 | 4040 | 0.0201032 | 2.03073 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 3000 | 3000 | 2.NP_SO-102 | 0 | 2920 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 34 | 99 | Odváděný | ETA | PO02.01.0515 | 0515 | no | ETA 34
13791103 | 1.NP_SO-102 | 5040 | 0.0201032 | 2.53338 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2975 | 2895 | 2895 | 1.NP_SO-102 | 0 | 2815 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 366 | Přívodní | SUP | PO02.01.0531 | 0531 | no | SUP 24
13791155 | 1.NP_SO-102 | 46.7957 | 0.0201032 | 0.0235221 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2975 | 2895 | 2895 | 1.NP_SO-102 | 0 | 2815 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 366 | Přívodní | SUP | PO02.01.0532 | 0532 | no | SUP 24
13791161 | 1.NP_SO-102 | 2987.99 | 0.0201032 | 1.50193 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2975 | 2895 | 2895 | 1.NP_SO-102 | 0 | 2815 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 370 | Přívodní | SUP | PO02.01.0533 | 0533 | no | SUP 24
13792986 | -1.PP_SO-102 | 6765.36 | 0.0397548 | 4.78215 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.53 | 3160.03 | 3160.03 | -1.PP_SO-102 | 0 | 3047.53 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 8 | 63 | Odváděný | ETA | PO02.01.0543 | 0543 | no | ETA 8 | Identifikační data - Komentáře: VZT 28
13794516 | -1.PP_SO-102 | 1331.31 | 0.0989649 | 1.48477 | 355 mm | 355 mm | 0 | 22.9216 | 0.611111 | 144828 | 6.1741 | 1.69599 | 1.27392 | 3277.5 | 3100 | 3100 | -1.PP_SO-102 | 0 | 2922.5 | Fáze 1 | 355 | Přívod vzduchu | 0.073991 | ODA 2 | 4 | Čerstvý | ODA | PO02.01.0550 | 0550 | yes | ODA 2
13794649 | -1.PP_SO-102 | 1331.31 | 0.0989649 | 1.48477 | 355 mm | 355 mm | 0 | 13.6867 | 0.472222 | 111912 | 4.77089 | 1.04207 | 0.78274 | 3255.5 | 3078 | 3078 | -1.PP_SO-102 | 0 | 2900.5 | Fáze 1 | 355 | Přívod vzduchu | 0.0761378 | ODA 1 | 6 | Čerstvý | ODA | PO02.01.0551 | 0551 | yes | ODA 1
13794997 | -1.PP_SO-102 | 30.3876 | 0.125636 | 0.0381862 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 2880 | 2880 | -1.PP_SO-102 | 0 | 2680 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 7 | 22 | Přívodní | SUP | PO02.01.0552 | 0552 | yes | SUP 7
13795246 | 1.NP_SO-102 | 3910 | 0.0989649 | 4.36069 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3365 | 3365 | -545 | 1.NP_SO-102 |  | -545 | Fáze 1 | 355 | Odváděný vzduch | 0 | EHA 2 | 4 | Znehodnocený | EHA | PO02.01.0553 | 0553 | yes | EHA 2
13797157 | 1.NP_SO-102 | 554.043 | 0.0779194 | 0.548282 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3252.5 | 3095 | 3095 | 1.NP_SO-102 | 0 | 2937.5 | Fáze 1 | 315 | Přívod vzduchu | 0 | SUP 24 | 559 | Přívodní | SUP | PO02.01.0559 | 0559 | yes | SUP 24
13797871 | 3.NP_SO-102 | 4045.92 | 0.0314112 | 2.54213 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3245.16 | 3145.16 | 3145.16 | 3.NP_SO-102 | 0 | 3045.16 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 9 | 422 | Přívodní | SUP | PO02.01.0561 | 0561 | no | SUP 9
13803133 | 2.NP_SO-102 | 6499.2 | 0.0314112 | 4.08357 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3280 | 3180 | 3180 | 2.NP_SO-102 | 0 | 3080 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 17 | 150 | Přívodní | SUP | PO02.01.0570 | 0570 | no | SUP 17
13803254 | 2.NP_SO-102 | 814.278 | 0.0314112 | 0.511626 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3280 | 3180 | 3180 | 2.NP_SO-102 | 0 | 3080 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 17 | 139 | Přívodní | SUP | PO02.01.0571 | 0571 | no | SUP 17
13803424 | 2.NP_SO-102 | 3324.14 | 0.0201032 | 1.6709 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3260 | 3180 | 3180 | 2.NP_SO-102 | 0 | 3100 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 17 | 126 | Přívodní | SUP | PO02.01.0572 | 0572 | no | SUP 17
13803606 | -1.PP_SO-102 | 7014.96 | 0.0989649 | 7.82355 | 355 mm | 385 mm | 15 | 0 | 0 | 0 | 0 | 0 | 0 | 3252.9 | 3075.4 | 3071.79 | -1.PP_SO-102 | 0.0514665 | 2894.29 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 27 | 172 | Odváděný | ETA | PO02.01.0575 | 0575 | yes | ETA 27 | Izolace - Typ izolace: Protipožární
13806033 | -1.PP_SO-102 | 100.458 | 0.0254431 | 0.0568074 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3170 | 3080 | 3080 | -1.PP_SO-102 | 0 | 2990 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 7 | 406 | Odváděný | ETA | PO02.01.0578 | 0578 | no | ETA 7 | Identifikační data - Komentáře: VZT18
13810141 | -1.PP_SO-102 | 195.059 | 0.0397548 | 0.137879 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.5 | 3160 | 3160 | -1.PP_SO-102 | 0 | 3047.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 8 | 52 | Odváděný | ETA | PO02.01.0597 | 0597 | yes | ETA 8 | Identifikační data - Komentáře: VZT 28
13810640 | -1.PP_SO-102 | 155.598 | 0.0989649 | 0.173534 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3277.5 | 3100 | 3100 | -1.PP_SO-102 | 0 | 2922.5 | Fáze 1 | 355 | Odváděný vzduch | 0 | EHA 2 | 4 | Znehodnocený | EHA | PO02.01.0600 | 0600 | yes | EHA 2
13810661 | -1.PP_SO-102 | 23.5526 | 0.0989649 | 0.0262674 | 355 mm | 355 mm | 0 | 22.9216 | 0.611111 | 144828 | 6.1741 | 0.0300043 | 1.27392 | 3277.5 | 3100 | 3100 | -1.PP_SO-102 | 0 | 2922.5 | Fáze 1 | 355 | Přívod vzduchu | 0.001309 | ODA 2 | 4 | Čerstvý | ODA | PO02.01.0601 | 0601 | yes | ODA 2
13810855 | -1.PP_SO-102 | 1136.68 | 0.0989649 | 1.2677 | 355 mm | 355 mm | 0 | 13.6867 | 0.472222 | 111912 | 4.77089 | 0.889729 | 0.78274 | 3255.5 | 3078 | 3078 | -1.PP_SO-102 | 0 | 2900.5 | Fáze 1 | 355 | Přívod vzduchu | 0.065007 | ODA 1 | 6 | Čerstvý | ODA | PO02.01.0603 | 0603 | yes | ODA 1
13810962 | -1.PP_SO-102 | 189.187 | 0.0989649 | 0.210994 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3254.64 | 3077.14 | 3077.14 | -1.PP_SO-102 | 0 | 2899.64 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 4 | 63 | Přívodní | SUP | PO02.01.0604 | 0604 | yes | SUP 4
13810978 | -1.PP_SO-102 | 123.449 | 0.0989649 | 0.137678 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3253.17 | 3075.67 | 3075.6 | -1.PP_SO-102 | 0.0514665 | 2898.1 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 27 | 172 | Odváděný | ETA | PO02.01.0605 | 0605 | yes | ETA 27
13814056 | -1.PP_SO-102 | 562.464 | 0.0989649 | 0.627297 | 355 mm | 355 mm | 0 | 22.9216 | 0.611111 | 144828 | 6.1741 | 0.716537 | 1.27392 | 3277.5 | 3100 | 3100 | -1.PP_SO-102 | 0 | 2922.5 | Fáze 1 | 355 | Přívod vzduchu | 0.0312603 | ODA 2 | 4 | Čerstvý | ODA | PO02.01.0606 | 0606 | yes | ODA 2
13817759 | 1.NP_SO-102 | 6509.1 | 0.0314112 | 4.08979 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -705 | -805 | -805 | 1.NP_SO-102 | 0 | -905 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 20 | 236 | Přívodní | SUP | PO02.01.0611 | 0611 | no | SUP 20 | Identifikační data - Komentáře: rozvody VZT dále vedené z úrovně 1.NP
13817804 | 1.NP_SO-102 | 81.7496 | 0.0314112 | 0.0513648 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3250 | 3150 | 3150 | 1.NP_SO-102 | 0 | 3050 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 13 | 224 | Přívodní | SUP | PO02.01.0612 | 0612 | no | SUP 13
13817821 | 1.NP_SO-102 | 30 | 0.04908 | 0.0235619 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3275 | 3150 | 3150 | 1.NP_SO-102 | 0 | 3025 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 13 | 58 | Přívodní | SUP | PO02.01.0613 | 0613 | yes | SUP 13
13817937 | 1.NP_SO-102 | 858.899 | 0.04908 | 0.674578 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3325.09 | 3200.09 | 3200.01 | 1.NP_SO-102 | 0.00958713 | 3075.01 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 9 | 364 | Přívodní | SUP | PO02.01.0614 | 0614 | no | SUP 9
13818067 | 1.NP_SO-102 | 164.451 | 0.04908 | 0.12916 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3325 | 3200 | 3200 | 1.NP_SO-102 | 0 | 3075 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 9 | 364 | Přívodní | SUP | PO02.01.0615 | 0615 | no | SUP 9
13818441 | 1.NP_SO-102 | 3489.63 | 0.0254431 | 1.97334 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2719.63 | 2719.63 | -770 | 1.NP_SO-102 |  | -770 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 7 | 161 | Odváděný | ETA | PO02.01.0616 | 0616 | no | ETA 7
13818679 | 1.NP_SO-102 | 1663.49 | 0.0201032 | 0.83616 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2983.77 | 2903.77 | 2903.77 | 1.NP_SO-102 | 0 | 2823.77 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 341 | Odváděný | ETA | PO02.01.0617 | 0617 | no | ETA 7
13818739 | 4.NP_SO-102 | 12599.2 | 0.0989649 | 14.0515 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2917.5 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 24 | 530 | Přívodní | SUP | PO02.01.0618 | 0618 | yes | SUP 24
13818773 | 4.NP_SO-102 | 16408.2 | 0.196306 | 25.774 | 500 mm | 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3345 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2845 | Fáze 1 | 500 | Přívod vzduchu | 0 | SUP 13 | 148 | Přívodní | SUP | PO02.01.0619 | 0619 | yes | SUP 13
13819737 | 3.NP_SO-102 | 3113.68 | 0.196306 | 4.89096 | 500 mm | 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3349.91 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 2849.91 | Fáze 1 | 500 | Přívod vzduchu | 0 | SUP 13 | 146 | Přívodní | SUP | PO02.01.0623 | 0623 | yes | SUP 13
13819759 | 3.NP_SO-102 | 2198.38 | 0.125636 | 2.76256 | 400 mm | 400 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3240 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2840 | Fáze 1 | 400 | Přívod vzduchu | 0 | SUP 1 | 43 | Přívodní | SUP | PO02.01.0624 | 0624 | yes | SUP 1
13819898 | 3.NP_SO-102 | 7183.62 | 0.0201032 | 3.61088 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2980 | 2900 | 2900 | 3.NP_SO-102 | 0 | 2820 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 13 | 242 | Přívodní | SUP | PO02.01.0625 | 0625 | no | SUP 13
13819911 | 3.NP_SO-102 | 3016.26 | 0.159008 | 4.26414 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3324.91 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 2874.91 | Fáze 1 | 450 | Přívod vzduchu | 0 | SUP 13 | 145 | Přívodní | SUP | PO02.01.0626 | 0626 | yes | SUP 13
13820291 | 2.NP_SO-102 | 1681.61 | 0.159008 | 2.37731 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3265 | 3040 | 3040 | 2.NP_SO-102 | 0 | 2815 | Fáze 1 | 450 | Přívod vzduchu | 0 | SUP 24 | 24 | Přívodní | SUP | PO02.01.0627 | 0627 | yes | SUP 24
13820312 | 2.NP_SO-102 | 1630.31 | 0.159008 | 2.30479 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3305 | 3080 | 3080 | 2.NP_SO-102 | 0 | 2855 | Fáze 1 | 450 | Přívod vzduchu | 0 | SUP 13 | 122 | Přívodní | SUP | PO02.01.0628 | 0628 | yes | SUP 13
13820358 | 2.NP_SO-102 | 249.958 | 0.0989649 | 0.27877 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3117.5 | 2940 | 2940 | 2.NP_SO-102 | 0 | 2762.5 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 9 | 383 | Přívodní | SUP | PO02.01.0629 | 0629 | yes | SUP 9
13820798 | 2.NP_SO-102 | 92.0338 | 0.159008 | 0.13011 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2989 | 2764 | 2764 | 2.NP_SO-102 | 0 | 2539 | Fáze 1 | 450 | Zpětný vzduch | 0 | ETA 12 | 114 | Odváděný | ETA | PO02.01.0633 | 0633 | yes | ETA 12
13820812 | 2.NP_SO-102 | 83.3679 | 0.159008 | 0.117859 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2989 | 2764 | 2764 | 2.NP_SO-102 | 0 | 2539 | Fáze 1 | 450 | Přívod vzduchu | 0 | SUP 17 | 158 | Přívodní | SUP | PO02.01.0634 | 0634 | yes | SUP 17
13837754 | 3.NP_SO-102 | 82.5403 | 0.04908 | 0.064827 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3165 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2915 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 1 | 258 | Přívodní | SUP | PO02.01.0669 | 0669 | no | SUP 1
13837771 | 3.NP_SO-102 | 2504.03 | 0.0397548 | 1.77 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3152.5 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2927.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 1 | 252 | Přívodní | SUP | PO02.01.0670 | 0670 | yes | SUP 1
13837899 | 3.NP_SO-102 | 7120.63 | 0.04908 | 5.59253 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3165 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2915 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 1 | 306 | Přívodní | SUP | PO02.01.0671 | 0671 | no | SUP 1
13837901 | 3.NP_SO-102 | 365.295 | 0.04908 | 0.286902 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3165 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2915 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 1 | 300 | Přívodní | SUP | PO02.01.0672 | 0672 | no | SUP 1
13837905 | 3.NP_SO-102 | 198.386 | 0.04908 | 0.155812 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3165 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2915 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 1 | 300 | Přívodní | SUP | PO02.01.0673 | 0673 | no | SUP 1
13837936 | 3.NP_SO-102 | 5679.3 | 0.0989649 | 6.33393 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3217.5 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2862.5 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 1 | 170 | Přívodní | SUP | PO02.01.0674 | 0674 | yes | SUP 1
13838107 | 3.NP_SO-102 | 985.389 | 0.0254431 | 0.557224 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3190 | 3100 | 3100 | 3.NP_SO-102 | 0 | 3010 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 13 | 191 | Přívodní | SUP | PO02.01.0676 | 0676 | no | SUP 13
13838116 | 3.NP_SO-102 | 6489 | 0.0254431 | 3.66945 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3190 | 3100 | 3100 | 3.NP_SO-102 | 0 | 3010 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 13 | 191 | Přívodní | SUP | PO02.01.0677 | 0677 | no | SUP 13
13847407 | 2.NP_SO-102 | 6297.05 | 0.159008 | 8.90224 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3305 | 3080 | 3080 | 2.NP_SO-102 | 0 | 2855 | Fáze 1 | 450 | Přívod vzduchu | 0 | SUP 13 | 122 | Přívodní | SUP | PO02.01.0747 | 0747 | yes | SUP 13
13847757 | 4.NP_SO-102 | 6341.06 | 0.196306 | 9.96051 | 500 mm | 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3345 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2845 | Fáze 1 | 500 | Přívod vzduchu | 0 | SUP 13 | 148 | Přívodní | SUP | PO02.01.0748 | 0748 | yes | SUP 13
13847809 | 4.NP_SO-102 | 2370.27 | 0.0989649 | 2.64348 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2917.5 | Fáze 2 | 355 | Přívod vzduchu | 0 | SUP 18 | 132 | Přívodní | SUP | PO02.01.0749 | 0749 | yes | SUP 18 | Identifikační data - Komentáře: PŘIPOJENÍ PŘÍVODNÍHO POTRUBÍ V II.ETAPĚ VÝSTAVBY
13848514 | 3.NP_SO-102 | 6168.03 | 0.196306 | 9.68872 | 500 mm | 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3349.91 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 2849.91 | Fáze 1 | 500 | Přívod vzduchu | 0 | SUP 13 | 146 | Přívodní | SUP | PO02.01.0750 | 0750 | yes | SUP 13
13848717 | 4.NP_SO-102 | 1643.94 | 0.0397548 | 1.16204 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 2 | 225 | Přívod vzduchu | 0 | SUP 24 | 164 | Přívodní | SUP | PO02.01.0751 | 0751 | no | SUP 24
13848766 | 4.NP_SO-102 | 1300.69 | 0.159008 | 1.8388 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3320 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2870 | Fáze 1 | 450 | Přívod vzduchu | 0 | SUP 24 | 443 | Přívodní | SUP | PO02.01.0752 | 0752 | yes | SUP 24
13848827 | 4.NP_SO-102 | 22.6305 | 0.196306 | 0.0355479 | 500 mm | 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3345 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2845 | Fáze 1 | 500 | Přívod vzduchu | 0 | SUP 13 | 148 | Přívodní | SUP | PO02.01.0753 | 0753 | yes | SUP 13 | Identifikační data - Komentáře: VZT19
13848862 | 3.NP_SO-102 | 1705.36 | 0.0989649 | 1.90192 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.5 | 3095 | 3095 | 3.NP_SO-102 | 0 | 2917.5 | Fáze 2 | 355 | Přívod vzduchu | 0 | SUP 24 | 488 | Přívodní | SUP | PO02.01.0754 | 0754 | yes | SUP 24
13848916 | 3.NP_SO-102 | 1221.78 | 0.196306 | 1.91917 | 500 mm | 500 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3349.91 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 2849.91 | Fáze 1 | 500 | Přívod vzduchu | 0 | SUP 13 | 143 | Přívodní | SUP | PO02.01.0755 | 0755 | yes | SUP 13
13848951 | 3.NP_SO-102 | 1202 | 0.246291 | 2.11466 | 560 mm | 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3320 | 3040 | 3040 | 3.NP_SO-102 | 0 | 2760 | Fáze 1 | 560 | Přívod vzduchu | 0 | SUP 24 | 147 | Přívodní | SUP | PO02.01.0756 | 0756 | yes | SUP 24
13849903 | 2.NP_SO-102 | 1247.69 | 0.159008 | 1.76388 | 450 mm | 450 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3320 | 3095 | 3095 | 2.NP_SO-102 | 0 | 2870 | Fáze 2 | 450 | Přívod vzduchu | 0 | SUP 24 | 80 | Přívodní | SUP | PO02.01.0757 | 0757 | yes | SUP 24
13850039 | 2.NP_SO-102 | 1218.91 | 0.246291 | 2.14442 | 560 mm | 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3320 | 3039.84 | 3040 | 2.NP_SO-102 | 0.0128468 | 2759.84 | Fáze 1 | 560 | Přívod vzduchu | 0 | SUP 24 | 14 | Přívodní | SUP | PO02.01.0758 | 0758 | yes | SUP 24
13850053 | 2.NP_SO-102 | 1045 | 0.246291 | 1.83846 | 560 mm | 560 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3360 | 3080 | 3080 | 2.NP_SO-102 | 0 | 2800 | Fáze 1 | 560 | Přívod vzduchu | 0 | SUP 13 | 99 | Přívodní | SUP | PO02.01.0759 | 0759 | yes | SUP 13
13850306 | -1.PP_SO-102 | 112.968 | 0.0989649 | 0.125989 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3254.64 | 3077.14 | 3077.14 | -1.PP_SO-102 | 0 | 2899.64 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 4 | 50 | Přívodní | SUP | PO02.01.0761 | 0761 | yes | SUP 4
13850332 | -1.PP_SO-102 | 143.344 | 0.0989649 | 0.159867 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3247.98 | 3070.41 | 3070.48 | -1.PP_SO-102 | 0.0486157 | 2892.91 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 27 | 173 | Odváděný | ETA | PO02.01.0762 | 0762 | yes | ETA 27
13853519 | 1.NP_SO-102 | 23.5296 | 0.0314112 | 0.0147841 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3195 | 3095 | 3095 | 1.NP_SO-102 | 0 | 2995 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 20 | 236 | Přívodní | SUP | PO02.01.0765 | 0765 | no | SUP 20
13864334 | 1.NP_SO-102 | 5318.3 | 0.0201032 | 2.67327 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3280.1 | 3200.1 | 3200.1 | 1.NP_SO-102 | 0 | 3120.1 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 9 | 352 | Přívodní | SUP | PO02.01.0776 | 0776 | no | SUP 9
13864347 | 1.NP_SO-102 | 59.764 | 0.04908 | 0.0469385 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3325.1 | 3200.1 | 3200.1 | 1.NP_SO-102 | 0 | 3075.1 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 9 | 364 | Přívodní | SUP | PO02.01.0777 | 0777 | no | SUP 9
13864870 | 2.NP_SO-102 | 5904.25 | 0.04908 | 4.63718 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3065 | 2940 | 2940 | 2.NP_SO-102 | 0 | 2815 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 9 | 493 | Přívodní | SUP | PO02.01.0778 | 0778 | no | SUP 9
13866689 | 4.NP_SO-102 | 151.966 | 0.0254431 | 0.0859347 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3185 | 3095 | 3095 | 4.NP_SO-102 | 0 | 3005 | Fáze 2 | 180 | Přívod vzduchu | 0 | SUP 18 | 166 | Přívodní | SUP | PO02.01.0795 | 0795 | no | SUP 18
13866812 | 4.NP_SO-102 | 878.724 | 0.04908 | 0.690148 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3220 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2970 | Fáze 2 | 250 | Přívod vzduchu | 0 | SUP 18 | 171 | Přívodní | SUP | PO02.01.0796 | 0796 | no | SUP 18
13866873 | 4.NP_SO-102 | 425.105 | 0.04908 | 0.333876 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3220 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2970 | Fáze 2 | 250 | Přívod vzduchu | 0 | SUP 18 | 161 | Přívodní | SUP | PO02.01.0797 | 0797 | no | SUP 18
13866887 | 4.NP_SO-102 | 32.6348 | 0.04908 | 0.0256313 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3220 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2970 | Fáze 2 | 250 | Přívod vzduchu | 0 | SUP 18 | 161 | Přívodní | SUP | PO02.01.0798 | 0798 | no | SUP 18
13866902 | 4.NP_SO-102 | 2322.69 | 0.0989649 | 2.59042 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2917.5 | Fáze 2 | 355 | Přívod vzduchu | 0 | SUP 18 | 143 | Přívodní | SUP | PO02.01.0799 | 0799 | yes | SUP 18
13867157 | 4.NP_SO-102 | 683.781 | 0.0254431 | 0.386669 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3185 | 3095 | 3095 | 4.NP_SO-102 | 0 | 3005 | Fáze 2 | 180 | Přívod vzduchu | 0 | SUP 18 | 149 | Přívodní | SUP | PO02.01.0800 | 0800 | no | SUP 18
13867210 | 4.NP_SO-102 | 629.813 | 0.0254431 | 0.356151 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3185 | 3095 | 3095 | 4.NP_SO-102 | 0 | 3005 | Fáze 2 | 180 | Přívod vzduchu | 0 | SUP 18 | 149 | Přívodní | SUP | PO02.01.0801 | 0801 | yes | SUP 18
13867277 | 4.NP_SO-102 | 608.615 | 0.0254431 | 0.344164 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3185 | 3095 | 3095 | 4.NP_SO-102 | 0 | 3005 | Fáze 2 | 180 | Přívod vzduchu | 0 | SUP 18 | 152 | Přívodní | SUP | PO02.01.0802 | 0802 | no | SUP 18
13867314 | 4.NP_SO-102 | 104.788 | 0.04908 | 0.0823001 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3220 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2970 | Fáze 2 | 250 | Přívod vzduchu | 0 | SUP 18 | 171 | Přívodní | SUP | PO02.01.0803 | 0803 | no | SUP 18
13867372 | 4.NP_SO-102 | 679.705 | 0.04908 | 0.533839 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3220 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2970 | Fáze 2 | 250 | Přívod vzduchu | 0 | SUP 18 | 157 | Přívodní | SUP | PO02.01.0804 | 0804 | no | SUP 18
13867433 | 4.NP_SO-102 | 474.92 | 0.0397548 | 0.335701 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 151 | Přívodní | SUP | PO02.01.0805 | 0805 | no | SUP 13
13867450 | 4.NP_SO-102 | 142.888 | 0.0397548 | 0.101002 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 151 | Přívodní | SUP | PO02.01.0806 | 0806 | no | SUP 13
