Properties of the parts of a building model (IFC4), part 19 of 45

# IfcBuildingElementProxy: Regulátor průtoku vzduchu kruhový.LH:225x500 (12)
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 225x500; Označení typu: 39; Popis: Regulátor průtoku kruhový; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu kruhový.LH
Classification: RG04 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.43294 m2; NetVolume: 0.0198794 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 225 mm-225 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 225 mm-225 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Připojení ELEKTRO: no; Připojení MaR: no
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0198794 m3; Plocha: 0.25087 m2; Velikost: 225-225
Jiné - Rodina: Regulátor průtoku vzduchu kruhový.LH; Id typu: 13840784; Rodina a typ: Regulátor průtoku vzduchu kruhový.LH: 225x500; Typ: 225x500
Name (Regulátor průtoku vzduchu kruhový.LH:225x500:...) | In | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13866810 | 4.NP_SO-102 | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | RG04.39.0142 | 0142
13871203 | 3.NP_SO-102 | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | RG04.39.0180 | 0180 | Jiné - Páteřní trasa: yes
13877537 | 2.NP_SO-102 | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.39.0218 | 0218 | Jiné - Páteřní trasa: yes
13878209 | 2.NP_SO-102 | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | RG04.39.0229 | 0229
13885011 | 3.NP_SO-102 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | RG04.39.0258 | 0258
13885111 | 3.NP_SO-102 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | RG04.39.0260 | 0260
13885403 | 3.NP_SO-102 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | RG04.39.0261 | 0261
13965321 | -1.PP_SO-102 | -1.PP_SO-102 | 2350 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | RG04.39.0359 | 0359
13966616 | -1.PP_SO-102 | -1.PP_SO-102 | 2700 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 27 | SUP | RG04.39.0363 | 0363
13989320 | -1.PP_SO-102 | -1.PP_SO-102 | 3077.14 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 25 | SUP | RG04.39.0380 | 0380
14051726 | 2.NP_SO-102 | 2.NP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | RG04.39.0418 | 0418
14052766 | 2.NP_SO-102 | 2.NP_SO-102 | 3010 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | RG04.39.0420 | 0420

# IfcBuildingElementProxy: Regulátor průtoku vzduchu kruhový.LH:250x500 (16)
Type - Material: 0-0-255
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu: 250 mm; Jmenovitá velikost výstupu: 250 mm; Průměr: 250 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 250x500; Označení typu: 46; Popis: Regulátor průtoku kruhový; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu kruhový.LH
Classification: RG04 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.490861 m2; NetVolume: 0.0245425 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 250 mm-250 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 250 mm-250 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Připojení ELEKTRO: no; Připojení MaR: no
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0245425 m3; Plocha: 0.28183 m2; Velikost: 250-250
Jiné - Rodina: Regulátor průtoku vzduchu kruhový.LH; Id typu: 13866578; Rodina a typ: Regulátor průtoku vzduchu kruhový.LH: 250x500; Typ: 250x500
Name (Regulátor průtoku vzduchu kruhový.LH:250x500:...) | In | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13875772 | 2.NP_SO-102 | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.46.0206 | 0206 | Jiné - Páteřní trasa: yes
13875834 | 2.NP_SO-102 | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.46.0207 | 0207
13875870 | 2.NP_SO-102 | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 42 | SUP | RG04.46.0208 | 0208 | Jiné - Páteřní trasa: yes
13876929 | 2.NP_SO-102 | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.46.0215 | 0215
13877612 | 2.NP_SO-102 | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 56 | SUP | RG04.46.0219 | 0219
13877656 | 2.NP_SO-102 | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 58 | SUP | RG04.46.0220 | 0220
13877719 | 2.NP_SO-102 | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 60 | SUP | RG04.46.0221 | 0221
13884107 | 3.NP_SO-102 | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.46.0249 | 0249 | Jiné - Páteřní trasa: yes
13884245 | 3.NP_SO-102 | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.46.0250 | 0250 | Jiné - Páteřní trasa: yes
13884428 | 3.NP_SO-102 | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.46.0251 | 0251
13885439 | 3.NP_SO-102 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | RG04.46.0262 | 0262
13885545 | 3.NP_SO-102 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | RG04.46.0263 | 0263
13959379 | -1.PP_SO-102 | -1.PP_SO-102 | 3080 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | RG04.46.0348 | 0348
13959413 | -1.PP_SO-102 | -1.PP_SO-102 | 3080 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | RG04.46.0349 | 0349 | Jiné - Páteřní trasa: yes
13959918 | -1.PP_SO-102 | -1.PP_SO-102 | 2900 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | RG04.46.0353 | 0353 | Jiné - Páteřní trasa: yes
14138309 | -1.PP_SO-102 | -1.PP_SO-102 | 2747.5 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.46.0457 | 0457 | Jiné - Páteřní trasa: yes

# IfcBuildingElementProxy: Regulátor průtoku vzduchu kruhový.LH:315x1000 (2)
In: 1.NP_SO-102
Type - Material: 0-0-255
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu: 315 mm; Jmenovitá velikost výstupu: 315 mm; Průměr: 315 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 315x1000; Označení typu: 49; Popis: Regulátor průtoku kruhový; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu kruhový.LH
Classification: RG04 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.650642 m2; NetVolume: 0.0389637 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 315 mm-315 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 315 mm-315 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: 1.NP_SO-102; Připojení ELEKTRO: no; Připojení MaR: no
Fázování - Fáze vytvoření: Fáze 2
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0389637 m3; Plocha: 0.366921 m2; Velikost: 315-315
Jiné - Rodina: Regulátor průtoku vzduchu kruhový.LH; Id typu: 13909416; Rodina a typ: Regulátor průtoku vzduchu kruhový.LH: 315x1000; Typ: 315x1000
Name (Regulátor průtoku vzduchu kruhový.LH:315x1000:...) | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13909449 | 3100 | Přívodní | Přívod vzduchu | SUP 12 | SUP | RG04.49.0283 | 0283
13914103 | 2740 | Odváděný | Zpětný vzduch | ETA 17 | ETA | RG04.49.0299 | 0299

# IfcBuildingElementProxy: Regulátor průtoku vzduchu kruhový.LH:355x500 (6)
Type - Material: 0-0-255
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu: 355 mm; Jmenovitá velikost výstupu: 355 mm; Průměr: 355 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 355x500; Označení typu: 47; Popis: Regulátor průtoku kruhový; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu kruhový.LH
Classification: RG04 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.755566 m2; NetVolume: 0.0494876 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 355 mm-355 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 355 mm-355 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Připojení ELEKTRO: no; Připojení MaR: no
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0494876 m3; Plocha: 0.422583 m2; Velikost: 355-355
Jiné - Rodina: Regulátor průtoku vzduchu kruhový.LH; Id typu: 13908368; Rodina a typ: Regulátor průtoku vzduchu kruhový.LH: 355x500; Typ: 355x500
Name (Regulátor průtoku vzduchu kruhový.LH:355x500:...) | In | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení | Páteřní trasa
13908401 | 1.NP_SO-102 | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | RG04.47.0278 | 0278
13911687 | 1.NP_SO-102 | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | RG04.47.0294 | 0294 | yes
13930796 | 2.NP_SO-102 | 2.NP_SO-102 | 2940 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | RG04.47.0318 | 0318 | yes
13935714 | 2.NP_SO-102 | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | RG04.47.0326 | 0326 | yes
13936808 | 2.NP_SO-102 | 2.NP_SO-102 | 2850 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | RG04.47.0331 | 0331 | yes
14051087 | 2.NP_SO-102 | 2.NP_SO-102 | 2910 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | RG04.47.0416 | 0416 | yes

# IfcBuildingElementProxy: Systemair_CWK_400-3-2_5_RFA_2021_LevelBased:CWK 315-3-2,5, Systemair_CWK_400-3-2_5_RFA_2021_LevelBased:CWK 315-3-2,5:14080755
In: -1.PP_SO-102
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - QmdConnectorList: 201;D;202;D
Type - Grafika - CAT0: yes
Type - Kóty - CAT: 0; CB: 560 mm; CB1: 280 mm; CH: 504 mm; CH1: 252 mm; D: 315 mm; DY: 22 mm; E: 15 mm; F: 400 mm; G: 40 mm; H2D: 504 mm; L: 276 mm; L1: 138 mm; L2D: 276 mm; W2D: 560 mm
Type - Identifikační data - Kód sestavy: CH01; magiPartTypeId: 206; magiProductCode: CWK 315-3-2,5; magiProductFamilyId: CWK *-3-2,5; magiProductId: CWK 315-3-2,5; Název typu: CWK 315-3-2,5; Označení typu: 68; Popis: Duct cooler for duct installation, circular; Popis sestavy: Vodní; URL: www.systemair.com/global; VersionID: 2.0/2021.6.24.1/SYSTEMAIR_CWK_Q13_001; Výrobce: Systemair
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Systemair_CWK_400-3-2_5_RFA_2021_LevelBased
Classification: CH01 Uniformat (Uniformat); Group: SUP 4
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.15181 m2; NetVolume: 0.0778982 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 315 mm-315 mm
Izolace - Celková velikost: 345 mm-345 mm; Tloušťka izolace: 15 mm; Typ izolace: Protipožární
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: EQC; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Výška od podlaží: 3077.14 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 4; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes
Kóty - ang2D: 0 deg; Objem: 0.0778982 m3; Plocha: 0.577161 m2; Velikost: 315-315
Identifikační data - ID systému: Potrubní chladič - externí; Kód prvku: CH01.68.0449; Označení: 0449; Productdata: © MagiCAD Group, all rights reserved
Jiné - Páteřní trasa: yes; Rodina: Systemair_CWK_400-3-2_5_RFA_2021_LevelBased; Id typu: 14080476; Rodina a typ: Systemair_CWK_400-3-2_5_RFA_2021_LevelBased: CWK 315-3-2,5; Typ: CWK 315-3-2,5

# IfcBuildingElementProxy: Systemair_CWK_400-3-2_5_RFA_2021_LevelBased:CWK 400-3-2,5, Systemair_CWK_400-3-2_5_RFA_2021_LevelBased:CWK 400-3-2,5:14080667
In: -1.PP_SO-102
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - QmdConnectorList: 201;D;202;D
Type - Grafika - CAT0: yes
Type - Kóty - CAT: 0; CB: 710 mm; CB1: 355 mm; CH: 529 mm; CH1: 264.5 mm; D: 400 mm; DY: 22 mm; E: 15 mm; F: 425 mm; G: 65 mm; H2D: 529 mm; L: 330 mm; L1: 165 mm; L2D: 330 mm; W2D: 710 mm
Type - Identifikační data - Kód sestavy: CH01; magiPartTypeId: 206; magiProductCode: CWK 400-3-2,5; magiProductFamilyId: CWK *-3-2,5; magiProductId: CWK 400-3-2,5; Název typu: CWK 400-3-2,5; Označení typu: 67; Popis: Duct cooler for duct installation, circular; Popis sestavy: Vodní; URL: www.systemair.com/global; VersionID: 2.0/2021.6.24.1/SYSTEMAIR_CWK_Q13_001; Výrobce: Systemair
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Systemair_CWK_400-3-2_5_RFA_2021_LevelBased
Classification: CH01 Uniformat (Uniformat); Group: SUP 7
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.56892 m2; NetVolume: 0.123945 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 400 mm-400 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 400 mm-400 mm
Text - CCI Funkční systém: J; CCI Komponenta: EQC; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Výška od podlaží: 2880 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 7; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes
Kóty - ang2D: 0 deg; Objem: 0.123945 m3; Plocha: 0.785717 m2; Velikost: 400-400
Identifikační data - ID systému: Potrubní chladič - externí; Kód prvku: CH01.67.0448; Označení: 0448; Productdata: © MagiCAD Group, all rights reserved
Jiné - Páteřní trasa: yes; Id typu: 14080474; Rodina: Systemair_CWK_400-3-2_5_RFA_2021_LevelBased; Rodina a typ: Systemair_CWK_400-3-2_5_RFA_2021_LevelBased: CWK 400-3-2,5; Typ: CWK 400-3-2,5

# IfcBuildingElementProxy: TLUMIČ HLUKU LDR.CC:500x200x1000 (3)
Type - Material: 255-0-0
Type - Mechanické – tok - PRŮTOK: 0 m3/s; TLAKOVÝ SPÁD: 0 Pa
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - DÉLKA: 1000 mm; POTRUBÍ_ŠÍŘKA: 500 mm; POTRUBÍ_VÝŠKA: 200 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.27; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: TC02; Komentáře k typům: Komentáře k typům; Model: Model; Nadpis OmniClass: Sound Attenuators; Název typu: 500x200x1000; Označení typu: 31; Popis: Popis; Popis sestavy: Akustický; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství potrubí; KJS: no; PK: yes; l: 1000 mm; Název rodiny: TLUMIČ HLUKU LDR.CC; Píruba_Šířka: 20 mm
Classification: TC02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.12464 m2; NetVolume: 0.100518 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 500 mm × 200 mm-500 mm × 200 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 500 mm × 200 mm-500 mm × 200 mm
Výsledky analýzy - PLOCHA IZOLACE: 0 m2; PLOCHA PLECHU: 1.4 m2
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Výška od podlaží: 3200 mm
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes
Kóty - TLOUŠŤKA IZOLACE: 0 mm; Objem: 0.100518 m3; Velikost: 500 × 200-500 × 200
Jiné - Rodina: TLUMIČ HLUKU LDR.CC; Id typu: 13838225; Rodina a typ: TLUMIČ HLUKU LDR.CC: 500x200x1000; Typ: 500x200x1000
Name (TLUMIČ HLUKU LDR.CC:500x200x1000:...) | In | Podlaží | Fáze vytvoření | Název systému = Group | Kód prvku | Označení
13838181 | 3.NP_SO-102 | 3.NP_SO-102 | Fáze 1 | ETA 51 | TC02.31.0072 | 0072
13838351 | 3.NP_SO-102 | 3.NP_SO-102 | Fáze 1 | ETA 64 | TC02.31.0073 | 0073
13838841 | 4.NP_SO-102 | 4.NP_SO-102 | Fáze 2 | ETA 67 | TC02.31.0088 | 0088

# IfcBuildingElementProxy: TLUMIČ HLUKU LDR.CC:500x300x1000 (18)
Type - Material: 255-0-0
Type - Mechanické – tok - PRŮTOK: 0 m3/s; TLAKOVÝ SPÁD: 0 Pa
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - DÉLKA: 1000 mm; POTRUBÍ_ŠÍŘKA: 500 mm; POTRUBÍ_VÝŠKA: 300 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.27; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: TC02; Komentáře k typům: Komentáře k typům; Model: Model; Nadpis OmniClass: Sound Attenuators; Název typu: 500x300x1000; Označení typu: 30; Popis: Popis; Popis sestavy: Akustický; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství potrubí; KJS: no; PK: yes; l: 1000 mm; Název rodiny: TLUMIČ HLUKU LDR.CC; Píruba_Šířka: 20 mm
Classification: TC02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.64144 m2; NetVolume: 0.150734 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 500 mm × 300 mm-500 mm × 300 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 500 mm × 300 mm-500 mm × 300 mm
Výsledky analýzy - PLOCHA IZOLACE: 0 m2; PLOCHA PLECHU: 1.6 m2
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes
Kóty - TLOUŠŤKA IZOLACE: 0 mm; Objem: 0.150734 m3; Velikost: 500 × 300-500 × 300
Jiné - Rodina: TLUMIČ HLUKU LDR.CC; Id typu: 13837985; Rodina a typ: TLUMIČ HLUKU LDR.CC: 500x300x1000; Typ: 500x300x1000
Name (TLUMIČ HLUKU LDR.CC:500x300x1000:...) | In | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Kód prvku | Označení
13837967 | 3.NP_SO-102 | 3.NP_SO-102 | 3200 | Fáze 1 | ETA 49 | TC02.30.0070 | 0070
13838144 | 3.NP_SO-102 | 3.NP_SO-102 | 3100 | Fáze 1 | ETA 50 | TC02.30.0071 | 0071
13838435 | 4.NP_SO-102 | 4.NP_SO-102 | 3200 | Fáze 1 | ETA 55 | TC02.30.0076 | 0076
13838447 | 4.NP_SO-102 | 4.NP_SO-102 | 3200 | Fáze 1 | ETA 56 | TC02.30.0077 | 0077
13838622 | 2.NP_SO-102 | 2.NP_SO-102 | 3200 | Fáze 1 | ETA 90 | TC02.30.0085 | 0085
13838634 | 2.NP_SO-102 | 2.NP_SO-102 | 3200 | Fáze 1 | ETA 65 | TC02.30.0086 | 0086
13838813 | 4.NP_SO-102 | 4.NP_SO-102 | 3200 | Fáze 2 | ETA 66 | TC02.30.0087 | 0087
13839100 | 4.NP_SO-102 | 4.NP_SO-102 | 3200 | Fáze 2 | ETA 71 | TC02.30.0091 | 0091
13839115 | 4.NP_SO-102 | 4.NP_SO-102 | 3200 | Fáze 2 | ETA 72 | TC02.30.0092 | 0092
13865063 | 1.NP_SO-102 | 1.NP_SO-102 | 3200 | Fáze 1 | ETA 92 | TC02.30.0136 | 0136
13865147 | 1.NP_SO-102 | 1.NP_SO-102 | 3200 | Fáze 1 | ETA 93 | TC02.30.0137 | 0137
13865164 | 1.NP_SO-102 | 1.NP_SO-102 | 3200 | Fáze 1 | ETA 94 | TC02.30.0138 | 0138
13865179 | 1.NP_SO-102 | 1.NP_SO-102 | 3200 | Fáze 1 | ETA 95 | TC02.30.0139 | 0139
13979810 | 3.NP_SO-102 | 3.NP_SO-102 | 3200 | Fáze 2 | ETA 33 | TC02.30.0367 | 0367
13985597 | 3.NP_SO-102 | 3.NP_SO-102 | 3200 | Fáze 2 | ETA 89 | TC02.30.0376 | 0376
14039737 | 1.NP_SO-102 | 1.NP_SO-102 | 3200 | Fáze 1 | ETA 98 | TC02.30.0409 | 0409
14040447 | 1.NP_SO-102 | 1.NP_SO-102 | 3200 | Fáze 1 | ETA 98 | TC02.30.0410 | 0410
14059535 | -1.PP_SO-102 | -1.PP_SO-102 | 3200 | Fáze 1 | ETA 99 | TC02.30.0428 | 0428

# IfcBuildingElementProxy: TLUMIČ HLUKU LDR.CC:800x300x1000 (37)
Type - Material: 255-0-0
Type - Mechanické – tok - PRŮTOK: 0 m3/s; TLAKOVÝ SPÁD: 0 Pa
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - DÉLKA: 1000 mm; POTRUBÍ_ŠÍŘKA: 800 mm; POTRUBÍ_VÝŠKA: 300 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.27; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: TC02; Komentáře k typům: Komentáře k typům; Model: Model; Nadpis OmniClass: Sound Attenuators; Název typu: 800x300x1000; Označení typu: 29; Popis: Popis; Popis sestavy: Akustický; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Příslušenství potrubí; KJS: no; l: 1000 mm; Název rodiny: TLUMIČ HLUKU LDR.CC; Píruba_Šířka: 20 mm; PK: yes
Classification: TC02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.83184 m2; NetVolume: 0.241142 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 800 mm × 300 mm-800 mm × 300 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 800 mm × 300 mm-800 mm × 300 mm
Výsledky analýzy - PLOCHA IZOLACE: 0 m2; PLOCHA PLECHU: 2.2 m2
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Výška od podlaží: 3200 mm
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes
Kóty - Objem: 0.241142 m3; TLOUŠŤKA IZOLACE: 0 mm; Velikost: 800 × 300-800 × 300
Jiné - Id typu: 13836991; Rodina: TLUMIČ HLUKU LDR.CC; Rodina a typ: TLUMIČ HLUKU LDR.CC: 800x300x1000; Typ: 800x300x1000
Name (TLUMIČ HLUKU LDR.CC:800x300x1000:...) | In | Tlaková ztráta (Pa) | Podlaží | Fáze vytvoření | Název systému = Group | Kód prvku | Označení
13836770 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | ETA 39 | TC02.29.0059 | 0059
13837340 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | ETA 38 | TC02.29.0060 | 0060
13837357 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | ETA 40 | TC02.29.0061 | 0061
13837372 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 1 | ETA 41 | TC02.29.0062 | 0062
13837434 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | ETA 42 | TC02.29.0063 | 0063
13837437 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | ETA 44 | TC02.29.0064 | 0064
13837440 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | ETA 46 | TC02.29.0065 | 0065
13837443 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | ETA 48 | TC02.29.0066 | 0066
13837535 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | ETA 43 | TC02.29.0067 | 0067
13837584 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | ETA 45 | TC02.29.0068 | 0068
13837597 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | ETA 47 | TC02.29.0069 | 0069
13838385 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | ETA 53 | TC02.29.0074 | 0074
13838400 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 1 | ETA 54 | TC02.29.0075 | 0075
13838477 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | ETA 57 | TC02.29.0078 | 0078
13838489 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | ETA 58 | TC02.29.0079 | 0079
13838511 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | ETA 59 | TC02.29.0080 | 0080
13838536 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | ETA 60 | TC02.29.0081 | 0081
13838563 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | ETA 61 | TC02.29.0082 | 0082
13838575 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | ETA 62 | TC02.29.0083 | 0083
13838587 | 2.NP_SO-102 | 0 | 2.NP_SO-102 | Fáze 1 | ETA 63 | TC02.29.0084 | 0084
13839003 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 2 | ETA 69 | TC02.29.0089 | 0089
13839037 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 2 | ETA 70 | TC02.29.0090 | 0090
13839231 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | ETA 73 | TC02.29.0093 | 0093
13839367 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | ETA 74 | TC02.29.0094 | 0094
13839547 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | ETA 75 | TC02.29.0095 | 0095
13839560 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | ETA 76 | TC02.29.0096 | 0096
13839675 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | ETA 78 | TC02.29.0097 | 0097
13839690 | 3.NP_SO-102 | 0 | 3.NP_SO-102 | Fáze 2 | ETA 79 | TC02.29.0098 | 0098
13839718 | 2.NP_SO-102 |  | 2.NP_SO-102 | Fáze 2 | ETA 80 | TC02.29.0099 | 0099
13839751 | 2.NP_SO-102 |  | 2.NP_SO-102 | Fáze 2 | ETA 81 | TC02.29.0100 | 0100
13839764 | 2.NP_SO-102 |  | 2.NP_SO-102 | Fáze 2 | ETA 82 | TC02.29.0101 | 0101
13839777 | 2.NP_SO-102 |  | 2.NP_SO-102 | Fáze 2 | ETA 83 | TC02.29.0102 | 0102
13839810 | 2.NP_SO-102 |  | 2.NP_SO-102 | Fáze 2 | ETA 84 | TC02.29.0103 | 0103
13839823 | 2.NP_SO-102 |  | 2.NP_SO-102 | Fáze 2 | ETA 85 | TC02.29.0104 | 0104
13840027 | 1.NP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | ETA 29 | TC02.29.0105 | 0105 | Identifikační data - ID systému: PT
13903908 | 1.NP_SO-102 | 0 | 1.NP_SO-102 | Fáze 1 | ETA 6 | TC02.29.0276 | 0276 | Fázování - Bouráno ve FÁZI 2: yes
13981207 | 4.NP_SO-102 | 0 | 4.NP_SO-102 | Fáze 2 | ETA 68 | TC02.29.0368 | 0368

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:1000x400x1500, Tlumič hluku hranatý kulisový.LH:1000x400x1500:13845605
In: 2.NP_SO-102
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1500 mm; Jmenovitá velikost vstupu - šířka: 1000 mm; Jmenovitá velikost vstupu - výška: 400 mm; Jmenovitá velikost výstupu - šířka: 1000 mm; Jmenovitá velikost výstupu - výška: 400 mm; Průtočná mezera: 100 mm; Šířka: 1000 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 400 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 1000x400x1500; Označení typu: 32; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: ODA 14
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.92 m2; NetVolume: 0.604725 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1000 mm × 400 mm-1000 mm × 400 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1000 mm × 400 mm-1000 mm × 400 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 2.94444 m3/s; Tlaková ztráta: -3258218 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Výška od podlaží: 2750 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Název systému: ODA 14; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.604725 m3; Plocha: 3.46 m2; Velikost: 1000 × 400-1000 × 400
Identifikační data - Kód prvku: TC03.32.0106; Označení: 0106
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13845572; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 1000x400x1500; Typ: 1000x400x1500

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:1120x630x2500, Tlumič hluku hranatý kulisový.LH:1120x630x2500:13825386
In: 2.NP_SO-102
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 2500 mm; Jmenovitá velikost vstupu - šířka: 1120 mm; Jmenovitá velikost vstupu - výška: 630 mm; Jmenovitá velikost výstupu - šířka: 1120 mm; Jmenovitá velikost výstupu - výška: 630 mm; Průtočná mezera: 100 mm; Šířka: 1120 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 630 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 1120x630x2500; Označení typu: 27; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: ODA 7
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 13.3806 m2; NetVolume: 1.77196 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1120 mm × 630 mm-1120 mm × 630 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1120 mm × 630 mm-1120 mm × 630 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0.972222 m3/s; Tlaková ztráta: -114158 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Výška od podlaží: 2775 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Název systému: ODA 7; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 1.77196 m3; Plocha: 6.6903 m2; Velikost: 1120 × 630-1120 × 630
Identifikační data - Kód prvku: TC03.27.0057; Označení: 0057
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13696760; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 1120x630x2500; Typ: 1120x630x2500

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:1200x900x2450, Tlumič hluku hranatý kulisový.LH:1200x900x2450:13641974
In: -1.PP_SO-102
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 2450 mm; Jmenovitá velikost vstupu - šířka: 1200 mm; Jmenovitá velikost vstupu - výška: 900 mm; Jmenovitá velikost výstupu - šířka: 1200 mm; Jmenovitá velikost výstupu - výška: 900 mm; Průtočná mezera: 100 mm; Šířka: 1200 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 900 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 1200x900x2450; Označení typu: 04; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: ODA 8
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 17.244 m2; NetVolume: 2.65788 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1200 mm × 900 mm-1200 mm × 900 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1200 mm × 900 mm-1200 mm × 900 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 4 m3/s; Tlaková ztráta: -824833 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Výška od podlaží: 2400 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Název systému: ODA 8; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 2.65788 m3; Plocha: 8.622 m2; Velikost: 1200 × 900-1200 × 900
Identifikační data - Kód prvku: TC03.04.0008; Označení: 0008
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13761109; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 1200x900x2450; Typ: 1200x900x2450

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:1250x500x1000 (3)
In: 2.NP_SO-102
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1000 mm; Jmenovitá velikost vstupu - šířka: 1250 mm; Jmenovitá velikost vstupu - výška: 500 mm; Jmenovitá velikost výstupu - šířka: 1250 mm; Jmenovitá velikost výstupu - výška: 500 mm; Průtočná mezera: 100 mm; Šířka: 1250 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 500 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 1250x500x1000; Označení typu: 53; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 7.647 m2; NetVolume: 0.63215 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1250 mm × 500 mm-1250 mm × 500 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1250 mm × 500 mm-1250 mm × 500 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.63215 m3; Plocha: 3.8235 m2; Velikost: 1250 × 500-1250 × 500
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13934659; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 1250x500x1000; Typ: 1250x500x1000
Name (Tlumič hluku hranatý kulisový.LH:1250x500x1000:...) | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13934840 | 2880 | Přívodní | Přívod vzduchu | SUP 9 | SUP | TC03.53.0321 | 0321
13935294 | 2920 | Odváděný | Zpětný vzduch | ETA 14 | ETA | TC03.53.0322 | 0322
14041467 | 2800 | Odváděný | Zpětný vzduch | ETA 3 | ETA | TC03.53.0413 | 0413

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:1250x600x1500, Tlumič hluku hranatý kulisový.LH:1250x600x1500:13846865
In: 2.NP_SO-102
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1500 mm; Jmenovitá velikost vstupu - šířka: 1250 mm; Jmenovitá velikost vstupu - výška: 600 mm; Jmenovitá velikost výstupu - šířka: 1250 mm; Jmenovitá velikost výstupu - výška: 600 mm; Průtočná mezera: 100 mm; Šířka: 1250 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 600 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 1250x600x1500; Označení typu: 34; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: ETA 3
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 10.469 m2; NetVolume: 1.13345 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1250 mm × 600 mm-1250 mm × 600 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1250 mm × 600 mm-1250 mm × 600 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Výška od podlaží: 2800 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 3; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 1.13345 m3; Plocha: 5.2345 m2; Velikost: 1250 × 600-1250 × 600
Identifikační data - Kód prvku: TC03.34.0110; Označení: 0110
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13846834; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 1250x600x1500; Typ: 1250x600x1500

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:1250x600x2000, Tlumič hluku hranatý kulisový.LH:1250x600x2000:13825705
In: 2.NP_SO-102
Type - Material: 128-64-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 2000 mm; Jmenovitá velikost vstupu - šířka: 1250 mm; Jmenovitá velikost vstupu - výška: 600 mm; Jmenovitá velikost výstupu - šířka: 1250 mm; Jmenovitá velikost výstupu - výška: 600 mm; Průtočná mezera: 100 mm; Šířka: 1250 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 600 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 1250x600x2000; Označení typu: 28; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: EHA 5
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 12.319 m2; NetVolume: 1.50845 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1250 mm × 600 mm-1250 mm × 600 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1250 mm × 600 mm-1250 mm × 600 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Výška od podlaží: 2700 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Znehodnocený; Klasifikace systému: Odváděný vzduch; Název systému: EHA 5; Zkratka systému: EHA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 1.50845 m3; Plocha: 6.1595 m2; Velikost: 1250 × 600-1250 × 600
Identifikační data - Kód prvku: TC03.28.0058; Označení: 0058
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13825314; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 1250x600x2000; Typ: 1250x600x2000

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:1250x710x3000, Tlumič hluku hranatý kulisový.LH:1250x710x3000:13965826
In: -1.PP_SO-102
Type - Material: 128-64-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 3000 mm; Jmenovitá velikost vstupu - šířka: 1250 mm; Jmenovitá velikost vstupu - výška: 710 mm; Jmenovitá velikost výstupu - šířka: 1250 mm; Jmenovitá velikost výstupu - výška: 710 mm; Průtočná mezera: 100 mm; Šířka: 1250 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 710 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 1250x710x3000; Označení typu: 60; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: EHA 17
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 17.5282 m2; NetVolume: 2.67238 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1250 mm × 710 mm-1250 mm × 710 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1250 mm × 710 mm-1250 mm × 710 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Výška od podlaží: 2300 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Znehodnocený; Klasifikace systému: Odváděný vzduch; Název systému: EHA 17; Zkratka systému: EHA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 2.67238 m3; Plocha: 8.7641 m2; Velikost: 1250 × 710-1250 × 710
Identifikační data - Kód prvku: TC03.60.0360; Označení: 0360
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13642058; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 1250x710x3000; Typ: 1250x710x3000

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:1250x800x2500, Tlumič hluku hranatý kulisový.LH:1250x800x2500:13697537
In: 2.NP_SO-102
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 2500 mm; Jmenovitá velikost vstupu - šířka: 1250 mm; Jmenovitá velikost vstupu - výška: 800 mm; Jmenovitá velikost výstupu - šířka: 1250 mm; Jmenovitá velikost výstupu - výška: 800 mm; Průtočná mezera: 100 mm; Šířka: 1250 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 800 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 1250x800x2500; Označení typu: 09; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: SUP 11
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 16.713 m2; NetVolume: 2.51105 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1250 mm × 800 mm-1250 mm × 800 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1250 mm × 800 mm-1250 mm × 800 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Výška od podlaží: 809 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 11; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 2.51105 m3; Plocha: 8.3565 m2; Velikost: 1250 × 800-1250 × 800
Identifikační data - Kód prvku: TC03.09.0019; Označení: 0019
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13697496; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 1250x800x2500; Typ: 1250x800x2500

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:1500x600x1850 (2)
In: 2.NP_SO-102
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1850 mm; Jmenovitá velikost vstupu - šířka: 1500 mm; Jmenovitá velikost vstupu - výška: 600 mm; Jmenovitá velikost výstupu - šířka: 1500 mm; Jmenovitá velikost výstupu - výška: 600 mm; Průtočná mezera: 100 mm; Šířka: 1500 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 600 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 1500x600x1850; Označení typu: 66; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 13.644 m2; NetVolume: 1.67508 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1500 mm × 600 mm-1500 mm × 600 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1500 mm × 600 mm-1500 mm × 600 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 1.67508 m3; Plocha: 6.822 m2; Velikost: 1500 × 600-1500 × 600
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 14077899; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 1500x600x1850; Typ: 1500x600x1850
Name (Tlumič hluku hranatý kulisový.LH:1500x600x1850:...) | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
14077940 | 2870 | Odváděný | Zpětný vzduch | ETA 14 | ETA | TC03.66.0442 | 0442
14078289 | 559 | Přívodní | Přívod vzduchu | SUP 9 | SUP | TC03.66.0443 | 0443 | Mechanické – tok - Tlaková ztráta: 0 Pa

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:1500x900x1500, Tlumič hluku hranatý kulisový.LH:1500x900x1500:13747010
In: 2.NP_SO-102
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1500 mm; Jmenovitá velikost vstupu - šířka: 1500 mm; Jmenovitá velikost vstupu - výška: 900 mm; Jmenovitá velikost výstupu - šířka: 1500 mm; Jmenovitá velikost výstupu - výška: 900 mm; Průtočná mezera: 100 mm; Šířka: 1500 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 900 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 1500x900x1500; Označení typu: 11; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: ODA 6
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 15.84 m2; NetVolume: 2.03973 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1500 mm × 900 mm-1500 mm × 900 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1500 mm × 900 mm-1500 mm × 900 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 4.16667 m3/s; Tlaková ztráta: -572801 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Výška od podlaží: 2543.58 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Název systému: ODA 6; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 2.03973 m3; Plocha: 7.92 m2; Velikost: 1500 × 900-1500 × 900
Identifikační data - Kód prvku: TC03.11.0021; Označení: 0021
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13757082; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 1500x900x1500; Typ: 1500x900x1500

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:1500x900x1500, Tlumič hluku hranatý kulisový.LH:1500x900x1500:13855111
In: 2.NP_SO-102
Type - Material: 128-64-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1500 mm; Jmenovitá velikost vstupu - šířka: 1500 mm; Jmenovitá velikost vstupu - výška: 900 mm; Jmenovitá velikost výstupu - šířka: 1500 mm; Jmenovitá velikost výstupu - výška: 900 mm; Průtočná mezera: 100 mm; Šířka: 1500 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 900 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 1500x900x1500; Označení typu: 11; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat); Group: EHA 8
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 15.84 m2; NetVolume: 2.03973 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1500 mm × 900 mm-1500 mm × 900 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1500 mm × 900 mm-1500 mm × 900 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Výška od podlaží: 2650 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Znehodnocený; Klasifikace systému: Odváděný vzduch; Název systému: EHA 8; Zkratka systému: EHA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 2.03973 m3; Plocha: 7.92 m2; Velikost: 1500 × 900-1500 × 900
Identifikační data - Kód prvku: TC03.11.0129; Označení: 0129
Jiné - Páteřní trasa: yes; Rodina: Tlumič hluku hranatý kulisový.LH; Id typu: 13757082; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 1500x900x1500; Typ: 1500x900x1500

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:1600x560x2500, Tlumič hluku hranatý kulisový.LH:1600x560x2500:13641770
In: -1.PP_SO-102
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 2500 mm; Jmenovitá velikost vstupu - šířka: 1600 mm; Jmenovitá velikost vstupu - výška: 560 mm; Jmenovitá velikost výstupu - šířka: 1600 mm; Jmenovitá velikost výstupu - výška: 560 mm; Průtočná mezera: 100 mm; Šířka: 1600 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 560 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 1600x560x2500; Označení typu: 03; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Tlumič hluku hranatý kulisový.LH; Počet kulis: 6
Classification: TC03 Uniformat (Uniformat); Group: ETA 1
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 16.6632 m2; NetVolume: 2.25007 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1600 mm × 560 mm-1600 mm × 560 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1600 mm × 560 mm-1600 mm × 560 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Výška od podlaží: 2405.78 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 1; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 2.25007 m3; Plocha: 8.3316 m2; Velikost: 1600 × 560-1600 × 560
Identifikační data - Kód prvku: TC03.03.0007; Označení: 0007
Jiné - Páteřní trasa: yes; Id typu: 13641735; Rodina: Tlumič hluku hranatý kulisový.LH; Rodina a typ: Tlumič hluku hranatý kulisový.LH: 1600x560x2500; Typ: 1600x560x2500

# IfcBuildingElementProxy: Tlumič hluku hranatý kulisový.LH:1800x710x1500 (2)
In: 2.NP_SO-102
Type - Material: 128-64-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 1500 mm; Jmenovitá velikost vstupu - šířka: 1800 mm; Jmenovitá velikost vstupu - výška: 710 mm; Jmenovitá velikost výstupu - šířka: 1800 mm; Jmenovitá velikost výstupu - výška: 710 mm; Průtočná mezera: 100 mm; Šířka: 1800 mm; Šířka kulisy: 200 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 710 mm
Type - Identifikační data - Cena: 0; ID kategorie: TH; Kód sestavy: TC03; Název typu: 1800x710x1500; Označení typu: 26; Popis: Tlumič hluku hranatý kulisový; Popis sestavy: Vložkový
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Počet kulis: 6; Název rodiny: Tlumič hluku hranatý kulisový.LH
Classification: TC03 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 15.7622 m2; NetVolume: 1.93106 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1800 mm × 710 mm-1800 mm × 710 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1800 mm × 710 mm-1800 mm × 710 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: FSE; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
