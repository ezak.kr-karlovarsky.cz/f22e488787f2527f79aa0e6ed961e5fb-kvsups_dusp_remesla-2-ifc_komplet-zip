Properties of the parts of a building model (IFC4), part 31 of 45

# IfcDuctFitting: M_Kulaté koleno:1 D (432)
Name (M_Kulaté koleno:1 D:...) | In | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Úhel (deg) | Délka1 (mm) | Objem (m3) | Poloměr potrubí (mm) | Střední poloměr (mm) | Velikost | Kód prvku | Označení | Páteřní trasa
13794184 | 1.NP_SO-102 | 500 mm-500 mm | 0 | 500 mm-500 mm |  | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 500 | 0.154205 | 250 | 500 | 500-500 | TA00.04.0324 | 0324 | yes
13794617 | -1.PP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | -2292137 | -1.PP_SO-102 | 3100 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 2 | ODA | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.0327 | 0327 | yes
13795256 | -1.PP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | 0 | -1.PP_SO-102 | 3100 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 2 | EHA | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.0328 | 0328 | yes
13795266 | 1.NP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | 0 | 1.NP_SO-102 | 3720 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 2 | EHA | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.0329 | 0329 | yes
13795308 | 1.NP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | 0 | 1.NP_SO-102 | 3723 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 9 | EHA | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.0330 | 0330 | yes
13796966 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 2800 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 12 | EHA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0334 | 0334 | yes
13796981 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 2.NP_SO-102 | 3678 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 12 | EHA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0335 | 0335 | yes
13803503 | 2.NP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm |  | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.0348 | 0348 | no
13803505 | 2.NP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm |  | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.0349 | 0349 | no
13806689 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | -879.056 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0358 | 0358 | no
13806705 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | -879.056 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0359 | 0359 | no
13807542 | 3.NP_SO-102 | 500 mm-500 mm | 0 | 500 mm-500 mm |  | 3.NP_SO-102 | 2420 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 13 | ODA | 90 | 500 | 0.154205 | 250 | 500 | 500-500 | TA00.04.0362 | 0362 | yes
13807555 | 3.NP_SO-102 | 500 mm-500 mm | 0 | 500 mm-500 mm |  | 3.NP_SO-102 | 3035.67 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 10 | ODA | 90 | 500 | 0.154205 | 250 | 500 | 500-500 | TA00.04.0363 | 0363 | yes
13807611 | 3.NP_SO-102 | 500 mm-500 mm | 0 | 500 mm-500 mm |  | 3.NP_SO-102 | 2415.67 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 10 | ODA | 90 | 500 | 0.154205 | 250 | 500 | 500-500 | TA00.04.0364 | 0364 | yes
13810475 | -1.PP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | 0 | -1.PP_SO-102 | 3100 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 2 | ODA | 45 | 147.046 | 0.0275959 | 177.5 | 355 | 355-355 | TA00.04.0370 | 0370 | yes
13810479 | -1.PP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | -2292137 | -1.PP_SO-102 | 3100 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 2 | ODA | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.0371 | 0371 | yes
13810503 | -1.PP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | 0 | -1.PP_SO-102 | 3100 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 2 | EHA | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.0373 | 0373 | yes
13810505 | -1.PP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | 0 | -1.PP_SO-102 | 3100 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 2 | EHA | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.0374 | 0374 | yes
13817828 | 1.NP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm |  | 1.NP_SO-102 | 3150 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.0386 | 0386 | no
13817993 | 1.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | 1.NP_SO-102 | 3200 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 45 | 103.553 | 0.00963785 | 125 | 250 | 250-250 | TA00.04.0387 | 0387 | no
13817995 | 1.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | 1.NP_SO-102 | 3200.1 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 45 | 103.553 | 0.00963785 | 125 | 250 | 250-250 | TA00.04.0388 | 0388 | no
13818642 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 1.NP_SO-102 | 2903.77 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0390 | 0390 | no
13837626 | 3.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm | 0 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.0400 | 0400 | no
13837776 | 3.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm | 0 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.0402 | 0402 | no
13837903 | 3.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm | 0 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.0403 | 0403 | no
13837943 | 3.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm | 0 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.0405 | 0405 | no
13838113 | 3.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0406 | 0406 | no
13838124 | 3.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0407 | 0407 | no
13838765 | 4.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0408 | 0408 | yes
13839524 | 3.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm | 0 | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0409 | 0409 | yes
13839869 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0410 | 0410 | no
13839914 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0411 | 0411 | no
13847737 | 4.NP_SO-102 | 500 mm-500 mm | 0 | 500 mm-500 mm |  | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 500 | 0.154205 | 250 | 500 | 500-500 | TA00.04.0423 | 0423 | yes
13853494 | 1.NP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm |  | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.0439 | 0439 | no
13867252 | 4.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0463 | 0463 | yes
13867447 | 4.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0467 | 0467 | no
13867470 | 4.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0469 | 0469 | no
13868706 | 4.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm |  | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 39 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0485 | 0485 | no
13868732 | 4.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm |  | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0487 | 0487 | no
13871308 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0504 | 0504 | no
13871485 | 3.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0505 | 0505 | no
13871510 | 3.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0507 | 0507 | no
13874854 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0512 | 0512 | no
13876763 | 2.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0533 | 0533 | no
13876782 | 2.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0535 | 0535 | no
13877294 | 2.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm |  | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0540 | 0540 | no
13877365 | 2.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm |  | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0541 | 0541 | no
13877367 | 2.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm |  | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 55 | SUP | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0542 | 0542 | no
13879721 | 4.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm | 0 | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.0566 | 0566 | no
13879787 | 4.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm | 0 | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.0570 | 0570 | no
13879904 | 4.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm | 0 | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.0571 | 0571 | no
13879964 | 4.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm | 0 | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.0573 | 0573 | no
13882291 | 4.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0576 | 0576 | no
13882323 | 4.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0577 | 0577 | no
13884402 | 3.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm | 0 | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0581 | 0581 | no
13884404 | 3.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm | 0 | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0582 | 0582 | no
13895924 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 1.NP_SO-102 | 3100 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0623 | 0623 | no
13895952 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 1.NP_SO-102 | 3100 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0624 | 0624 | no
13895961 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 1.NP_SO-102 | 3100 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0625 | 0625 | no
13898827 | 4.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | 4.NP_SO-102 | 3100 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.0633 | 0633 | no
13901080 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | -879.056 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0635 | 0635 | no
13902162 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 3300 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0639 | 0639 | no
13902833 | 4.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | STŘECHA_SO-102 | 966.89 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 8 | ETA | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0641 | 0641 | yes
13908080 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0645 | 0645 | no
13908872 | 1.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0650 | 0650 | no
13908951 | 1.NP_SO-102 | 315 mm-315 mm | 0 | 315 mm-315 mm | 0 | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 90 | 315 | 0.0385592 | 157.5 | 315 | 315-315 | TA00.04.0653 | 0653 | no
13911838 | 1.NP_SO-102 | 450 mm-450 mm | 0 | 450 mm-450 mm | 0 | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 90 | 450 | 0.112416 | 225 | 450 | 450-450 | TA00.04.0666 | 0666 | yes
13911979 | 1.NP_SO-102 | 450 mm-450 mm | 0 | 450 mm-450 mm |  | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 90 | 450 | 0.112416 | 225 | 450 | 450-450 | TA00.04.0669 | 0669 | yes
13914384 | 1.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0686 | 0686 | no
13914386 | 1.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0687 | 0687 | no
13914427 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 2.NP_SO-102 | 2700 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0689 | 0689 | no
13914457 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 2.NP_SO-102 | 2700 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0690 | 0690 | no
13914466 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 2.NP_SO-102 | 2700 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0691 | 0691 | no
13914477 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 2.NP_SO-102 | 2700 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0692 | 0692 | no
13915325 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.0697 | 0697 | no
13915330 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 2.NP_SO-102 | 2900 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.0698 | 0698 | no
13926765 | 1.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 35 | SUP | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0710 | 0710 | no
13927053 | 1.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0716 | 0716 | no
13927055 | 1.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0717 | 0717 | no
13936462 | 2.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm |  | 2.NP_SO-102 | 2700 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0743 | 0743 | no
13936676 | 2.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm |  | 2.NP_SO-102 | 2700 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0744 | 0744 | no
13939578 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.0761 | 0761 | yes
13939580 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.0762 | 0762 | yes
13939816 | 2.NP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm | 0 | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.0763 | 0763 | yes
13943579 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 2350 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0767 | 0767 | no
13943748 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 2350 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0768 | 0768 | no
13950316 | -1.PP_SO-102 | 400 mm-400 mm | 0 | 400 mm-400 mm | 0 | -1.PP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 7 | SUP | 90 | 400 | 0.0789531 | 200 | 400 | 400-400 | TA00.04.0775 | 0775 | yes
13950844 | -1.PP_SO-102 | 400 mm-400 mm | 0 | 400 mm-400 mm | 0 | -1.PP_SO-102 | 3150 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 18 | ETA | 90 | 400 | 0.0789531 | 200 | 400 | 400-400 | TA00.04.0776 | 0776 | yes
13950848 | -1.PP_SO-102 | 400 mm-400 mm | 0 | 400 mm-400 mm | 0 | -1.PP_SO-102 | 3150 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 18 | ETA | 90 | 400 | 0.0789531 | 200 | 400 | 400-400 | TA00.04.0777 | 0777 | yes
13951019 | -1.PP_SO-102 | 400 mm-400 mm | 0 | 400 mm-400 mm | 0 | -1.PP_SO-102 | 3150 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 18 | ETA | 45 | 165.685 | 0.0394758 | 200 | 400 | 400-400 | TA00.04.0779 | 0779 | yes
13951851 | -1.PP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | 0 | -1.PP_SO-102 | 3076.47 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 9 | EHA | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.0781 | 0781 | yes
13951853 | -1.PP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | 0 | -1.PP_SO-102 | 3076.47 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 9 | EHA | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.0782 | 0782 | yes
13951987 | -1.PP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | 0 | -1.PP_SO-102 | 3076.47 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 1 | ODA | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.0784 | 0784 | yes
13951999 | -1.PP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | 0 | -1.PP_SO-102 | 3076.47 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 1 | ODA | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.0785 | 0785 | yes
13952179 | 1.NP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | 0 | 1.NP_SO-102 | -923.528 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 9 | EHA | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.0788 | 0788 | yes
13952256 | -1.PP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | 0 | -1.PP_SO-102 | 2700 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 1 | ODA | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.0789 | 0789 | yes
13952289 | -1.PP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | -1368652 | -1.PP_SO-102 | 3078 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 1 | ODA | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.0790 | 0790 | yes
13952291 | -1.PP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | -1368652 | -1.PP_SO-102 | 3078 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 1 | ODA | 45 | 147.046 | 0.0275959 | 177.5 | 355 | 355-355 | TA00.04.0791 | 0791 | yes
13952422 | -1.PP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | 0 | -1.PP_SO-102 | 2700 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 1 | ODA | 45 | 147.046 | 0.0275959 | 177.5 | 355 | 355-355 | TA00.04.0792 | 0792 | yes
13952434 | -1.PP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | 0 | -1.PP_SO-102 | 3076.47 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 1 | ODA | 45 | 147.046 | 0.0275959 | 177.5 | 355 | 355-355 | TA00.04.0794 | 0794 | yes
13952549 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | -1.PP_SO-102 | 2700 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0795 | 0795 | no
13952566 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | -1.PP_SO-102 | 2700 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0796 | 0796 | no
13955582 | -1.PP_SO-102 | 400 mm-400 mm | 0 | 400 mm-400 mm |  | -1.PP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 7 | SUP | 90 | 400 | 0.0789531 | 200 | 400 | 400-400 | TA00.04.0802 | 0802 | yes
13955800 | -1.PP_SO-102 | 400 mm-400 mm | 0 | 400 mm-400 mm |  | -1.PP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 7 | SUP | 90 | 400 | 0.0789531 | 200 | 400 | 400-400 | TA00.04.0803 | 0803 | yes
13955802 | -1.PP_SO-102 | 400 mm-400 mm | 0 | 400 mm-400 mm |  | -1.PP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 7 | SUP | 90 | 400 | 0.0789531 | 200 | 400 | 400-400 | TA00.04.0804 | 0804 | yes
13956006 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 3150 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 18 | ETA | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.0806 | 0806 | no
13956015 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 3150 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 18 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0807 | 0807 | no
13956166 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | -1.PP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 7 | SUP | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.0809 | 0809 | no
13956175 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | -1.PP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 7 | SUP | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.0810 | 0810 | no
13957319 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 2.NP_SO-102 | 2600 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.0813 | 0813 | no
13957323 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 2.NP_SO-102 | 2940 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.0814 | 0814 | no
13957464 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 2.NP_SO-102 | 2600 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0815 | 0815 | no
13957708 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 2.NP_SO-102 | 2580 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0816 | 0816 | no
13961090 | -1.PP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | -1.PP_SO-102 | 3069.13 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0824 | 0824 | no
13961930 | -1.PP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | -1.PP_SO-102 | 3067.62 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0825 | 0825 | no
13963208 | -1.PP_SO-102 | 355 mm-355 mm | 15 | 385 mm-385 mm | 0 | -1.PP_SO-102 | 3077.14 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 45 | 147.046 | 0.0275959 | 177.5 | 355 | 355-355 | TA00.04.0828 | 0828 | yes | Izolace - Typ izolace: Protipožární
13963220 | -1.PP_SO-102 | 355 mm-355 mm | 15 | 385 mm-385 mm | 0 | -1.PP_SO-102 | 3077.14 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 45 | 147.046 | 0.0275959 | 177.5 | 355 | 355-355 | TA00.04.0829 | 0829 | yes | Izolace - Typ izolace: Protipožární
13966154 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 3067.64 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0839 | 0839 | no
13966360 | -1.PP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | -1.PP_SO-102 | 3068.84 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0841 | 0841 | no
13966792 | -1.PP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | -1.PP_SO-102 | 3077.14 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 45 | 103.553 | 0.00963785 | 125 | 250 | 250-250 | TA00.04.0845 | 0845 | no
13966802 | -1.PP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | -1.PP_SO-102 | 2700 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 45 | 103.553 | 0.00963785 | 125 | 250 | 250-250 | TA00.04.0846 | 0846 | no
13967507 | -1.PP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm |  | -1.PP_SO-102 | 2350 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0851 | 0851 | no
13971154 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0856 | 0856 | no
13977926 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 45 | 66.2742 | 0.00252651 | 80 | 160 | 160-160 | TA00.04.0858 | 0858 | no
13977937 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 3.NP_SO-102 | 2900 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0859 | 0859 | no
13977939 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 3.NP_SO-102 | 2900 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.0860 | 0860 | no
13981727 | 4.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm |  | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0865 | 0865 | no
13981920 | 4.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm |  | 4.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 23 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0868 | 0868 | no
13982811 | 4.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm |  | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 45 | 74.5584 | 0.00359731 | 90 | 180 | 180-180 | TA00.04.0871 | 0871 | no
13982822 | 4.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm |  | 4.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 45 | 74.5584 | 0.00359731 | 90 | 180 | 180-180 | TA00.04.0872 | 0872 | no
13982826 | 4.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm |  | 4.NP_SO-102 | 2903.77 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 45 | 74.5584 | 0.00359731 | 90 | 180 | 180-180 | TA00.04.0873 | 0873 | no
13982830 | 4.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm |  | 4.NP_SO-102 | 2903.77 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 45 | 74.5584 | 0.00359731 | 90 | 180 | 180-180 | TA00.04.0874 | 0874 | no
13984374 | 3.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0876 | 0876 | no
13985038 | 3.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0882 | 0882 | no
13985048 | 3.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0883 | 0883 | no
13987653 | -1.PP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm |  | -1.PP_SO-102 | 3150 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 18 | ETA | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.0885 | 0885 | yes
13987790 | -1.PP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm |  | -1.PP_SO-102 | 3150 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 18 | ETA | 45 | 147.046 | 0.0275959 | 177.5 | 355 | 355-355 | TA00.04.0887 | 0887 | yes
13988969 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 3067.64 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0888 | 0888 | no
13988993 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 3067.64 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0890 | 0890 | no
13989148 | -1.PP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | -1.PP_SO-102 | 3077.14 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.0891 | 0891 | no
13989219 | -1.PP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | -1.PP_SO-102 | 3077.14 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.0893 | 0893 | no
13991017 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 3.NP_SO-102 | 2800 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0900 | 0900 | no
13991415 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0902 | 0902 | no
13991426 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0903 | 0903 | no
13991847 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0904 | 0904 | no
13992242 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 4.NP_SO-102 | 3230 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0906 | 0906 | no
13993746 | 1.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm |  | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0909 | 0909 | yes
13993748 | 1.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm |  | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.0910 | 0910 | yes
13993999 | 1.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm | 0 | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0912 | 0912 | no
13994012 | 1.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm | 0 | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0913 | 0913 | no
13996538 | 3.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | 3.NP_SO-102 | 3100 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.0914 | 0914 | no
13998627 | 4.NP_SO-102 | 280 mm-280 mm | 0 | 280 mm-280 mm |  | 4.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 90 | 280 | 0.0270813 | 140 | 280 | 280-280 | TA00.04.0919 | 0919 | yes
14000446 | 4.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 4.NP_SO-102 | -4900 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0921 | 0921 | no
14000530 | 4.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 4.NP_SO-102 | -5120 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0922 | 0922 | no
14000586 | 4.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 4.NP_SO-102 | -5120 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0923 | 0923 | no
14000662 | 3.NP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm | 0 | 3.NP_SO-102 | 3145.16 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.0924 | 0924 | no
14000913 | 4.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 4.NP_SO-102 | -4900 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0925 | 0925 | no
14000917 | 4.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 4.NP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0926 | 0926 | no
14002961 | 4.NP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm |  | STŘECHA_SO-102 | 1000 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 10 | ODA | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.0927 | 0927 | yes
14002965 | 4.NP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm |  | STŘECHA_SO-102 | 1000 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 10 | ODA | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.0929 | 0929 | yes
14003000 | 4.NP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm |  | STŘECHA_SO-102 | 1000 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 10 | ODA | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.0931 | 0931 | yes
14004720 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 2980 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0935 | 0935 | no
14004731 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 2980 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0936 | 0936 | no
14005091 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 2600 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0939 | 0939 | no
14006950 | -1.PP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm | 0 | -1.PP_SO-102 | 2700 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.0945 | 0945 | no
14016872 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 3.NP_SO-102 | 2739.7 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0962 | 0962 | no
14017070 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 3.NP_SO-102 | 2739.7 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0964 | 0964 | no
14017454 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 2.NP_SO-102 | 2900 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0968 | 0968 | no
14017623 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 4.NP_SO-102 | 2950 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0969 | 0969 | no
14017956 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 4.NP_SO-102 | 2950 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0970 | 0970 | no
14029063 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 19 | ODA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0973 | 0973 | yes
14029073 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 19 | ODA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0974 | 0974 | yes
14029698 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 12 | EHA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0977 | 0977 | yes
14029773 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 12 | EHA | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.0978 | 0978 | yes
14029898 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 2800 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 12 | EHA | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.0979 | 0979 | yes
14029902 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 2800 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 12 | EHA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.0980 | 0980 | yes
14034478 | 4.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm |  | 4.NP_SO-102 | 3100 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.0997 | 0997 | no
14036733 | 2.NP_SO-102 | 450 mm-450 mm | 0 | 450 mm-450 mm | 0 | 2.NP_SO-102 | 2937.5 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 45 | 186.396 | 0.0562067 | 225 | 450 | 450-450 | TA00.04.1004 | 1004 | yes
14039168 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 14 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1017 | 1017 | yes
14039177 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 14 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1018 | 1018 | yes
14039188 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 14 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1019 | 1019 | yes
14039257 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 14 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1021 | 1021 | yes
14040580 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 2895 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1026 | 1026 | no
14040608 | 1.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | 1.NP_SO-102 | 2895 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 45 | 74.5584 | 0.00359731 | 90 | 180 | 180-180 | TA00.04.1028 | 1028 | no
14040618 | 1.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 45 | 74.5584 | 0.00359731 | 90 | 180 | 180-180 | TA00.04.1029 | 1029 | no
14049526 | 2.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 2.NP_SO-102 | 3100 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.1036 | 1036 | no
14049593 | 2.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 2.NP_SO-102 | 3100 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 45 | 93.198 | 0.00702599 | 112.5 | 225 | 225-225 | TA00.04.1037 | 1037 | no
14049598 | 2.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 2.NP_SO-102 | 2650 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 45 | 93.198 | 0.00702599 | 112.5 | 225 | 225-225 | TA00.04.1038 | 1038 | no
14051676 | 2.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 2.NP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.1043 | 1043 | no
14051964 | 2.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 2.NP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.1044 | 1044 | no
14051966 | 2.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 2.NP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.1045 | 1045 | no
14052216 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 2.NP_SO-102 | 2580 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1047 | 1047 | no
14052377 | 2.NP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm | 0 | 2.NP_SO-102 | 2910 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 355 | 0.0551926 | 177.5 | 355 | 355-355 | TA00.04.1049 | 1049 | yes
14052405 | 2.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm |  | 2.NP_SO-102 | 2580 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.1050 | 1050 | no
14053517 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 2.NP_SO-102 | 2910 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1059 | 1059 | no
14053525 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 2.NP_SO-102 | 2580 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1060 | 1060 | no
14053529 | 2.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 2.NP_SO-102 | 2580 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1062 | 1062 | no
14055192 | 4.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 4.NP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.1064 | 1064 | no
14055194 | 4.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 4.NP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.1065 | 1065 | no
14055363 | 3.NP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm | 0 | 3.NP_SO-102 | 3145.16 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.1067 | 1067 | no
14055725 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 4.NP_SO-102 | 3200 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1072 | 1072 | no
14055757 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 4.NP_SO-102 | 3200 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1073 | 1073 | no
14055766 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 4.NP_SO-102 | 3200 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.1074 | 1074 | no
14055775 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 4.NP_SO-102 | 3200 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.1075 | 1075 | no
14055988 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 3.NP_SO-102 | 2900 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1078 | 1078 | no
14056403 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 23 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1081 | 1081 | yes
14056635 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 23 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1083 | 1083 | yes
14056895 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 12 | EHA | 30 | 42.8719 | 0.00168433 | 80 | 160 | 160-160 | TA00.04.1088 | 1088 | yes
14057460 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3200 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1094 | 1094 | no
14058334 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 2903.77 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1099 | 1099 | no
14060501 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 122.773 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1105 | 1105 | no
14060731 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 3250 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1106 | 1106 | no
14060735 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 2600 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1107 | 1107 | no
14060763 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 2600 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1108 | 1108 | no
14060867 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 2600 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1109 | 1109 | no
14060871 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1110 | 1110 | no
14061727 | 1.NP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm |  | 1.NP_SO-102 | -805 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.1112 | 1112 | no
14061742 | 1.NP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm |  | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.1113 | 1113 | no
14063997 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1115 | 1115 | no
14064008 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1116 | 1116 | no
14064758 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1117 | 1117 | no
14065920 | 1.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm | 0 | 1.NP_SO-102 | -849.999 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.1121 | 1121 | no
14065963 | -1.PP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm |  | -1.PP_SO-102 | 3150 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.1123 | 1123 | no
14075580 | 2.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | 2.NP_SO-102 | -799.99 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90.0373 | 250.163 | 0.0192839 | 125 | 250 | 250-250 | TA00.04.1130 | 1130 | no
14075594 | 1.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | 1.NP_SO-102 | 3200.01 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.1131 | 1131 | no
14076355 | 2.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | 2.NP_SO-102 | 2620 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.1133 | 1133 | no
14078559 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1148 | 1148 | no
14078584 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1150 | 1150 | no
14079106 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1151 | 1151 | no
14079155 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1153 | 1153 | no
14081092 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 4.NP_SO-102 | 2950 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1158 | 1158 | no
14081148 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 4.NP_SO-102 | 3300 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 2 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1159 | 1159 | no
14081216 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 4.NP_SO-102 | 3300 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 2 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1162 | 1162 | yes
14081417 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 4.NP_SO-102 | 3300 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 2 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1163 | 1163 | no
14081785 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 4.NP_SO-102 | 3300 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 2 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1166 | 1166 | no
14081796 | 4.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 4.NP_SO-102 | 3300 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 2 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1167 | 1167 | no
14081984 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 3.NP_SO-102 | 3300 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1169 | 1169 | no
14082080 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 3.NP_SO-102 | 3300 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1170 | 1170 | no
14082089 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 3.NP_SO-102 | 3300 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1171 | 1171 | no
14082318 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 3.NP_SO-102 | 3300 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.1174 | 1174 | no
14082356 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 3.NP_SO-102 | 3100 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.1175 | 1175 | no
14084627 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 12 | EHA | 30 | 42.8719 | 0.00168433 | 80 | 160 | 160-160 | TA00.04.1182 | 1182 | yes
14109726 | 1.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm |  | 1.NP_SO-102 | -950 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 180 | 0.00719471 | 90 | 180 | 180-180 | TA00.04.1191 | 1191 | no
14110717 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 19 | ODA | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.1203 | 1203 | yes
14110727 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 19 | ODA | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.1204 | 1204 | yes
14114089 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 3250 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1209 | 1209 | no
14114542 | 2.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm |  | 2.NP_SO-102 | 2700 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 45 | 74.5584 | 0.00359731 | 90 | 180 | 180-180 | TA00.04.1214 | 1214 | no
14114707 | 2.NP_SO-102 | 180 mm-180 mm | 0 | 180 mm-180 mm |  | 2.NP_SO-102 | 2851.43 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 45 | 74.5584 | 0.00359731 | 90 | 180 | 180-180 | TA00.04.1215 | 1215 | no
14114731 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 3.NP_SO-102 | 3102.4 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1217 | 1217 | no
14114735 | 3.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | 3.NP_SO-102 | 3102.4 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1218 | 1218 | no
14115615 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 3300 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.1220 | 1220 | no
14115633 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 3300 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1221 | 1221 | no
14115637 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 3300 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.1222 | 1222 | no
14116223 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 2980 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.1229 | 1229 | no
14116303 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 3240 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 45 | 66.2742 | 0.0025265 | 80 | 160 | 160-160 | TA00.04.1230 | 1230 | no
14116522 | -1.PP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm | 0 | -1.PP_SO-102 | 2600 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.1233 | 1233 | no
14116524 | -1.PP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm | 0 | -1.PP_SO-102 | 3070 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.1234 | 1234 | no
14116538 | -1.PP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm | 0 | -1.PP_SO-102 | 3070 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.1236 | 1236 | no
14116604 | -1.PP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm | 0 | -1.PP_SO-102 | 2600 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.1239 | 1239 | no
14116608 | -1.PP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm | 0 | -1.PP_SO-102 | 3070 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.1240 | 1240 | no
14116903 | -1.PP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm | 0 | -1.PP_SO-102 | 2700 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.1242 | 1242 | no
14117166 | -1.PP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm | 0 | -1.PP_SO-102 | 2700 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 45 | 82.8427 | 0.00493458 | 100 | 200 | 200-200 | TA00.04.1243 | 1243 | no
14117168 | -1.PP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm | 0 | -1.PP_SO-102 | 2700 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 45 | 82.8427 | 0.00493458 | 100 | 200 | 200-200 | TA00.04.1244 | 1244 | no
14117546 | -1.PP_SO-102 | 450 mm-450 mm | 0 | 450 mm-450 mm | 0 | -1.PP_SO-102 | 3070 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 90 | 450 | 0.112416 | 225 | 450 | 450-450 | TA00.04.1245 | 1245 | yes
14117703 | -1.PP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm | 0 | -1.PP_SO-102 | 3070 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 45 | 82.8427 | 0.00493458 | 100 | 200 | 200-200 | TA00.04.1248 | 1248 | no
14117707 | -1.PP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm | 0 | -1.PP_SO-102 | 2600 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 45 | 82.8427 | 0.00493458 | 100 | 200 | 200-200 | TA00.04.1249 | 1249 | no
14117736 | -1.PP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm | 0 | -1.PP_SO-102 | 2600 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.1251 | 1251 | no
14120116 | 1.NP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1256 | 1256 | no
14120353 | 2.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | 2.NP_SO-102 | 2620 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 250 | 0.019276 | 125 | 250 | 250-250 | TA00.04.1258 | 1258 | yes
14120634 | 2.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | 2.NP_SO-102 | 2910 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 45 | 103.553 | 0.00963785 | 125 | 250 | 250-250 | TA00.04.1260 | 1260 | yes
14120638 | 2.NP_SO-102 | 250 mm-250 mm | 0 | 250 mm-250 mm |  | 2.NP_SO-102 | 2620 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 45 | 103.553 | 0.00963785 | 125 | 250 | 250-250 | TA00.04.1261 | 1261 | yes
14120747 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 2400 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1263 | 1263 | no
14121039 | 2.NP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm |  | 2.NP_SO-102 | 2920 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 45 | 147.046 | 0.0275959 | 177.5 | 355 | 355-355 | TA00.04.1265 | 1265 | yes
14121050 | 2.NP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm |  | 2.NP_SO-102 | 2495.74 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 45 | 147.046 | 0.0275959 | 177.5 | 355 | 355-355 | TA00.04.1266 | 1266 | yes
14121085 | 2.NP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm |  | 2.NP_SO-102 | 2495.74 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 45 | 147.046 | 0.0275959 | 177.5 | 355 | 355-355 | TA00.04.1267 | 1267 | yes
14121089 | 2.NP_SO-102 | 355 mm-355 mm | 0 | 355 mm-355 mm |  | 2.NP_SO-102 | 2910 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 45 | 147.046 | 0.0275959 | 177.5 | 355 | 355-355 | TA00.04.1268 | 1268 | yes
14121941 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | -1.PP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 45 | 66.2742 | 0.00252651 | 80 | 160 | 160-160 | TA00.04.1273 | 1273 | no
14121947 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | -1.PP_SO-102 | 3240 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 45 | 66.2742 | 0.00252651 | 80 | 160 | 160-160 | TA00.04.1274 | 1274 | no
14121952 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm |  | -1.PP_SO-102 | 3240 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1275 | 1275 | no
14123079 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 2430 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1282 | 1282 | no
14123350 | -1.PP_SO-102 | 160 mm-160 mm | 0 | 160 mm-160 mm | 0 | -1.PP_SO-102 | 3070 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 160 | 0.00505308 | 80 | 160 | 160-160 | TA00.04.1284 | 1284 | no
14123627 | 4.NP_SO-102 | 200 mm-200 mm | 0 | 200 mm-200 mm |  | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 200 | 0.00986929 | 100 | 200 | 200-200 | TA00.04.1286 | 1286 | yes
14123975 | 4.NP_SO-102 | 225 mm-225 mm | 0 | 225 mm-225 mm | 0 | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 225 | 0.0140522 | 112.5 | 225 | 225-225 | TA00.04.1291 | 1291 | yes
