Properties of the parts of a building model (IFC4), part 17 of 45

# IfcBuildingElementProxy: 19_1_VZT_Ucebny jih:19_1_VZT_Ucebny jih, 19_1_VZT_Ucebny jih:19_1_VZT_Ucebny jih:13862870
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Exhaust 1 Sound generation: 71 80 71 73 66 62 58 52 dB; Extract 1 Sound generation: 68 73 68 61 56 51 46 45 dB; Fan efficiency, extract: 72.3 %; Fan efficiency, supply: 73.1 %; Fan speed, extract: 1313 RPM; Fan speed, supply: 1401 RPM; Heat recovery: 80.1 %; Klasifikace systému: Přívod vzduchu,Zpětný vzduch,Odváděný vzduch; Název systému: SUP 13,ETA 91,EHA 13; Outdoor 1 Sound generation: 63 71 65 59 52 46 39 36 dB; SFPe, dimensional filters excluding frequency converter: 1.61 kW/(m3/s); SFPe, výp. tlak. ztráta filtrù, s FM: 1.70 kW/(m3/s); SFPv, clean filters excluding frequency converter: 1.52 kW/(m3/s); SFPv, clean filters including frequency converter: 1.60 kW/(m3/s); Sound power level, extract: 64 dB(A); Sound power level, supply: 73 dB(A); Supply 1 Sound generation: 69 79 70 73 68 61 58 51 dB
Kóty - Objem: 22.8192 m3; Plocha: 52.2695 m2
Identifikační data - Kód prvku: JV01.10.0013; Komentáře: VZT č.19 VZT jednotka horizontální Vp/Vo=10600 m3/h dp=300 Pa ZZT-deskový P=8,4 kW; Označení: 0013; Productdata: © MagiCAD Group, all rights reserved
Jiné - Páteřní trasa: yes; Id typu: 13862841; Rodina: 19_1_VZT_Ucebny jih; Rodina a typ: 19_1_VZT_Ucebny jih: 19_1_VZT_Ucebny jih; Typ: 19_1_VZT_Ucebny jih

# IfcBuildingElementProxy: 20_1_VZT_Dílny 1_NP:20_1_VZT_Dílny 1_NP, 20_1_VZT_Dílny 1_NP:20_1_VZT_Dílny 1_NP:13697620
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Weight: 859 kg
Type - Grafika - magiFamilyGeom: MagiCAD_Geniox 12 Dílny 1.NP/Dílny 1.NP
Type - Kóty - MC Height: 1400 mm; MC Length: 4164 mm; MC Width: 1282 mm
Type - Identifikační data - Kód sestavy: JV01; magiPartTypeId: 210; magiProductCode: Geniox 12 Dílny 1.NP/Dílny 1.NP; magiProductId: Geniox 12 Dílny 1.NP/Dílny 1.NP; Model: Geniox 12 : Dílny 1.NP/Dílny 1.NP; Název typu: 20_1_VZT_Dílny 1_NP; Označení typu: 07; Popis sestavy: Samostatná; VersionID: 1.0/2023.1
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: 20_1_VZT_Dílny 1_NP
Classification: JV01 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 49.6567 m2; NetVolume: 7.24247 m3
Mechanické – tok - Exhaust 1 Airflow max ls: 1.9 m3/s; Exhaust 1 Airflow min ls: 0.4 m3/s; Exhaust 1 Airflow operation point max ls: 0.933 m3/s; Exhaust 1 Airflow operation point min ls: 0.844 m3/s; Exhaust 1 Flow: 0.889 m3/s; Exhaust 1 Pressure drop: 0 Pa; Extract 1 Airflow max ls: 1.9 m3/s; Extract 1 Airflow min ls: 0.4 m3/s; Extract 1 Airflow operation point max ls: 0.933 m3/s; Extract 1 Airflow operation point min ls: 0.844 m3/s; Extract 1 Flow: 0.889 m3/s; Extract 1 Pressure drop: 0 Pa; Outdoor 1 Airflow max ls: 1.9 m3/s; Outdoor 1 Airflow min ls: 0.4 m3/s; Outdoor 1 Airflow operation point max ls: 0.933 m3/s; Outdoor 1 Airflow operation point min ls: 0.844 m3/s; Outdoor 1 Flow: 0.889 m3/s; Outdoor 1 Pressure drop: 0 Pa; Pressure rise, extract: 300 Pa; Pressure rise, supply: 300 Pa; Supply 1 Airflow max ls: 1.9 m3/s; Supply 1 Airflow min ls: 0.4 m3/s; Supply 1 Airflow operation point max ls: 0.933 m3/s; Supply 1 Airflow operation point min ls: 0.844 m3/s; Supply 1 Flow: 0.889 m3/s; Supply 1 Pressure drop: 300 Pa
Text - CCI Funkční systém: J; CCI Komponenta: GQB; CCI Technický systém: HF
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: -1.PP_SO-102; Hostitel: Podlaží : -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 2
Mechanické - Exhaust 1 Sound generation: 64 73 68 70 70 67 62 59 dB; Extract 1 Sound generation: 60 67 61 59 53 48 43 39 dB; Fan efficiency, extract: 66.7 %; Fan efficiency, supply: 66.4 %; Fan speed, extract: 1977 RPM; Fan speed, supply: 2083 RPM; Heat recovery: 89.0 %; Klasifikace systému: Přívod vzduchu,Zpětný vzduch,Odváděný vzduch; Outdoor 1 Sound generation: 61 69 65 62 55 50 44 40 dB; SFPe, dimensional filters excluding frequency converter: 1.74 kW/(m3/s); SFPe, výp. tlak. ztráta filtrù, s FM: 1.83 kW/(m3/s); SFPv, clean filters excluding frequency converter: 1.64 kW/(m3/s); SFPv, clean filters including frequency converter: 1.73 kW/(m3/s); Sound power level, extract: 60 dB(A); Sound power level, supply: 71 dB(A); Supply 1 Sound generation: 63 74 69 69 66 60 56 50 dB
Kóty - Objem: 7.24247 m3; Plocha: 24.8395 m2
Identifikační data - Kód prvku: JV01.07.0007; Komentáře: VZT č.20 VZT jednotka horizontální Vp/Vo=4200 m3/h dp=300 Pa ZZT-deskový P=5,0 kW; Označení: 0007; Productdata: © MagiCAD Group, all rights reserved
Jiné - Páteřní trasa: yes; Id typu: 13674169; Rodina: 20_1_VZT_Dílny 1_NP; Rodina a typ: 20_1_VZT_Dílny 1_NP: 20_1_VZT_Dílny 1_NP; Typ: 20_1_VZT_Dílny 1_NP

# IfcBuildingElementProxy: 21_1_VZT_Telocvicna:21_1_VZT_Telocvicna, 21_1_VZT_Telocvicna:21_1_VZT_Telocvicna:13689832
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Weight: 2267 kg
Type - Grafika - magiFamilyGeom: MagiCAD_Geniox 24 Tìlocvièna/Tìlocvièna
Type - Kóty - Délka: 4782 mm; MC Height: 2700 mm; MC Length: 3664 mm; MC Width: 2482 mm; Šířka: 2632 mm; Výška: 2782 mm
Type - Identifikační data - Kód sestavy: JV01; magiPartTypeId: 210; Název typu: 21_1_VZT_Telocvicna; Označení typu: 05; Popis sestavy: Samostatná; VersionID: 1.0/2023.1
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: 21_1_VZT_Telocvicna
Classification: JV01 Uniformat (Uniformat); Group: ETA 11; SUP 11
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 143.088 m2; NetVolume: 22.3646 m3
Mechanické – tok - Exhaust 1 Airflow max ls: 8 m3/s; Exhaust 1 Airflow min ls: 1.9 m3/s; Exhaust 1 Airflow operation point max ls: 4.375 m3/s; Exhaust 1 Airflow operation point min ls: 3.958 m3/s; Exhaust 1 Flow: 4.167 m3/s; Exhaust 1 Pressure drop: 0 Pa; Extract 1 Airflow max ls: 8 m3/s; Extract 1 Airflow min ls: 1.9 m3/s; Extract 1 Airflow operation point max ls: 4.375 m3/s; Extract 1 Airflow operation point min ls: 3.958 m3/s; Extract 1 Flow: 4.167 m3/s; Extract 1 Pressure drop: 0 Pa; Outdoor 1 Airflow max ls: 8 m3/s; Outdoor 1 Airflow min ls: 1.9 m3/s; Outdoor 1 Airflow operation point max ls: 4.375 m3/s; Outdoor 1 Airflow operation point min ls: 3.958 m3/s; Outdoor 1 Flow: 4.167 m3/s; Outdoor 1 Pressure drop: 0 Pa; Pressure rise, extract: 300 Pa; Pressure rise, supply: 300 Pa; Průtok vzduchu čerstvý: 4.16667 m3/s; Průtok vzduchu odváděný: 4.16667 m3/s; Průtok vzduchu přívodní: 4.16667 m3/s; Průtok vzduchu znehodnocený: 4.16667 m3/s; Supply 1 Airflow max ls: 8 m3/s; Supply 1 Airflow min ls: 1.9 m3/s; Supply 1 Airflow operation point max ls: 4.375 m3/s; Supply 1 Airflow operation point min ls: 3.958 m3/s; Supply 1 Flow: 4.167 m3/s; Supply 1 Pressure drop: 300 Pa
Text - CCI Funkční systém: J; CCI Komponenta: GQB; CCI Technický systém: HF
Vazby - Odsazení od hostitele: 0 mm; Podlaží: 2.NP_SO-102; Výška od podlaží: 0 mm; Hostitel: Podlaží : 2.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Exhaust 1 Sound generation: 77 83 74 76 72 68 64 59 dB; Extract 1 Sound generation: 70 72 66 57 52 44 37 31 dB; Fan efficiency, extract: 71.2 %; Fan efficiency, supply: 70.3 %; Fan speed, extract: 1205 RPM; Fan speed, supply: 1283 RPM; Heat recovery: 81.4 %; Klasifikace systému: Přívod vzduchu,Zpětný vzduch,Odváděný vzduch; Název systému: SUP 11,ETA 11; Outdoor 1 Sound generation: 69 77 68 59 54 46 39 33 dB; SFPe, dimensional filters excluding frequency converter: 1.57 kW/(m3/s); SFPe, výp. tlak. ztráta filtrù, s FM: 1.65 kW/(m3/s); SFPv, clean filters excluding frequency converter: 1.47 kW/(m3/s); SFPv, clean filters including frequency converter: 1.55 kW/(m3/s); Sound power level, extract: 61 dB(A); Sound power level, supply: 76 dB(A); Supply 1 Sound generation: 75 86 74 75 69 62 58 50 dB
Kóty - Objem: 22.3646 m3; Plocha: 71.5553 m2
Identifikační data - Kód prvku: JV01.05.0005; Komentáře: VZT č.21 VZT jednotka horizontální Vp/Vo=15000 m3/h dp=300 Pa ZZT-rotační P=13,6 kW; Označení: 0005; Productdata: © MagiCAD Group, all rights reserved
Jiné - Páteřní trasa: yes; Id typu: 13689801; Rodina: 21_1_VZT_Telocvicna; Rodina a typ: 21_1_VZT_Telocvicna: 21_1_VZT_Telocvicna; Typ: 21_1_VZT_Telocvicna

# IfcBuildingElementProxy: 22_1_VZT_Posilovna:22_1_VZT_Posilovna, 22_1_VZT_Posilovna:22_1_VZT_Posilovna:13389183
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Weight: 0 kg
Type - Grafika - magiFamilyGeom: MagiCAD_Topvex TC70-R-HWH-B
Type - Kóty - Délka: 2742 mm; MC Height: 1458 mm; MC Length: 2108 mm; MC Width: 2742 mm; Šířka: 1695 mm; Výška: 1427 mm
Type - Identifikační data - Kód sestavy: JV01; magiPartTypeId: 210; Název typu: 22_1_VZT_Posilovna; Označení typu: 03; Popis: Kompaktní VZT jednotka, vertikální připojení, protiproudý deskový rekuperátor; Popis sestavy: Samostatná; VersionID: 1.0/2023.1; Výrobce: Výrobce
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: 22_1_VZT_Posilovna
Classification: JV01 Uniformat (Uniformat); Group: SUP 7; ODA 2; ETA 18; EHA 2
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 57.1055 m2; NetVolume: 6.93004 m3
Mechanické – tok - Exhaust, top Air flow: 0.583 m3/s; Exhaust, top Airflow operation point max l/s: 0.612 m3/s; Exhaust, top Airflow operation point min l/s: 0.554 m3/s; Exhaust, top Maximum pressure drop: 82 Pa; Exhaust, top Minimum pressure drop: 68 Pa; Exhaust, top Pressure drop: 75 Pa; Exhaust, top Pressure drop max: 82.5 Pa; Exhaust, top Pressure drop min: 67.5 Pa; Extract, top Air flow: 0.583 m3/s; Extract, top Airflow operation point max l/s: 0.612 m3/s; Extract, top Airflow operation point min l/s: 0.554 m3/s; Extract, top Maximum pressure drop: 248 Pa; Extract, top Minimum pressure drop: 202 Pa; Extract, top Pressure drop: 225 Pa; Extract, top Pressure drop max: 247.5 Pa; Extract, top Pressure drop min: 202.5 Pa; Outdoor, top Air flow: 0.583 m3/s; Outdoor, top Airflow operation point max l/s: 0.612 m3/s; Outdoor, top Airflow operation point min l/s: 0.554 m3/s; Outdoor, top Maximum pressure drop: 82 Pa; Outdoor, top Minimum pressure drop: 68 Pa; Outdoor, top Pressure drop: 75 Pa; Outdoor, top Pressure drop max: 82.5 Pa; Outdoor, top Pressure drop min: 67.5 Pa; Pressure rise, extract: 300 Pa; Pressure rise, supply: 300 Pa; Průtok vzduchu čerstvý: 0.611111 m3/s; Průtok vzduchu odváděný: 0.611111 m3/s; Průtok vzduchu přívodní: 0.611111 m3/s; Průtok vzduchu znehodnocený: 0.611111 m3/s; Supply, top Air flow: 0.583 m3/s; Supply, top Airflow operation point max l/s: 0.612 m3/s; Supply, top Airflow operation point min l/s: 0.554 m3/s; Supply, top Maximum pressure drop: 248 Pa; Supply, top Minimum pressure drop: 202 Pa; Supply, top Pressure drop: 225 Pa; Supply, top Pressure drop max: 247.5 Pa; Supply, top Pressure drop min: 202.5 Pa
Text - CCI Funkční systém: J; CCI Komponenta: GQB; CCI Technický systém: HF
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Podlaží: -1.PP_SO-102; Hostitel: Podlaží : -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Exhaust, top Sound power level: 69 70 72 68 69 64 58 53 73 73 dB; Extract, top Sound power level: 67 70 62 57 53 42 35 26 60 60 dB; Klasifikace systému: Přívod vzduchu,Zpětný vzduch,Odváděný vzduch; Název systému: SUP 7,ODA 2,ETA 18,EHA 2; Outdoor, top Sound power level: 63 66 58 55 52 42 35 26 57 57 dB; Supply, top Sound power level: 65 67 70 67 68 64 60 53 72 72 dB
Kóty - Objem: 6.93004 m3; Plocha: 28.5639 m2
Identifikační data - Kód prvku: JV01.03.0003; Komentáře: VZT č.22 VZT jednotka vertikální Vp/Vo=2200 m3/h dp=300 Pa ZZT-deskový P=4,6 kW; Označení: 0003; Productdata: © MagiCAD Group, all rights reserved
Jiné - Páteřní trasa: yes; Id typu: 13389154; Rodina: 22_1_VZT_Posilovna; Rodina a typ: 22_1_VZT_Posilovna: 22_1_VZT_Posilovna; Typ: 22_1_VZT_Posilovna

# IfcBuildingElementProxy: 23_1_VZT_Hygienicke_zazemi:23_1_VZT_Hygienicke_zazemi, 23_1_VZT_Hygienicke_zazemi:23_1_VZT_Hygienicke_zazemi:13372822
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Weight: 0 kg
Type - Grafika - magiFamilyGeom: MagiCAD_Topvex FC04 HWH-R-CAV_1
Type - Kóty - Délka: 2546 mm; MC Height: 431 mm; MC Length: 2144 mm; MC Width: 3100 mm; Šířka: 2214 mm; Výška: 507 mm
Type - Identifikační data - Kód sestavy: JV01; magiPartTypeId: 210; Název typu: 23_1_VZT_Hygienicke_zazemi; Označení typu: 02; Popis: Kompaktní VZT jednotka do podhledu, protiproudý deskový rekuperátor; Popis sestavy: Samostatná; VersionID: 1.0/2023.1; Výrobce: Systemair
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: 23_1_VZT_Hygienicke_zazemi
Classification: JV01 Uniformat (Uniformat); Group: ETA 27; SUP 4; ODA 1; EHA 9
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 21.5447 m2; NetVolume: 2.23989 m3
Mechanické – tok - Exhaust, left Air flow: 0.333 m3/s; Exhaust, left Airflow operation point max l/s: 0.35 m3/s; Exhaust, left Airflow operation point min l/s: 0.317 m3/s; Exhaust, left Maximum pressure drop: 82 Pa; Exhaust, left Minimum pressure drop: 68 Pa; Exhaust, left Pressure drop: 75 Pa; Exhaust, left Pressure drop max: 82.5 Pa; Exhaust, left Pressure drop min: 67.5 Pa; Extract, right Air flow: 0.333 m3/s; Extract, right Airflow operation point max l/s: 0.35 m3/s; Extract, right Airflow operation point min l/s: 0.317 m3/s; Extract, right Maximum pressure drop: 248 Pa; Extract, right Minimum pressure drop: 202 Pa; Extract, right Pressure drop: 225 Pa; Extract, right Pressure drop max: 247.5 Pa; Extract, right Pressure drop min: 202.5 Pa; Outdoor, left Air flow: 0.333 m3/s; Outdoor, left Airflow operation point max l/s: 0.35 m3/s; Outdoor, left Airflow operation point min l/s: 0.317 m3/s; Outdoor, left Maximum pressure drop: 82 Pa; Outdoor, left Minimum pressure drop: 68 Pa; Outdoor, left Pressure drop: 75 Pa; Outdoor, left Pressure drop max: 82.5 Pa; Outdoor, left Pressure drop min: 67.5 Pa; Pressure rise, extract: 300 Pa; Pressure rise, supply: 300 Pa; Průtok vzduchu čerstvý: 0.472222 m3/s; Průtok vzduchu odváděný: 0.472222 m3/s; Průtok vzduchu přívodní: 0.472222 m3/s; Průtok vzduchu znehodnocený: 0.472222 m3/s; Supply, right Air flow: 0.333 m3/s; Supply, right Airflow operation point max l/s: 0.35 m3/s; Supply, right Airflow operation point min l/s: 0.317 m3/s; Supply, right Maximum pressure drop: 248 Pa; Supply, right Minimum pressure drop: 202 Pa; Supply, right Pressure drop: 225 Pa; Supply, right Pressure drop max: 247.5 Pa; Supply, right Pressure drop min: 202.5 Pa
Text - CCI Funkční systém: J; CCI Komponenta: GQB; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Hostitel: Podlaží : -1.PP_SO-102; Odsazení od hostitele: 2848.53 mm; Výška od podlaží: 2848.53 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Exhaust, left Sound power level: 81 82 87 75 74 71 60 57 81 81 dB; Extract, right Sound power level: 78 75 72 56 49 40 31 26 65 65 dB; Klasifikace systému: Přívod vzduchu,Zpětný vzduch,Odváděný vzduch; Název systému: SUP 4,ODA 1,ETA 27,EHA 9; Outdoor, left Sound power level: 85 76 72 58 53 43 36 35 66 66 dB; Supply, right Sound power level: 84 82 89 80 78 74 67 65 84 84 dB
Kóty - Objem: 2.23989 m3; Plocha: 10.7835 m2
Identifikační data - Kód prvku: JV01.02.0002; Komentáře: VZT č.23 VZT jednotka podstropní Vp/Vo=1700 m3/h dp=300 Pa ZZT-deskový P=5,2 kW; Označení: 0002; Productdata: © MagiCAD Group, all rights reserved
Jiné - Páteřní trasa: yes; Id typu: 13372820; Rodina: 23_1_VZT_Hygienicke_zazemi; Rodina a typ: 23_1_VZT_Hygienicke_zazemi: 23_1_VZT_Hygienicke_zazemi; Typ: 23_1_VZT_Hygienicke_zazemi

# IfcBuildingElementProxy: 24_1_VZT_Jídelna_zázemí:24_1 VZT_Jídelna_zázemí, 24_1_VZT_Jídelna_zázemí:24_1 VZT_Jídelna_zázemí:12887694
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Weight: 839 kg
Type - Grafika - magiFamilyGeom: MagiCAD_Geniox 11 10.1 Jídelna/10.1 Jídelna
Type - Kóty - Délka: 4164 mm; MC Height: 1300 mm; MC Length: 4764 mm; MC Width: 1182 mm; Šířka: 1282 mm; Výška: 1400 mm
Type - Identifikační data - Kód sestavy: JV01; magiPartTypeId: 210; Název typu: 24_1 VZT_Jídelna_zázemí; Označení typu: 01; Popis sestavy: Samostatná; VersionID: 1.0/2023.1
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: 24_1_VZT_Jídelna_zázemí
Classification: JV01 Uniformat (Uniformat); Group: SUP 17; ODA 7; ETA 12; EHA 5
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 49.6348 m2; NetVolume: 7.00143 m3
Mechanické – tok - Exhaust 1 Airflow max ls: 1.5 m3/s; Exhaust 1 Airflow min ls: 0.3 m3/s; Exhaust 1 Airflow operation point max ls: 0.729 m3/s; Exhaust 1 Airflow operation point min ls: 0.66 m3/s; Exhaust 1 Flow: 0.694 m3/s; Exhaust 1 Pressure drop: 0 Pa; Extract 1 Airflow max ls: 1.5 m3/s; Extract 1 Airflow min ls: 0.3 m3/s; Extract 1 Airflow operation point max ls: 0.729 m3/s; Extract 1 Airflow operation point min ls: 0.66 m3/s; Extract 1 Flow: 0.694 m3/s; Extract 1 Pressure drop: 0 Pa; Outdoor 1 Airflow max ls: 1.5 m3/s; Outdoor 1 Airflow min ls: 0.3 m3/s; Outdoor 1 Airflow operation point max ls: 0.729 m3/s; Outdoor 1 Airflow operation point min ls: 0.66 m3/s; Outdoor 1 Flow: 0.694 m3/s; Outdoor 1 Pressure drop: 0 Pa; Pressure rise, extract: 300 Pa; Pressure rise, supply: 300 Pa; Průtok vzduchu čerstvý: 0.972222 m3/s; Průtok vzduchu odváděný: 0.972222 m3/s; Průtok vzduchu přívodní: 0.972222 m3/s; Průtok vzduchu znehodnocený: 0.972222 m3/s; Supply 1 Airflow max ls: 1.5 m3/s; Supply 1 Airflow min ls: 0.3 m3/s; Supply 1 Airflow operation point max ls: 0.729 m3/s; Supply 1 Airflow operation point min ls: 0.66 m3/s; Supply 1 Flow: 0.694 m3/s; Supply 1 Pressure drop: 300 Pa
Text - CCI Funkční systém: J; CCI Komponenta: GQB; CCI Technický systém: HF
Vazby - Hostitel: Podlaží : 2.NP_SO-102; Odsazení od hostitele: 0 mm; Podlaží: 2.NP_SO-102; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Exhaust 1 Sound generation: 63 78 67 68 68 65 60 56 dB; Extract 1 Sound generation: 59 71 61 58 52 47 41 36 dB; Fan efficiency, extract: 63.0 %; Fan efficiency, supply: 63.6 %; Fan speed, extract: 1799 RPM; Fan speed, supply: 2353 RPM; Heat recovery: 89.3 %; Klasifikace systému: Přívod vzduchu,Zpětný vzduch,Odváděný vzduch; Název systému: SUP 17,ODA 7,ETA 12,EHA 5; Outdoor 1 Sound generation: 62 63 63 59 54 50 44 39 dB; SFPe, dimensional filters excluding frequency converter: 1.75 kW/(m3/s); SFPe, výp. tlak. ztráta filtrù, s FM: 1.84 kW/(m3/s); SFPv, clean filters excluding frequency converter: 1.67 kW/(m3/s); SFPv, clean filters including frequency converter: 1.75 kW/(m3/s); Sound power level, extract: 60 dB(A); Sound power level, supply: 70 dB(A); Supply 1 Sound generation: 64 68 69 67 66 63 58 52 dB
Kóty - Objem: 7.00143 m3; Plocha: 24.8285 m2
Identifikační data - Kód prvku: JV01.01.0001; Komentáře: VZT č.24 VZT jednotka horizontální Vp/Vo=3500 m3/h dp=300 Pa ZZT-deskový P=2,7 kW; Označení: 0001; Productdata: © MagiCAD Group, all rights reserved
Jiné - Id typu: 12887665; Páteřní trasa: yes; Rodina: 24_1_VZT_Jídelna_zázemí; Rodina a typ: 24_1_VZT_Jídelna_zázemí: 24_1 VZT_Jídelna_zázemí; Typ: 24_1 VZT_Jídelna_zázemí

# IfcBuildingElementProxy: 25_1_VZT_Vystavni_sal_aula:25_1_VZT_Výstavní sál_aula, 25_1_VZT_Vystavni_sal_aula:25_1_VZT_Výstavní sál_aula:13695937
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Weight: 1534 kg
Type - Grafika - magiFamilyGeom: MagiCAD_Geniox 18 Výstavní sál/aula/Výstavní sál/aula
Type - Kóty - Délka: 4764 mm; MC Height: 2000 mm; MC Length: 4664 mm; MC Width: 1882 mm; Šířka: 1682 mm; Výška: 1800 mm
Type - Identifikační data - Kód sestavy: JV01; magiPartTypeId: 210; Název typu: 25_1_VZT_Výstavní sál_aula; Označení typu: 06; Popis sestavy: Samostatná; VersionID: 1.0/2023.1
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: 25_1_VZT_Vystavni_sal_aula
Classification: JV01 Uniformat (Uniformat); Group: SUP 9; ETA 14
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 87.1909 m2; NetVolume: 16.2601 m3
Mechanické – tok - Exhaust 1 Airflow max ls: 4.4 m3/s; Exhaust 1 Airflow min ls: 1 m3/s; Exhaust 1 Airflow operation point max ls: 2.479 m3/s; Exhaust 1 Airflow operation point min ls: 2.243 m3/s; Exhaust 1 Flow: 2.361 m3/s; Exhaust 1 Pressure drop: 0 Pa; Extract 1 Airflow max ls: 4.4 m3/s; Extract 1 Airflow min ls: 1 m3/s; Extract 1 Airflow operation point max ls: 2.479 m3/s; Extract 1 Airflow operation point min ls: 2.243 m3/s; Extract 1 Flow: 2.361 m3/s; Extract 1 Pressure drop: 0 Pa; Outdoor 1 Airflow max ls: 4.4 m3/s; Outdoor 1 Airflow min ls: 1 m3/s; Outdoor 1 Airflow operation point max ls: 2.479 m3/s; Outdoor 1 Airflow operation point min ls: 2.243 m3/s; Outdoor 1 Flow: 2.361 m3/s; Outdoor 1 Pressure drop: 0 Pa; Pressure rise, extract: 300 Pa; Pressure rise, supply: 300 Pa; Průtok vzduchu čerstvý: 2.05556 m3/s; Průtok vzduchu odváděný: 2.05556 m3/s; Průtok vzduchu přívodní: 2.05556 m3/s; Průtok vzduchu znehodnocený: 2.05556 m3/s; Supply 1 Airflow max ls: 4.4 m3/s; Supply 1 Airflow min ls: 1 m3/s; Supply 1 Airflow operation point max ls: 2.479 m3/s; Supply 1 Airflow operation point min ls: 2.243 m3/s; Supply 1 Flow: 2.361 m3/s; Supply 1 Pressure drop: 300 Pa
Text - CCI Funkční systém: J; CCI Komponenta: GQB; CCI Technický systém: HF
Vazby - Odsazení od hostitele: 0 mm; Podlaží: 2.NP_SO-102; Výška od podlaží: 0 mm; Hostitel: Podlaží : 2.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Exhaust 1 Sound generation: 71 82 73 75 71 68 64 59 dB; Extract 1 Sound generation: 64 74 66 60 56 51 45 42 dB; Fan efficiency, extract: 72.4 %; Fan efficiency, supply: 71.1 %; Fan speed, extract: 1334 RPM; Fan speed, supply: 1407 RPM; Heat recovery: 88.0 %; Klasifikace systému: Přívod vzduchu,Zpětný vzduch,Odváděný vzduch; Název systému: SUP 9,ETA 14; Outdoor 1 Sound generation: 63 77 67 62 57 52 46 44 dB; SFPe, dimensional filters excluding frequency converter: 1.84 kW/(m3/s); SFPe, výp. tlak. ztráta filtrù, s FM: 1.94 kW/(m3/s); SFPv, clean filters excluding frequency converter: 1.72 kW/(m3/s); SFPv, clean filters including frequency converter: 1.81 kW/(m3/s); Sound power level, extract: 64 dB(A); Sound power level, supply: 74 dB(A); Supply 1 Sound generation: 69 83 71 73 68 61 58 50 dB
Kóty - Objem: 16.2601 m3; Plocha: 43.6066 m2
Identifikační data - Kód prvku: JV01.06.0006; Komentáře: VZT č.25 VZT jednotka horizontální Vp/Vo=7400 m3/h dp=300 Pa ZZT-deskový P=7,0 kW; Označení: 0006; Productdata: © MagiCAD Group, all rights reserved
Jiné - Páteřní trasa: yes; Id typu: 13695908; Rodina: 25_1_VZT_Vystavni_sal_aula; Rodina a typ: 25_1_VZT_Vystavni_sal_aula: 25_1_VZT_Výstavní sál_aula; Typ: 25_1_VZT_Výstavní sál_aula

# IfcBuildingElementProxy: 26_1_VZT Byt skolnika:26_1_VZT Byt skolnika, 26_1_VZT Byt skolnika:26_1_VZT Byt skolnika:14028699
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné; Weight: 0 kg
Type - Grafika - magiFamilyGeom: MagiCAD_Topvex FR03 HWH-R-CAV
Type - Kóty - Délka: 1000 mm; MC Height: 565 mm; MC Length: 1120 mm; MC Width: 2139 mm; Šířka: 660 mm; Výška: 198 mm
Type - Identifikační data - Kód sestavy: JV01; magiPartTypeId: 210; magiProductCode: Topvex FR03 HWH-R-CAV; magiProductId: Topvex FR03 HWH-R-CAV; Model: Topvex FR03 HWH-R-CAV; Název typu: 26_1_VZT Byt skolnika; Označení typu: 11; Popis: Kompaktní VZT jednotka do podhledu, rotační rekuperátor; Popis sestavy: Samostatná; VersionID: 1.0/2023.1; Výrobce: Systemair
Type - Jiné - Kategorie: Mechanické zařízení; Název rodiny: 26_1_VZT Byt skolnika
Classification: JV01 Uniformat (Uniformat); Group: ODA 19; SUP 14; ETA 23; ETA 101
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 10.7973 m2; NetVolume: 0.960108 m3
Mechanické – tok - Exhaust, left Air flow: 0.114 m3/s; Exhaust, left Airflow operation point max l/s: 0.12 m3/s; Exhaust, left Airflow operation point min l/s: 0.108 m3/s; Exhaust, left Maximum pressure drop: 69 Pa; Exhaust, left Minimum pressure drop: 56 Pa; Exhaust, left Pressure drop: 62 Pa; Extract, right Air flow: 0.114 m3/s; Extract, right Airflow operation point max l/s: 0.12 m3/s; Extract, right Airflow operation point min l/s: 0.108 m3/s; Extract, right Maximum pressure drop: 206 Pa; Extract, right Minimum pressure drop: 169 Pa; Extract, right Pressure drop: 188 Pa; Outdoor, left Air flow: 0.114 m3/s; Outdoor, left Airflow operation point max l/s: 0.12 m3/s; Outdoor, left Airflow operation point min l/s: 0.108 m3/s; Outdoor, left Maximum pressure drop: 69 Pa; Outdoor, left Minimum pressure drop: 56 Pa; Outdoor, left Pressure drop: 62 Pa; Pressure rise, extract: 250 Pa; Pressure rise, supply: 250 Pa; Průtok vzduchu čerstvý: 0.0416667 m3/s; Průtok vzduchu odváděný: 0.0416667 m3/s; Průtok vzduchu přívodní: 0.0416667 m3/s; Průtok vzduchu znehodnocený: 0.0416667 m3/s; Supply, right Air flow: 0.114 m3/s; Supply, right Airflow operation point max l/s: 0.12 m3/s; Supply, right Airflow operation point min l/s: 0.108 m3/s; Supply, right Maximum pressure drop: 206 Pa; Supply, right Minimum pressure drop: 169 Pa; Supply, right Pressure drop: 188 Pa
Text - CCI Funkční systém: J; CCI Komponenta: GQB; CCI Technický systém: HF
Vazby - Podlaží: 1.NP_SO-102; Hostitel: Podlaží : 1.NP_SO-102; Odsazení od hostitele: 2800 mm; Výška od podlaží: 2800 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Exhaust, left Sound power level: 74 78 73 62 61 57 47 49 68 68 dB; Extract, right Sound power level: 70 73 59 41 38 29 22 22 58 58 dB; Klasifikace systému: Přívod vzduchu,Zpětný vzduch,Odváděný vzduch; Název systému: ODA 19,SUP 14,ETA 101,ETA 23; Outdoor, left Sound power level: 71 74 57 42 39 33 28 20 59 59 dB; Supply, right Sound power level: 75 77 70 62 61 59 52 45 68 68 dB
Kóty - Objem: 0.960108 m3; Plocha: 5.40982 m2
Identifikační data - Kód prvku: JV01.11.0015; Komentáře: VZT č.26 VZT jednotka podstropní Vp/Vo=150 m3/h dp=200 Pa ZZT-deskový P=2,0 kW; Označení: 0015; Productdata: © MagiCAD Group, all rights reserved
Jiné - Páteřní trasa: yes; Id typu: 13611307; Rodina: 26_1_VZT Byt skolnika; Rodina a typ: 26_1_VZT Byt skolnika: 26_1_VZT Byt skolnika; Typ: 26_1_VZT Byt skolnika

# IfcBuildingElementProxy: Dveřní mřížka:500x200 (88)
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: A1
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 150 mm; Šířka: 500 mm; Šířka mřížky: 500 mm; Výška: 200 mm; Výška mřížky: 200 mm
Type - Identifikační data - Kód sestavy: VV07; Název typu: 500x200; Označení typu: 01; Popis sestavy: Mřížka
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Dveřní mřížka
Classification: VV07 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: NAC; CCI Technický systém: HF
Vazby - Přesunout s blízkými prvky: no
Kóty - Úroveň dveří nad podlahou: 0 mm
Jiné - Id typu: 13524686; Rodina: Dveřní mřížka; Rodina a typ: Dveřní mřížka: 500x200; Typ: 500x200
Name (Dveřní mřížka:500x200:...) | In | NetSurfaceArea (m2) | NetVolume (m3) = Objem (m3) | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Plocha (m2) | Šířka dveří (mm) | Tloušťka dveří (mm) = Tloušťka mřížky (mm) | Kód prvku | Označení
13560602 | -1.PP_SO-102 | 0.245 | 0.0075 | -1.PP_SO-102 | 2500 | Fáze 1 | 0.1225 | 500 | 125 | VV07.01.0001 | 0001
13560868 | -1.PP_SO-102 | 0.245 | 0.0075 | -1.PP_SO-102 | 2100 | Fáze 1 | 0.1225 | 500 | 125 | VV07.01.0002 | 0002
13560886 | -1.PP_SO-102 | 0.245 | 0.0075 | -1.PP_SO-102 | 2100 | Fáze 1 | 0.1225 | 500 | 125 | VV07.01.0003 | 0003
13560909 | -1.PP_SO-102 | 0.22 | 0.006 | -1.PP_SO-102 | 2300 | Fáze 1 | 0.11 | 500 | 100 | VV07.01.0004 | 0004
13847923 | 4.NP_SO-102 | 0.3575 | 0.01125 | 4.NP_SO-102 | 2800 | Fáze 2 | 0.17875 | 700 | 112.5 | VV07.01.0114 | 0114
13848071 | 4.NP_SO-102 | 0.354 | 0.011 | 4.NP_SO-102 | 2800 | Fáze 2 | 0.177 | 700 | 110 | VV07.01.0115 | 0115
13856246 | -1.PP_SO-102 | 0.245 | 0.0075 | -1.PP_SO-102 | 2500 | Fáze 1 | 0.1225 | 500 | 125 | VV07.01.0132 | 0132
13856310 | -1.PP_SO-102 | 0.245 | 0.0075 | -1.PP_SO-102 | 2500 | Fáze 1 | 0.1225 | 500 | 125 | VV07.01.0133 | 0133
13856351 | -1.PP_SO-102 | 0.235 | 0.0069 | -1.PP_SO-102 | 2800 | Fáze 1 | 0.1175 | 500 | 115 | VV07.01.0134 | 0134
13856442 | -1.PP_SO-102 | 0.22 | 0.006 | -1.PP_SO-102 | 2500 | Fáze 1 | 0.11 | 500 | 100 | VV07.01.0135 | 0135
13869998 | 4.NP_SO-102 | 0.34 | 0.0132 | 4.NP_SO-102 | 2600 | Fáze 2 | 0.17 | 500 | 220 | VV07.01.0166 | 0166
13870111 | 4.NP_SO-102 | 0.34 | 0.0132 | 4.NP_SO-102 | 2600 | Fáze 2 | 0.17 | 500 | 220 | VV07.01.0167 | 0167
13870122 | 4.NP_SO-102 | 0.34 | 0.0132 | 4.NP_SO-102 | 2600 | Fáze 2 | 0.17 | 500 | 220 | VV07.01.0168 | 0168
13870135 | 4.NP_SO-102 | 0.32 | 0.012 | 4.NP_SO-102 | 2600 | Fáze 2 | 0.16 | 500 | 200 | VV07.01.0169 | 0169
13870192 | 4.NP_SO-102 | 0.27 | 0.009 | 4.NP_SO-102 | 2600 | Fáze 2 | 0.135 | 500 | 150 | VV07.01.0170 | 0170
13870284 | 4.NP_SO-102 | 0.32 | 0.012 | 4.NP_SO-102 | 2600 | Fáze 1 | 0.16 | 500 | 200 | VV07.01.0171 | 0171
13870507 | 4.NP_SO-102 | 0.32 | 0.012 | 4.NP_SO-102 | 2600 | Fáze 1 | 0.16 | 500 | 200 | VV07.01.0172 | 0172
13870519 | 3.NP_SO-102 | 0.32 | 0.012 | 3.NP_SO-102 | 2600 | Fáze 2 | 0.16 | 500 | 200 | VV07.01.0173 | 0173
13870615 | 3.NP_SO-102 | 0.32 | 0.012 | 3.NP_SO-102 | 2600 | Fáze 2 | 0.16 | 500 | 200 | VV07.01.0174 | 0174
13870626 | 3.NP_SO-102 | 0.32 | 0.012 | 3.NP_SO-102 | 2600 | Fáze 2 | 0.16 | 500 | 200 | VV07.01.0175 | 0175
13870650 | 3.NP_SO-102 | 0.32 | 0.012 | 3.NP_SO-102 | 2600 | Fáze 2 | 0.16 | 500 | 200 | VV07.01.0176 | 0176
13873109 | 4.NP_SO-102 | 0.32 | 0.012 | 4.NP_SO-102 | 2600 | Fáze 1 | 0.16 | 500 | 200 | VV07.01.0185 | 0185
13873122 | 4.NP_SO-102 | 0.32 | 0.012 | 4.NP_SO-102 | 2600 | Fáze 1 | 0.16 | 500 | 200 | VV07.01.0186 | 0186
13873134 | 3.NP_SO-102 | 0.27 | 0.009 | 3.NP_SO-102 | 2600 | Fáze 1 | 0.135 | 500 | 150 | VV07.01.0187 | 0187
13873209 | 3.NP_SO-102 | 0.32 | 0.012 | 3.NP_SO-102 | 2600 | Fáze 1 | 0.16 | 500 | 200 | VV07.01.0188 | 0188
13873324 | 3.NP_SO-102 | 0.32 | 0.012 | 3.NP_SO-102 | 2600 | Fáze 1 | 0.16 | 500 | 200 | VV07.01.0189 | 0189
13873359 | 3.NP_SO-102 | 0.32 | 0.012 | 3.NP_SO-102 | 2600 | Fáze 1 | 0.16 | 500 | 200 | VV07.01.0190 | 0190
13873376 | 3.NP_SO-102 | 0.32 | 0.012 | 3.NP_SO-102 | 2600 | Fáze 1 | 0.16 | 500 | 200 | VV07.01.0191 | 0191
13873410 | 2.NP_SO-102 | 0.32 | 0.012 | 2.NP_SO-102 | 2600 | Fáze 2 | 0.16 | 500 | 200 | VV07.01.0192 | 0192
13873476 | 2.NP_SO-102 | 0.32 | 0.012 | 2.NP_SO-102 | 2600 | Fáze 2 | 0.16 | 500 | 200 | VV07.01.0193 | 0193
13873487 | 2.NP_SO-102 | 0.32 | 0.012 | 2.NP_SO-102 | 2600 | Fáze 2 | 0.16 | 500 | 200 | VV07.01.0194 | 0194
13873502 | 2.NP_SO-102 | 0.32 | 0.012 | 2.NP_SO-102 | 2600 | Fáze 2 | 0.16 | 500 | 200 | VV07.01.0195 | 0195
13873536 | 2.NP_SO-102 | 0.32 | 0.012 | 2.NP_SO-102 | 2600 | Fáze 1 | 0.16 | 500 | 200 | VV07.01.0196 | 0196
13873586 | 2.NP_SO-102 | 0.32 | 0.012 | 2.NP_SO-102 | 2600 | Fáze 1 | 0.16 | 500 | 200 | VV07.01.0197 | 0197
13873601 | 2.NP_SO-102 | 0.32 | 0.012 | 2.NP_SO-102 | 2600 | Fáze 1 | 0.16 | 500 | 200 | VV07.01.0198 | 0198
13873616 | 2.NP_SO-102 | 0.32 | 0.012 | 2.NP_SO-102 | 2600 | Fáze 1 | 0.16 | 500 | 200 | VV07.01.0199 | 0199
13878536 | 2.NP_SO-102 | 0.22 | 0.006 | 2.NP_SO-102 | 2600 | Fáze 1 | 0.11 | 500 | 100 | VV07.01.0232 | 0232
13878641 | 2.NP_SO-102 | 0.22 | 0.006 | 2.NP_SO-102 | 2600 | Fáze 1 | 0.11 | 500 | 100 | VV07.01.0233 | 0233
13878748 | 2.NP_SO-102 | 0.22 | 0.006 | 2.NP_SO-102 | 2600 | Fáze 1 | 0.11 | 500 | 100 | VV07.01.0234 | 0234
13878779 | 2.NP_SO-102 | 0.22 | 0.006 | 2.NP_SO-102 | 2600 | Fáze 1 | 0.11 | 500 | 100 | VV07.01.0235 | 0235
13878838 | 2.NP_SO-102 | 0.22 | 0.006 | 2.NP_SO-102 | 2600 | Fáze 1 | 0.11 | 500 | 100 | VV07.01.0236 | 0236
13878849 | 2.NP_SO-102 | 0.42 | 0.018 | 2.NP_SO-102 | 2600 | Fáze 1 | 0.21 | 500 | 300 | VV07.01.0237 | 0237
13878889 | 2.NP_SO-102 | 0.195 | 0.0045 | 2.NP_SO-102 | 2600 | Fáze 1 | 0.0975 | 500 | 75 | VV07.01.0238 | 0238
13879005 | 2.NP_SO-102 | 0.195 | 0.0045 | 2.NP_SO-102 | 2600 | Fáze 1 | 0.0975 | 500 | 75 | VV07.01.0239 | 0239
13879016 | 2.NP_SO-102 | 0.22 | 0.006 | 2.NP_SO-102 | 2600 | Fáze 1 | 0.11 | 500 | 100 | VV07.01.0240 | 0240
13879082 | 2.NP_SO-102 | 0.22 | 0.006 | 2.NP_SO-102 | 2600 | Fáze 1 | 0.11 | 500 | 100 | VV07.01.0241 | 0241
13879107 | 2.NP_SO-102 | 0.22 | 0.006 | 2.NP_SO-102 | 2600 | Fáze 1 | 0.11 | 500 | 100 | VV07.01.0242 | 0242
13879161 | 2.NP_SO-102 | 0.22 | 0.006 | 2.NP_SO-102 | 2300 | Fáze 1 | 0.11 | 500 | 100 | VV07.01.0243 | 0243
13879174 | 2.NP_SO-102 | 0.22 | 0.006 | 2.NP_SO-102 | 2200 | Fáze 1 | 0.11 | 500 | 100 | VV07.01.0244 | 0244
13879188 | 2.NP_SO-102 | 0.22 | 0.006 | 2.NP_SO-102 | 2300 | Fáze 1 | 0.11 | 500 | 100 | VV07.01.0245 | 0245
13879315 | 2.NP_SO-102 | 0.22 | 0.006 | 2.NP_SO-102 | 2300 | Fáze 1 | 0.11 | 500 | 100 | VV07.01.0246 | 0246
13879358 | 2.NP_SO-102 | 0.22 | 0.006 | 2.NP_SO-102 | 2300 | Fáze 1 | 0.11 | 500 | 100 | VV07.01.0247 | 0247
13891898 | 2.NP_SO-102 | 0.245 | 0.0075 | 2.NP_SO-102 | 2600 | Fáze 1 | 0.1225 | 500 | 125 | VV07.01.0273 | 0273
13893444 | 2.NP_SO-102 | 0.22 | 0.006 | 2.NP_SO-102 | 2600 | Fáze 1 | 0.11 | 500 | 100 | VV07.01.0274 | 0274
13893536 | 2.NP_SO-102 | 0.22 | 0.006 | 2.NP_SO-102 | 2600 | Fáze 1 | 0.11 | 500 | 100 | VV07.01.0275 | 0275
13909933 | 1.NP_SO-102 | 0.32 | 0.012 | 1.NP_SO-102 | 2600 | Fáze 1 | 0.16 | 500 | 200 | VV07.01.0284 | 0284
13910005 | 1.NP_SO-102 | 0.32 | 0.012 | 1.NP_SO-102 | 2600 | Fáze 1 | 0.16 | 500 | 200 | VV07.01.0285 | 0285
13910018 | 1.NP_SO-102 | 0.32 | 0.012 | 1.NP_SO-102 | 2600 | Fáze 1 | 0.16 | 500 | 200 | VV07.01.0286 | 0286
13913535 | 1.NP_SO-102 | 0.32 | 0.012 | 1.NP_SO-102 | 2600 | Fáze 1 | 0.16 | 500 | 200 | VV07.01.0297 | 0297
13913546 | 1.NP_SO-102 | 0.32 | 0.012 | 1.NP_SO-102 | 2600 | Fáze 1 | 0.16 | 500 | 200 | VV07.01.0298 | 0298
13930588 | 1.NP_SO-102 | 0.27 | 0.009 | 1.NP_SO-102 | 2600 | Fáze 1 | 0.135 | 500 | 150 | VV07.01.0317 | 0317
13947585 | -1.PP_SO-102 | 0.506313 | 0.0213157 | -1.PP_SO-102 | 2800 | Fáze 1 | 0.253157 | 732.891 | 200 | VV07.01.0335 | 0335 | Identifikační data - ID systému: PSUM
13947768 | -1.PP_SO-102 | 0.506313 | 0.0213157 | -1.PP_SO-102 | 2800 | Fáze 1 | 0.253157 | 732.891 | 200 | VV07.01.0336 | 0336 | Identifikační data - ID systému: PSUM
13947779 | -1.PP_SO-102 | 0.506313 | 0.0213157 | -1.PP_SO-102 | 2800 | Fáze 1 | 0.253157 | 732.891 | 200 | VV07.01.0337 | 0337 | Identifikační data - ID systému: PSUM
13947788 | -1.PP_SO-102 | 0.506313 | 0.0213157 | -1.PP_SO-102 | 2800 | Fáze 1 | 0.253157 | 732.891 | 200 | VV07.01.0338 | 0338 | Identifikační data - ID systému: PSUM
13952476 | -1.PP_SO-102 | 0.245 | 0.0075 | -1.PP_SO-102 | 2500 | Fáze 1 | 0.1225 | 500 | 125 | VV07.01.0344 | 0344
13952728 | -1.PP_SO-102 | 0.27 | 0.009 | -1.PP_SO-102 | 2800 | Fáze 1 | 0.135 | 500 | 150 | VV07.01.0345 | 0345
13965947 | -1.PP_SO-102 | 0.27 | 0.009 | -1.PP_SO-102 | 2500 | Fáze 1 | 0.135 | 500 | 150 | VV07.01.0361 | 0361 | Identifikační data - ID systému: PSUM
13966451 | -1.PP_SO-102 | 0.27 | 0.009 | -1.PP_SO-102 | 2500 | Fáze 1 | 0.135 | 500 | 150 | VV07.01.0362 | 0362 | Identifikační data - ID systému: PSUM
13976337 | 3.NP_SO-102 | 0.22 | 0.006 | 3.NP_SO-102 | 2600 | Fáze 1 | 0.11 | 500 | 100 | VV07.01.0365 | 0365
13979270 | 3.NP_SO-102 | 0.245 | 0.0075 | 3.NP_SO-102 | 2600 | Fáze 2 | 0.1225 | 500 | 125 | VV07.01.0366 | 0366
14002207 | -1.PP_SO-102 | 0.506313 | 0.0213157 | -1.PP_SO-102 | 2800 | Fáze 2 | 0.253157 | 732.891 | 200 | VV07.01.0386 | 0386 | Identifikační data - ID systému: PSUM
14004156 | -1.PP_SO-102 | 0.289803 | 0.00906763 | -1.PP_SO-102 | 2800 | Fáze 2 | 0.144902 | 577.818 | 120 | VV07.01.0387 | 0387 | Identifikační data - ID systému: PSUM
14004279 | -1.PP_SO-102 | 0.38905 | 0.0127894 | -1.PP_SO-102 | 2800 | Fáze 2 | 0.194525 | 732.891 | 120 | VV07.01.0388 | 0388 | Identifikační data - ID systému: PSUM
14005827 | -1.PP_SO-102 | 0.506329 | 0.0213168 | -1.PP_SO-102 | 2500 | Fáze 2 | 0.253165 | 732.891 | 200.011 | VV07.01.0389 | 0389 | Identifikační data - ID systému: PSUM
14005898 | -1.PP_SO-102 | 0.307115 | 0.00971683 | -1.PP_SO-102 | 2800 | Fáze 2 | 0.153558 | 604.868 | 120 | VV07.01.0390 | 0390 | Identifikační data - ID systému: PSUM
14005961 | -1.PP_SO-102 | 0.27774 | 0.00861525 | -1.PP_SO-102 | 2800 | Fáze 2 | 0.13887 | 558.969 | 120 | VV07.01.0391 | 0391 | Identifikační data - ID systému: PSUM
14006367 | -1.PP_SO-102 | 0.307115 | 0.00971683 | -1.PP_SO-102 | 2800 | Fáze 2 | 0.153558 | 604.868 | 120 | VV07.01.0392 | 0392 | Identifikační data - ID systému: PSUM
14040642 | 2.NP_SO-102 | 0.42 | 0.018 | 2.NP_SO-102 | 2600 | Fáze 1 | 0.21 | 500 | 300 | VV07.01.0411 | 0411
14057182 | 1.NP_SO-102 | 0.32 | 0.012 | 1.NP_SO-102 | 2600 | Fáze 1 | 0.16 | 500 | 200 | VV07.01.0424 | 0424
14057323 | 1.NP_SO-102 | 0.27 | 0.009 | 1.NP_SO-102 | 2600 | Fáze 1 | 0.135 | 500 | 150 | VV07.01.0425 | 0425
14061303 | -1.PP_SO-102 | 0.27 | 0.009 | -1.PP_SO-102 | 2800 | Fáze 1 | 0.135 | 500 | 150 | VV07.01.0429 | 0429
14061375 | -1.PP_SO-102 | 0.321966 | 0.0121179 | -1.PP_SO-102 | 2400 | Fáze 1 | 0.160983 | 500 | 201.966 | VV07.01.0430 | 0430
14065072 | 4.NP_SO-102 | 0.3575 | 0.01125 | 4.NP_SO-102 | 2800 | Fáze 2 | 0.17875 | 700 | 112.5 | VV07.01.0436 | 0436
14068994 | 1.NP_SO-102 | 0.22 | 0.006 | 1.NP_SO-102 | 2600 | Fáze 1 | 0.11 | 500 | 100 | VV07.01.0439 | 0439 | Identifikační data - ID systému: PSUM
14152276 | 2.NP_SO-102 | 0.22 | 0.006 | 2.NP_SO-102 | 2600 | Fáze 1 | 0.11 | 500 | 100 | VV07.01.0464 | 0464
14184651 | -1.PP_SO-102 | 0.245 | 0.0075 | -1.PP_SO-102 | 2500 | Fáze 1 | 0.1225 | 500 | 125 | VV07.01.0465 | 0465
14184681 | -1.PP_SO-102 | 0.245 | 0.0075 | -1.PP_SO-102 | 2100 | Fáze 1 | 0.1225 | 500 | 125 | VV07.01.0466 | 0466

# IfcBuildingElementProxy: Odvodní ventilátor:Odvodní ventilátor, Odvodní ventilátor:Odvodní ventilátor:13628810
In: -1.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - DÉLKA: 303 mm; POTRUBÍ_PRŮMĚR: 100 mm; Šířka: 217 mm; Výška: 293 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.35.17.24; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VN01; Komentáře k typům: Komentáře k typům; Model: Model; Nadpis OmniClass: Axial Fans; Název typu: Odvodní ventilátor; Označení typu: 04; Popis: Popis; Popis sestavy: Axiální; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Mechanické zařízení; a: 30 mm; b: 84.708 mm; C: 115 mm; D: 97 mm; E: 100 mm; F: 90 mm; G: 20 mm; H: 60 mm; Název rodiny: Odvodní ventilátor
Classification: VN01 Uniformat (Uniformat); Group: ETA 8
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.176726 m2; NetVolume: 0.00521594 m3
Mechanické – tok - PRŮTOK: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: MAA; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Hostitel: Podlaží : -1.PP_SO-102; Odsazení od hostitele: 3160 mm; Výška od podlaží: 3160 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Odváděný vzduch; Název systému: ETA 8
Kóty - Objem: 0.00521594 m3; Plocha: 0.0460233 m2
Identifikační data - ID instance: Odvodní ventilátor; ID systému: VZT č.28; Kód prvku: VN01.04.0004; Komentáře: VZT č.28 Odvodní ventilátor Vo=790 m3/h dp=200 Pa P=0,1 kW; Označení: 0004
Jiné - Páteřní trasa: yes; Id typu: 13542076; Rodina: Odvodní ventilátor; Rodina a typ: Odvodní ventilátor: Odvodní ventilátor; Typ: Odvodní ventilátor

# IfcBuildingElementProxy: Požární klapka hranatá.LH:1000x400 (5)
In: 2.NP_SO-102
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 1000 mm; Jmenovitá velikost vstupu - výška: 400 mm; Jmenovitá velikost výstupu - šířka: 1000 mm; Jmenovitá velikost výstupu - výška: 400 mm; Šířka: 1000 mm; Šířka příruby: 30 mm; Tloušťka příruby: 5 mm; Výška: 400 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: 1000x400; Označení typu: 24; Popis: Požářní klapka hranatá; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka hranatá.LH
Classification: PK00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.22062 m2; NetVolume: 0.210088 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1000 mm × 400 mm-1000 mm × 400 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1000 mm × 400 mm-1000 mm × 400 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Připojení ELEKTRO: no; Připojení EPS: no; Připojení MaR: no
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.205212 m3; Velikost: 1000 × 400-1000 × 400
Jiné - Páteřní trasa: yes; Rodina: Požární klapka hranatá.LH; Id typu: 13820414; Rodina a typ: Požární klapka hranatá.LH: 1000x400; Typ: 1000x400
Name (Požární klapka hranatá.LH:1000x400:...) | Tlaková ztráta (Pa) | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému | Zkratka systému | Kód prvku | Označení | Group
13820447 | 0 | 2920 | Odváděný | Zpětný vzduch | ETA 14 | ETA | PK00.24.0051 | 0051 | ETA 14
14012008 | 0 | 87.5142 | Přívodní | Přívod vzduchu | SUP 11 | SUP | PK00.24.0395 | 0395 | SUP 11
14012065 |  | 0 | Přívodní | Přívod vzduchu | SUP 15 | SUP | PK00.24.0396 | 0396 | SUP 15
14012769 |  | 0 | Přívodní | Přívod vzduchu | SUP 62 | SUP | PK00.24.0397 | 0397 | ETA 11
14012854 | 0 | 0 | Přívodní | Přívod vzduchu | SUP 64 | SUP | PK00.24.0398 | 0398 | ETA 11; SUP 64

# IfcBuildingElementProxy: Požární klapka hranatá.LH:1120x400 (2)
In: -1.PP_SO-102
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 1120 mm; Jmenovitá velikost vstupu - výška: 400 mm; Jmenovitá velikost výstupu - šířka: 1120 mm; Jmenovitá velikost výstupu - výška: 400 mm; Šířka: 1120 mm; Šířka příruby: 30 mm; Tloušťka příruby: 5 mm; Výška: 400 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: 1120x400; Označení typu: 12; Popis: Požářní klapka hranatá; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka hranatá.LH
Classification: PK00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.88302 m2; NetVolume: 0.235192 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1120 mm × 400 mm-1120 mm × 400 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1120 mm × 400 mm-1120 mm × 400 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Připojení ELEKTRO: no; Připojení EPS: no; Připojení MaR: no
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.229764 m3; Velikost: 1120 × 400-1120 × 400
Jiné - Páteřní trasa: yes; Rodina: Požární klapka hranatá.LH; Id typu: 13788635; Rodina a typ: Požární klapka hranatá.LH: 1120x400; Typ: 1120x400
Name (Požární klapka hranatá.LH:1120x400:...) | Výška od podlaží (mm) | Název systému = Group | Kód prvku | Označení
13788666 | 2485.78 | ETA 1 | PK00.12.0022 | 0022
13809205 | 3080 | ETA 7 | PK00.12.0028 | 0028

# IfcBuildingElementProxy: Požární klapka hranatá.LH:1250x400 (2)
In: 2.NP_SO-102
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 1250 mm; Jmenovitá velikost vstupu - výška: 400 mm; Jmenovitá velikost výstupu - šířka: 1250 mm; Jmenovitá velikost výstupu - výška: 400 mm; Šířka: 1250 mm; Šířka příruby: 30 mm; Tloušťka příruby: 5 mm; Výška: 400 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: 1250x400; Označení typu: 25; Popis: Požářní klapka hranatá; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka hranatá.LH
Classification: PK00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 7.60062 m2; NetVolume: 0.262388 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1250 mm × 400 mm-1250 mm × 400 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1250 mm × 400 mm-1250 mm × 400 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Připojení ELEKTRO: no; Připojení EPS: no; Připojení MaR: no
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.256362 m3; Velikost: 1250 × 400-1250 × 400
Jiné - Páteřní trasa: yes; Rodina: Požární klapka hranatá.LH; Id typu: 13820598; Rodina a typ: Požární klapka hranatá.LH: 1250x400; Typ: 1250x400
Name (Požární klapka hranatá.LH:1250x400:...) | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13820645 | 2920 | Odváděný | Zpětný vzduch | ETA 14 | ETA | PK00.25.0052 | 0052
13820674 | 2880 | Přívodní | Přívod vzduchu | SUP 9 | SUP | PK00.25.0053 | 0053 | Mechanické – tok - Tlaková ztráta: 0 Pa

# IfcBuildingElementProxy: Požární klapka hranatá.LH:1250x560 (2)
In: 2.NP_SO-102
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 1250 mm; Jmenovitá velikost vstupu - výška: 560 mm; Jmenovitá velikost výstupu - šířka: 1250 mm; Jmenovitá velikost výstupu - výška: 560 mm; Šířka: 1250 mm; Šířka příruby: 30 mm; Tloušťka příruby: 5 mm; Výška: 560 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: 1250x560; Označení typu: 33; Popis: Požářní klapka hranatá; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka hranatá.LH
Classification: PK00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 9.84382 m2; NetVolume: 0.36658 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1250 mm × 560 mm-1250 mm × 560 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1250 mm × 560 mm-1250 mm × 560 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Připojení ELEKTRO: no; Připojení EPS: no; Připojení MaR: no
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.358458 m3; Velikost: 1250 × 560-1250 × 560
Jiné - Páteřní trasa: yes; Rodina: Požární klapka hranatá.LH; Id typu: 13825174; Rodina a typ: Požární klapka hranatá.LH: 1250x560; Typ: 1250x560
Name (Požární klapka hranatá.LH:1250x560:...) | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13846539 | 2700 | Přívodní | Přívod vzduchu | SUP 13 | SUP | PK00.33.0108 | 0108
13846670 | 2800 | Odváděný | Zpětný vzduch | ETA 3 | ETA | PK00.33.0109 | 0109

# IfcBuildingElementProxy: Požární klapka hranatá.LH:1250x710, Požární klapka hranatá.LH:1250x710:13805546
In: -1.PP_SO-102
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 1250 mm; Jmenovitá velikost vstupu - výška: 710 mm; Jmenovitá velikost výstupu - šířka: 1250 mm; Jmenovitá velikost výstupu - výška: 710 mm; Šířka: 1250 mm; Šířka příruby: 30 mm; Tloušťka příruby: 5 mm; Výška: 710 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: 1250x710; Označení typu: 14; Popis: Požářní klapka hranatá; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka hranatá.LH
Classification: PK00 Uniformat (Uniformat); Group: SUP 24
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 11.9468 m2; NetVolume: 0.46426 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1250 mm × 710 mm-1250 mm × 710 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1250 mm × 710 mm-1250 mm × 710 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Připojení ELEKTRO: no; Připojení EPS: no; Připojení MaR: no; Výška od podlaží: 2550 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 24; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.454173 m3; Velikost: 1250 × 710-1250 × 710
Identifikační data - Kód prvku: PK00.14.0027; Označení: 0027
Jiné - Páteřní trasa: yes; Rodina: Požární klapka hranatá.LH; Id typu: 13805529; Rodina a typ: Požární klapka hranatá.LH: 1250x710; Typ: 1250x710

# IfcBuildingElementProxy: Požární klapka hranatá.LH:1400x500 (2)
In: -1.PP_SO-102
Type - Material: 128-64-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 1400 mm; Jmenovitá velikost vstupu - výška: 500 mm; Jmenovitá velikost výstupu - šířka: 1400 mm; Jmenovitá velikost výstupu - výška: 500 mm; Šířka: 1400 mm; Šířka příruby: 30 mm; Tloušťka příruby: 5 mm; Výška: 500 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: 1400x500; Označení typu: 15; Popis: Požářní klapka hranatá; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka hranatá.LH
Classification: PK00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 9.98062 m2; NetVolume: 0.366688 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1400 mm × 500 mm-1400 mm × 500 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1400 mm × 500 mm-1400 mm × 500 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Připojení ELEKTRO: no; Připojení EPS: no; Připojení MaR: no
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Znehodnocený; Klasifikace systému: Odváděný vzduch; Zkratka systému: EHA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.358512 m3; Velikost: 1400 × 500-1400 × 500
Jiné - Páteřní trasa: yes; Rodina: Požární klapka hranatá.LH; Id typu: 13809763; Rodina a typ: Požární klapka hranatá.LH: 1400x500; Typ: 1400x500
Name (Požární klapka hranatá.LH:1400x500:...) | Výška od podlaží (mm) | Název systému = Group | Kód prvku | Označení
13809264 | 3050 | EHA 1 | PK00.15.0029 | 0029 | Mechanické – tok - Tlaková ztráta: 0 Pa
13809870 | 2300 | EHA 17 | PK00.15.0031 | 0031

# IfcBuildingElementProxy: Požární klapka hranatá.LH:1600x500 (2)
In: -1.PP_SO-102
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 1600 mm; Jmenovitá velikost vstupu - výška: 500 mm; Jmenovitá velikost výstupu - šířka: 1600 mm; Jmenovitá velikost výstupu - výška: 500 mm; Šířka: 1600 mm; Šířka příruby: 30 mm; Tloušťka příruby: 5 mm; Výška: 500 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: 1600x500; Označení typu: 16; Popis: Požářní klapka hranatá; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka hranatá.LH
Classification: PK00 Uniformat (Uniformat); Group: SUP 24
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 11.2846 m2; NetVolume: 0.418928 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1600 mm × 500 mm-1600 mm × 500 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1600 mm × 500 mm-1600 mm × 500 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Připojení ELEKTRO: no; Připojení EPS: no; Připojení MaR: no; Výška od podlaží: 3090 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 24; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.409632 m3; Velikost: 1600 × 500-1600 × 500
Jiné - Rodina: Požární klapka hranatá.LH; Id typu: 13809088; Rodina a typ: Požární klapka hranatá.LH: 1600x500; Typ: 1600x500
Name (Požární klapka hranatá.LH:1600x500:...) | Kód prvku | Označení
13809788 | PK00.16.0030 | 0030 | Jiné - Páteřní trasa: yes
13810240 | PK00.16.0034 | 0034

# IfcBuildingElementProxy: Požární klapka hranatá.LH:500x160 (2)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 500 mm; Jmenovitá velikost vstupu - výška: 160 mm; Jmenovitá velikost výstupu - šířka: 500 mm; Jmenovitá velikost výstupu - výška: 160 mm; Šířka: 500 mm; Šířka příruby: 30 mm; Tloušťka příruby: 5 mm; Výška: 160 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: 500x160; Označení typu: 73; Popis: Požářní klapka hranatá; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka hranatá.LH
Classification: PK00 Uniformat (Uniformat); Group: SUP 13
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.89582 m2; NetVolume: 0.0427996 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 500 mm × 160 mm-500 mm × 160 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 500 mm × 160 mm-500 mm × 160 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Připojení ELEKTRO: no; Připojení EPS: no; Připojení MaR: no; Výška od podlaží: 2735 mm
Fázování - Fáze vytvoření: Fáze 2
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Název systému: SUP 13; Zkratka systému: SUP
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0415676 m3; Velikost: 500 × 160-500 × 160
Jiné - Rodina: Požární klapka hranatá.LH; Id typu: 14195721; Rodina a typ: Požární klapka hranatá.LH: 500x160; Typ: 500x160
Name (Požární klapka hranatá.LH:500x160:...) | In | Podlaží | Kód prvku | Označení
14194984 | 3.NP_SO-102 | 3.NP_SO-102 | PK00.73.0468 | 0468
14196743 | 2.NP_SO-102 | 2.NP_SO-102 | PK00.73.0469 | 0469

# IfcBuildingElementProxy: Požární klapka hranatá.LH:500x225 (3)
In: 2.NP_SO-102
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 500 mm; Jmenovitá velikost vstupu - výška: 225 mm; Jmenovitá velikost výstupu - šířka: 500 mm; Jmenovitá velikost výstupu - výška: 225 mm; Šířka: 500 mm; Šířka příruby: 30 mm; Tloušťka příruby: 5 mm; Výška: 225 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: 500x225; Označení typu: 63; Popis: Požářní klapka hranatá; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka hranatá.LH
Classification: PK00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.31962 m2; NetVolume: 0.0597776 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 500 mm × 225 mm-500 mm × 225 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 500 mm × 225 mm-500 mm × 225 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Připojení ELEKTRO: no; Připojení EPS: no; Připojení MaR: no
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0581816 m3; Velikost: 500 × 225-500 × 225
Jiné - Páteřní trasa: yes; Rodina: Požární klapka hranatá.LH; Typ: 500x225; Id typu: 14036568; Rodina a typ: Požární klapka hranatá.LH: 500x225
Name (Požární klapka hranatá.LH:500x225:...) | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
14036603 | 2925 | Odváděný | Zpětný vzduch | ETA 14 | ETA | PK00.63.0403 | 0403
14036880 | 2880 | Přívodní | Přívod vzduchu | SUP 9 | SUP | PK00.63.0404 | 0404
14037547 | 2880 | Přívodní | Přívod vzduchu | SUP 9 | SUP | PK00.63.0406 | 0406

# IfcBuildingElementProxy: Požární klapka hranatá.LH:500x280 (4)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 500 mm; Jmenovitá velikost vstupu - výška: 280 mm; Jmenovitá velikost výstupu - šířka: 500 mm; Jmenovitá velikost výstupu - výška: 280 mm; Šířka: 500 mm; Šířka příruby: 30 mm; Tloušťka příruby: 5 mm; Výška: 280 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: 500x280; Označení typu: 51; Popis: Požářní klapka hranatá; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka hranatá.LH
Classification: PK00 Uniformat (Uniformat); Group: ETA 7
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 2.67822 m2; NetVolume: 0.0741436 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 500 mm × 280 mm-500 mm × 280 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 500 mm × 280 mm-500 mm × 280 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
