Properties of the parts of a building model (IFC4), part 35 of 45

# IfcDuctFitting: M_Přechod, hranaté na kulaté, úhel:45 stupňů (10)
Name (M_Přechod, hranaté na kulaté, úhel:45 stupňů:...) | In | Volná velikost = Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Šířka odsazení od základny (mm) | Délka01 (mm) = Délka 8 (mm) | Delta 1 (mm) | Delta 2 (mm) = Délka 5 (mm) = Délka 6 (mm) | Dočas. šířka odsazení | Dočas. výška odsazení | Objem (m3) | Odskok – šířka | Odskok – výška = Polovina V0 (mm) | Plocha (m2) | Poloměr potrubí (mm) | Průměr vedení (mm) | Šířka potrubí (mm) | Velikost | Výška potrubí (mm) | Kód prvku | Označení | Délka 3 (mm) | Číslo 1 | Číslo 10 | Číslo 2 | Číslo 3 | Číslo 5 | Číslo 6 = Číslo 7 | Číslo 8 | Délka 1 (mm) | Délka 2 (mm) | Délka 7 (mm) | Polovina Š0 (mm)
13810481 | -1.PP_SO-102 | 800 mm × 400 mm-355 mm | 20.351 | -1.PP_SO-102 | 2207.84 | Čerstvý | Přívod vzduchu | ODA 2 | ODA | 3048 | 537.163 | 222.5 | 22.5 | -0.111111 | 0.0555556 | 0.113159 | 400 | 200 | 0.632986 | 177.5 | 355 | 800 | 800 × 400-355 | 400 | TA00.05.0372 | 0372 | 0 | 8.9 | 2.17279 | 8.9 | 17.8 | 21.4865 | 0.9 | 1.8 | 222.5 | 222.5 | 54.3198 | 400
13810507 | -1.PP_SO-102 | 800 mm × 400 mm-355 mm | 0 | -1.PP_SO-102 | 2207.84 | Znehodnocený | Odváděný vzduch | EHA 2 | EHA | 3048 | 537.163 | 222.5 | 22.5 | -0.111111 | 0.0555556 | 0.113159 | 400 | 200 | 0.632986 | 177.5 | 355 | 800 | 800 × 400-355 | 400 | TA00.05.0375 | 0375 | 0 | 8.9 | 2.17279 | 8.9 | 17.8 | 21.4865 | 0.9 | 1.8 | 222.5 | 222.5 | 54.3198 | 400
13951647 | -1.PP_SO-102 | 500 mm × 250 mm-355 mm | 0 | -1.PP_SO-102 | 3076.47 | Znehodnocený | Odváděný vzduch | EHA 9 | EHA | 3048 | 175.03 | 72.5 | 52.5 | -0.0694444 | 0.0347222 | 0.0208347 | 250 | 125 | 0.194356 | 177.5 | 355 | 500 | 500 × 250-355 | 250 | TA00.05.0780 | 0780 | 0 | 2.9 | 5.06985 | 2.9 | 5.8 | 7.00122 | 2.1 | 4.2 | 72.5 | 72.5 | 126.746 | 250
14002967 | 4.NP_SO-102 | 500 mm × 450 mm-355 mm |  | STŘECHA_SO-102 | 1000 | Čerstvý | Přívod vzduchu | ODA 10 | ODA | 3048 | 175.03 | 72.5 | 47.5 | -0.0694444 | 0.0625 | 0.0287403 | 250 | 225 | 0.237287 | 177.5 | 355 | 500 | 500 × 450-355 | 450 | TA00.05.0930 | 0930 | 0 | 2.9 | 4.58701 | 2.9 | 5.8 | 7.00122 | 1.9 | 3.8 | 72.5 | 72.5 | 114.675 | 250
14003005 | 4.NP_SO-102 | 500 mm × 450 mm-355 mm |  | STŘECHA_SO-102 | 1000 | Čerstvý | Přívod vzduchu | ODA 10 | ODA | 3047.94 | 175.03 | 72.5 | 47.5 | -0.0694269 | 0.0625 | 0.0287403 | 249.937 | 225 | 0.237287 | 177.5 | 355 | 500 | 500 × 450-355 | 450 | TA00.05.0933 | 0933 | 0.0631373 | 2.90253 | 4.58701 | 2.89747 | 5.8 | 7.00122 | 1.9 | 3.8 | 72.5631 | 72.4369 | 114.675 | 250

# IfcDuctFitting: M_Přechod, hranaté na kulaté, úhel:45 stupňů (10)
In: -1.PP_SO-102
Type - Material: 128-64-0
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Cena: 10; Číslo OmniClass: 23.75.70.14; ID kategorie: R; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 05; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Přechod, hranaté na kulaté, úhel
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 600 mm × 600 mm-355 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 600 mm × 600 mm-355 mm
Mechanické – tok - Tlaková ztráta: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - Šířka odsazení od základny: 3048 mm; Výška odsazení od základny: 3048 mm; Délka01: 295.741 mm; Delta 1: 122.5 mm; Delta 2: 122.5 mm; Dočas. šířka odsazení: -0.0833333; Dočas. výška odsazení: 0.0833333; Objem: 0.066244 m3; Odskok – šířka: 300; Odskok – výška: 300; Plocha: 0.415574 m2; Poloměr potrubí: 177.5 mm; Průměr vedení: 355 mm; Šířka potrubí: 600 mm; Velikost: 600 × 600-355; Výška potrubí: 600 mm
Jiné - Páteřní trasa: yes; Číslo 4: 1; Délka 3: 0 mm; Typ: 45 stupňů; Číslo 9: 1; Délka 4: 0 mm; Id typu: 1559786; Rodina: M_Přechod, hranaté na kulaté, úhel; Rodina a typ: M_Přechod, hranaté na kulaté, úhel: 45 stupňů; Číslo 1: 4.9; Číslo 10: 11.8296; Číslo 2: 4.9; Číslo 3: 9.8; Číslo 5: 11.8296; Číslo 6: 4.9; Číslo 7: 4.9; Číslo 8: 9.8; Délka 1: 122.5 mm; Délka 2: 122.5 mm; Délka 5: 122.5 mm; Délka 6: 122.5 mm; Délka 7: 295.741 mm; Délka 8: 295.741 mm; Polovina Š0: 300 mm; Polovina V0: 300 mm
Name (M_Přechod, hranaté na kulaté, úhel:45 stupňů:...) | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13810642 | 3100 | Znehodnocený | Odváděný vzduch | EHA 2 | EHA | TA00.05.0376 | 0376
13810644 | 3100 | Znehodnocený | Odváděný vzduch | EHA 2 | EHA | TA00.05.0377 | 0377
13810663 | 3100 | Čerstvý | Přívod vzduchu | ODA 2 | ODA | TA00.05.0378 | 0378
13810664 | 3100 | Čerstvý | Přívod vzduchu | ODA 2 | ODA | TA00.05.0379 | 0379
13810964 | 3077.14 | Přívodní | Přívod vzduchu | SUP 4 | SUP | TA00.05.0380 | 0380
13810965 | 3077.14 | Přívodní | Přívod vzduchu | SUP 4 | SUP | TA00.05.0381 | 0381
13951913 | 3077.14 | Znehodnocený | Odváděný vzduch | EHA 9 | EHA | TA00.05.0783 | 0783
13952073 | 3077.14 | Čerstvý | Přívod vzduchu | ODA 1 | ODA | TA00.05.0786 | 0786
13952178 | 3076.47 | Znehodnocený | Odváděný vzduch | EHA 9 | EHA | TA00.05.0787 | 0787
13952433 | 3076.47 | Čerstvý | Přívod vzduchu | ODA 1 | ODA | TA00.05.0793 | 0793

# IfcDuctFitting: M_Přechod, hranaté na kulaté, úhel:45 stupňů (59)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Cena: 10; Číslo OmniClass: 23.75.70.14; ID kategorie: R; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 05; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Přechod, hranaté na kulaté, úhel
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Grafika - Použít měřítko poznámky: yes
Jiné - Číslo 4: 1; Typ: 45 stupňů; Číslo 9: 1; Id typu: 1559786; Rodina: M_Přechod, hranaté na kulaté, úhel; Rodina a typ: M_Přechod, hranaté na kulaté, úhel: 45 stupňů
Name (M_Přechod, hranaté na kulaté, úhel:45 stupňů:...) | In | Volná velikost = Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Šířka odsazení od základny (mm) | Výška odsazení od základny (mm) | Delta 1 (mm) | Délka01 (mm) | Delta 2 (mm) | Dočas. šířka odsazení | Dočas. výška odsazení | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Poloměr potrubí (mm) | Průměr vedení (mm) | Šířka potrubí (mm) | Velikost | Výška potrubí (mm) | Kód prvku | Označení | Délka 3 (mm) | Páteřní trasa | Délka 4 (mm) | Číslo 1 | Délka 1 (mm) | Délka 2 (mm) | Číslo 10 | Číslo 2 | Číslo 3 | Číslo 5 | Číslo 6 | Číslo 7 | Číslo 8 | Délka 5 (mm) | Délka 6 (mm) | Délka 7 (mm) | Délka 8 (mm) | Polovina Š0 (mm) | Polovina V0 (mm)
13629669 | -1.PP_SO-102 | 225 mm-225 mm × 75 mm | 0 | -1.PP_SO-102 | 3160 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 8 | ETA | 3048 | 3048 | 0 | 181.066 | 75 | -0.03125 | 0.0104167 | 0.00545526 | 112.5 | 37.5 | 0.0864531 | 112.5 | 225 | 225 | 225-225 × 75 | 75 | TA00.05.0134 | 0134 | 0 | no | 0 | 0 | 0 | 0 | 7.24264 | 0 | 0 | 0 | 3 | 3 | 6 | 75 | 75 | 181.066 | 0 | 112.5 | 37.5 | Identifikační data - Komentáře: VZT 28
13629832 | -1.PP_SO-102 | 800 mm × 400 mm-400 mm | 0 | -1.PP_SO-102 | 1692 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 18 | ETA | 3048 | 3048 | 200 | 482.843 | 0 | -0.111111 | 0.0555556 | 0.110356 | 400 | 200 | 0.610799 | 200 | 400 | 800 | 800 × 400-400 | 400 | TA00.05.0135 | 0135 | 0 | yes | 0 | 8 | 200 | 200 | 0 | 8 | 16 | 19.3137 | 0 | 0 | 0 | 0 | 0 | 0 | 482.843 | 400 | 200
13629980 | -1.PP_SO-102 | 800 mm × 400 mm-400 mm | 0 | -1.PP_SO-102 | 1692 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 7 | SUP | 3048 | 3048 | 200 | 482.843 | 0 | -0.111111 | 0.0555556 | 0.110356 | 400 | 200 | 0.610799 | 200 | 400 | 800 | 800 × 400-400 | 400 | TA00.05.0136 | 0136 | 0 | yes | 0 | 8 | 200 | 200 | 0 | 8 | 16 | 19.3137 | 0 | 0 | 0 | 0 | 0 | 0 | 482.843 | 400 | 200
13631822 | -1.PP_SO-102 | 500 mm × 250 mm-355 mm | 0 | -1.PP_SO-102 | 3076.56 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 3048 | 3047.91 | 72.5 | 175.03 | 52.5 | -0.0694444 | 0.0347472 | 0.0208347 | 250 | 125.09 | 0.194362 | 177.5 | 355 | 500 | 500 × 250-355 | 250 | TA00.05.0139 | 0139 | 0 | yes | 0.090082 | 2.9 | 72.5 | 72.5 | 5.06985 | 2.9 | 5.8 | 7.00122 | 2.1036 | 2.0964 | 4.2 | 52.5901 | 52.4099 | 126.746 | 175.03 | 250 | 125
13808444 | -1.PP_SO-102 | 160 mm-225 mm × 75 mm | 0 | -1.PP_SO-102 | -879.056 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0366 | 0366 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
13818255 | -1.PP_SO-102 | 315 mm × 500 mm-315 mm | 0 | -1.PP_SO-102 | 3080 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 0 | 223.315 | 92.5 | -0.04375 | 0.0694444 | 0.0270802 | 157.5 | 250 | 0.228424 | 157.5 | 315 | 315 | 315 × 500-315 | 500 | TA00.05.0389 | 0389 | 0.00000436343 | no | 0 | 1.74537e-07 | 0.00000436343 | -0.00000436343 | 8.93259 | -1.74537e-07 | 0 | 0 | 3.7 | 3.7 | 7.4 | 92.5 | 92.5 | 223.315 | 0 | 157.5 | 250
13901082 | -1.PP_SO-102 | 200 mm × 200 mm-160 mm | 0 | -1.PP_SO-102 | -670.772 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 20 | 48.2843 | 20 | -0.0277778 | 0.0277778 | 0.00148243 | 100 | 100 | 0.0344984 | 80 | 160 | 200 | 200 × 200-160 | 200 | TA00.05.0636 | 0636 | 0 | no | 0 | 0.8 | 20 | 20 | 1.93137 | 0.8 | 1.6 | 1.93137 | 0.8 | 0.8 | 1.6 | 20 | 20 | 48.2843 | 48.2843 | 100 | 100
13902926 | 4.NP_SO-102 | 400 mm × 250 mm-225 mm | 0 | STŘECHA_SO-102 | 966.89 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 8 | ETA | 3048 | 3048 | 87.5 | 211.244 | 12.5 | -0.0555556 | 0.0347222 | 0.0149903 | 200 | 125 | 0.155965 | 112.5 | 225 | 400 | 400 × 250-225 | 250 | TA00.05.0642 | 0642 | 0 | yes | 0 | 3.5 | 87.5 | 87.5 | 1.20711 | 3.5 | 7 | 8.44975 | 0.5 | 0.5 | 1 | 12.5 | 12.5 | 30.1777 | 211.244 | 200 | 125
13939226 | 2.NP_SO-102 | 160 mm-225 mm × 75 mm | 0 | 2.NP_SO-102 | 2908.28 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0758 | 0758 | 0 | yes | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
13954359 | 1.NP_SO-102 | 160 mm-225 mm × 75 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 23 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0799 | 0799 | 0 | yes | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
13956114 | -1.PP_SO-102 | 160 mm-225 mm × 75 mm | 0 | -1.PP_SO-102 | 3150 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 18 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0808 | 0808 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
13957781 | 2.NP_SO-102 | 160 mm-225 mm × 75 mm | 0 | 2.NP_SO-102 | 2580 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0817 | 0817 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
13964729 | -1.PP_SO-102 | 160 mm-225 mm × 75 mm | 0 | -1.PP_SO-102 | 3070 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0832 | 0832 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
13965084 | -1.PP_SO-102 | 160 mm-225 mm × 75 mm | 0 | -1.PP_SO-102 | 3071.97 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0833 | 0833 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
13966273 | -1.PP_SO-102 | 225 mm × 125 mm-160 mm | 0 | -1.PP_SO-102 | 3070.07 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 3048 | 3048 | 32.5 | 78.4619 | 17.5 | -0.03125 | 0.0173611 | 0.00199375 | 112.5 | 62.5 | 0.0403622 | 80 | 160 | 225 | 225 × 125-160 | 125 | TA00.05.0840 | 0840 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 1.68995 | 1.3 | 2.6 | 3.13848 | 0.7 | 0.7 | 1.4 | 17.5 | 17.5 | 42.2487 | 78.4619 | 112.5 | 62.5
13991053 | 3.NP_SO-102 | 160 mm-225 mm × 75 mm | 0 | 3.NP_SO-102 | 2800 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0901 | 0901 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
13993809 | 1.NP_SO-102 | 225 mm × 75 mm-125 mm | 0 | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 3048 | 3048 | 50 | 120.711 | 25 | -0.03125 | 0.0104167 | 0.00192722 | 112.5 | 37.5 | 0.0420419 | 62.5 | 125 | 225 | 225 × 75-125 | 75 | TA00.05.0911 | 0911 | 0 | yes | 0 | 2 | 50 | 50 | 2.41421 | 2 | 4 | 4.82843 | 1 | 1 | 2 | 25 | 25 | 60.3553 | 120.711 | 112.5 | 37.5
14003833 | -1.PP_SO-102 | 160 mm-225 mm × 75 mm | 0 | -1.PP_SO-102 | 2600 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0934 | 0934 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
14004944 | -1.PP_SO-102 | 160 mm-225 mm × 75 mm | 0 | -1.PP_SO-102 | 2600 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0938 | 0938 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
14005140 | -1.PP_SO-102 | 160 mm-225 mm × 75 mm | 0 | -1.PP_SO-102 | 2600 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0940 | 0940 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
14005515 | -1.PP_SO-102 | 800 mm × 400 mm-500 mm |  | -1.PP_SO-102 | 3070 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 3048 | 3048 | 150 | 362.132 | 50 | -0.111111 | 0.0555556 | 0.0985421 | 400 | 200 | 0.548675 | 250 | 500 | 800 | 800 × 400-500 | 400 | TA00.05.0941 | 0941 | 0 | yes | 0 | 6 | 150 | 150 | 4.82843 | 6 | 12 | 14.4853 | 2 | 2 | 4 | 50 | 50 | 120.711 | 362.132 | 400 | 200
14017072 | 3.NP_SO-102 | 500 mm × 160 mm-160 mm | 0 | 3.NP_SO-102 | 2739.7 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3070.01 | 3048 | 170 | 409.407 | 0 | -0.075557 | 0.0222222 | 0.020867 | 272.005 | 80 | 0.229805 | 80 | 160 | 500 | 500 × 160-160 | 160 | TA00.05.0965 | 0965 | 22.0052 | no | 0 | 7.68021 | 192.005 | 147.995 | 0 | 5.91979 | 13.6 | 16.3763 | 0 | 0 | 0 | 0 | 0 | 0 | 409.407 | 250 | 80
14017196 | 3.NP_SO-102 | 160 mm-225 mm × 75 mm | 0 | 3.NP_SO-102 | 2739.7 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0966 | 0966 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
14018085 | 4.NP_SO-102 | 160 mm-225 mm × 75 mm | 0 | 4.NP_SO-102 | 2950 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0971 | 0971 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
14029374 | 1.NP_SO-102 | 160 mm-225 mm × 75 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 23 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.0976 | 0976 | 0 | yes | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
14034476 | 3.NP_SO-102 | 225 mm × 500 mm-225 mm |  | 3.NP_SO-102 | 3929.5 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 3047.87 | 3048 | 0 | 331.954 | 137.5 | -0.0312149 | 0.0694444 | 0.0258729 | 112.374 | 250 | 0.238881 | 112.5 | 225 | 225 | 225 × 500-225 | 500 | TA00.05.0996 | 0996 | 0.126239 | yes | 0 | 0.00504955 | 0.126239 | -0.126239 | 13.2782 | -0.00504955 | 0 | 0 | 5.5 | 5.5 | 11 | 137.5 | 137.5 | 331.954 | 0 | 112.5 | 250
14035397 | 3.NP_SO-102 | 225 mm × 250 mm-250 mm |  | 3.NP_SO-102 | 3100 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 3048.11 | 3048 | 12.5 | 30.1773 | 0 | -0.0312805 | 0.0347222 | 0.00165686 | 112.61 | 125 | 0.0447098 | 125 | 250 | 225 | 225 × 250-250 | 250 | TA00.05.1001 | 1001 | 0.10972 | no | 0 | 0.504389 | 12.6097 | 12.3903 | 0 | 0.495611 | 1 | 1.20709 | 0 | 0 | 0 | 0 | 0 | 0 | 30.1773 | 112.5 | 125
14040837 | 2.NP_SO-102 | 160 mm × 710 mm-160 mm | 0 | 2.NP_SO-102 | 2800 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 3048 | 3048 | 0 | 663.909 | 275 | -0.0222222 | 0.0986111 | 0.0449923 | 80 | 355 | 0.434202 | 80 | 160 | 160 | 160 × 710-160 | 710 | TA00.05.1031 | 1031 | 0 | yes | 0 | 0 | 0 | 0 | 26.5563 | 0 | 0 | 0 | 11 | 11 | 22 | 275 | 275 | 663.909 | 0 | 80 | 355
14040912 | 2.NP_SO-102 | 160 mm-225 mm × 75 mm | 0 | 2.NP_SO-102 | 2800 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.1032 | 1032 | 0 | yes | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
14052545 | 2.NP_SO-102 | 160 mm-225 mm × 75 mm | 0 | 2.NP_SO-102 | 2580 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.1053 | 1053 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
14053380 | 2.NP_SO-102 | 160 mm-225 mm × 75 mm | 0 | 2.NP_SO-102 | 2910 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.1058 | 1058 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
14055014 | -1.PP_SO-102 | 160 mm-225 mm × 75 mm | 0 | -1.PP_SO-102 | 2400 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.1063 | 1063 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
14055610 | 3.NP_SO-102 | 160 mm-225 mm × 75 mm | 0 | 3.NP_SO-102 | 3100 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.1069 | 1069 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
14055986 | 3.NP_SO-102 | 160 mm × 500 mm-160 mm | 0 | 3.NP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 3048 | 3148 | 0 | 388.632 | 170 | -0.0222222 | 0.0416667 | 0.0198081 | 80 | 150 | 0.224609 | 80 | 160 | 160 | 160 × 500-160 | 500 | TA00.05.1077 | 1077 | 0 | no | 100 | 0 | 0 | 0 | 15.5453 | 0 | 0 | 0 | 10.8 | 2.8 | 13.6 | 270 | 70 | 388.632 | 0 | 80 | 250
14056061 | 3.NP_SO-102 | 160 mm-225 mm × 75 mm | 0 | 3.NP_SO-102 | 2900 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 3 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.1079 | 1079 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
14057138 | 1.NP_SO-102 | 160 mm-225 mm × 75 mm | 0 | 1.NP_SO-102 | 2903.77 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.1092 | 1092 | 5.32708e-07 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
14057827 | 1.NP_SO-102 | 160 mm-225 mm × 75 mm | 0 | 1.NP_SO-102 | 3200 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.1096 | 1096 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
14058148 | 1.NP_SO-102 | 160 mm-225 mm × 75 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.1097 | 1097 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
14058445 | 1.NP_SO-102 | 325 mm × 75 mm-160 mm | 0 | 1.NP_SO-102 | 2903.77 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 82.5 | 199.173 | 42.5 | -0.0451389 | 0.0104167 | 0.00507765 | 162.5 | 37.5 | 0.0857037 | 80 | 160 | 325 | 325 × 75-160 | 75 | TA00.05.1100 | 1100 | 0 | no | 0 | 3.3 | 82.5 | 82.5 | 4.10416 | 3.3 | 6.6 | 7.9669 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 199.173 | 162.5 | 37.5
14061085 | -1.PP_SO-102 | 160 mm-225 mm × 75 mm | 0 | -1.PP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.1111 | 1111 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
14065182 | -1.PP_SO-102 | 325 mm × 75 mm-160 mm | 0 | -1.PP_SO-102 | 3300 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 3048 | 3048 | 82.5 | 199.173 | 42.5 | -0.0451389 | 0.0104167 | 0.00507765 | 162.5 | 37.5 | 0.0857037 | 80 | 160 | 325 | 325 × 75-160 | 75 | TA00.05.1119 | 1119 | 0 | no | 0 | 3.3 | 82.5 | 82.5 | 4.10416 | 3.3 | 6.6 | 7.9669 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 199.173 | 162.5 | 37.5
14065331 | -1.PP_SO-102 | 325 mm × 75 mm-160 mm | 0 | -1.PP_SO-102 | 3270 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 3048 | 3048 | 82.5 | 199.173 | 42.5 | -0.0451389 | 0.0104167 | 0.00507765 | 162.5 | 37.5 | 0.0857037 | 80 | 160 | 325 | 325 × 75-160 | 75 | TA00.05.1120 | 1120 | 0 | no | 0 | 3.3 | 82.5 | 82.5 | 4.10416 | 3.3 | 6.6 | 7.9669 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 199.173 | 162.5 | 37.5
14081660 | 4.NP_SO-102 | 160 mm-225 mm × 75 mm | 0 | 4.NP_SO-102 | 3300 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 2 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.1164 | 1164 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
14081853 | 4.NP_SO-102 | 160 mm-225 mm × 75 mm | 0 | 4.NP_SO-102 | 3300 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 2 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.1168 | 1168 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
14082210 | 3.NP_SO-102 | 160 mm-225 mm × 75 mm | 0 | 3.NP_SO-102 | 3300 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.1173 | 1173 | 0 | no | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
14108511 | -1.PP_SO-102 | 315 mm × 315 mm-250 mm | 0 | -1.PP_SO-102 | 3080 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 32.5 | 78.4619 | 32.5 | -0.04375 | 0.04375 | 0.00593859 | 157.5 | 157.5 | 0.0865885 | 125 | 250 | 315 | 315 × 315-250 | 315 | TA00.05.1186 | 1186 | 0 | yes | 0 | 1.3 | 32.5 | 32.5 | 3.13848 | 1.3 | 2.6 | 3.13848 | 1.3 | 1.3 | 2.6 | 32.5 | 32.5 | 78.4619 | 78.4619 | 157.5 | 157.5
14109730 | -1.PP_SO-102 | 180 mm × 355 mm-180 mm |  | -1.PP_SO-102 | 3080 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 0 | 211.244 | 87.5 | -0.025 | 0.0493056 | 0.00968178 | 90 | 177.5 | 0.120173 | 90 | 180 | 180 | 180 × 355-180 | 355 | TA00.05.1192 | 1192 | 0 | no | 0 | 0 | 0 | 0 | 8.44975 | 0 | 0 | 0 | 3.5 | 3.5 | 7 | 87.5 | 87.5 | 211.244 | 0 | 90 | 177.5
14110298 | -1.PP_SO-102 | 180 mm × 355 mm-180 mm |  | -1.PP_SO-102 | 3150 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 0 | 211.244 | 87.5 | -0.025 | 0.0493059 | 0.00968178 | 90 | 177.501 | 0.120173 | 90 | 180 | 180 | 180 × 355-180 | 355 | TA00.05.1199 | 1199 | 0 | no | 0.00129128 | 0 | 0 | 0 | 8.44975 | 0 | 0 | 0 | 3.50005 | 3.49995 | 7 | 87.5013 | 87.4987 | 211.244 | 0 | 90 | 177.5
14114091 | -1.PP_SO-102 | 160 mm × 500 mm-160 mm | 0 | -1.PP_SO-102 | 3080 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 2878 | 0 | 340 | 170 | -0.0222222 | 0.116667 | 0.0173294 | 80 | 420 | 0.196211 | 80 | 160 | 160 | 160 × 500-160 | 500 | TA00.05.1210 | 1210 | 0 | no | 170 | 0 | 0 | 0 | 13.6 | 0 | 0 | 0 | 13.6 | 0 | 13.6 | 340 | 0 | 340 | 0 | 80 | 250
14114234 | -1.PP_SO-102 | 630 mm × 355 mm-355 mm | 0 | -1.PP_SO-102 | 3076.36 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 3048 | 3048 | 137.5 | 331.954 | 0 | -0.0875 | 0.0493056 | 0.0550455 | 315 | 177.5 | 0.373605 | 177.5 | 355 | 630 | 630 × 355-355 | 355 | TA00.05.1212 | 1212 | 0 | yes | 0 | 5.5 | 137.5 | 137.5 | 0 | 5.5 | 11 | 13.2782 | 0 | 0 | 0 | 0 | 0 | 0 | 331.954 | 315 | 177.5
14114236 | -1.PP_SO-102 | 630 mm × 355 mm-355 mm | 0 | -1.PP_SO-102 | 3075.84 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 3048 | 3048 | 137.5 | 331.954 | 0 | -0.0875 | 0.0493056 | 0.0550455 | 315 | 177.5 | 0.373605 | 177.5 | 355 | 630 | 630 × 355-355 | 355 | TA00.05.1213 | 1213 | 0 | yes | 0 | 5.5 | 137.5 | 137.5 | 0 | 5.5 | 11 | 13.2782 | 0 | 0 | 0 | 0 | 0 | 0 | 331.954 | 315 | 177.5
14121026 | 2.NP_SO-102 | 355 mm × 400 mm-355 mm |  | 2.NP_SO-102 | 2920 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 3048 | 3048 | 0 | 54.3198 | 22.5 | -0.0493056 | 0.0555556 | 0.00678984 | 177.5 | 200 | 0.10759 | 177.5 | 355 | 355 | 355 × 400-355 | 400 | TA00.05.1264 | 1264 | 0 | yes | 0 | 0 | 0 | 0 | 2.17279 | 0 | 0 | 0 | 0.9 | 0.9 | 1.8 | 22.5 | 22.5 | 54.3198 | 0 | 177.5 | 200
14138338 | -1.PP_SO-102 | 315 mm × 315 mm-250 mm | 0 | -1.PP_SO-102 | 2747.5 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 32.5 | 78.4619 | 32.5 | -0.04375 | 0.04375 | 0.00593859 | 157.5 | 157.5 | 0.0865885 | 125 | 250 | 315 | 315 × 315-250 | 315 | TA00.05.1328 | 1328 | 0 | yes | 0 | 1.3 | 32.5 | 32.5 | 3.13848 | 1.3 | 2.6 | 3.13848 | 1.3 | 1.3 | 2.6 | 32.5 | 32.5 | 78.4619 | 78.4619 | 157.5 | 157.5
14138342 | -1.PP_SO-102 | 315 mm × 315 mm-250 mm | 0 | -1.PP_SO-102 | 2747.5 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 3048 | 3048 | 32.5 | 78.4619 | 32.5 | -0.04375 | 0.04375 | 0.00593859 | 157.5 | 157.5 | 0.0865885 | 125 | 250 | 315 | 315 × 315-250 | 315 | TA00.05.1329 | 1329 | 0 | yes | 0 | 1.3 | 32.5 | 32.5 | 3.13848 | 1.3 | 2.6 | 3.13848 | 1.3 | 1.3 | 2.6 | 32.5 | 32.5 | 78.4619 | 78.4619 | 157.5 | 157.5
14138933 | -1.PP_SO-102 | 200 mm × 560 mm-200 mm | 0 | -1.PP_SO-102 | 2404.86 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 3048 | 3048 | 0 | 434.558 | 180 | -0.0277778 | 0.0777778 | 0.031783 | 100 | 280 | 0.293624 | 100 | 200 | 200 | 200 × 560-200 | 560 | TA00.05.1332 | 1332 | 0 | yes | 0 | 0 | 0 | 0 | 17.3823 | 0 | 0 | 0 | 7.2 | 7.2 | 14.4 | 180 | 180 | 434.558 | 0 | 100 | 280
14138974 | -1.PP_SO-102 | 200 mm × 400 mm-200 mm | 0 | -1.PP_SO-102 | 2404.86 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 3048 | 3048 | 0 | 241.421 | 100 | -0.0277778 | 0.0555556 | 0.0137945 | 100 | 200 | 0.1527 | 100 | 200 | 200 | 200 × 400-200 | 400 | TA00.05.1334 | 1334 | 0 | yes | 0 | 0 | 0 | 0 | 9.65685 | 0 | 0 | 0 | 4 | 4 | 8 | 100 | 100 | 241.421 | 0 | 100 | 200
14173005 | 1.NP_SO-102 | 160 mm-225 mm × 75 mm | 0 | 1.NP_SO-102 | 2763.77 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.0312487 | 0.0104167 | 0.00208564 | 112.495 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.1426 | 1426 | 0.00459517 |  | 0 | 1.30018 | 32.5046 | 32.4954 | 4.10416 | 1.29982 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5
14175117 | -1.PP_SO-102 | 355 mm × 280 mm-250 mm | 0 | -1.PP_SO-102 | 2900 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 52.5 | 126.746 | 15 | -0.0493056 | 0.0388889 | 0.0096269 | 177.5 | 140 | 0.113921 | 125 | 250 | 355 | 355 × 280-250 | 280 | TA00.05.1438 | 1438 | 0 | yes | 0 | 2.1 | 52.5 | 52.5 | 1.44853 | 2.1 | 4.2 | 5.06985 | 0.6 | 0.6 | 1.2 | 15 | 15 | 36.2132 | 126.746 | 177.5 | 140
14187167 | -1.PP_SO-102 | 160 mm-225 mm × 75 mm | 0 | -1.PP_SO-102 | 2600 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 3048 | 3048 | 32.5 | 102.604 | 42.5 | -0.03125 | 0.0104167 | 0.00208564 | 112.5 | 37.5 | 0.0435349 | 80 | 160 | 225 | 160-225 × 75 | 75 | TA00.05.1511 | 1511 | 0 |  | 0 | 1.3 | 32.5 | 32.5 | 4.10416 | 1.3 | 2.6 | 3.13848 | 1.7 | 1.7 | 3.4 | 42.5 | 42.5 | 102.604 | 78.4619 | 112.5 | 37.5

# IfcDuctFitting: Pravoúhlý přechod, koleno, poloměr, přírubový:Standardní (49)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - ID kategorie: R; Kód sestavy: TA00; Název typu: Standardní; Označení typu: 03; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: Pravoúhlý přechod, koleno, poloměr, přírubový
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Grafika - Použít měřítko poznámky: yes
Kóty - e: 0 mm; f: 0 mm; r: 100 mm; Rozšíření příruby: 30 mm; Tloušťka příruby: 5 mm
Jiné - Typ: Standardní; Id typu: 1165284; Rodina: Pravoúhlý přechod, koleno, poloměr, přírubový; Rodina a typ: Pravoúhlý přechod, koleno, poloměr, přírubový: Standardní; Viditelnost 1: yes; Viditelnost 2: no; Délka 17: 500 mm; e1: 50 mm; e2: 50 mm; f1: 50 mm; f2: 50 mm; r1: 100 mm; Šířka 2: 200 mm
Name (Pravoúhlý přechod, koleno, poloměr, přírubový:Standardní:...) | In | Length (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | alfa (deg) = alfa 2 (deg) = alfa 3 (deg) = alfa 4 (deg) | a (mm) = c (mm) = Výš. (mm) | b (mm) | d (mm) | Objem (m3) | Příruba a (mm) = Příruba c (mm) | Příruba b (mm) | Příruba d (mm) | Velikost | Kód prvku | Označení | Páteřní trasa | alfa 1 (deg) | Délka 10 (mm) | Délka 12 (mm) | Délka 20 (mm) = Délka 21 (mm) = Posouzení 2 (mm) | Délka 5 (mm) | Délka 7 (mm) | Délka 1 (mm) | Délka 11 (mm) | Délka 13 (mm) | Délka 14 (mm) | Délka 15 (mm) | Délka 16 (mm) | Délka 18 (mm) = Délka 19 (mm) | Délka 2 (mm) | Délka 22 (mm) | Délka 23 (mm) = r2 (mm) = r3 (mm) | Délka 24 (mm) | Délka 25 (mm) | Délka 3 (mm) | Délka 4 (mm) | Délka 6 (mm) | Délka 8 (mm) | Délka 9 (mm) | Max ab (mm) | Max abcd (mm) | Max bd (mm) | Max cd (mm) | Polovina b (mm) | Posouzení 1 (mm) | r4 (mm) | Šířka 1 (mm)
13095415 | 2.NP_SO-102 | 500 | 0.02475 | 0.505 | 450 mm × 500 mm-450 mm × 500 mm | 0 | 450 mm × 500 mm-450 mm × 500 mm | 2.NP_SO-102 | 2764 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 90 | 500 | 450 | 450 | 0.139614 | 560 | 510 | 510 | 450 × 500-450 × 500 | TA00.03.0004 | 0004 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10325 | 50 | 5 | 600 | 600 | 777.817 | 550 | 325 | 550 | 550 | 450 | 650 | 325 | 325 | 10000 | 325 | 375 | 500 | 500 | 450 | 500 | 225 | 550 | 1050 | 875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13097172 | 2.NP_SO-102 | 1100 | 0.02475 | 1.111 | 450 mm × 1100 mm-450 mm × 1100 mm | 0 | 450 mm × 1100 mm-450 mm × 1100 mm | 2.NP_SO-102 | 384 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 90 | 1100 | 450 | 450 | 0.30715 | 1160 | 510 | 510 | 450 × 1100-450 × 1100 | TA00.03.0011 | 0011 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10325 | 50 | 5 | 600 | 600 | 777.817 | 550 | 325 | 550 | 550 | 450 | 650 | 325 | 325 | 10000 | 325 | 375 | 1100 | 1100 | 450 | 1100 | 225 | 550 | 1050 | 875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13097444 | 2.NP_SO-102 | 1100 | 0.02475 | 1.111 | 450 mm × 1100 mm-450 mm × 1100 mm | 0 | 450 mm × 1100 mm-450 mm × 1100 mm | 2.NP_SO-102 | 1034 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 90 | 1100 | 450 | 450 | 0.30715 | 1160 | 510 | 510 | 450 × 1100-450 × 1100 | TA00.03.0013 | 0013 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10325 | 50 | 5 | 600 | 600 | 777.817 | 550 | 325 | 550 | 550 | 450 | 650 | 325 | 325 | 10000 | 325 | 375 | 1100 | 1100 | 450 | 1100 | 225 | 550 | 1050 | 875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13097648 | 2.NP_SO-102 | 500 | 0.02475 | 0.505 | 450 mm × 500 mm-450 mm × 500 mm | 0 | 450 mm × 500 mm-450 mm × 500 mm | 2.NP_SO-102 | 2764 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 90 | 500 | 450 | 450 | 0.139614 | 560 | 510 | 510 | 450 × 500-450 × 500 | TA00.03.0015 | 0015 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10325 | 50 | 5 | 600 | 600 | 777.817 | 550 | 325 | 550 | 550 | 450 | 650 | 325 | 325 | 10000 | 325 | 375 | 500 | 500 | 450 | 500 | 225 | 550 | 1050 | 875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13113179 | 2.NP_SO-102 | 1100 | 0.02475 | 1.111 | 450 mm × 1100 mm-450 mm × 1100 mm | 0 | 450 mm × 1100 mm-450 mm × 1100 mm | 2.NP_SO-102 | 1034 | Fáze 1 | Čerstvý | Přívod vzduchu | ODA 7 | ODA | 90 | 1100 | 450 | 450 | 0.30715 | 1160 | 510 | 510 | 450 × 1100-450 × 1100 | TA00.03.0027 | 0027 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10325 | 50 | 5 | 600 | 600 | 777.817 | 550 | 325 | 550 | 550 | 450 | 650 | 325 | 325 | 10000 | 325 | 375 | 1100 | 1100 | 450 | 1100 | 225 | 550 | 1050 | 875 | Mechanické – tok - Tlaková ztráta: 0 Pa
13429118 | -1.PP_SO-102 | 500 | 0.088 | 1.655 | 1600 mm × 500 mm-1250 mm × 500 mm | 15 | 1630 mm × 530 mm-1280 mm × 530 mm | -1.PP_SO-102 | 3090 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 500 | 1600 | 1250 | 1.02643 | 560 | 1660 | 1310 | 1600 × 500-1250 × 500 | TA00.03.0113 | 0113 | yes | 90 | 0 | 0 | 0 | 175 | 0 | 10725 | 50 | 5 | 1400 | 1750 | 2170.83 | 1350 | 900 | 1350 | 1350 | 1250 | 1450 | 725 | 900 | 10000 | 900 | 775 | 1600 | 1600 | 1600 | 1250 | 800 | 1350 | 1850 | 2600 | Izolace - Typ izolace: Protipožární
13459867 | -1.PP_SO-102 | 1250 | 0.03905 | 1.9125 | 710 mm × 1250 mm-710 mm × 1250 mm | 0 | 710 mm × 1250 mm-710 mm × 1250 mm | -1.PP_SO-102 | 2550 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 45 | 1250 | 710 | 710 | 0.414778 | 1310 | 770 | 770 | 710 × 1250-710 × 1250 | TA00.03.0121 | 0121 | yes | 135 | 35.3553 | 3.53553 | 237.244 | 0 | 321.734 | 10188.5 | 35.3553 | 3.53553 | 860 | 622.756 | 619.947 | 572.756 | 455 | 335.513 | 810 | 710 | 910 | 455 | 188.467 | 9866.73 | 188.467 | 238.467 | 1250 | 1250 | 710 | 1250 | 355 | 335.513 | 1310 | 1265
13647955 | -1.PP_SO-102 | 500 | 0.066 | 1.255 | 1200 mm × 500 mm-800 mm × 500 mm | 0 | 1200 mm × 500 mm-800 mm × 500 mm | -1.PP_SO-102 | 409 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 90 | 500 | 1200 | 800 | 0.549157 | 560 | 1260 | 860 | 1200 × 500-800 × 500 | TA00.03.0166 | 0166 | yes | 90 | 0 | 0 | 0 | 200 | 0 | 10500 | 50 | 5 | 950 | 1350 | 1581.14 | 900 | 700 | 900 | 900 | 800 | 1000 | 500 | 700 | 10000 | 700 | 550 | 1200 | 1200 | 1200 | 800 | 600 | 900 | 1400 | 2000 | Mechanické – tok - Tlaková ztráta: 0 Pa
13742239 | -1.PP_SO-102 | 400 | 0.044 | 0.684 | 800 mm × 400 mm-800 mm × 400 mm | 15 | 830 mm × 430 mm-830 mm × 430 mm | -1.PP_SO-102 | 3130 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 400 | 800 | 800 | 0.286526 | 460 | 860 | 860 | 800 × 400-800 × 400 | TA00.03.0227 | 0227 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10500 | 50 | 5 | 950 | 950 | 1272.79 | 900 | 500 | 900 | 900 | 800 | 1000 | 500 | 500 | 10000 | 500 | 550 | 800 | 800 | 800 | 800 | 400 | 900 | 1400 | 1400 | Izolace - Typ izolace: Protipožární
13792574 | -1.PP_SO-102 | 630 | 0.06875 | 1.6443 | 1250 mm × 630 mm-1250 mm × 630 mm | 15 | 1280 mm × 660 mm-1280 mm × 660 mm | -1.PP_SO-102 | 3090 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 630 | 1250 | 1250 | 0.9835 | 690 | 1310 | 1310 | 1250 × 630-1250 × 630 | TA00.03.0314 | 0314 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10725 | 50 | 5 | 1400 | 1400 | 1909.19 | 1350 | 725 | 1350 | 1350 | 1250 | 1450 | 725 | 725 | 10000 | 725 | 775 | 1250 | 1250 | 1250 | 1250 | 625 | 1350 | 1850 | 2075 | Izolace - Typ izolace: Protipožární
13793955 | -1.PP_SO-102 | 1250 | 0.03465 | 1.7125 | 630 mm × 1250 mm-500 mm × 1250 mm | 0 | 630 mm × 1250 mm-500 mm × 1250 mm | -1.PP_SO-102 | 3090 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 1250 | 630 | 500 | 0.518798 | 1310 | 690 | 560 | 630 × 1250-500 × 1250 | TA00.03.0319 | 0319 | yes | 90 | 0 | 0 | 0 | 65 | 0 | 10350 | 50 | 5 | 650 | 780 | 944.934 | 600 | 415 | 600 | 600 | 500 | 700 | 350 | 415 | 10000 | 415 | 400 | 1250 | 1250 | 630 | 1250 | 315 | 600 | 1100 | 1145
13798277 | -1.PP_SO-102 | 800 | 0.0275 | 0.888 | 800 mm × 800 mm-500 mm × 800 mm | 0 | 800 mm × 800 mm-500 mm × 800 mm | -1.PP_SO-102 | 409 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 90 | 800 | 500 | 800 | 0.421113 | 860 | 560 | 860 | 800 × 800-500 × 800 | TA00.03.0339 | 0339 | yes | 90 | 0 | 0 | 0 | -150 | 0 | 10500 | 50 | 5 | 950 | 650 | 1081.67 | 900 | 350 | 600 | 600 | 500 | 1000 | 500 | 350 | 10000 | 350 | 550 | 800 | 800 | 800 | 800 | 250 | 900 | 1100 | 1250 | Mechanické – tok - Tlaková ztráta: 0 Pa
13805163 | -1.PP_SO-102 | 500 | 0.088 | 1.655 | 1600 mm × 500 mm-1600 mm × 500 mm | 0 | 1600 mm × 500 mm-1600 mm × 500 mm | -1.PP_SO-102 | 3090 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 45 | 500 | 1600 | 1600 | 0.653487 | 560 | 1660 | 1660 | 1600 × 500-1600 × 500 | TA00.03.0351 | 0351 | yes | 135 | 35.3553 | 3.53553 | 497.918 | 0 | 636.396 | 10372.8 | 35.3553 | 3.53553 | 1750 | 1252.08 | 1301.12 | 1202.08 | 900 | 704.163 | 1700 | 1600 | 1800 | 900 | 372.792 | 9736.4 | 372.792 | 422.792 | 1600 | 1600 | 1600 | 1600 | 800 | 704.163 | 2200 | 2600
13805164 | -1.PP_SO-102 | 500 | 0.088 | 1.655 | 1600 mm × 500 mm-1600 mm × 500 mm | 0 | 1600 mm × 500 mm-1600 mm × 500 mm | -1.PP_SO-102 | 3090 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 45 | 500 | 1600 | 1600 | 0.653487 | 560 | 1660 | 1660 | 1600 × 500-1600 × 500 | TA00.03.0352 | 0352 | yes | 135 | 35.3553 | 3.53553 | 497.918 | 0 | 636.396 | 10372.8 | 35.3553 | 3.53553 | 1750 | 1252.08 | 1301.12 | 1202.08 | 900 | 704.163 | 1700 | 1600 | 1800 | 900 | 372.792 | 9736.4 | 372.792 | 422.792 | 1600 | 1600 | 1600 | 1600 | 800 | 704.163 | 2200 | 2600
13809352 | -1.PP_SO-102 | 500 | 0.088 | 1.655 | 1600 mm × 500 mm-1600 mm × 500 mm | 0 | 1600 mm × 500 mm-1600 mm × 500 mm | -1.PP_SO-102 | 3090 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 500 | 1600 | 1600 | 1.21902 | 560 | 1660 | 1660 | 1600 × 500-1600 × 500 | TA00.03.0367 | 0367 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10900 | 50 | 5 | 1750 | 1750 | 2404.16 | 1700 | 900 | 1700 | 1700 | 1600 | 1800 | 900 | 900 | 10000 | 900 | 950 | 1600 | 1600 | 1600 | 1600 | 800 | 1700 | 2200 | 2600
13809353 | -1.PP_SO-102 |  |  |  | 710 mm × 1250 mm-500 mm × 1250 mm | 0 | 710 mm × 1250 mm-500 mm × 1250 mm | -1.PP_SO-102 | 3090 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 45 | 1250 | 710 | 500 | 0.318891 | 1310 | 770 | 560 | 710 × 1250-500 × 1250 | TA00.03.0368 | 0368 | yes | 135 | 35.3553 | 3.53553 | 385.736 | 105 | 247.487 | 10040 | 35.3553 | 3.53553 | 860 | 622.756 | 573.404 | 424.264 | 455 | 38.5281 | 93.0152 | 500 | 700 | 350 | 188.467 | 9792.49 | 293.467 | 89.9747 | 1250 | 1250 | 710 | 1250 | 355 | 38.5281 | 593.015 | 1265
13846522 | 2.NP_SO-102 | 1250 | 0.0308 | 1.5375 | 560 mm × 1250 mm-560 mm × 1250 mm | 0 | 560 mm × 1250 mm-560 mm × 1250 mm | 2.NP_SO-102 | 2700 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 1250 | 560 | 560 | 0.494834 | 1310 | 620 | 620 | 560 × 1250-560 × 1250 | TA00.03.0413 | 0413 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10380 | 50 | 5 | 710 | 710 | 933.381 | 660 | 380 | 660 | 660 | 560 | 760 | 380 | 380 | 10000 | 380 | 430 | 1250 | 1250 | 560 | 1250 | 280 | 660 | 1160 | 1040 | Mechanické – tok - Tlaková ztráta: 0 Pa
13846525 | 2.NP_SO-102 | 1800 | 0.03905 | 2.754 | 710 mm × 1800 mm-560 mm × 1800 mm | 0 | 710 mm × 1800 mm-560 mm × 1800 mm | 2.NP_SO-102 | 709 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 90 | 1800 | 710 | 560 | 0.905604 | 1860 | 770 | 620 | 710 × 1800-560 × 1800 | TA00.03.0414 | 0414 | yes | 90 | 0 | 0 | 0 | 75 | 0 | 10380 | 50 | 5 | 710 | 860 | 1044.84 | 660 | 455 | 660 | 660 | 560 | 760 | 380 | 455 | 10000 | 455 | 430 | 1800 | 1800 | 710 | 1800 | 355 | 660 | 1160 | 1265 | Mechanické – tok - Tlaková ztráta: 0 Pa
13954762 | 1.NP_SO-102 | 160 | 0.0088 | 0.0688 | 325 mm × 160 mm-160 mm × 160 mm | 0 | 325 mm × 160 mm-160 mm × 160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 14 | SUP | 90 | 160 | 160 | 325 | 0.0183703 | 220 | 220 | 385 | 325 × 160-160 × 160 | TA00.03.0800 | 0800 | yes | 90 | 0 | 0 | 0 | -82.5 | 0 | 10262.5 | 50 | 5 | 475 | 310 | 498.222 | 425 | 180 | 260 | 260 | 160 | 525 | 262.5 | 180 | 10000 | 180 | 312.5 | 160 | 325 | 325 | 325 | 80 | 425 | 760 | 605 | Mechanické – tok - Tlaková ztráta: 0 Pa
14014446 | 2.NP_SO-102 | 1000 | 0.022 | 0.91 | 450 mm × 1000 mm-400 mm × 1000 mm | 0 | 450 mm × 1000 mm-400 mm × 1000 mm | 2.NP_SO-102 | -750 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 15 | SUP | 90 | 1000 | 400 | 450 | 0.260247 | 1060 | 460 | 510 | 450 × 1000-400 × 1000 | TA00.03.0959 | 0959 | yes | 90 | 0 | 0 | 0 | -25 | 0 | 10325 | 50 | 5 | 600 | 550 | 743.303 | 550 | 300 | 500 | 500 | 400 | 650 | 325 | 300 | 10000 | 300 | 375 | 1000 | 1000 | 450 | 1000 | 200 | 550 | 1000 | 850
14016778 | 3.NP_SO-102 | 500 | 0.01375 | 0.305 | 250 mm × 500 mm-250 mm × 500 mm | 0 | 250 mm × 500 mm-250 mm × 500 mm | 3.NP_SO-102 | 194.25 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 30 | 500 | 250 | 250 | 0.0284761 | 560 | 310 | 310 | 250 × 500-250 × 500 | TA00.03.0961 | 0961 | yes | 150 | 43.3013 | 4.33013 | 81.2178 | 0 | 194.856 | 10060.3 | 25 | 2.5 | 252.073 | 225 | 181.173 | 175 | 225 | 93.7822 | 350 | 250 | 450 | 225 | 60.2886 | 9947.79 | 60.2886 | 110.289 | 500 | 500 | 250 | 500 | 125 | 93.7822 | 850 | 575
14032834 | 2.NP_SO-102 | 1000 | 0.022 | 0.91 | 800 mm × 1000 mm-400 mm × 1000 mm | 0 | 800 mm × 1000 mm-400 mm × 1000 mm | 2.NP_SO-102 | 809 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 11 | SUP | 90 | 1000 | 400 | 800 | 0.454495 | 1060 | 460 | 860 | 800 × 1000-400 × 1000 | TA00.03.0986 | 0986 | yes | 90 | 0 | 0 | 0 | -200 | 0 | 10500 | 50 | 5 | 950 | 550 | 1029.56 | 900 | 300 | 500 | 500 | 400 | 1000 | 500 | 300 | 10000 | 300 | 550 | 1000 | 1000 | 800 | 1000 | 200 | 900 | 1000 | 1200
14036702 | 2.NP_SO-102 | 315 | 0.06875 | 0.82215 | 1250 mm × 315 mm-500 mm × 315 mm | 0 | 1250 mm × 315 mm-500 mm × 315 mm | 2.NP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 90 | 315 | 1250 | 500 | 0.25866 | 375 | 1310 | 560 | 1250 × 315-500 × 315 | TA00.03.1003 | 1003 | yes | 90 | 0 | 0 | 0 | 375 | 0 | 10350 | 50 | 5 | 650 | 1400 | 1477.33 | 600 | 725 | 600 | 600 | 500 | 700 | 350 | 725 | 10000 | 725 | 400 | 1250 | 1250 | 1250 | 500 | 625 | 600 | 1100 | 2075 | Mechanické – tok - Tlaková ztráta: 0 Pa
14037287 | 3.NP_SO-102 | 500 | 0.01375 | 0.305 | 250 mm × 500 mm-250 mm × 500 mm | 0 | 250 mm × 500 mm-250 mm × 500 mm | 3.NP_SO-102 | -126.185 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 30 | 500 | 250 | 250 | 0.0284761 | 560 | 310 | 310 | 250 × 500-250 × 500 | TA00.03.1009 | 1009 | yes | 150 | 43.3013 | 4.33013 | 81.2178 | 0 | 194.856 | 10060.3 | 25 | 2.5 | 252.073 | 225 | 181.173 | 175 | 225 | 93.7822 | 350 | 250 | 450 | 225 | 60.2886 | 9947.79 | 60.2886 | 110.289 | 500 | 500 | 250 | 500 | 125 | 93.7822 | 850 | 575
14037643 | 2.NP_SO-102 | 225 | 0.0275 | 0.24975 | 500 mm × 225 mm-500 mm × 225 mm | 0 | 500 mm × 225 mm-500 mm × 225 mm | 2.NP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 90 | 225 | 500 | 500 | 0.0742247 | 285 | 560 | 560 | 500 × 225-500 × 225 | TA00.03.1011 | 1011 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10350 | 50 | 5 | 650 | 650 | 848.528 | 600 | 350 | 600 | 600 | 500 | 700 | 350 | 350 | 10000 | 350 | 400 | 500 | 500 | 500 | 500 | 250 | 600 | 1100 | 950 | Mechanické – tok - Tlaková ztráta: 0 Pa
14049197 | 2.NP_SO-102 | 1000 | 0.022 | 0.91 | 450 mm × 1000 mm-400 mm × 1000 mm | 0 | 450 mm × 1000 mm-400 mm × 1000 mm | 2.NP_SO-102 | -800 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 11 | ETA | 90 | 1000 | 400 | 450 | 0.260247 | 1060 | 460 | 510 | 450 × 1000-400 × 1000 | TA00.03.1035 | 1035 | yes | 90 | 0 | 0 | 0 | -25 | 0 | 10325 | 50 | 5 | 600 | 550 | 743.303 | 550 | 300 | 500 | 500 | 400 | 650 | 325 | 300 | 10000 | 300 | 375 | 1000 | 1000 | 450 | 1000 | 200 | 550 | 1000 | 850 | Mechanické – tok - Tlaková ztráta: 0 Pa
14050641 | 2.NP_SO-102 | 225 | 0.0275 | 0.24975 | 1250 mm × 225 mm-500 mm × 225 mm | 0 | 1250 mm × 225 mm-500 mm × 225 mm | 2.NP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 90 | 225 | 500 | 1250 | 0.184757 | 285 | 560 | 1310 | 1250 × 225-500 × 225 | TA00.03.1039 | 1039 | yes | 90 | 0 | 0 | 0 | -375 | 0 | 10725 | 50 | 5 | 1400 | 650 | 1477.33 | 1350 | 350 | 600 | 600 | 500 | 1450 | 725 | 350 | 10000 | 350 | 775 | 500 | 1250 | 1250 | 1250 | 250 | 1350 | 1100 | 1700 | Mechanické – tok - Tlaková ztráta: 0 Pa
14076594 | 2.NP_SO-102 | 225 | 0.0275 | 0.24975 | 500 mm × 225 mm-500 mm × 225 mm | 0 | 500 mm × 225 mm-500 mm × 225 mm | 2.NP_SO-102 | 2925 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 90 | 225 | 500 | 500 | 0.0742247 | 285 | 560 | 560 | 500 × 225-500 × 225 | TA00.03.1134 | 1134 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10350 | 50 | 5 | 650 | 650 | 848.528 | 600 | 350 | 600 | 600 | 500 | 700 | 350 | 350 | 10000 | 350 | 400 | 500 | 500 | 500 | 500 | 250 | 600 | 1100 | 950 | Mechanické – tok - Tlaková ztráta: 0 Pa
14078252 | 2.NP_SO-102 | 1250 | 0.022 | 1.1375 | 500 mm × 1250 mm-400 mm × 1250 mm | 0 | 500 mm × 1250 mm-400 mm × 1250 mm | 2.NP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 89.976 | 1250 | 400 | 500 | 0.359916 | 1310 | 460 | 560 | 500 × 1250-400 × 1250 | TA00.03.1143 | 1143 | yes | 90.024 | 0.0209118 | 0.00209118 | 0.209013 | -50 | 0.146382 | 10349.9 | 50 | 5 | 1195550 | 550 | 780.864 | 600 | 300 | 499.749 | 499.958 | 400 | 700 | 350 | 299.875 | 9999.87 | 299.854 | 399.875 | 1250 | 1250 | 500 | 1250 | 200 | 599.791 | 999.958 | 900 | Mechanické – tok - Tlaková ztráta: 0 Pa
14078255 | 2.NP_SO-102 | 1250 | 0.0275 | 1.3875 | 1250 mm × 1250 mm-500 mm × 1250 mm | 0 | 1250 mm × 1250 mm-500 mm × 1250 mm | 2.NP_SO-102 | 559 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 90 | 1250 | 500 | 1250 | 1.02643 | 1310 | 560 | 1310 | 1250 × 1250-500 × 1250 | TA00.03.1144 | 1144 | yes | 90 | 0 | 0 | 0 | -375 | 0 | 10725 | 50 | 5 | 1400 | 650 | 1477.33 | 1350 | 350 | 600 | 600 | 500 | 1450 | 725 | 350 | 10000 | 350 | 775 | 1250 | 1250 | 1250 | 1250 | 250 | 1350 | 1100 | 1700 | Mechanické – tok - Tlaková ztráta: 0 Pa
14122398 | -1.PP_SO-102 | 400 | 0.044 | 0.684 | 800 mm × 400 mm-800 mm × 400 mm | 0 | 800 mm × 400 mm-800 mm × 400 mm | -1.PP_SO-102 | 2400 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | 90 | 400 | 800 | 800 | 0.286526 | 460 | 860 | 860 | 800 × 400-800 × 400 | TA00.03.1277 | 1277 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10500 | 50 | 5 | 950 | 950 | 1272.79 | 900 | 500 | 900 | 900 | 800 | 1000 | 500 | 500 | 10000 | 500 | 550 | 800 | 800 | 800 | 800 | 400 | 900 | 1400 | 1400
14123795 | -1.PP_SO-102 | 800 | 0.022 | 0.728 | 400 mm × 800 mm-400 mm × 800 mm | 0 | 400 mm × 800 mm-400 mm × 800 mm | -1.PP_SO-102 | 3130 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 800 | 400 | 400 | 0.185996 | 860 | 460 | 460 | 400 × 800-400 × 800 | TA00.03.1288 | 1288 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10300 | 50 | 5 | 550 | 550 | 707.107 | 500 | 300 | 500 | 500 | 400 | 600 | 300 | 300 | 10000 | 300 | 350 | 800 | 800 | 400 | 800 | 200 | 500 | 1000 | 800
14173904 | -1.PP_SO-102 | 400 | 0.044 | 0.684 | 800 mm × 400 mm-800 mm × 400 mm | 0 | 800 mm × 400 mm-800 mm × 400 mm | -1.PP_SO-102 | 3130 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 400 | 800 | 800 | 0.286526 | 460 | 860 | 860 | 800 × 400-800 × 400 | TA00.03.1432 | 1432 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10500 | 50 | 5 | 950 | 950 | 1272.79 | 900 | 500 | 900 | 900 | 800 | 1000 | 500 | 500 | 10000 | 500 | 550 | 800 | 800 | 800 | 800 | 400 | 900 | 1400 | 1400
14174116 | -1.PP_SO-102 | 400 | 0.044 | 0.684 | 800 mm × 400 mm-800 mm × 400 mm | 0 | 800 mm × 400 mm-800 mm × 400 mm | -1.PP_SO-102 | 3130 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 400 | 800 | 800 | 0.286526 | 460 | 860 | 860 | 800 × 400-800 × 400 | TA00.03.1433 | 1433 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10500 | 50 | 5 | 950 | 950 | 1272.79 | 900 | 500 | 900 | 900 | 800 | 1000 | 500 | 500 | 10000 | 500 | 550 | 800 | 800 | 800 | 800 | 400 | 900 | 1400 | 1400
14176987 | -1.PP_SO-102 | 800 | 0.022 | 0.728 | 400 mm × 800 mm-400 mm × 800 mm | 0 | 400 mm × 800 mm-400 mm × 800 mm | -1.PP_SO-102 | 2500 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90 | 800 | 400 | 400 | 0.185996 | 860 | 460 | 460 | 400 × 800-400 × 800 | TA00.03.1443 | 1443 | yes | 90 | 0 | 0 | 0 | 0 | 0 | 10300 | 50 | 5 | 550 | 550 | 707.107 | 500 | 300 | 500 | 500 | 400 | 600 | 300 | 300 | 10000 | 300 | 350 | 800 | 800 | 400 | 800 | 200 | 500 | 1000 | 800
14181685 | 1.NP_SO-102 | 315 | 0.03905 | 0.48195 | 710 mm × 315 mm-710 mm × 315 mm | 0 | 710 mm × 315 mm-710 mm × 315 mm | 1.NP_SO-102 | 3250 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 15 | SUP | 90 | 315 | 710 | 710 | 0.184446 | 375 | 770 | 770 | 710 × 315-710 × 315 | TA00.03.1473 | 1473 |  | 90 | 0 | 0 | 0 | 0 | 0 | 10455 | 50 | 5 | 860 | 860 | 1145.51 | 810 | 455 | 810 | 810 | 710 | 910 | 455 | 455 | 10000 | 455 | 505 | 710 | 710 | 710 | 710 | 355 | 810 | 1310 | 1265 | Mechanické – tok - Tlaková ztráta: 0 Pa
14182375 | 1.NP_SO-102 | 315 | 0.03905 | 0.48195 | 710 mm × 315 mm-710 mm × 315 mm | 0 | 710 mm × 315 mm-710 mm × 315 mm | 1.NP_SO-102 | 3250 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 15 | SUP | 90 | 315 | 710 | 710 | 0.184446 | 375 | 770 | 770 | 710 × 315-710 × 315 | TA00.03.1489 | 1489 |  | 90 | 0 | 0 | 0 | 0 | 0 | 10455 | 50 | 5 | 860 | 860 | 1145.51 | 810 | 455 | 810 | 810 | 710 | 910 | 455 | 455 | 10000 | 455 | 505 | 710 | 710 | 710 | 710 | 355 | 810 | 1310 | 1265
14183061 | 1.NP_SO-102 | 315 | 0.03905 | 0.48195 | 710 mm × 315 mm-710 mm × 315 mm | 0 | 710 mm × 315 mm-710 mm × 315 mm | 1.NP_SO-102 | 3317.5 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 15 | SUP | 90 | 315 | 710 | 710 | 0.184446 | 375 | 770 | 770 | 710 × 315-710 × 315 | TA00.03.1491 | 1491 |  | 90 | 0 | 0 | 0 | 0 | 0 | 10455 | 50 | 5 | 860 | 860 | 1145.51 | 810 | 455 | 810 | 810 | 710 | 910 | 455 | 455 | 10000 | 455 | 505 | 710 | 710 | 710 | 710 | 355 | 810 | 1310 | 1265 | Mechanické – tok - Tlaková ztráta: 0 Pa
14183409 | 1.NP_SO-102 | 315 | 0.03905 | 0.48195 | 710 mm × 315 mm-710 mm × 315 mm | 0 | 710 mm × 315 mm-710 mm × 315 mm | 1.NP_SO-102 | 3250 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 15 | SUP | 60 | 315 | 710 | 710 | 0.131165 | 375 | 770 | 770 | 710 × 315-710 × 315 | TA00.03.1494 | 1494 |  | 120 | 25 | 2.5 | 233.827 | 0 | 227.5 | 10262.7 | 43.3013 | 4.33013 | 1452.96 | 751.481 | 810 | 701.481 | 455 | 467.654 | 810 | 710 | 910 | 455 | 262.694 | 9868.65 | 262.694 | 312.694 | 710 | 710 | 710 | 710 | 355 | 467.654 | 1310 | 1265 | Mechanické – tok - Tlaková ztráta: 0 Pa
14183443 | 1.NP_SO-102 | 315 | 0.03905 | 0.48195 | 710 mm × 315 mm-710 mm × 315 mm | 0 | 710 mm × 315 mm-710 mm × 315 mm | 1.NP_SO-102 | 3250 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 15 | SUP | 60 | 315 | 710 | 710 | 0.131165 | 375 | 770 | 770 | 710 × 315-710 × 315 | TA00.03.1496 | 1496 |  | 120 | 25 | 2.5 | 233.827 | 0 | 227.5 | 10262.7 | 43.3013 | 4.33013 | 1452.96 | 751.481 | 810 | 701.481 | 455 | 467.654 | 810 | 710 | 910 | 455 | 262.694 | 9868.65 | 262.694 | 312.694 | 710 | 710 | 710 | 710 | 355 | 467.654 | 1310 | 1265
14193502 | 4.NP_SO-102 | 500 | 0.088 | 1.655 | 1600 mm × 500 mm-1600 mm × 500 mm | 0 | 1600 mm × 500 mm-1600 mm × 500 mm | 4.NP_SO-102 | 4579.33 | Fáze 1 | Znehodnocený | Odváděný vzduch | EHA 1 | EHA | 90 | 500 | 1600 | 1600 | 1.21902 | 560 | 1660 | 1660 | 1600 × 500-1600 × 500 | TA00.03.1525 | 1525 |  | 90 | 0 | 0 | 0 | 0 | 0 | 10900 | 50 | 5 | 1750 | 1750 | 2404.16 | 1700 | 900 | 1700 | 1700 | 1600 | 1800 | 900 | 900 | 10000 | 900 | 950 | 1600 | 1600 | 1600 | 1600 | 800 | 1700 | 2200 | 2600 | Mechanické – tok - Tlaková ztráta: 0 Pa
14194975 | 3.NP_SO-102 | 500 | 0.0088 | 0.215 | 160 mm × 500 mm-160 mm × 500 mm | 0 | 160 mm × 500 mm-160 mm × 500 mm | 3.NP_SO-102 | 2735 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 45 | 500 | 160 | 160 | 0.0201096 | 560 | 220 | 220 | 160 × 500-160 × 500 | TA00.03.1530 | 1530 |  | 135 | 35.3553 | 3.53553 | 76.1522 | 0 | 127.279 | 10074.6 | 35.3553 | 3.53553 | 310 | 233.848 | 198.995 | 183.848 | 180 | 107.696 | 260 | 160 | 360 | 180 | 74.5584 | 9947.28 | 74.5584 | 124.558 | 500 | 500 | 160 | 500 | 80 | 107.696 | 760 | 440
14195687 | 3.NP_SO-102 | 500 | 0.0088 | 0.215 | 160 mm × 500 mm-160 mm × 500 mm | 0 | 160 mm × 500 mm-160 mm × 500 mm | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 45 | 500 | 160 | 160 | 0.0201096 | 560 | 220 | 220 | 160 × 500-160 × 500 | TA00.03.1531 | 1531 |  | 135 | 35.3553 | 3.53553 | 76.1522 | 0 | 127.279 | 10074.6 | 35.3553 | 3.53553 | 310 | 233.848 | 198.995 | 183.848 | 180 | 107.696 | 260 | 160 | 360 | 180 | 74.5584 | 9947.28 | 74.5584 | 124.558 | 500 | 500 | 160 | 500 | 80 | 107.696 | 760 | 440
14195856 | 3.NP_SO-102 | 500 | 0.0088 | 0.215 | 160 mm × 500 mm-160 mm × 500 mm | 0 | 160 mm × 500 mm-160 mm × 500 mm | 3.NP_SO-102 | 2735 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 45 | 500 | 160 | 160 | 0.0201096 | 560 | 220 | 220 | 160 × 500-160 × 500 | TA00.03.1533 | 1533 |  | 135 | 35.3553 | 3.53553 | 76.1522 | 0 | 127.279 | 10074.6 | 35.3553 | 3.53553 | 310 | 233.848 | 198.995 | 183.848 | 180 | 107.696 | 260 | 160 | 360 | 180 | 74.5584 | 9947.28 | 74.5584 | 124.558 | 500 | 500 | 160 | 500 | 80 | 107.696 | 760 | 440
14196115 | 3.NP_SO-102 | 500 | 0.0088 | 0.215 | 160 mm × 500 mm-160 mm × 500 mm | 0 | 160 mm × 500 mm-160 mm × 500 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 45 | 500 | 160 | 160 | 0.0201096 | 560 | 220 | 220 | 160 × 500-160 × 500 | TA00.03.1535 | 1535 |  | 135 | 35.3553 | 3.53553 | 76.1522 | 0 | 127.279 | 10074.6 | 35.3553 | 3.53553 | 310 | 233.848 | 198.995 | 183.848 | 180 | 107.696 | 260 | 160 | 360 | 180 | 74.5584 | 9947.28 | 74.5584 | 124.558 | 500 | 500 | 160 | 500 | 80 | 107.696 | 760 | 440
14196298 | 2.NP_SO-102 | 500 | 0.0088 | 0.215 | 160 mm × 500 mm-160 mm × 500 mm | 0 | 160 mm × 500 mm-160 mm × 500 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 45 | 500 | 160 | 160 | 0.0201096 | 560 | 220 | 220 | 160 × 500-160 × 500 | TA00.03.1537 | 1537 |  | 135 | 35.3553 | 3.53553 | 76.1522 | 0 | 127.279 | 10074.6 | 35.3553 | 3.53553 | 310 | 233.848 | 198.995 | 183.848 | 180 | 107.696 | 260 | 160 | 360 | 180 | 74.5584 | 9947.28 | 74.5584 | 124.558 | 500 | 500 | 160 | 500 | 80 | 107.696 | 760 | 440
14196439 | 2.NP_SO-102 | 500 | 0.0088 | 0.215 | 160 mm × 500 mm-160 mm × 500 mm | 0 | 160 mm × 500 mm-160 mm × 500 mm | 2.NP_SO-102 | 2735 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 45 | 500 | 160 | 160 | 0.0201096 | 560 | 220 | 220 | 160 × 500-160 × 500 | TA00.03.1538 | 1538 |  | 135 | 35.3553 | 3.53553 | 76.1522 | 0 | 127.279 | 10074.6 | 35.3553 | 3.53553 | 310 | 233.848 | 198.995 | 183.848 | 180 | 107.696 | 260 | 160 | 360 | 180 | 74.5584 | 9947.28 | 74.5584 | 124.558 | 500 | 500 | 160 | 500 | 80 | 107.696 | 760 | 440
14196703 | 2.NP_SO-102 | 500 | 0.0088 | 0.215 | 160 mm × 500 mm-160 mm × 500 mm | 0 | 160 mm × 500 mm-160 mm × 500 mm | 2.NP_SO-102 | 2735 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 45 | 500 | 160 | 160 | 0.0201096 | 560 | 220 | 220 | 160 × 500-160 × 500 | TA00.03.1540 | 1540 |  | 135 | 35.3553 | 3.53553 | 76.1522 | 0 | 127.279 | 10074.6 | 35.3553 | 3.53553 | 310 | 233.848 | 198.995 | 183.848 | 180 | 107.696 | 260 | 160 | 360 | 180 | 74.5584 | 9947.28 | 74.5584 | 124.558 | 500 | 500 | 160 | 500 | 80 | 107.696 | 760 | 440
14196706 | 2.NP_SO-102 | 500 | 0.0088 | 0.215 | 160 mm × 500 mm-160 mm × 500 mm | 0 | 160 mm × 500 mm-160 mm × 500 mm | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 45 | 500 | 160 | 160 | 0.0201096 | 560 | 220 | 220 | 160 × 500-160 × 500 | TA00.03.1541 | 1541 |  | 135 | 35.3553 | 3.53553 | 76.1522 | 0 | 127.279 | 10074.6 | 35.3553 | 3.53553 | 310 | 233.848 | 198.995 | 183.848 | 180 | 107.696 | 260 | 160 | 360 | 180 | 74.5584 | 9947.28 | 74.5584 | 124.558 | 500 | 500 | 160 | 500 | 80 | 107.696 | 760 | 440

# IfcDuctFitting: Pravoúhlý přechod, koleno, poloměr, přírubový:Standardní (57)
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - ID kategorie: R; Kód sestavy: TA00; Název typu: Standardní; Označení typu: 03; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: Pravoúhlý přechod, koleno, poloměr, přírubový
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Grafika - Použít měřítko poznámky: yes
Kóty - e: 0 mm; f: 0 mm; r: 100 mm; Rozšíření příruby: 30 mm; Tloušťka příruby: 5 mm
