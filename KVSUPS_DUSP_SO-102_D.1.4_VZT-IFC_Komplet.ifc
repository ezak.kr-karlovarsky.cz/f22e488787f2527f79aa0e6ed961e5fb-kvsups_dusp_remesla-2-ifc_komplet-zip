Properties of the parts of a building model (IFC4), part 44 of 45

# IfcDuctSegment: Kulaté potrubí:SPIRO POZINK/T spoj (978)
Name (Kulaté potrubí:SPIRO POZINK/T spoj:...) | In | Length (mm) = Délka (mm) | GrossCrossSectionArea (m2) = NetCrossSectionArea (m2) | OuterSurfaceArea (m2) = Plocha (m2) | Volná velikost | Celková velikost | Tloušťka izolace (mm) | Dynamický tlak (Pa) | Průtok (m3/s) | Reynoldsovo číslo | Rychlost (m/s) | Tlaková ztráta (Pa) | Tření (kg/m2/s2) | Horní výška (mm) | Koncová střední výška (mm) | Počáteční střední výška (mm) = Střední výška (mm) | Referenční podlaží | Sklon | Spodní výška (mm) | Fáze vytvoření | Ekvivaletní průměr (mm) = Hydraulický průměr (mm) = Průměr (mm) = Velikost | Klasifikace systému | Koeficient ztrát | Název systému | Řez | Typ systému | Zkratka systému | Kód prvku | Označení | Páteřní trasa | Group
13960615 | -1.PP_SO-102 | 380.048 | 0.0254431 | 0.214912 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3159.42 | 3069.23 | 3069.42 | -1.PP_SO-102 | 0.0514665 | 2979.23 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 27 | 92 | Odváděný | ETA | PO02.01.1109 | 1109 | no | ETA 27
13960623 | -1.PP_SO-102 | 930.529 | 0.0254431 | 0.526202 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3158.2 | 3067.71 | 3068.2 | -1.PP_SO-102 | 0.0530295 | 2977.71 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 27 | 92 | Odváděný | ETA | PO02.01.1110 | 1110 | no | ETA 27
13960632 | -1.PP_SO-102 | 2220 | 0.0201032 | 1.11589 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3147.64 | 3067.64 | 3067.64 | -1.PP_SO-102 | 0 | 2987.64 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 27 | 154 | Odváděný | ETA | PO02.01.1111 | 1111 | no | ETA 27
13961166 | -1.PP_SO-102 | 2027.55 | 0.0254431 | 1.14655 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3157.71 | 3067.69 | 3067.71 | -1.PP_SO-102 | 0 | 2977.69 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 27 | 116 | Odváděný | ETA | PO02.01.1112 | 1112 | no | ETA 27
13961975 | -1.PP_SO-102 | 71.4003 | 0.0254431 | 0.0403759 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3157.62 | 3067.62 | 3067.62 | -1.PP_SO-102 | 0 | 2977.62 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 27 | 111 | Odváděný | ETA | PO02.01.1113 | 1113 | no | ETA 27
13963095 | -1.PP_SO-102 | 4233.96 | 0.0989649 | 4.72199 | 355 mm | 385 mm | 15 | 0 | 0 | 0 | 0 | 0 | 0 | 3254.64 | 3077.14 | 3077.14 | -1.PP_SO-102 | 0 | 2899.64 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 4 | 50 | Přívodní | SUP | PO02.01.1114 | 1114 | yes | SUP 4 | Izolace - Typ izolace: Protipožární
13963193 | -1.PP_SO-102 | 1084.11 | 0.0989649 | 1.20907 | 355 mm | 385 mm | 15 | 0 | 0 | 0 | 0 | 0 | 0 | 3254.64 | 3077.14 | 3077.14 | -1.PP_SO-102 | 0 | 2899.64 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 4 | 50 | Přívodní | SUP | PO02.01.1115 | 1115 | yes | SUP 4 | Izolace - Typ izolace: Protipožární
13963200 | -1.PP_SO-102 | 405.245 | 0.0989649 | 0.451956 | 355 mm | 385 mm | 15 | 0 | 0 | 0 | 0 | 0 | 0 | 3254.64 | 3077.14 | 3077.14 | -1.PP_SO-102 | 0 | 2899.64 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 4 | 50 | Přívodní | SUP | PO02.01.1116 | 1116 | yes | SUP 4 | Izolace - Typ izolace: Protipožární
13963210 | -1.PP_SO-102 | 152.448 | 0.0989649 | 0.17002 | 355 mm | 385 mm | 15 | 0 | 0 | 0 | 0 | 0 | 0 | 3254.64 | 3077.14 | 3077.14 | -1.PP_SO-102 | 0 | 2899.64 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 4 | 50 | Přívodní | SUP | PO02.01.1117 | 1117 | yes | SUP 4 | Izolace - Typ izolace: Protipožární
13963352 | -1.PP_SO-102 | 9.6812 | 0.04908 | 0.0076036 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3202.14 | 3077.14 | 3077.14 | -1.PP_SO-102 | 0 | 2952.14 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 25 | 55 | Přívodní | SUP | PO02.01.1118 | 1118 | no | SUP 25
13963433 | -1.PP_SO-102 | 760.488 | 0.04908 | 0.597286 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3202.14 | 3077.14 | 3077.14 | -1.PP_SO-102 | 0 | 2952.14 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 25 | 58 | Přívodní | SUP | PO02.01.1119 | 1119 | no | SUP 25
13963453 | -1.PP_SO-102 | 2008.64 | 0.0201032 | 1.00965 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3157.14 | 3077.14 | 3077.14 | -1.PP_SO-102 | 0 | 2997.14 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 25 | 60 | Přívodní | SUP | PO02.01.1120 | 1120 | no | SUP 25
13964135 | -1.PP_SO-102 | 487.89 | 0.0201032 | 0.24524 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3149.6 | 3069.6 | 3069.6 | -1.PP_SO-102 | 0 | 2989.6 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 27 | 127 | Odváděný | ETA | PO02.01.1121 | 1121 | no | ETA 27
13964148 | -1.PP_SO-102 | 219.448 | 0.0201032 | 0.110307 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3149.6 | 3069.6 | 3069.59 | -1.PP_SO-102 | 0 | 2989.59 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 27 | 122 | Odváděný | ETA | PO02.01.1122 | 1122 | no | ETA 27
13964544 | -1.PP_SO-102 | 482.891 | 0.0201024 | 0.242727 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3150 | 3070 | 3069.99 | -1.PP_SO-102 | 0 | 2989.99 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 27 | 130 | Odváděný | ETA | PO02.01.1123 | 1123 | no | ETA 27
13964551 | -1.PP_SO-102 | 2205.29 | 0.0254431 | 1.24706 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3157.62 | 3067.62 | 3067.62 | -1.PP_SO-102 | 0 | 2977.62 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 27 | 116 | Odváděný | ETA | PO02.01.1124 | 1124 | no | ETA 27
13965234 | -1.PP_SO-102 | 358.821 | 0.04908 | 0.281817 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2925 | 2800 | 2800 | -1.PP_SO-102 | 0 | 2675 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 27 | 174 | Odváděný | ETA | PO02.01.1125 | 1125 | no | ETA 27
13965341 | -1.PP_SO-102 | 342.057 | 0.04908 | 0.268651 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2475.05 | 2350.05 | 2350 | -1.PP_SO-102 | 0.0156196 | 2225 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 27 | 78 | Odváděný | ETA | PO02.01.1126 | 1126 | no | ETA 27
13966052 | -1.PP_SO-102 | 114.538 | 0.0201032 | 0.0575731 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3147.64 | 3067.64 | 3067.64 | -1.PP_SO-102 | 0 | 2987.64 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 27 | 154 | Odváděný | ETA | PO02.01.1128 | 1128 | no | ETA 27
13966662 | -1.PP_SO-102 | 1086.31 | 0.04908 | 0.853189 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2825 | 2700 | 2700 | -1.PP_SO-102 | 0 | 2575 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 4 | 61 | Přívodní | SUP | PO02.01.1129 | 1129 | no | SUP 4
13966781 | -1.PP_SO-102 | 59.818 | 0.04908 | 0.0469809 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2825 | 2700 | 2700 | -1.PP_SO-102 | 0 | 2575 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 4 | 61 | Přívodní | SUP | PO02.01.1130 | 1130 | no | SUP 4
13966790 | -1.PP_SO-102 | 326.249 | 0.04908 | 0.256235 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3092.3 | 2773.22 | 3003.92 | -1.PP_SO-102 | 100 | 2684.83 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 4 | 61 | Přívodní | SUP | PO02.01.1131 | 1131 | no | SUP 4
13966929 | -1.PP_SO-102 | 4258.87 | 0.04908 | 3.34491 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2925 | 2800 | 2800 | -1.PP_SO-102 | 0 | 2675 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 27 | 174 | Odváděný | ETA | PO02.01.1132 | 1132 | no | ETA 27
13967497 | -1.PP_SO-102 | 740.329 | 0.0254431 | 0.418646 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2440 | 2350 | 2350 | -1.PP_SO-102 | 0 | 2260 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 27 | 158 | Odváděný | ETA | PO02.01.1133 | 1133 | no | ETA 27
13967539 | -1.PP_SO-102 | 635.904 | 0.0254431 | 0.359595 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2440 | 2350 | 2350 | -1.PP_SO-102 | 0 | 2260 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 27 | 158 | Odváděný | ETA | PO02.01.1134 | 1134 | no | ETA 27
13971146 | 1.NP_SO-102 | 4010.27 | 0.0201032 | 2.01578 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 413 | Přívodní | SUP | PO02.01.1136 | 1136 | no | SUP 24
13977611 | 3.NP_SO-102 | 3540 | 0.0201032 | 1.7794 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2980 | 2900 | 2900 | 3.NP_SO-102 | 0 | 2820 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 13 | 242 | Přívodní | SUP | PO02.01.1139 | 1139 | no | SUP 13
13977922 | 3.NP_SO-102 | 733.284 | 0.0201032 | 0.368589 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3179.91 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 3019.91 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 13 | 242 | Přívodní | SUP | PO02.01.1140 | 1140 | no | SUP 13
13977923 | 3.NP_SO-102 | 150.294 | 0.0201032 | 0.075546 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3109.71 | 2946.86 | 3053.14 | 3.NP_SO-102 | 100 | 2890.29 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 13 | 242 | Přívodní | SUP | PO02.01.1141 | 1141 | no | SUP 13
13981807 | 4.NP_SO-102 | 726.689 | 0.0397548 | 0.513666 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3207.5 | 3095 | 3095 | 4.NP_SO-102 | 0 | 2982.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 247 | Přívodní | SUP | PO02.01.1148 | 1148 | no | SUP 13
13981906 | 4.NP_SO-102 | 1152.15 | 0.0397548 | 0.814405 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3292.5 | 3180 | 3180 | 4.NP_SO-102 | 0 | 3067.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 23 | 248 | Přívodní | SUP | PO02.01.1149 | 1149 | no | SUP 23
13981912 | 4.NP_SO-102 | 6186.98 | 0.0397548 | 4.37332 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3292.5 | 3180 | 3180 | 4.NP_SO-102 | 0 | 3067.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 23 | 254 | Přívodní | SUP | PO02.01.1150 | 1150 | no | SUP 23
13982163 | 4.NP_SO-102 | 57.4613 | 0.0397548 | 0.040617 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3292.5 | 3180 | 3180 | 4.NP_SO-102 | 0 | 3067.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 23 | 248 | Přívodní | SUP | PO02.01.1151 | 1151 | no | SUP 23
13982697 | 4.NP_SO-102 | 670.442 | 0.0254431 | 0.379126 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3185 | 3095 | 3095 | 4.NP_SO-102 | 0 | 3005 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 13 | 251 | Přívodní | SUP | PO02.01.1153 | 1153 | no | SUP 13
13982795 | 4.NP_SO-102 | 296.894 | 0.0254431 | 0.167889 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2993.77 | 2903.77 | 2903.77 | 4.NP_SO-102 | 0 | 2813.77 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 13 | 251 | Přívodní | SUP | PO02.01.1154 | 1154 | no | SUP 13
13982809 | 4.NP_SO-102 | 121.322 | 0.0254431 | 0.068606 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3105.92 | 2956.49 | 3042.28 | 4.NP_SO-102 | 100 | 2892.85 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 13 | 251 | Přívodní | SUP | PO02.01.1155 | 1155 | no | SUP 13
13982820 | 4.NP_SO-102 | 241.53 | 0.0254431 | 0.136582 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3190.92 | 2956.49 | 3127.28 | 4.NP_SO-102 | 100 | 2892.85 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 13 | 251 | Přívodní | SUP | PO02.01.1156 | 1156 | no | SUP 13
13984192 | 3.NP_SO-102 | 8305.38 | 0.0779194 | 8.21902 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3257.41 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 2942.41 | Fáze 1 | 315 | Přívod vzduchu | 0 | SUP 13 | 254 | Přívodní | SUP | PO02.01.1157 | 1157 | no | SUP 13
13984305 | 3.NP_SO-102 | 99.8097 | 0.0779194 | 0.0987719 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3257.41 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 2942.41 | Fáze 1 | 315 | Přívod vzduchu | 0 | SUP 13 | 254 | Přívodní | SUP | PO02.01.1158 | 1158 | no | SUP 13
13984346 | 3.NP_SO-102 | 267.5 | 0.0397548 | 0.189085 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3212.41 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 2987.41 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 258 | Přívodní | SUP | PO02.01.1159 | 1159 | no | SUP 13
13984358 | 3.NP_SO-102 | 329.653 | 0.0397548 | 0.233018 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3212.41 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 2987.41 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 256 | Přívodní | SUP | PO02.01.1160 | 1160 | no | SUP 13
13984366 | 3.NP_SO-102 | 175 | 0.0397548 | 0.1237 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3212.5 | 3100 | 3100 | 3.NP_SO-102 | 0 | 2987.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 269 | Přívodní | SUP | PO02.01.1161 | 1161 | no | SUP 13
13984588 | 3.NP_SO-102 | 153.561 | 0.0397548 | 0.108546 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3212.41 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 2987.41 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 263 | Přívodní | SUP | PO02.01.1162 | 1162 | no | SUP 13
13984681 | 3.NP_SO-102 | 375.793 | 0.0397548 | 0.265632 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3212.5 | 3100 | 3100 | 3.NP_SO-102 | 0 | 2987.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 258 | Přívodní | SUP | PO02.01.1163 | 1163 | no | SUP 13
13984848 | 3.NP_SO-102 | 153.561 | 0.0397548 | 0.108546 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3212.5 | 3100 | 3100 | 3.NP_SO-102 | 0 | 2987.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 269 | Přívodní | SUP | PO02.01.1164 | 1164 | no | SUP 13
13985028 | 3.NP_SO-102 | 8312.3 | 0.0397548 | 5.87562 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3212.5 | 3100 | 3100 | 3.NP_SO-102 | 0 | 2987.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 269 | Přívodní | SUP | PO02.01.1165 | 1165 | no | SUP 13
13985318 | 3.NP_SO-102 | 8320.68 | 0.0254431 | 4.70523 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3190 | 3100 | 3100 | 3.NP_SO-102 | 0 | 3010 | Fáze 2 | 180 | Přívod vzduchu | 0 | SUP 13 | 281 | Přívodní | SUP | PO02.01.1166 | 1166 | no | SUP 13 | Identifikační data - Komentáře: PŘIPOJENÍ PŘÍVODNÍHO POTRUBÍ V II.ETAPĚ VÝSTAVBY
13985410 | 3.NP_SO-102 | 8100 | 0.0397548 | 5.72555 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3212.5 | 3100 | 3100 | 3.NP_SO-102 | 0 | 2987.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 13 | 269 | Přívodní | SUP | PO02.01.1167 | 1167 | no | SUP 13 | Identifikační data - Komentáře: ZASLEPENÁ ODBOČKA PŘÍPRAVA PRO NAPOJENÍ MÍSTNOSTI VE II.ETAPĚ VÝSTAVBY
13986735 | -1.PP_SO-102 | 320 | 0.0201032 | 0.16085 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2910 | 2910 | 2590 | -1.PP_SO-102 |  | 2590 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 437 | Přívodní | SUP | PO02.01.1169 | 1169 | no | SUP 24
13986742 | -1.PP_SO-102 | 3365.3 | 0.0201032 | 1.69158 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2510 | 2430 | 2430 | -1.PP_SO-102 | 0 | 2350 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 8 | Přívodní | SUP | PO02.01.1170 | 1170 | no | SUP 24
13987766 | -1.PP_SO-102 | 98.6573 | 0.0989649 | 0.110029 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3327.5 | 3150 | 3150 | -1.PP_SO-102 | 0 | 2972.5 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 18 | 30 | Odváděný | ETA | PO02.01.1171 | 1171 | yes | ETA 18
13988329 | -1.PP_SO-102 | 22.8356 | 0.0989649 | 0.0254678 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3327.5 | 3150 | 3150 | -1.PP_SO-102 | 0 | 2972.5 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 18 | 30 | Odváděný | ETA | PO02.01.1172 | 1172 | yes | ETA 18
13988620 | -1.PP_SO-102 | 144.179 | 0.0254431 | 0.0815314 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3159.11 | 3069.08 | 3069.11 | -1.PP_SO-102 | 0 | 2979.08 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 27 | 92 | Odváděný | ETA | PO02.01.1173 | 1173 | no | ETA 27
13988959 | -1.PP_SO-102 | 1180 | 0.0201032 | 0.593132 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3147.64 | 3067.64 | 3067.64 | -1.PP_SO-102 | 0 | 2987.64 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 27 | 139 | Odváděný | ETA | PO02.01.1174 | 1174 | no | ETA 27
13988971 | -1.PP_SO-102 | 162.734 | 0.0201032 | 0.0817993 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3147.64 | 3067.64 | 3067.64 | -1.PP_SO-102 | 0 | 2987.64 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 27 | 139 | Odváděný | ETA | PO02.01.1175 | 1175 | no | ETA 27
13989046 | -1.PP_SO-102 | 109.761 | 0.0254431 | 0.0620685 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3158.84 | 3068.78 | 3068.84 | -1.PP_SO-102 | 0.0530295 | 2978.78 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 27 | 92 | Odváděný | ETA | PO02.01.1176 | 1176 | no | ETA 27
13989138 | -1.PP_SO-102 | 500 | 0.04908 | 0.392699 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3202.14 | 3077.14 | 3077.14 | -1.PP_SO-102 | 0 | 2952.14 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 4 | 49 | Přívodní | SUP | PO02.01.1177 | 1177 | no | SUP 4
13989201 | -1.PP_SO-102 | 330 | 0.04908 | 0.259181 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3202.14 | 3077.14 | 3077.14 | -1.PP_SO-102 | 0 | 2952.14 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 4 | 49 | Přívodní | SUP | PO02.01.1178 | 1178 | no | SUP 4
13989322 | -1.PP_SO-102 | 35.0909 | 0.04908 | 0.0275603 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3202.14 | 3077.14 | 3077.14 | -1.PP_SO-102 | 0 | 2952.14 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 4 | 32 | Přívodní | SUP | PO02.01.1179 | 1179 | yes | SUP 4
13989798 | -1.PP_SO-102 | 25.3291 | 0.0201032 | 0.0127318 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 4202.77 | 4122.77 | 4122.77 | -1.PP_SO-102 | 0 | 4042.77 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 437 | Odváděný | ETA | PO02.01.1180 | 1180 | no | ETA 7 | Identifikační data - Komentáře: VZT18
13989800 | 1.NP_SO-102 | 3640 | 0.0201032 | 1.82966 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 10670 | 10670 | 7030 | 1.NP_SO-102 |  | 7030 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 318 | Odváděný | ETA | PO02.01.1181 | 1181 | no | ETA 7
13990465 | 1.NP_SO-102 | 6487.23 | 0.0201032 | 3.26084 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 6770 | 6770 | 282.773 | 1.NP_SO-102 |  | 282.773 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 437 | Odváděný | ETA | PO02.01.1183 | 1183 | no | ETA 7 | Identifikační data - Komentáře: VZT18
13990996 | 3.NP_SO-102 | 830 | 0.0201032 | 0.417204 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2880 | 2800 | 2800 | 3.NP_SO-102 | 0 | 2720 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 316 | Odváděný | ETA | PO02.01.1185 | 1185 | no | ETA 7
13991009 | 3.NP_SO-102 | 74.7887 | 0.0201032 | 0.0375929 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2880 | 2800 | 2800 | 3.NP_SO-102 | 0 | 2720 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 311 | Odváděný | ETA | PO02.01.1186 | 1186 | no | ETA 7
13991402 | 3.NP_SO-102 | 180 | 0.0201032 | 0.0904779 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 3.NP_SO-102 | 0 | 3020 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 13 | 289 | Přívodní | SUP | PO02.01.1187 | 1187 | no | SUP 13
13991418 | 3.NP_SO-102 | 3925.78 | 0.0201032 | 1.97331 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 3.NP_SO-102 | 0 | 3020 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 13 | 289 | Přívodní | SUP | PO02.01.1188 | 1188 | no | SUP 13
13991602 | 3.NP_SO-102 | 220 | 0.0201032 | 0.110584 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3179.91 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 3019.91 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 13 | 85 | Přívodní | SUP | PO02.01.1189 | 1189 | no | SUP 13
13991697 | 3.NP_SO-102 | 190 | 0.0201032 | 0.0955044 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 3.NP_SO-102 | 0 | 3020 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 13 | 289 | Přívodní | SUP | PO02.01.1190 | 1190 | no | SUP 13
13991819 | 3.NP_SO-102 | 85.575 | 0.0201032 | 0.0430147 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 3.NP_SO-102 | 0 | 3020 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 13 | 289 | Přívodní | SUP | PO02.01.1191 | 1191 | no | SUP 13
13991967 | 3.NP_SO-102 | 96.766 | 0.0201032 | 0.0486399 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3179.91 | 3099.91 | 3099.91 | 3.NP_SO-102 | 0 | 3019.91 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 13 | 85 | Přívodní | SUP | PO02.01.1192 | 1192 | no | SUP 13
13992001 | 3.NP_SO-102 | 96.766 | 0.0201032 | 0.0486399 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 3.NP_SO-102 | 0 | 3020 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 13 | 289 | Přívodní | SUP | PO02.01.1193 | 1193 | no | SUP 13
13992197 | 1.NP_SO-102 | 12.3977 | 0.0201032 | 0.00623176 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 10942.4 | 10942.4 | 10930 | 1.NP_SO-102 |  | 10930 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 320 | Odváděný | ETA | PO02.01.1194 | 1194 | no | ETA 7
13992210 | 1.NP_SO-102 | 243.099 | 0.0201032 | 0.122195 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 11182.4 | 11102.4 | 11102.4 | 1.NP_SO-102 | 0 | 11022.4 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 320 | Odváděný | ETA | PO02.01.1195 | 1195 | no | ETA 7 | Identifikační data - Komentáře: VZT18
13992221 | 1.NP_SO-102 | 3807.6 | 0.0201032 | 1.91391 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 15070 | 15070 | 11262.4 | 1.NP_SO-102 |  | 11262.4 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 320 | Odváděný | ETA | PO02.01.1196 | 1196 | no | ETA 7
13992234 | 4.NP_SO-102 | 761.294 | 0.0201032 | 0.382668 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3310 | 3230 | 3230 | 4.NP_SO-102 | 0 | 3150 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 320 | Odváděný | ETA | PO02.01.1197 | 1197 | no | ETA 7 | Identifikační data - Komentáře: VZT18
13992544 | 4.NP_SO-102 | 1357.25 | 0.0989649 | 1.5137 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1177.5 | 1000 | 1000 | STŘECHA_SO-102 | 0 | 822.5 | Fáze 1 | 355 | Přívod vzduchu | 0 | ODA 10 | 138 | Čerstvý | ODA | PO02.01.1199 | 1199 | yes | ODA 10
13992568 | 4.NP_SO-102 | 1131.67 | 0.0989649 | 1.26211 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 1177.5 | 1000 | 1000 | STŘECHA_SO-102 | 0 | 822.5 | Fáze 1 | 355 | Přívod vzduchu | 0 | ODA 10 | 134 | Čerstvý | ODA | PO02.01.1200 | 1200 | yes | ODA 10
13993728 | 1.NP_SO-102 | 220 | 0.0254431 | 0.124407 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2830 | 2740 | 2740 | 1.NP_SO-102 | 0 | 2650 | Fáze 2 | 180 | Zpětný vzduch | 0 | ETA 17 | 72 | Odváděný | ETA | PO02.01.1201 | 1201 | yes | ETA 17
13993736 | 1.NP_SO-102 | 1292.39 | 0.0254431 | 0.730828 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2830 | 2740 | 2740 | 1.NP_SO-102 | 0 | 2650 | Fáze 2 | 180 | Zpětný vzduch | 0 | ETA 17 | 72 | Odváděný | ETA | PO02.01.1202 | 1202 | yes | ETA 17
13993988 | 1.NP_SO-102 | 998.121 | 0.061566 | 0.877993 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2880 | 2740 | 2740 | 1.NP_SO-102 | 0 | 2600 | Fáze 2 | 280 | Zpětný vzduch | 0 | ETA 17 | 91 | Odváděný | ETA | PO02.01.1203 | 1203 | no | ETA 17
13994001 | 1.NP_SO-102 | 7020 | 0.061566 | 6.17511 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2880 | 2740 | 2740 | 1.NP_SO-102 | 0 | 2600 | Fáze 2 | 280 | Zpětný vzduch | 0 | ETA 17 | 91 | Odváděný | ETA | PO02.01.1204 | 1204 | no | ETA 17
13996296 | 3.NP_SO-102 | 4481.58 | 0.04908 | 3.51983 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3225 | 3100 | 3100 | 3.NP_SO-102 | 0 | 2975 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 14 | 234 | Odváděný | ETA | PO02.01.1205 | 1205 | no | ETA 14
13996574 | 3.NP_SO-102 | 1898.76 | 0.04908 | 1.49128 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3225 | 3100 | 3100 | 3.NP_SO-102 | 0 | 2975 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 14 | 234 | Odváděný | ETA | PO02.01.1206 | 1206 | no | ETA 14
13997263 | 3.NP_SO-102 | 5265.1 | 0.0314112 | 3.30816 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3245.16 | 3145.16 | 3145.16 | 3.NP_SO-102 | 0 | 3045.16 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 9 | 411 | Přívodní | SUP | PO02.01.1207 | 1207 | no | SUP 9
13997667 | 4.NP_SO-102 | 4603.43 | 0.0314112 | 2.89242 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3280 | 3180 | 3180 | 4.NP_SO-102 | 0 | 3080 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 9 | 16 | Přívodní | SUP | PO02.01.1208 | 1208 | no | SUP 9
13997720 | 4.NP_SO-102 | 3738.8 | 0.0254431 | 2.11424 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3270 | 3180 | 3180 | 4.NP_SO-102 | 0 | 3090 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 9 | 6 | Přívodní | SUP | PO02.01.1209 | 1209 | no | SUP 9
13998136 | 4.NP_SO-102 | 7871.2 | 0.061566 | 6.92387 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3320 | 3180 | 3180 | 4.NP_SO-102 | 0 | 3040 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 9 | 8 | Přívodní | SUP | PO02.01.1210 | 1210 | no | SUP 9
13998665 | 4.NP_SO-102 | 6651.46 | 0.061566 | 5.85093 | 280 mm | 280 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3320 | 3180 | 3180 | 4.NP_SO-102 | 0 | 3040 | Fáze 1 | 280 | Přívod vzduchu | 0 | SUP 9 | 416 | Přívodní | SUP | PO02.01.1211 | 1211 | no | SUP 9 | Identifikační data - Komentáře: VZT25
13999002 | 4.NP_SO-102 | 2326.31 | 0.0397548 | 1.64437 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3112.5 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2887.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 14 | 323 | Odváděný | ETA | PO02.01.1212 | 1212 | no | ETA 14
13999413 | 4.NP_SO-102 | 3545 | 0.0397548 | 2.50581 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2775 | 2775 | -770 | 4.NP_SO-102 |  | -770 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 14 | 324 | Odváděný | ETA | PO02.01.1213 | 1213 | no | ETA 14
13999665 | 2.NP_SO-102 | 4875.18 | 0.0989649 | 5.43712 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3087.5 | 2910 | 2910 | 2.NP_SO-102 | 0 | 2732.5 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 14 | 328 | Odváděný | ETA | PO02.01.1214 | 1214 | no | ETA 14
14000399 | 4.NP_SO-102 | 10695.2 | 0.0397548 | 7.55999 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -4787.5 | -4900 | -4900 | 4.NP_SO-102 | 0 | -5012.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 14 | 333 | Odváděný | ETA | PO02.01.1215 | 1215 | no | ETA 14 | Identifikační data - Komentáře: VZT25
14000438 | 2.NP_SO-102 | 11829.5 | 0.0397548 | 8.36178 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3212.5 | 3100 | 3100 | 2.NP_SO-102 | 0 | 2987.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 14 | 333 | Odváděný | ETA | PO02.01.1216 | 1216 | no | ETA 14
14000526 | 4.NP_SO-102 | 3890.16 | 0.0397548 | 2.74979 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1004.84 | -4895 | -1004.84 | 4.NP_SO-102 |  | -4895 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 9 | 424 | Přívodní | SUP | PO02.01.1217 | 1217 | no | SUP 9
14000528 | 4.NP_SO-102 | 11203.5 | 0.0397548 | 7.91929 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -5007.5 | -5120 | -5120 | 4.NP_SO-102 | 0 | -5232.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 9 | 424 | Přívodní | SUP | PO02.01.1218 | 1218 | no | SUP 9
14000578 | 2.NP_SO-102 | 539.831 | 0.0397548 | 0.381584 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2992.5 | 2880 | 2880 | 2.NP_SO-102 | 0 | 2767.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 9 | 424 | Přívodní | SUP | PO02.01.1219 | 1219 | no | SUP 9
14000640 | 3.NP_SO-102 | 3217.61 | 0.0314112 | 2.02168 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3245.16 | 3145.16 | 3145.16 | 3.NP_SO-102 | 0 | 3045.16 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 9 | 468 | Přívodní | SUP | PO02.01.1220 | 1220 | no | SUP 9 | Identifikační data - Komentáře: VZT25
14007735 | -1.PP_SO-102 | 1100 | 0.0201032 | 0.55292 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3157.14 | 3077.14 | 3077.14 | -1.PP_SO-102 | 0 | 2997.14 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 25 | 62 | Přívodní | SUP | PO02.01.1236 | 1236 | no | SUP 25
14008176 | -1.PP_SO-102 | 2864.15 | 0.04908 | 2.2495 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3202.14 | 3077.14 | 3077.14 | -1.PP_SO-102 | 0 | 2952.14 | Fáze 1 | 250 | Přívod vzduchu | 0 | SUP 25 | 58 | Přívodní | SUP | PO02.01.1237 | 1237 | no | SUP 25
14008193 | -1.PP_SO-102 | 84.2621 | 0.0254431 | 0.0476491 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3159.67 | 3069.63 | 3069.67 | -1.PP_SO-102 | 0.0514665 | 2979.63 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 27 | 92 | Odváděný | ETA | PO02.01.1238 | 1238 | yes | ETA 27
14016855 | 3.NP_SO-102 | 549.296 | 0.0201032 | 0.276106 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2819.7 | 2739.7 | 2739.7 | 3.NP_SO-102 | 0 | 2659.7 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 324 | Odváděný | ETA | PO02.01.1262 | 1262 | no | ETA 7
14016862 | 3.NP_SO-102 | 300 | 0.0201032 | 0.150796 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2819.7 | 2739.7 | 2739.7 | 3.NP_SO-102 | 0 | 2659.7 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 324 | Odváděný | ETA | PO02.01.1263 | 1263 | no | ETA 7
14016983 | 3.NP_SO-102 | 38.8775 | 0.0201032 | 0.0195419 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2819.7 | 2739.7 | 2739.7 | 3.NP_SO-102 | 0 | 2659.7 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 324 | Odváděný | ETA | PO02.01.1264 | 1264 | no | ETA 7
14017279 | 2.NP_SO-102 | 490 | 0.0201032 | 0.246301 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2980 | 2900 | 2900 | 2.NP_SO-102 | 0 | 2820 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 327 | Odváděný | ETA | PO02.01.1266 | 1266 | no | ETA 7
14017429 | 2.NP_SO-102 | 50 | 0.0201032 | 0.0251327 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2980 | 2900 | 2900 | 2.NP_SO-102 | 0 | 2820 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 329 | Odváděný | ETA | PO02.01.1267 | 1267 | no | ETA 7
14017440 | 2.NP_SO-102 | 116.737 | 0.0201032 | 0.0586785 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2980 | 2900 | 2900 | 2.NP_SO-102 | 0 | 2820 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 313 | Odváděný | ETA | PO02.01.1268 | 1268 | no | ETA 7 | Identifikační data - Komentáře: VZT18
14017446 | 2.NP_SO-102 | 460 | 0.0201032 | 0.231221 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2980 | 2900 | 2900 | 2.NP_SO-102 | 0 | 2820 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 329 | Odváděný | ETA | PO02.01.1269 | 1269 | no | ETA 7
14017615 | 4.NP_SO-102 | 3397.83 | 0.0201032 | 1.70793 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3030 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2870 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 332 | Odváděný | ETA | PO02.01.1270 | 1270 | no | ETA 7
14017948 | 4.NP_SO-102 | 3210.4 | 0.0201032 | 1.61372 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3030 | 2950 | 2950 | 4.NP_SO-102 | 0 | 2870 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 332 | Odváděný | ETA | PO02.01.1271 | 1271 | no | ETA 7
14028937 | 1.NP_SO-102 | 5742.21 | 0.0201032 | 2.88635 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | ODA 19 | 2 | Čerstvý | ODA | PO02.01.1272 | 1272 | yes | ODA 19
14029001 | 1.NP_SO-102 | 93.7258 | 0.0201032 | 0.0471117 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | ODA 19 | 4 | Čerstvý | ODA | PO02.01.1273 | 1273 | yes | ODA 19
14029055 | 1.NP_SO-102 | 2704.84 | 0.0201032 | 1.3596 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | ODA 19 | 2 | Čerstvý | ODA | PO02.01.1274 | 1274 | yes | ODA 19
14029065 | 1.NP_SO-102 | 1474.97 | 0.0201032 | 0.741403 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3172.8 | 3092.8 | 3092.8 | 1.NP_SO-102 | 0 | 3012.8 | Fáze 1 | 160 | Přívod vzduchu | 0 | ODA 19 | 2 | Čerstvý | ODA | PO02.01.1275 | 1275 | yes | ODA 19
14029103 | 1.NP_SO-102 | 5849.68 | 0.0201032 | 2.94037 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Odváděný vzduch | 0 | EHA 12 | 2 | Znehodnocený | EHA | PO02.01.1276 | 1276 | yes | EHA 12
14029274 | 1.NP_SO-102 | 320.284 | 0.0201032 | 0.160992 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Odváděný vzduch | 0 | EHA 12 | 4 | Znehodnocený | EHA | PO02.01.1277 | 1277 | yes | EHA 12
14029690 | 1.NP_SO-102 | 1398.95 | 0.0201032 | 0.703188 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Odváděný vzduch | 0 | EHA 12 | 2 | Znehodnocený | EHA | PO02.01.1278 | 1278 | yes | EHA 12
14029700 | 1.NP_SO-102 | 1678.67 | 0.0201032 | 0.843793 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2880 | 2800 | 2800 | 1.NP_SO-102 | 0 | 2720 | Fáze 1 | 160 | Odváděný vzduch | 0 | EHA 12 | 2 | Znehodnocený | EHA | PO02.01.1279 | 1279 | yes | EHA 12
14029771 | 1.NP_SO-102 | 284.645 | 0.0201032 | 0.143078 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3104.71 | 2846.86 | 3048.14 | 1.NP_SO-102 | 100 | 2790.29 | Fáze 1 | 160 | Odváděný vzduch | 0 | EHA 12 | 2 | Znehodnocený | EHA | PO02.01.1280 | 1280 | yes | EHA 12
14033684 | 2.NP_SO-102 | 2613.55 | 0.0397548 | 1.84741 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 10875.1 | 10875 | 8261.45 | 2.NP_SO-102 | 233323 | 8261.35 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 14 | 264 | Odváděný | ETA | PO02.01.1292 | 1292 | yes | ETA 14
14039160 | 1.NP_SO-102 | 2213.46 | 0.0201032 | 1.11261 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 14 | 5 | Přívodní | SUP | PO02.01.1305 | 1305 | yes | SUP 14
14039171 | 1.NP_SO-102 | 31.9808 | 0.0201032 | 0.0160753 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 14 | 3 | Přívodní | SUP | PO02.01.1306 | 1306 | yes | SUP 14
14039180 | 1.NP_SO-102 | 1142.81 | 0.0201032 | 0.57444 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 14 | 3 | Přívodní | SUP | PO02.01.1307 | 1307 | yes | SUP 14
14039238 | 1.NP_SO-102 | 413.611 | 0.0201032 | 0.207904 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 14 | 3 | Přívodní | SUP | PO02.01.1308 | 1308 | yes | SUP 14
14039862 | 1.NP_SO-102 | 338.371 | 0.0201032 | 0.170084 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2975 | 2895 | 2895 | 1.NP_SO-102 | 0 | 2815 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 394 | Přívodní | SUP | PO02.01.1313 | 1313 | no | SUP 24
14040289 | 1.NP_SO-102 | 2719.86 | 0.0254431 | 1.53805 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3185 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3005 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 24 | 397 | Přívodní | SUP | PO02.01.1315 | 1315 | no | SUP 24
14040604 | 1.NP_SO-102 | 687.019 | 0.0254431 | 0.3885 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2985 | 2895 | 2895 | 1.NP_SO-102 | 0 | 2805 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 24 | 397 | Přívodní | SUP | PO02.01.1317 | 1317 | no | SUP 24
14040605 | 1.NP_SO-102 | 133.726 | 0.0254431 | 0.0756202 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3105.92 | 3042.28 | 2947.72 | 1.NP_SO-102 | 100 | 2884.08 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 24 | 397 | Přívodní | SUP | PO02.01.1318 | 1318 | no | SUP 24
14040815 | 2.NP_SO-102 | 202.16 | 0.0201032 | 0.101617 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2880 | 2800 | 2800 | 2.NP_SO-102 | 0 | 2720 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 3 | 23 | Odváděný | ETA | PO02.01.1319 | 1319 | yes | ETA 3
14049529 | 2.NP_SO-102 | 2262.97 | 0.0397548 | 1.5996 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3212.5 | 3100 | 3100 | 2.NP_SO-102 | 0 | 2987.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 14 | 333 | Odváděný | ETA | PO02.01.1323 | 1323 | no | ETA 14
14049579 | 2.NP_SO-102 | 288.708 | 0.0397548 | 0.204076 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2762.5 | 2650 | 2650 | 2.NP_SO-102 | 0 | 2537.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 14 | 333 | Odváděný | ETA | PO02.01.1324 | 1324 | no | ETA 14
14049591 | 2.NP_SO-102 | 450 | 0.0397548 | 0.318086 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3113.65 | 2715.9 | 3034.1 | 2.NP_SO-102 | 100 | 2636.35 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 14 | 333 | Odváděný | ETA | PO02.01.1325 | 1325 | no | ETA 14
14049662 | 2.NP_SO-102 | 434.376 | 0.0397548 | 0.307042 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3122.5 | 3010 | 3010 | 2.NP_SO-102 | 0 | 2897.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 14 | 333 | Odváděný | ETA | PO02.01.1326 | 1326 | no | ETA 14
14049673 | 2.NP_SO-102 | 1960 | 0.0397548 | 1.38544 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3122.5 | 3010 | 3010 | 2.NP_SO-102 | 0 | 2897.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 14 | 333 | Odváděný | ETA | PO02.01.1327 | 1327 | no | ETA 14
14049979 | 2.NP_SO-102 | 107.121 | 0.0397548 | 0.0757193 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3122.5 | 3010 | 3010 | 2.NP_SO-102 | 0 | 2897.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 14 | 333 | Odváděný | ETA | PO02.01.1328 | 1328 | no | ETA 14
14050349 | 2.NP_SO-102 | 12712.1 | 0.0397548 | 8.98565 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2992.5 | 2880 | 2880 | 2.NP_SO-102 | 0 | 2767.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 9 | 424 | Přívodní | SUP | PO02.01.1329 | 1329 | no | SUP 9
14050372 | 2.NP_SO-102 | 2868.19 | 0.0397548 | 2.0274 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2992.5 | 2880 | 2880 | 2.NP_SO-102 | 0 | 2767.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 9 | 424 | Přívodní | SUP | PO02.01.1330 | 1330 | no | SUP 9
14050883 | 2.NP_SO-102 | 834.545 | 0.0397548 | 0.589905 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2992.5 | 2880 | 2880 | 2.NP_SO-102 | 0 | 2767.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 9 | 424 | Přívodní | SUP | PO02.01.1331 | 1331 | no | SUP 9
14051119 | 2.NP_SO-102 | 432.22 | 0.0989649 | 0.48204 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3087.5 | 2910 | 2910 | 2.NP_SO-102 | 0 | 2732.5 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 14 | 241 | Odváděný | ETA | PO02.01.1332 | 1332 | yes | ETA 14
14051225 | 2.NP_SO-102 | 140.361 | 0.0989649 | 0.15654 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3087.5 | 2910 | 2910 | 2.NP_SO-102 | 0 | 2732.5 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 14 | 241 | Odváděný | ETA | PO02.01.1333 | 1333 | yes | ETA 14
14051661 | 2.NP_SO-102 | 289.417 | 0.0397548 | 0.204577 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2992.5 | 2880 | 2880 | 2.NP_SO-102 | 0 | 2767.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 9 | 424 | Přívodní | SUP | PO02.01.1334 | 1334 | no | SUP 9
14051772 | 2.NP_SO-102 | 199.688 | 0.0397548 | 0.141151 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2992.5 | 2880 | 2880 | 2.NP_SO-102 | 0 | 2767.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 9 | 424 | Přívodní | SUP | PO02.01.1336 | 1336 | no | SUP 9
14051876 | 2.NP_SO-102 | 312.114 | 0.0397548 | 0.22062 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2992.5 | 2880 | 2880 | 2.NP_SO-102 | 0 | 2767.5 | Fáze 1 | 225 | Přívod vzduchu | 0 | SUP 9 | 424 | Přívodní | SUP | PO02.01.1337 | 1337 | no | SUP 9
14052275 | 2.NP_SO-102 | 735.858 | 0.0201032 | 0.369883 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2660 | 2580 | 2580 | 2.NP_SO-102 | 0 | 2500 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 14 | 299 | Odváděný | ETA | PO02.01.1338 | 1338 | no | ETA 14
14052289 | 2.NP_SO-102 | 2872.91 | 0.0254431 | 1.62459 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2670 | 2580 | 2580 | 2.NP_SO-102 | 0 | 2490 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 14 | 287 | Odváděný | ETA | PO02.01.1339 | 1339 | no | ETA 14
14052326 | 2.NP_SO-102 | 1213.27 | 0.0254431 | 0.686088 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2670 | 2580 | 2580 | 2.NP_SO-102 | 0 | 2490 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 14 | 316 | Odváděný | ETA | PO02.01.1340 | 1340 | no | ETA 14
14052395 | 2.NP_SO-102 | 1971.52 | 0.0254431 | 1.11487 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2670 | 2580 | 2580 | 2.NP_SO-102 | 0 | 2490 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 14 | 289 | Odváděný | ETA | PO02.01.1341 | 1341 | no | ETA 14
14052788 | 2.NP_SO-102 | 396.136 | 0.0397548 | 0.280012 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3122.5 | 3010 | 3010 | 2.NP_SO-102 | 0 | 2897.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 14 | 333 | Odváděný | ETA | PO02.01.1342 | 1342 | no | ETA 14
14052929 | 2.NP_SO-102 | 682.294 | 0.0397548 | 0.482285 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3122.5 | 3010 | 3010 | 2.NP_SO-102 | 0 | 2897.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 14 | 333 | Odváděný | ETA | PO02.01.1343 | 1343 | no | ETA 14
14053200 | 2.NP_SO-102 | 988.119 | 0.0397548 | 0.69846 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3022.5 | 2910 | 2910 | 2.NP_SO-102 | 0 | 2797.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 14 | 294 | Odváděný | ETA | PO02.01.1344 | 1344 | no | ETA 14
14053216 | 2.NP_SO-102 | 292.728 | 0.0989649 | 0.32647 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3087.5 | 2910 | 2910 | 2.NP_SO-102 | 0 | 2732.5 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 14 | 241 | Odváděný | ETA | PO02.01.1345 | 1345 | yes | ETA 14
14053257 | 2.NP_SO-102 | 426.219 | 0.0254431 | 0.241021 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3000 | 2910 | 2910 | 2.NP_SO-102 | 0 | 2820 | Fáze 1 | 180 | Zpětný vzduch | 0 | ETA 14 | 296 | Odváděný | ETA | PO02.01.1346 | 1346 | no | ETA 14
14053266 | 2.NP_SO-102 | 47.5 | 0.0989649 | 0.0529751 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3087.5 | 2910 | 2910 | 2.NP_SO-102 | 0 | 2732.5 | Fáze 1 | 355 | Zpětný vzduch | 0 | ETA 14 | 241 | Odváděný | ETA | PO02.01.1347 | 1347 | yes | ETA 14
14053277 | 2.NP_SO-102 | 260 | 0.0201032 | 0.13069 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2990 | 2910 | 2910 | 2.NP_SO-102 | 0 | 2830 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 14 | 332 | Odváděný | ETA | PO02.01.1348 | 1348 | no | ETA 14
14053506 | 2.NP_SO-102 | 2050.91 | 0.0201032 | 1.0309 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2660 | 2580 | 2580 | 2.NP_SO-102 | 0 | 2500 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 14 | 301 | Odváděný | ETA | PO02.01.1349 | 1349 | no | ETA 14
14055131 | 4.NP_SO-102 | 2526.11 | 0.0397548 | 1.7856 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3112.5 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2887.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 14 | 324 | Odváděný | ETA | PO02.01.1351 | 1351 | no | ETA 14 | Identifikační data - Komentáře: VZT25
14055178 | 4.NP_SO-102 | 334.676 | 0.0397548 | 0.236568 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3112.5 | 3000 | 3000 | 4.NP_SO-102 | 0 | 2887.5 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 14 | 323 | Odváděný | ETA | PO02.01.1352 | 1352 | no | ETA 14
14055293 | 3.NP_SO-102 | 50.3959 | 0.0201032 | 0.0253318 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3180 | 3100 | 3100 | 3.NP_SO-102 | 0 | 3020 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 14 | 325 | Odváděný | ETA | PO02.01.1353 | 1353 | no | ETA 14
14055304 | 4.NP_SO-102 | 3645 | 0.0397548 | 2.5765 | 225 mm | 225 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | -1030 | -1030 | -4675 | 4.NP_SO-102 |  | -4675 | Fáze 1 | 225 | Zpětný vzduch | 0 | ETA 14 | 333 | Odváděný | ETA | PO02.01.1354 | 1354 | no | ETA 14
14055348 | 3.NP_SO-102 | 82.1117 | 0.0314112 | 0.0515923 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3245.16 | 3145.16 | 3145.16 | 3.NP_SO-102 | 0 | 3045.16 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 9 | 319 | Přívodní | SUP | PO02.01.1355 | 1355 | no | SUP 9
14055678 | 3.NP_SO-102 | 3666.38 | 0.0201032 | 1.84292 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 7040 | 7040 | 3373.62 | 3.NP_SO-102 |  | 3373.62 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 9 | 475 | Přívodní | SUP | PO02.01.1356 | 1356 | no | SUP 9
14055730 | 4.NP_SO-102 | 100 | 0.0201032 | 0.0502655 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3280 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3120 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 9 | 475 | Přívodní | SUP | PO02.01.1357 | 1357 | no | SUP 9
14055749 | 4.NP_SO-102 | 413.726 | 0.0201032 | 0.207961 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3280 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3120 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 9 | 475 | Přívodní | SUP | PO02.01.1358 | 1358 | no | SUP 9
14055760 | 4.NP_SO-102 | 387.452 | 0.0201032 | 0.194754 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3280 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3120 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 9 | 475 | Přívodní | SUP | PO02.01.1359 | 1359 | no | SUP 9
14055769 | 4.NP_SO-102 | 3433.73 | 0.0201032 | 1.72598 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3280 | 3200 | 3200 | 4.NP_SO-102 | 0 | 3120 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 9 | 475 | Přívodní | SUP | PO02.01.1360 | 1360 | no | SUP 9
14055956 | 3.NP_SO-102 | 7388.92 | 0.0201032 | 3.71408 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2980 | 2900 | 2900 | 3.NP_SO-102 | 0 | 2820 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 3 | 40 | Odváděný | ETA | PO02.01.1361 | 1361 | no | ETA 3
14055965 | 3.NP_SO-102 | 582.598 | 0.0201032 | 0.292845 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2980 | 2900 | 2900 | 3.NP_SO-102 | 0 | 2820 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 3 | 39 | Odváděný | ETA | PO02.01.1362 | 1362 | no | ETA 3
14056230 | 1.NP_SO-102 | 2557.31 | 0.0201032 | 1.28544 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 23 | 8 | Odváděný | ETA | PO02.01.1364 | 1364 | yes | ETA 23
14056238 | 1.NP_SO-102 | 353.59 | 0.0201032 | 0.177734 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 23 | 6 | Odváděný | ETA | PO02.01.1365 | 1365 | yes | ETA 23
14056312 | 1.NP_SO-102 | 146.096 | 0.0201032 | 0.0734359 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 23 | 6 | Odváděný | ETA | PO02.01.1366 | 1366 | yes | ETA 23
14056632 | 1.NP_SO-102 | 325.227 | 0.0201032 | 0.163477 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 23 | 9 | Odváděný | ETA | PO02.01.1367 | 1367 | yes | ETA 23
14056659 | 1.NP_SO-102 | 532.879 | 0.0201032 | 0.267854 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 23 | 6 | Odváděný | ETA | PO02.01.1368 | 1368 | yes | ETA 23
14056805 | 1.NP_SO-102 | 411.285 | 0.0201032 | 0.206734 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 14 | 5 | Přívodní | SUP | PO02.01.1369 | 1369 | yes | SUP 14
14056885 | 1.NP_SO-102 | 381.677 | 0.0201032 | 0.191852 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Odváděný vzduch | 0 | EHA 12 | 4 | Znehodnocený | EHA | PO02.01.1370 | 1370 | yes | EHA 12
14056898 | 1.NP_SO-102 | 202.555 | 0.0201032 | 0.101815 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Odváděný vzduch | 0 | EHA 12 | 4 | Znehodnocený | EHA | PO02.01.1371 | 1371 | yes | EHA 12; ETA 101
14056995 | 1.NP_SO-102 | 180.396 | 0.0201024 | 0.0906769 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2983.77 | 2903.77 | 2903.77 | 1.NP_SO-102 | 0 | 2823.77 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 337 | Odváděný | ETA | PO02.01.1372 | 1372 | no | ETA 7
14057002 | 1.NP_SO-102 | 4925.6 | 0.0201032 | 2.47588 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2983.77 | 2903.77 | 2903.77 | 1.NP_SO-102 | 0 | 2823.77 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 289 | Odváděný | ETA | PO02.01.1373 | 1373 | no | ETA 7 | Identifikační data - Komentáře: VZT18
14057380 | 1.NP_SO-102 | 1463.19 | 0.0201032 | 0.73548 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3280 | 3200 | 3200 | 1.NP_SO-102 | 0 | 3120 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 9 | 479 | Přívodní | SUP | PO02.01.1374 | 1374 | no | SUP 9
14057389 | 1.NP_SO-102 | 50.3959 | 0.0201032 | 0.0253318 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3280 | 3200 | 3200 | 1.NP_SO-102 | 0 | 3120 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 9 | 479 | Přívodní | SUP | PO02.01.1375 | 1375 | no | SUP 9
14058311 | 1.NP_SO-102 | 1995.24 | 0.0201032 | 1.00292 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2983.77 | 2903.77 | 2903.77 | 1.NP_SO-102 | 0 | 2823.77 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 344 | Odváděný | ETA | PO02.01.1376 | 1376 | no | ETA 7
14058320 | 1.NP_SO-102 | 1250.91 | 0.0201032 | 0.628775 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2983.77 | 2903.77 | 2903.77 | 1.NP_SO-102 | 0 | 2823.77 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 336 | Odváděný | ETA | PO02.01.1377 | 1377 | no | ETA 7
14058326 | 1.NP_SO-102 | 2013.83 | 0.0201032 | 1.01226 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2983.77 | 2903.77 | 2903.77 | 1.NP_SO-102 | 0 | 2823.77 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 344 | Odváděný | ETA | PO02.01.1378 | 1378 | no | ETA 7
14058960 | -1.PP_SO-102 | 316.458 | 0.0201032 | 0.159069 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2510 | 2430 | 2430 | -1.PP_SO-102 | 0 | 2350 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 437 | Přívodní | SUP | PO02.01.1379 | 1379 | no | SUP 24
14059095 | -1.PP_SO-102 | 483.931 | 0.0201032 | 0.24325 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2510 | 2430 | 2430 | -1.PP_SO-102 | 0 | 2350 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 437 | Přívodní | SUP | PO02.01.1380 | 1380 | no | SUP 24
14059602 | -1.PP_SO-102 | 8277.39 | 0.0201032 | 4.16067 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3330 | 3250 | 3250 | -1.PP_SO-102 | 0 | 3170 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 439 | Odváděný | ETA | PO02.01.1383 | 1383 | no | ETA 7
14060507 | -1.PP_SO-102 | 474.671 | 0.0201032 | 0.238596 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2630 | 2550 | 2550 | -1.PP_SO-102 | 0 | 2470 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 437 | Odváděný | ETA | PO02.01.1386 | 1386 | no | ETA 7
14060586 | -1.PP_SO-102 | 267.778 | 0.0201032 | 0.1346 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3330 | 3250 | 3250 | -1.PP_SO-102 | 0 | 3170 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 357 | Odváděný | ETA | PO02.01.1387 | 1387 | no | ETA 7
14060596 | -1.PP_SO-102 | 1875.35 | 0.0201032 | 0.942653 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3330 | 3250 | 3250 | -1.PP_SO-102 | 0 | 3170 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 357 | Odváděný | ETA | PO02.01.1388 | 1388 | no | ETA 7
14060729 | -1.PP_SO-102 | 330 | 0.0201032 | 0.165876 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3090 | 2760 | 3090 | -1.PP_SO-102 |  | 2760 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 439 | Odváděný | ETA | PO02.01.1389 | 1389 | no | ETA 7
14060741 | -1.PP_SO-102 | 663.001 | 0.0201032 | 0.33326 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2680 | 2600 | 2600 | -1.PP_SO-102 | 0 | 2520 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 361 | Odváděný | ETA | PO02.01.1390 | 1390 | no | ETA 7
14060747 | -1.PP_SO-102 | 985.089 | 0.0201032 | 0.49516 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2680 | 2600 | 2600 | -1.PP_SO-102 | 0 | 2520 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 361 | Odváděný | ETA | PO02.01.1391 | 1391 | no | ETA 7
14060766 | -1.PP_SO-102 | 5150.4 | 0.0201032 | 2.58887 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3080 | 3000 | 3000 | -1.PP_SO-102 | 0 | 2920 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 361 | Odváděný | ETA | PO02.01.1392 | 1392 | no | ETA 7
14060865 | -1.PP_SO-102 | 80 | 0.0201032 | 0.0402124 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2840 | 2840 | 2760 | -1.PP_SO-102 |  | 2760 | Fáze 1 | 160 | Zpětný vzduch | 0 | ETA 7 | 361 | Odváděný | ETA | PO02.01.1393 | 1393 | no | ETA 7
14061474 | 1.NP_SO-102 | 121.698 | 0.0201032 | 0.0611723 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3280.1 | 3200.1 | 3200.1 | 1.NP_SO-102 | 0 | 3120.1 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 9 | 352 | Přívodní | SUP | PO02.01.1394 | 1394 | no | SUP 9
14061716 | 1.NP_SO-102 | 3500 | 0.0314112 | 2.19911 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2895 | 2895 | -605 | 1.NP_SO-102 |  | -605 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 20 | 236 | Přívodní | SUP | PO02.01.1395 | 1395 | no | SUP 20
14061732 | 1.NP_SO-102 | 8.46553 | 0.0314112 | 0.00531905 | 200 mm | 200 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3195 | 3095 | 3095 | 1.NP_SO-102 | 0 | 2995 | Fáze 1 | 200 | Přívod vzduchu | 0 | SUP 20 | 236 | Přívodní | SUP | PO02.01.1396 | 1396 | no | SUP 20 | Identifikační data - Komentáře: rozvody VZT vedené dále v úrovni 1.PP
14063969 | 1.NP_SO-102 | 261.375 | 0.0201032 | 0.131382 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 426 | Přívodní | SUP | PO02.01.1399 | 1399 | no | SUP 24
14063983 | 1.NP_SO-102 | 4023.37 | 0.0779194 | 3.98154 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3252.5 | 3095 | 3095 | 1.NP_SO-102 | 0 | 2937.5 | Fáze 1 | 315 | Přívod vzduchu | 0 | SUP 24 | 416 | Přívodní | SUP | PO02.01.1400 | 1400 | yes | SUP 24
14063991 | 1.NP_SO-102 | 700.683 | 0.0201032 | 0.352202 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 426 | Přívodní | SUP | PO02.01.1401 | 1401 | no | SUP 24
14064000 | 1.NP_SO-102 | 5200 | 0.0201032 | 2.61381 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 426 | Přívodní | SUP | PO02.01.1402 | 1402 | no | SUP 24
14064160 | 1.NP_SO-102 | 142.889 | 0.0201032 | 0.0718236 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 426 | Přívodní | SUP | PO02.01.1403 | 1403 | no | SUP 24
14064238 | 1.NP_SO-102 | 115.9 | 0.0201032 | 0.0582579 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 426 | Přívodní | SUP | PO02.01.1404 | 1404 | no | SUP 24
14064750 | 1.NP_SO-102 | 232.5 | 0.0201032 | 0.116867 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 24 | 411 | Přívodní | SUP | PO02.01.1405 | 1405 | no | SUP 24
14064752 | 1.NP_SO-102 | 85.2937 | 0.0201032 | 0.0428733 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 24 | 411 | Přívodní | SUP | PO02.01.1406 | 1406 | no | SUP 24
14064756 | 1.NP_SO-102 | 3400 | 0.0201032 | 1.70903 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 24 | 411 | Přívodní | SUP | PO02.01.1407 | 1407 | no | SUP 24
14064761 | 1.NP_SO-102 | 171.764 | 0.0201032 | 0.086338 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 24 | 411 | Přívodní | SUP | PO02.01.1408 | 1408 | no | SUP 24
14064764 | 1.NP_SO-102 | 526.351 | 0.0201032 | 0.264573 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 2 | 160 | Přívod vzduchu | 0 | SUP 24 | 411 | Přívodní | SUP | PO02.01.1409 | 1409 | no | SUP 24
14065403 | 1.NP_SO-102 | 3249.63 | 0.0254431 | 1.83762 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2579.63 | 2579.63 | -669.999 | 1.NP_SO-102 |  | -669.999 | Fáze 2 | 180 | Zpětný vzduch | 0 | ETA 7 | 393 | Odváděný | ETA | PO02.01.1410 | 1410 | no | ETA 7
14065654 | 1.NP_SO-102 | 6620 | 0.0201032 | 3.32757 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2843.77 | 2763.77 | 2763.77 | 1.NP_SO-102 | 0 | 2683.77 | Fáze 2 | 160 | Zpětný vzduch | 0 | ETA 7 | 412 | Odváděný | ETA | PO02.01.1411 | 1411 | no | ETA 7
14065924 | -1.PP_SO-102 | 1111.84 | 0.0254431 | 0.628732 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3240 | 3150 | 3150 | -1.PP_SO-102 | 0 | 3060 | Fáze 2 | 180 | Zpětný vzduch | 0 | ETA 7 | 367 | Odváděný | ETA | PO02.01.1412 | 1412 | no | ETA 7 | Identifikační data - Komentáře: PŘIPOJENÍ ODVODNÍHO POTRUBÍ V II.ETAPĚ VÝSTAVBY
14065940 | -1.PP_SO-102 | 854.126 | 0.0254431 | 0.482997 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3240 | 3150 | 3150 | -1.PP_SO-102 | 0 | 3060 | Fáze 2 | 180 | Zpětný vzduch | 0 | ETA 7 | 367 | Odváděný | ETA | PO02.01.1413 | 1413 | no | ETA 7
14068088 | 1.NP_SO-102 | 42.0992 | 0.0254431 | 0.0238066 | 180 mm | 180 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3240 | 3150 | 3150 | 1.NP_SO-102 | 0 | 3060 | Fáze 1 | 180 | Přívod vzduchu | 0 | SUP 13 | 51 | Přívodní | SUP | PO02.01.1419 | 1419 | no | SUP 13
14075519 | 2.NP_SO-102 | 2919.83 | 0.04908 | 2.29323 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2370.08 | -549.827 | 2370 | 2.NP_SO-102 | 153702 | -549.909 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 14 | 494 | Odváděný | ETA | PO02.01.1423 | 1423 | no | ETA 14
14075567 | 1.NP_SO-102 | 2303.87 | 0.04908 | 1.80946 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3325.01 | 3200.01 | 3200.01 | 1.NP_SO-102 | 0 | 3075.01 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 14 | 494 | Odváděný | ETA | PO02.01.1424 | 1424 | no | ETA 14
14075586 | 1.NP_SO-102 | 9162.56 | 0.04908 | 7.19626 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3325.01 | 3200.01 | 3200.01 | 1.NP_SO-102 | 0 | 3075.01 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 14 | 494 | Odváděný | ETA | PO02.01.1425 | 1425 | no | ETA 14
14075616 | 1.NP_SO-102 | 2087.44 | 0.04908 | 1.63947 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3325.01 | 3200.01 | 3200.01 | 1.NP_SO-102 | 0 | 3075.01 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 14 | 494 | Odváděný | ETA | PO02.01.1426 | 1426 | no | ETA 14
14076238 | 2.NP_SO-102 | 2014.5 | 0.04908 | 1.58219 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2745 | 2620 | 2620 | 2.NP_SO-102 | 0 | 2495 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 14 | 494 | Odváděný | ETA | PO02.01.1427 | 1427 | yes | ETA 14
14076262 | 2.NP_SO-102 | 20.2075 | 0.04908 | 0.0158709 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2745 | 2620 | 2620 | 2.NP_SO-102 | 0 | 2495 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 14 | 494 | Odváděný | ETA | PO02.01.1428 | 1428 | no | ETA 14
14076386 | 2.NP_SO-102 | 67.4585 | 0.04908 | 0.0529818 | 250 mm | 250 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 2745 | 2620 | 2620 | 2.NP_SO-102 | 0 | 2495 | Fáze 1 | 250 | Zpětný vzduch | 0 | ETA 14 | 494 | Odváděný | ETA | PO02.01.1429 | 1429 | yes | ETA 14
14078549 | 1.NP_SO-102 | 134.181 | 0.0201032 | 0.0674465 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 425 | Přívodní | SUP | PO02.01.1435 | 1435 | no | SUP 24
14078562 | 1.NP_SO-102 | 91.1821 | 0.0201032 | 0.0458331 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 425 | Přívodní | SUP | PO02.01.1436 | 1436 | no | SUP 24
14078577 | 1.NP_SO-102 | 1478.21 | 0.0989649 | 1.6486 | 355 mm | 355 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3272.5 | 3095 | 3095 | 1.NP_SO-102 | 0 | 2917.5 | Fáze 1 | 355 | Přívod vzduchu | 0 | SUP 24 | 481 | Přívodní | SUP | PO02.01.1437 | 1437 | yes | SUP 24
14078604 | 1.NP_SO-102 | 541.531 | 0.0201032 | 0.272203 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 425 | Přívodní | SUP | PO02.01.1438 | 1438 | no | SUP 24
14078628 | 1.NP_SO-102 | 200.521 | 0.0201032 | 0.100793 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 425 | Přívodní | SUP | PO02.01.1439 | 1439 | no | SUP 24
14078963 | 1.NP_SO-102 | 47.2856 | 0.0201032 | 0.0237683 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 413 | Přívodní | SUP | PO02.01.1440 | 1440 | no | SUP 24
14079100 | 1.NP_SO-102 | 49.4318 | 0.0201032 | 0.0248472 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 413 | Přívodní | SUP | PO02.01.1441 | 1441 | no | SUP 24
14079137 | 1.NP_SO-102 | 53.1132 | 0.0201032 | 0.0266976 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 413 | Přívodní | SUP | PO02.01.1442 | 1442 | no | SUP 24
14079148 | 1.NP_SO-102 | 1055.08 | 0.0779194 | 1.04411 | 315 mm | 315 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3252.5 | 3095 | 3095 | 1.NP_SO-102 | 0 | 2937.5 | Fáze 1 | 315 | Přívod vzduchu | 0 | SUP 24 | 401 | Přívodní | SUP | PO02.01.1443 | 1443 | yes | SUP 24
14079188 | 1.NP_SO-102 | 452.592 | 0.0201032 | 0.227498 | 160 mm | 160 mm | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 3175 | 3095 | 3095 | 1.NP_SO-102 | 0 | 3015 | Fáze 1 | 160 | Přívod vzduchu | 0 | SUP 24 | 413 | Přívodní | SUP | PO02.01.1444 | 1444 | no | SUP 24
