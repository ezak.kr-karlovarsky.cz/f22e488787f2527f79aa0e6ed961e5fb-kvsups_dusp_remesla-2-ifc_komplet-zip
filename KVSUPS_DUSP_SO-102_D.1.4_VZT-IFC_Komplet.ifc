Properties of the parts of a building model (IFC4), part 24 of 45

# IfcDistributionPort (8507)
Name | FlowDirection | SystemType | Group
InPort_13786605_0 | SINK | VENTILATION | SUP 24
OutPort_13853073_3 | SOURCE | VENTILATION | SUP 24
InPort_13850984_1 | SINK | VENTILATION | SUP 24
OutPort_13786605_1 | SOURCE | VENTILATION | SUP 24
InPort_13786740_0 | SINK | VENTILATION | SUP 24
OutPort_13853055_2 | SOURCE | VENTILATION | SUP 24
InPort_14138062_3 | SINK | VENTILATION | SUP 24
OutPort_13786740_1 | SOURCE | VENTILATION | SUP 24
InPort_13787059_1 | SINK | EXHAUST | EHA 11
OutPort_13786811_1 | SOURCE | EXHAUST | EHA 11
InPort_13787065_1 | SINK | EXHAUST | EHA 11
OutPort_13787059_2 | SOURCE | EXHAUST | EHA 11
Port_13788069_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13810018_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13788069_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14059871_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13788424_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13788666_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13788424_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13788666_2 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13788668_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13788668_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13854302_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13788784_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13789465_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13788784_2 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13788786_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13788786_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13789724_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13789035_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13789050_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13789035_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13789043_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13789050_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13789043_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13789167_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13789156_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13789167_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13789156_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13789191_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13789191_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13789192_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13789465_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_14122398_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13789605_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13945050_2 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13789605_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_14122509_2 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13789717_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13789724_2 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13789717_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_14122509_1 | SOURCEANDSINK | VENTILATION | ETA 1
InPort_13791103_0 | SINK | VENTILATION | SUP 24
OutPort_13791115_1 | SOURCE | VENTILATION | SUP 24
Port_13791103_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13925723_1 | SINK | VENTILATION | SUP 24
OutPort_13791103_2 | SOURCE | VENTILATION | SUP 24
InPort_13791115_2 | SINK | VENTILATION | SUP 24
OutPort_13791155_1 | SOURCE | VENTILATION | SUP 24
InPort_13791155_0 | SINK | VENTILATION | SUP 24
OutPort_13926311_1 | SOURCE | VENTILATION | SUP 24
InPort_13791161_0 | SINK | VENTILATION | SUP 24
OutPort_13926333_1 | SOURCE | VENTILATION | SUP 24
Port_13791161_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_14039913_1 | SINK | VENTILATION | SUP 24
OutPort_13791161_3 | SOURCE | VENTILATION | SUP 24
InPort_13792457_3 | SINK | VENTILATION | ETA 7
OutPort_13791764_1 | SOURCE | VENTILATION | ETA 7
Port_13792025_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13792026_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13792025_3 | SINK | VENTILATION | ETA 7
OutPort_13792035_2 | SOURCE | VENTILATION | ETA 7
Port_13792026_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14017064_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13792183_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13793387_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13792183_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13792184_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13792405_1 | SINK | VENTILATION | ETA 7
OutPort_13792243_1 | SOURCE | VENTILATION | ETA 7
Port_13792333_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14017065_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13792397_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13792398_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13792397_3 | SINK | VENTILATION | ETA 7
OutPort_13792405_2 | SOURCE | VENTILATION | ETA 7
Port_13792398_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13792457_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13792457_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13792458_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13792458_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13900082_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13792563_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13792574_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13792563_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13793955_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13792751_0 | SINK | VENTILATION | ODA 12
OutPort_14121218_1 | SOURCE | VENTILATION | ODA 12
InPort_14067814_2 | SINK | VENTILATION | ODA 12
OutPort_13792751_1 | SOURCE | VENTILATION | ODA 12
InPort_14121218_2 | SINK | VENTILATION | ODA 12
OutPort_13792771_0 | SOURCE | VENTILATION | ODA 12
InPort_13792771_1 | SINK | VENTILATION | ODA 12
OutPort_14121221_1 | SOURCE | VENTILATION | ODA 12
InPort_14121171_0 | SINK | VENTILATION | ODA 12
OutPort_13792771_2 | SOURCE | VENTILATION | ODA 12
InPort_14121221_2 | SINK | VENTILATION | ODA 12
OutPort_13792850_0 | SOURCE | VENTILATION | ODA 12
InPort_13792850_1 | SINK | VENTILATION | ODA 12
OutPort_14067628_2 | SOURCE | VENTILATION | ODA 12
Port_13792986_1 | SOURCEANDSINK | VENTILATION | ETA 8
Port_13793387_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13793845_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13793886_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13793885_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13793886_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13793885_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13794033_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13793885_3 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13793894_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13793893_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13848951_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13793955_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13794178_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13793962_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13793963_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13793962_3 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13793967_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13793963_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13794177_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13794033_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13794143_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13794177_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13794178_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13794177_3 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13794186_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13794184_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14105798_0 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13794358_0 | SINK | VENTILATION | ODA 25
OutPort_13794486_2 | SOURCE | VENTILATION | ODA 25
InPort_13912340_2 | SINK | VENTILATION | ODA 25
OutPort_13794358_1 | SOURCE | VENTILATION | ODA 25
InPort_13794486_1 | SINK | VENTILATION | ODA 25
OutPort_13819022_0 | SOURCE | VENTILATION | ODA 25
InPort_13814054_2 | SINK | VENTILATION | ODA 2
OutPort_13794516_0 | SOURCE | VENTILATION | ODA 2
InPort_13794516_1 | SINK | VENTILATION | ODA 2
OutPort_13795438_1 | SOURCE | VENTILATION | ODA 2
InPort_13794617_2 | SINK | VENTILATION | ODA 2
OutPort_13814056_0 | SOURCE | VENTILATION | ODA 2
InPort_13814040_2 | SINK | VENTILATION | ODA 1
OutPort_13794649_0 | SOURCE | VENTILATION | ODA 1
InPort_13794649_1 | SINK | VENTILATION | ODA 1
OutPort_13795427_1 | SOURCE | VENTILATION | ODA 1
Port_13794995_2 | SOURCEANDSINK | VENTILATION | SUP 7
Port_14080669_0 | SOURCEANDSINK | VENTILATION | SUP 7
InPort_13794997_0 | SINK | VENTILATION | SUP 7
OutPort_13950527_1 | SOURCE | VENTILATION | SUP 7
InPort_13950941_1 | SINK | VENTILATION | SUP 7
OutPort_13794997_1 | SOURCE | VENTILATION | SUP 7
InPort_13795246_0 | SINK | EXHAUST | EHA 2
OutPort_13795256_2 | SOURCE | EXHAUST | EHA 2
InPort_13795266_1 | SINK | EXHAUST | EHA 2
OutPort_13795246_1 | SOURCE | EXHAUST | EHA 2
OutPort_13795266_2 | SOURCE | EXHAUST | EHA 2
InPort_13795290_0 | SINK | EXHAUST | EHA 9
OutPort_13952179_1 | SOURCE | EXHAUST | EHA 9
InPort_13795308_1 | SINK | EXHAUST | EHA 9
OutPort_13795290_1 | SOURCE | EXHAUST | EHA 9
OutPort_13795308_2 | SOURCE | EXHAUST | EHA 9
InPort_13795427_0 | SINK | VENTILATION | ODA 1
OutPort_13795424_1 | SOURCE | VENTILATION | ODA 1
InPort_13795438_0 | SINK | VENTILATION | ODA 2
OutPort_13795436_1 | SOURCE | VENTILATION | ODA 2
Port_13796652_0 | SOURCEANDSINK | EXHAUST | EHA 15
Port_13796652_1 | SOURCEANDSINK | EXHAUST | EHA 15
Port_13796724_0 | SOURCEANDSINK | EXHAUST | EHA 16
Port_13796724_1 | SOURCEANDSINK | EXHAUST | EHA 16
InPort_13796787_1 | SINK | EXHAUST
InPort_13796834_1 | SINK | EXHAUST
InPort_13796905_0 | SINK | VENTILATION | ODA 19
OutPort_13796900_1 | SOURCE | VENTILATION | ODA 19
InPort_14029065_0 | SINK | VENTILATION | ODA 19
OutPort_13796905_1 | SOURCE | VENTILATION | ODA 19
InPort_13796958_0 | SINK | EXHAUST | EHA 12
OutPort_13796966_2 | SOURCE | EXHAUST | EHA 12
InPort_13796981_1 | SINK | EXHAUST | EHA 12
OutPort_13796958_1 | SOURCE | EXHAUST | EHA 12
InPort_13796970_0 | SINK | EXHAUST | EHA 12
OutPort_13796981_2 | SOURCE | EXHAUST | EHA 12
InPort_13797068_1 | SINK | EXHAUST | EHA 12
OutPort_13796970_1 | SOURCE | EXHAUST | EHA 12
InPort_13797065_1 | SINK | EXHAUST | EHA 12
OutPort_13797068_0 | SOURCE | EXHAUST | EHA 12
Port_13797157_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14120108_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13797157_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13797159_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13797159_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14179900_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13797487_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13854302_2 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13797487_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13797498_2 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13797487_2 | SOURCEANDSINK | VENTILATION | ETA 1
Port_14122737_0 | SOURCEANDSINK | VENTILATION | ETA 1
InPort_13797871_0 | SINK | VENTILATION | SUP 9
OutPort_14000662_2 | SOURCE | VENTILATION | SUP 9
InPort_14055363_1 | SINK | VENTILATION | SUP 9
OutPort_13797871_1 | SOURCE | VENTILATION | SUP 9
InPort_13955347_1 | SINK | VENTILATION | SUP 9
OutPort_13797871_2 | SOURCE | VENTILATION | SUP 9
InPort_13955371_1 | SINK | VENTILATION | SUP 9
OutPort_13797871_3 | SOURCE | VENTILATION | SUP 9
InPort_14038367_1 | SINK | VENTILATION | SUP 9
OutPort_13797871_4 | SOURCE | VENTILATION | SUP 9
InPort_13798279_1 | SINK | VENTILATION | SUP 12
OutPort_13798277_2 | SOURCE | VENTILATION | SUP 12
InPort_14159390_2 | SINK | VENTILATION | ODA 12
OutPort_13800247_1 | SOURCE | VENTILATION | ODA 12
InPort_13800247_2 | SINK | VENTILATION | ODA 12
OutPort_14158617_0 | SOURCE | VENTILATION | ODA 12
InPort_13801713_1 | SINK | VENTILATION | ODA 21
OutPort_13801707_1 | SOURCE | VENTILATION | ODA 21
InPort_13801707_2 | SINK | VENTILATION | ODA 21
OutPort_13801710_1 | SOURCE | VENTILATION | ODA 21
InPort_13801708_0 | SINK | VENTILATION | ODA 21
OutPort_13801713_2 | SOURCE | VENTILATION | ODA 21
InPort_13802164_2 | SINK | VENTILATION | ODA 21
OutPort_13801708_1 | SOURCE | VENTILATION | ODA 21
InPort_13801710_2 | SINK | VENTILATION | ODA 21
OutPort_13801709_0 | SOURCE | VENTILATION | ODA 21
InPort_13801709_1 | SINK | VENTILATION | ODA 21
OutPort_13801965_1 | SOURCE | VENTILATION | ODA 21
InPort_13802119_0 | SINK | VENTILATION | ODA 21
OutPort_13802164_1 | SOURCE | VENTILATION | ODA 21
InPort_13802166_2 | SINK | VENTILATION | ODA 21
OutPort_13802119_1 | SOURCE | VENTILATION | ODA 21
InPort_13918301_0 | SINK | VENTILATION | ODA 21
OutPort_13802165_1 | SOURCE | VENTILATION | ODA 21
InPort_13802165_2 | SINK | VENTILATION | ODA 21
OutPort_13802166_1 | SOURCE | VENTILATION | ODA 21
InPort_13992395_1 | SINK | VENTILATION | ODA 10
OutPort_13802202_1 | SOURCE | VENTILATION | ODA 10
InPort_13802202_2 | SINK | VENTILATION | ODA 4
OutPort_13802205_1 | SOURCE | VENTILATION | ODA 4
InPort_13802203_0 | SINK | VENTILATION | ODA 10
OutPort_13992395_2 | SOURCE | VENTILATION | ODA 10
InPort_13992408_1 | SINK | VENTILATION | ODA 10
OutPort_13802203_1 | SOURCE | VENTILATION | ODA 10
InPort_13802205_2 | SINK | VENTILATION | ODA 4
OutPort_13802204_0 | SOURCE | VENTILATION | ODA 4
InPort_13802204_1 | SINK | VENTILATION | ODA 4
OutPort_13802304_1 | SOURCE | VENTILATION | ODA 4
InPort_14193502_1 | SINK | EXHAUST | EHA 1
OutPort_13802748_0 | SOURCE | EXHAUST | EHA 1
InPort_13802748_1 | SINK | EXHAUST | EHA 1
OutPort_14188787_1 | SOURCE | EXHAUST | EHA 1
InPort_13802881_1 | SINK | EXHAUST | EHA 1
OutPort_14193591_0 | SOURCE | EXHAUST | EHA 1
InPort_14155699_2 | SINK | VENTILATION | EHA 3
OutPort_13802895_1 | SOURCE | VENTILATION | EHA 3
InPort_13802895_2 | SINK | VENTILATION | ODA 23
Port_13802896_0 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14155750_2 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13802896_1 | SOURCEANDSINK | VENTILATION | ETA 97
InPort_13902674_1 | SINK | EXHAUST | EHA 3
OutPort_13802899_0 | SOURCE | EXHAUST | EHA 3
InPort_13802899_1 | SINK | EXHAUST | EHA 3
OutPort_14155699_1 | SOURCE | VENTILATION | EHA 3
InPort_13803133_0 | SINK | VENTILATION | SUP 17
OutPort_13935842_1 | SOURCE | VENTILATION | SUP 17
Port_13803133_1 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13803505_1 | SOURCEANDSINK | VENTILATION | SUP 17
InPort_14038607_1 | SINK | VENTILATION | SUP 17
OutPort_13803133_2 | SOURCE | VENTILATION | SUP 17
InPort_14038705_1 | SINK | VENTILATION | SUP 17
OutPort_13803133_3 | SOURCE | VENTILATION | SUP 17
InPort_13803148_1 | SINK | VENTILATION | SUP 17
OutPort_13935716_0 | SOURCE | VENTILATION | SUP 17
InPort_13935542_0 | SINK | VENTILATION | SUP 17
OutPort_13803148_3 | SOURCE | VENTILATION | SUP 17
Port_13803254_0 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13803503_2 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13803254_1 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13803505_2 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13803424_0 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13803424_1 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13915145_2 | SOURCEANDSINK | VENTILATION | SUP 17
InPort_13914939_1 | SINK | VENTILATION | SUP 17
OutPort_13803424_2 | SOURCE | VENTILATION | SUP 17
InPort_13915031_1 | SINK | VENTILATION | SUP 17
OutPort_13803424_3 | SOURCE | VENTILATION | SUP 17
Port_13803503_1 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13915147_1 | SOURCEANDSINK | VENTILATION | SUP 17
InPort_13803523_0 | SINK | VENTILATION | ODA 25
OutPort_13803540_3 | SOURCE | VENTILATION | ODA 25
InPort_13912512_2 | SINK | VENTILATION | ODA 25
OutPort_13803523_1 | SOURCE | VENTILATION | ODA 25
InPort_13803541_1 | SINK | VENTILATION | ODA 25
OutPort_13803540_1 | SOURCE | VENTILATION | ODA 25
InPort_13819021_1 | SINK | VENTILATION | ODA 25
OutPort_13803541_0 | SOURCE | VENTILATION | ODA 25
InPort_13803588_1 | SINK | VENTILATION | SUP 4
OutPort_13810962_0 | SOURCE | VENTILATION | SUP 4
InPort_14080757_0 | SINK | VENTILATION | SUP 4
OutPort_13803588_2 | SOURCE | VENTILATION | SUP 4
InPort_13810978_0 | SINK | VENTILATION | ETA 27
OutPort_13803604_1 | SOURCE | VENTILATION | ETA 27
InPort_13803604_2 | SINK | VENTILATION | ETA 27
OutPort_13803606_1 | SOURCE | VENTILATION | ETA 27
InPort_13803606_0 | SINK | VENTILATION | ETA 27
OutPort_13850334_1 | SOURCE | VENTILATION | ETA 27
Port_13805111_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13805163_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13805111_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13805164_2 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13805219_2 | SINK | VENTILATION | ETA 7
OutPort_13806114_1 | SOURCE | VENTILATION | ETA 7
Port_13805546_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13805548_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13805548_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14138062_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13806033_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14137987_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13806033_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14109730_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13806063_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14159895_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13806063_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14110275_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13806114_0 | SINK | VENTILATION | ETA 7
OutPort_13902974_2 | SOURCE | VENTILATION | ETA 7
InPort_13817360_1 | SINK | VENTILATION | ODA 17
OutPort_13806191_0 | SOURCE | VENTILATION | ODA 17
InPort_13806191_1 | SINK | VENTILATION | ODA 17
OutPort_13806215_1 | SOURCE | VENTILATION | ODA 17
InPort_13806198_2 | SINK | VENTILATION | ODA 17
OutPort_13817254_1 | SOURCE | VENTILATION | ODA 17
InPort_13806215_2 | SINK | VENTILATION | ODA 17
OutPort_13806200_0 | SOURCE | VENTILATION | ODA 17
InPort_13806200_1 | SINK | VENTILATION | ODA 17
OutPort_13806228_2 | SOURCE | VENTILATION | ODA 17
InPort_13817283_2 | SINK | VENTILATION | ODA 17
OutPort_13806217_0 | SOURCE | VENTILATION | ODA 17
InPort_13806217_1 | SINK | VENTILATION | ODA 17
OutPort_13817255_2 | SOURCE | VENTILATION | ODA 17
InPort_13806228_1 | SINK | VENTILATION | ODA 17
OutPort_13817285_0 | SOURCE | VENTILATION | ODA 17
InPort_13817255_1 | SINK | VENTILATION | ODA 17
OutPort_13806293_1 | SOURCE | VENTILATION | ODA 17
InPort_13806374_0 | SINK | VENTILATION | ETA 7
OutPort_13901082_0 | SOURCE | VENTILATION | ETA 7
InPort_13901084_1 | SINK | VENTILATION | ETA 7
OutPort_13806374_1 | SOURCE | VENTILATION | ETA 7
InPort_13901080_1 | SINK | VENTILATION | ETA 7
OutPort_13806542_0 | SOURCE | VENTILATION | ETA 7
InPort_13806542_1 | SINK | VENTILATION | ETA 7
OutPort_13806689_2 | SOURCE | VENTILATION | ETA 7
InPort_13806689_1 | SINK | VENTILATION | ETA 7
OutPort_13806681_0 | SOURCE | VENTILATION | ETA 7
InPort_13806681_1 | SINK | VENTILATION | ETA 7
OutPort_13806705_2 | SOURCE | VENTILATION | ETA 7
InPort_13806681_2 | SINK | VENTILATION | ETA 7
OutPort_13806768_1 | SOURCE | VENTILATION | ETA 7
InPort_13806681_3 | SINK | VENTILATION | ETA 7
OutPort_13806794_1 | SOURCE | VENTILATION | ETA 7
InPort_13806705_1 | SINK | VENTILATION | ETA 7
OutPort_13806699_0 | SOURCE | VENTILATION | ETA 7
InPort_13806699_1 | SINK | VENTILATION | ETA 7
OutPort_13808444_1 | SOURCE | VENTILATION | ETA 7
InPort_13808444_0 | SINK | VENTILATION | ETA 7
OutPort_13806838_1 | SOURCE | VENTILATION | ETA 7
Port_13807310_0 | SOURCEANDSINK | VENTILATION | ODA 13
Port_13807335_1 | SOURCEANDSINK | VENTILATION | ODA 13
Port_13807310_1 | SOURCEANDSINK | VENTILATION | ODA 13
Port_13807359_1 | SOURCEANDSINK | VENTILATION | ODA 13
InPort_13923491_1 | SINK | VENTILATION | ODA 13
OutPort_13807310_2 | SOURCE | VENTILATION | ODA 13
Port_13807335_2 | SOURCEANDSINK | VENTILATION | ODA 13
Port_13923338_0 | SOURCEANDSINK | VENTILATION | ODA 13
Port_13807534_0 | SOURCEANDSINK | VENTILATION | ODA 10
Port_13807555_1 | SOURCEANDSINK | VENTILATION | ODA 10
Port_13807534_1 | SOURCEANDSINK | VENTILATION | ODA 10
Port_13807542_2 | SOURCEANDSINK | VENTILATION | ODA 13
Port_13807555_2 | SOURCEANDSINK | VENTILATION | ODA 10
Port_13807780_0 | SOURCEANDSINK | VENTILATION | ODA 10
Port_13807611_1 | SOURCEANDSINK | VENTILATION | ODA 10
Port_13807611_2 | SOURCEANDSINK | VENTILATION | ODA 10
Port_13807840_0 | SOURCEANDSINK | VENTILATION | ODA 10
Port_13807780_1 | SOURCEANDSINK | VENTILATION | ODA 10
Port_14003002_1 | SOURCEANDSINK | VENTILATION | ODA 10
Port_13807808_1 | SOURCEANDSINK | VENTILATION | ODA 10
Port_13807816_0 | SOURCEANDSINK | VENTILATION | ODA 10
InPort_13807808_2 | SINK | VENTILATION | ODA 10
OutPort_13992397_0 | SOURCE | VENTILATION | ODA 10
Port_13807808_3 | SOURCEANDSINK | VENTILATION | ODA 10
Port_14003005_0 | SOURCEANDSINK | VENTILATION | ODA 10
Port_13807816_1 | SOURCEANDSINK | VENTILATION | ODA 10
Port_14002967_0 | SOURCEANDSINK | VENTILATION | ODA 10
Port_13807840_1 | SOURCEANDSINK | VENTILATION | ODA 10
Port_14002963_1 | SOURCEANDSINK | VENTILATION | ODA 10
InPort_13808837_1 | SINK | VENTILATION | ODA 12
OutPort_13808637_0 | SOURCE | VENTILATION | ODA 12
InPort_13808637_1 | SINK | VENTILATION | ODA 12
OutPort_13917391_2 | SOURCE | VENTILATION | ODA 12
Port_13809205_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13989866_0 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13809266_1 | SINK | EXHAUST | EHA 1
OutPort_13809264_1 | SOURCE | EXHAUST | EHA 1
Port_13809352_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13809790_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13809353_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13809404_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13809788_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13809790_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13809870_2 | SOURCEANDSINK | EXHAUST | EHA 17
Port_13965779_1 | SOURCEANDSINK | EXHAUST | EHA 17
Port_13809872_0 | SOURCEANDSINK | EXHAUST | EHA 17
Port_13965747_2 | SOURCEANDSINK | EXHAUST | EHA 17
Port_13809872_1 | SOURCEANDSINK | EXHAUST | EHA 17
Port_13965779_2 | SOURCEANDSINK | EXHAUST | EHA 17
InPort_13810138_2 | SINK | EXHAUST | ETA 8
OutPort_13810141_1 | SOURCE | EXHAUST | ETA 8
Port_13810240_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13810242_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13810295_1 | SINK | VENTILATION | ETA 7
OutPort_13810297_1 | SOURCE | VENTILATION | ETA 7
InPort_13959884_0 | SINK | VENTILATION | ETA 7
OutPort_13810295_2 | SOURCE | VENTILATION | ETA 7
InPort_13810661_0 | SINK | VENTILATION | ODA 2
OutPort_13810475_2 | SOURCE | VENTILATION | ODA 2
InPort_13810481_1 | SINK | VENTILATION | ODA 2
OutPort_13810479_1 | SOURCE | VENTILATION | ODA 2
InPort_13810503_1 | SINK | EXHAUST | EHA 2
OutPort_13810640_0 | SOURCE | EXHAUST | EHA 2
InPort_13810505_1 | SINK | EXHAUST | EHA 2
OutPort_13810507_1 | SOURCE | EXHAUST | EHA 2
InPort_13810642_0 | SINK | EXHAUST | EHA 2
OutPort_13810638_1 | SOURCE | EXHAUST | EHA 2
InPort_13810638_3 | SINK | EXHAUST | EHA 2
OutPort_13810644_0 | SOURCE | EXHAUST | EHA 2
InPort_13810640_1 | SINK | EXHAUST | EHA 2
OutPort_13810642_1 | SOURCE | EXHAUST | EHA 2
InPort_13810659_1 | SINK | VENTILATION | ODA 2
OutPort_13810663_0 | SOURCE | VENTILATION | ODA 2
InPort_13810664_0 | SINK | VENTILATION | ODA 2
OutPort_13810659_3 | SOURCE | VENTILATION | ODA 2
InPort_13810663_1 | SINK | VENTILATION | ODA 2
OutPort_13810661_1 | SOURCE | VENTILATION | ODA 2
InPort_13810728_0 | SINK | EXHAUST | EHA 9
OutPort_13952178_1 | SOURCE | EXHAUST | EHA 9
InPort_13952179_2 | SINK | EXHAUST | EHA 9
OutPort_13810728_1 | SOURCE | EXHAUST | EHA 9
InPort_13952289_2 | SINK | VENTILATION | ODA 1
OutPort_13810855_0 | SOURCE | VENTILATION | ODA 1
InPort_13810855_1 | SINK | VENTILATION | ODA 1
OutPort_13814040_1 | SOURCE | VENTILATION | ODA 1
InPort_13810964_0 | SINK | VENTILATION | SUP 4
OutPort_13810960_1 | SOURCE | VENTILATION | SUP 4
InPort_13810960_3 | SINK | VENTILATION | SUP 4
OutPort_13810965_0 | SOURCE | VENTILATION | SUP 4
InPort_13810962_1 | SINK | VENTILATION | SUP 4
OutPort_13810964_1 | SOURCE | VENTILATION | SUP 4
InPort_13810976_1 | SINK | VENTILATION | ETA 27
OutPort_14114236_0 | SOURCE | VENTILATION | ETA 27
InPort_14114234_0 | SINK | VENTILATION | ETA 27
OutPort_13810976_3 | SOURCE | VENTILATION | ETA 27
InPort_14114236_1 | SINK | VENTILATION | ETA 27
OutPort_13810978_1 | SOURCE | VENTILATION | ETA 27
InPort_13814056_1 | SINK | VENTILATION | ODA 2
OutPort_13814054_1 | SOURCE | VENTILATION | ODA 2
Port_13814130_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13814132_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13814130_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13945967_0 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13814132_0 | SINK | VENTILATION | ETA 7
OutPort_13959763_1 | SOURCE | VENTILATION | ETA 7
InPort_14181001_0 | SINK | VENTILATION | ETA 7
OutPort_13814132_2 | SOURCE | VENTILATION | ETA 7
InPort_13817254_2 | SINK | VENTILATION | ODA 17
OutPort_13817362_0 | SOURCE | VENTILATION | ODA 17
InPort_13817285_1 | SINK | VENTILATION | ODA 17
OutPort_13817283_1 | SOURCE | VENTILATION | ODA 17
InPort_13817362_1 | SINK | VENTILATION | ODA 17
OutPort_13817360_2 | SOURCE | VENTILATION | ODA 17
Port_13817542_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13817544_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13817544_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14173904_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13817713_1 | SINK | VENTILATION | SUP 13
OutPort_13817821_0 | SOURCE | VENTILATION | SUP 13
Port_13817759_0 | SOURCEANDSINK | VENTILATION | SUP 20
Port_14061727_1 | SOURCEANDSINK | VENTILATION | SUP 20
Port_13817759_1 | SOURCEANDSINK | VENTILATION | SUP 20
InPort_13929379_1 | SINK | VENTILATION | SUP 20
OutPort_13817759_2 | SOURCE | VENTILATION | SUP 20
InPort_13929422_1 | SINK | VENTILATION | SUP 20
OutPort_13817759_3 | SOURCE | VENTILATION | SUP 20
InPort_13929470_1 | SINK | VENTILATION | SUP 20
OutPort_13817759_4 | SOURCE | VENTILATION | SUP 20
Port_13817804_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13817820_3 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13817804_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13817828_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13817821_1 | SINK | VENTILATION | SUP 13
OutPort_13817820_2 | SOURCE | VENTILATION | SUP 13
Port_13817937_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13817993_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13817937_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13817995_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13817993_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13818067_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13818065_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13818067_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13818441_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14109726_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13818441_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13818644_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13818642_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13818644_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13818642_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14057002_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13818679_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14058319_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13818679_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13818679_2 | SINK | VENTILATION | ETA 7
OutPort_13970217_1 | SOURCE | VENTILATION | ETA 7
InPort_13818679_3 | SINK | VENTILATION | ETA 7
OutPort_13970370_1 | SOURCE | VENTILATION | ETA 7
Port_13818737_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13818739_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13818773_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13847754_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13818773_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13847737_2 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13818909_0 | SINK | VENTILATION | ODA 25
OutPort_13819021_3 | SOURCE | VENTILATION | ODA 25
InPort_13912448_2 | SINK | VENTILATION | ODA 25
OutPort_13818909_1 | SOURCE | VENTILATION | ODA 25
InPort_13819022_1 | SINK | VENTILATION | ODA 25
OutPort_13819021_2 | SOURCE | VENTILATION | ODA 25
InPort_13819069_1 | SINK | VENTILATION | ODA 25
OutPort_13912448_1 | SOURCE | VENTILATION | ODA 25
InPort_13819164_1 | SINK | VENTILATION | ODA 25
OutPort_13912340_1 | SOURCE | VENTILATION | ODA 25
InPort_13819339_1 | SINK | VENTILATION | ODA 25
OutPort_13912512_1 | SOURCE | VENTILATION | ODA 25
InPort_13819539_1 | SINK | VENTILATION | ODA 25
OutPort_13819538_0 | SOURCE | VENTILATION | ODA 25
InPort_13819538_1 | SINK | VENTILATION | ODA 25
OutPort_14151945_1 | SOURCE | VENTILATION | ODA 25
Port_13819737_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13848512_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13819757_2 | SOURCEANDSINK | VENTILATION | SUP 1
Port_13819759_1 | SOURCEANDSINK | VENTILATION | SUP 1
Port_13819898_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13977937_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13819898_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13977939_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13819910_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13848457_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13819910_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13819911_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13819910_3 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13977922_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13820288_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13820291_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13820291_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877205_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13820312_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13847405_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13820312_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13847383_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13820356_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13820358_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13820358_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13957308_2 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13820447_2 | SINK | VENTILATION | ETA 14
OutPort_13820449_1 | SOURCE | VENTILATION | ETA 14
Port_13820645_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13820647_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13820647_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13892878_2 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_13850147_0 | SINK | VENTILATION | SUP 9
OutPort_13820674_1 | SOURCE | VENTILATION | SUP 9
InPort_13820674_2 | SINK | VENTILATION | SUP 9
OutPort_13820676_1 | SOURCE | VENTILATION | SUP 9
InPort_13820676_0 | SINK | VENTILATION | SUP 9
OutPort_14078252_1 | SOURCE | VENTILATION | SUP 9
InPort_13820798_1 | SINK | VENTILATION | ETA 12
OutPort_13820796_2 | SOURCE | VENTILATION | ETA 12
InPort_13820810_2 | SINK | VENTILATION | SUP 17
OutPort_13820812_1 | SOURCE | VENTILATION | SUP 17
InPort_14009700_1 | SINK | EXHAUST | EHA 13
OutPort_13821879_0 | SOURCE | EXHAUST | EHA 13
InPort_13821879_1 | SINK | EXHAUST | EHA 13
OutPort_14194075_2 | SOURCE | EXHAUST | EHA 13
InPort_13821922_1 | SINK | EXHAUST | EHA 13
OutPort_14009394_2 | SOURCE | EXHAUST | EHA 13
InPort_14194075_1 | SINK | EXHAUST | EHA 13
OutPort_13821922_3 | SOURCE | EXHAUST | EHA 13
InPort_14009394_1 | SINK | EXHAUST | EHA 13
OutPort_13822147_0 | SOURCE | EXHAUST | EHA 13
InPort_13822147_1 | SINK | EXHAUST | EHA 13
OutPort_13824313_2 | SOURCE | EXHAUST | EHA 13
InPort_13855113_0 | SINK | EXHAUST | EHA 8
OutPort_13823015_2 | SOURCE | EXHAUST | EHA 8
InPort_13823917_0 | SINK | EXHAUST | EHA 5
OutPort_13825705_3 | SOURCE | EXHAUST | EHA 5
InPort_14184346_1 | SINK | EXHAUST | EHA 5
OutPort_13823917_1 | SOURCE | EXHAUST | EHA 5
InPort_13824313_1 | SINK | EXHAUST | EHA 13
OutPort_13824306_0 | SOURCE | EXHAUST | EHA 13
InPort_13824306_1 | SINK | EXHAUST | EHA 13
OutPort_13824374_1 | SOURCE | EXHAUST | EHA 13
InPort_13824405_2 | SINK | EXHAUST | EHA 13
OutPort_13824365_0 | SOURCE | EXHAUST | EHA 13
InPort_13824365_1 | SINK | EXHAUST | EHA 13
OutPort_14151072_2 | SOURCE | EXHAUST | EHA 13
InPort_13824374_2 | SINK | EXHAUST | EHA 13
OutPort_13824373_0 | SOURCE | EXHAUST | EHA 13
InPort_13824373_1 | SINK | EXHAUST | EHA 13
OutPort_13824405_1 | SOURCE | EXHAUST | EHA 13
InPort_14151072_1 | SINK | EXHAUST | EHA 13
OutPort_13824409_0 | SOURCE | EXHAUST | EHA 13
InPort_13824409_1 | SINK | EXHAUST | EHA 13
OutPort_13862870_4 | SOURCE | EXHAUST | EHA 13
InPort_13824854_0 | SINK | VENTILATION | ODA 14
OutPort_13845605_3 | SOURCE | VENTILATION | ODA 14
InPort_13824915_1 | SINK | VENTILATION | ODA 14
OutPort_13824854_1 | SOURCE | VENTILATION | ODA 14
InPort_13824906_0 | SINK | VENTILATION | ODA 14
OutPort_13824915_2 | SOURCE | VENTILATION | ODA 14
InPort_13825228_1 | SINK | VENTILATION | ODA 14
OutPort_13824906_1 | SOURCE | VENTILATION | ODA 14
InPort_13825193_0 | SINK | VENTILATION | SUP 13
OutPort_13846611_2 | SOURCE | VENTILATION | SUP 13
InPort_13825221_0 | SINK | VENTILATION | ODA 14
OutPort_13825228_2 | SOURCE | VENTILATION | ODA 14
InPort_13845471_1 | SINK | VENTILATION | ODA 14
OutPort_13825221_1 | SOURCE | VENTILATION | ODA 14
InPort_13896852_1 | SINK | VENTILATION | ODA 7
OutPort_13825386_1 | SOURCE | VENTILATION | ODA 7
InPort_13825386_3 | SINK | VENTILATION | ODA 7
OutPort_13896608_0 | SOURCE | VENTILATION | ODA 7
InPort_13825705_1 | SINK | EXHAUST | EHA 5
OutPort_13897049_0 | SOURCE | EXHAUST | EHA 5
InPort_13825707_0 | SINK | EXHAUST | EHA 5
OutPort_13897141_2 | SOURCE | EXHAUST | EHA 5
InPort_13897143_2 | SINK | EXHAUST | EHA 5
OutPort_13825707_1 | SOURCE | EXHAUST | EHA 5
InPort_13837023_0 | SINK | VENTILATION | ETA 39
OutPort_13836770_1 | SOURCE | VENTILATION | ETA 39
InPort_13836770_2 | SINK | VENTILATION | ETA 39
OutPort_13837198_0 | SOURCE | VENTILATION | ETA 39
OutPort_13837023_1 | SOURCE | VENTILATION | ETA 39
InPort_13837198_1 | SINK | VENTILATION | ETA 39
OutPort_13978439_1 | SOURCE | VENTILATION | ETA 39
InPort_13837341_0 | SINK | VENTILATION | ETA 38
OutPort_13837340_1 | SOURCE | VENTILATION | ETA 38
InPort_13837340_2 | SINK | VENTILATION | ETA 38
OutPort_13837342_0 | SOURCE | VENTILATION | ETA 38
OutPort_13837341_1 | SOURCE | VENTILATION | ETA 38
InPort_13837342_1 | SINK | VENTILATION | ETA 38
OutPort_13978337_1 | SOURCE | VENTILATION | ETA 38
InPort_13837358_0 | SINK | VENTILATION | ETA 40
OutPort_13837357_1 | SOURCE | VENTILATION | ETA 40
InPort_13837357_2 | SINK | VENTILATION | ETA 40
OutPort_13837359_0 | SOURCE | VENTILATION | ETA 40
OutPort_13837358_1 | SOURCE | VENTILATION | ETA 40
InPort_13837359_1 | SINK | VENTILATION | ETA 40
OutPort_13978207_1 | SOURCE | VENTILATION | ETA 40
InPort_13837373_0 | SINK | VENTILATION | ETA 41
OutPort_13837372_1 | SOURCE | VENTILATION | ETA 41
InPort_13837372_2 | SINK | VENTILATION | ETA 41
OutPort_13837374_0 | SOURCE | VENTILATION | ETA 41
OutPort_13837373_1 | SOURCE | VENTILATION | ETA 41
InPort_13837374_1 | SINK | VENTILATION | ETA 41
OutPort_13978125_1 | SOURCE | VENTILATION | ETA 41
InPort_13837435_0 | SINK | VENTILATION | ETA 42
OutPort_13837434_1 | SOURCE | VENTILATION | ETA 42
InPort_13837434_2 | SINK | VENTILATION | ETA 42
OutPort_13837436_0 | SOURCE | VENTILATION | ETA 42
OutPort_13837435_1 | SOURCE | VENTILATION | ETA 42
InPort_13837436_1 | SINK | VENTILATION | ETA 42
OutPort_13975804_1 | SOURCE | VENTILATION | ETA 42
InPort_13837438_0 | SINK | VENTILATION | ETA 44
OutPort_13837437_1 | SOURCE | VENTILATION | ETA 44
InPort_13837437_2 | SINK | VENTILATION | ETA 44
OutPort_13837439_0 | SOURCE | VENTILATION | ETA 44
OutPort_13837438_1 | SOURCE | VENTILATION | ETA 44
InPort_13837439_1 | SINK | VENTILATION | ETA 44
OutPort_13975442_1 | SOURCE | VENTILATION | ETA 44
InPort_13837441_0 | SINK | VENTILATION | ETA 46
OutPort_13837440_1 | SOURCE | VENTILATION | ETA 46
InPort_13837440_2 | SINK | VENTILATION | ETA 46
OutPort_13837442_0 | SOURCE | VENTILATION | ETA 46
OutPort_13837441_1 | SOURCE | VENTILATION | ETA 46
InPort_13837442_1 | SINK | VENTILATION | ETA 46
OutPort_13975384_1 | SOURCE | VENTILATION | ETA 46
InPort_13837444_0 | SINK | VENTILATION | ETA 48
OutPort_13837443_1 | SOURCE | VENTILATION | ETA 48
InPort_13837443_2 | SINK | VENTILATION | ETA 48
OutPort_13837445_0 | SOURCE | VENTILATION | ETA 48
OutPort_13837444_1 | SOURCE | VENTILATION | ETA 48
InPort_13837445_1 | SINK | VENTILATION | ETA 48
OutPort_13975298_1 | SOURCE | VENTILATION | ETA 48
InPort_13837536_0 | SINK | VENTILATION | ETA 43
OutPort_13837535_1 | SOURCE | VENTILATION | ETA 43
InPort_13837535_2 | SINK | VENTILATION | ETA 43
OutPort_13837537_0 | SOURCE | VENTILATION | ETA 43
OutPort_13837536_1 | SOURCE | VENTILATION | ETA 43
InPort_13837537_1 | SINK | VENTILATION | ETA 43
OutPort_13975715_1 | SOURCE | VENTILATION | ETA 43
InPort_13837585_0 | SINK | VENTILATION | ETA 45
OutPort_13837584_1 | SOURCE | VENTILATION | ETA 45
InPort_13837584_2 | SINK | VENTILATION | ETA 45
OutPort_13837586_0 | SOURCE | VENTILATION | ETA 45
OutPort_13837585_1 | SOURCE | VENTILATION | ETA 45
InPort_13837586_1 | SINK | VENTILATION | ETA 45
OutPort_13975358_1 | SOURCE | VENTILATION | ETA 45
InPort_13837598_0 | SINK | VENTILATION | ETA 47
OutPort_13837597_1 | SOURCE | VENTILATION | ETA 47
InPort_13837597_2 | SINK | VENTILATION | ETA 47
OutPort_13837599_0 | SOURCE | VENTILATION | ETA 47
OutPort_13837598_1 | SOURCE | VENTILATION | ETA 47
InPort_13837599_1 | SINK | VENTILATION | ETA 47
OutPort_13975328_1 | SOURCE | VENTILATION | ETA 47
InPort_13884989_0 | SINK | VENTILATION | SUP 1
OutPort_13837626_1 | SOURCE | VENTILATION | SUP 1
InPort_13837626_2 | SINK | VENTILATION | SUP 1
OutPort_13885013_0 | SOURCE | VENTILATION | SUP 1
InPort_13837754_0 | SINK | VENTILATION | SUP 1
OutPort_13837770_3 | SOURCE | VENTILATION | SUP 1
InPort_13837776_1 | SINK | VENTILATION | SUP 1
OutPort_13837754_1 | SOURCE | VENTILATION | SUP 1
InPort_13848629_1 | SINK | VENTILATION | SUP 1
OutPort_13837770_1 | SOURCE | VENTILATION | SUP 1
InPort_13884914_1 | SINK | VENTILATION | SUP 1
OutPort_13837771_0 | SOURCE | VENTILATION | SUP 1
InPort_13837771_1 | SINK | VENTILATION | SUP 1
OutPort_13848629_2 | SOURCE | VENTILATION | SUP 1
InPort_13837899_0 | SINK | VENTILATION | SUP 1
OutPort_13885178_2 | SOURCE | VENTILATION | SUP 1
Port_13837899_1 | SOURCEANDSINK | VENTILATION | SUP 1
InPort_13883259_1 | SINK | VENTILATION | SUP 1
OutPort_13837899_2 | SOURCE | VENTILATION | SUP 1
InPort_13883299_1 | SINK | VENTILATION | SUP 1
OutPort_13837899_3 | SOURCE | VENTILATION | SUP 1
InPort_13883327_1 | SINK | VENTILATION | SUP 1
OutPort_13837899_4 | SOURCE | VENTILATION | SUP 1
InPort_13885180_2 | SINK | VENTILATION | SUP 1
OutPort_13837901_0 | SOURCE | VENTILATION | SUP 1
InPort_13837901_1 | SINK | VENTILATION | SUP 1
OutPort_13837943_1 | SOURCE | VENTILATION | SUP 1
InPort_13837903_1 | SINK | VENTILATION | SUP 1
OutPort_13885113_0 | SOURCE | VENTILATION | SUP 1
InPort_13885176_1 | SINK | VENTILATION | SUP 1
OutPort_13837903_2 | SOURCE | VENTILATION | SUP 1
InPort_13837943_2 | SINK | VENTILATION | SUP 1
OutPort_13837905_0 | SOURCE | VENTILATION | SUP 1
InPort_13837905_1 | SINK | VENTILATION | SUP 1
OutPort_13837935_3 | SOURCE | VENTILATION | SUP 1
InPort_13837935_2 | SINK | VENTILATION | SUP 1
OutPort_13837936_1 | SOURCE | VENTILATION | SUP 1
InPort_13837967_1 | SINK | VENTILATION | ETA 49
OutPort_14148423_0 | SOURCE | VENTILATION | ETA 49
InPort_13838017_0 | SINK | VENTILATION | ETA 49
OutPort_13837967_2 | SOURCE | VENTILATION | ETA 49
OutPort_13838017_1 | SOURCE | VENTILATION | ETA 49
InPort_13838107_0 | SINK | VENTILATION | SUP 13
OutPort_13886499_2 | SOURCE | VENTILATION | SUP 13
InPort_13838124_1 | SINK | VENTILATION | SUP 13
OutPort_13838107_1 | SOURCE | VENTILATION | SUP 13
InPort_13886519_0 | SINK | VENTILATION | SUP 13
OutPort_13838113_1 | SOURCE | VENTILATION | SUP 13
InPort_13838116_0 | SINK | VENTILATION | SUP 13
OutPort_13886096_1 | SOURCE | VENTILATION | SUP 13
Port_13838116_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13885977_1 | SINK | VENTILATION | SUP 13
OutPort_13838116_2 | SOURCE | VENTILATION | SUP 13
InPort_13886002_1 | SINK | VENTILATION | SUP 13
OutPort_13838116_3 | SOURCE | VENTILATION | SUP 13
InPort_13886026_1 | SINK | VENTILATION | SUP 13
OutPort_13838116_4 | SOURCE | VENTILATION | SUP 13
InPort_13886112_0 | SINK | VENTILATION | SUP 13
OutPort_13838124_2 | SOURCE | VENTILATION | SUP 13
InPort_13838144_1 | SINK | VENTILATION | ETA 50
OutPort_14148347_1 | SOURCE | VENTILATION | ETA 50
InPort_13838145_0 | SINK | VENTILATION | ETA 50
OutPort_13838144_2 | SOURCE | VENTILATION | ETA 50
OutPort_13838145_1 | SOURCE | VENTILATION | ETA 50
InPort_13838181_1 | SINK | VENTILATION | ETA 51
OutPort_14148458_1 | SOURCE | VENTILATION | ETA 51
InPort_13838250_0 | SINK | VENTILATION | ETA 51
OutPort_13838181_2 | SOURCE | VENTILATION | ETA 51
OutPort_13838250_1 | SOURCE | VENTILATION | ETA 51
InPort_13838353_0 | SINK | VENTILATION | ETA 64
OutPort_13838351_1 | SOURCE | VENTILATION | ETA 64
InPort_13838351_2 | SINK | VENTILATION | ETA 64
OutPort_13990588_0 | SOURCE | VENTILATION | ETA 64
OutPort_13838353_1 | SOURCE | VENTILATION | ETA 64
InPort_13838385_1 | SINK | VENTILATION | ETA 53
OutPort_13838386_0 | SOURCE | VENTILATION | ETA 53
InPort_13838387_0 | SINK | VENTILATION | ETA 53
OutPort_13838385_2 | SOURCE | VENTILATION | ETA 53
InPort_13838386_1 | SINK | VENTILATION | ETA 53
OutPort_13977215_1 | SOURCE | VENTILATION | ETA 53
InPort_13838386_2 | SINK | VENTILATION | ETA 53
OutPort_13971572_0 | SOURCE | VENTILATION | ETA 53
OutPort_13838387_1 | SOURCE | VENTILATION | ETA 53
InPort_13838400_1 | SINK | VENTILATION | ETA 54
OutPort_14148528_0 | SOURCE | VENTILATION | ETA 54
InPort_13838402_0 | SINK | VENTILATION | ETA 54
OutPort_13838400_2 | SOURCE | VENTILATION | ETA 54
OutPort_13838402_1 | SOURCE | VENTILATION | ETA 54
InPort_13838435_1 | SINK | VENTILATION | ETA 55
OutPort_14148586_1 | SOURCE | VENTILATION | ETA 55
InPort_13838436_0 | SINK | VENTILATION | ETA 55
OutPort_13838435_2 | SOURCE | VENTILATION | ETA 55
OutPort_13838436_1 | SOURCE | VENTILATION | ETA 55
InPort_13838447_1 | SINK | VENTILATION | ETA 56
OutPort_14148617_1 | SOURCE | VENTILATION | ETA 56
InPort_13982426_0 | SINK | VENTILATION | ETA 56
OutPort_13838447_2 | SOURCE | VENTILATION | ETA 56
InPort_13838478_0 | SINK | VENTILATION | ETA 57
OutPort_13838477_1 | SOURCE | VENTILATION | ETA 57
InPort_13838477_2 | SINK | VENTILATION | ETA 57
OutPort_13838479_0 | SOURCE | VENTILATION | ETA 57
OutPort_13838478_1 | SOURCE | VENTILATION | ETA 57
InPort_13838479_1 | SINK | VENTILATION | ETA 57
OutPort_13974384_1 | SOURCE | VENTILATION | ETA 57
InPort_13838490_0 | SINK | VENTILATION | ETA 58
OutPort_13838489_1 | SOURCE | VENTILATION | ETA 58
InPort_13838489_2 | SINK | VENTILATION | ETA 58
OutPort_13838491_0 | SOURCE | VENTILATION | ETA 58
OutPort_13838490_1 | SOURCE | VENTILATION | ETA 58
InPort_13838491_1 | SINK | VENTILATION | ETA 58
OutPort_13974326_1 | SOURCE | VENTILATION | ETA 58
InPort_13838512_0 | SINK | VENTILATION | ETA 59
OutPort_13838511_1 | SOURCE | VENTILATION | ETA 59
InPort_13838511_2 | SINK | VENTILATION | ETA 59
OutPort_13838513_0 | SOURCE | VENTILATION | ETA 59
OutPort_13838512_1 | SOURCE | VENTILATION | ETA 59
InPort_13838513_1 | SINK | VENTILATION | ETA 59
OutPort_13974296_1 | SOURCE | VENTILATION | ETA 59
InPort_13838537_0 | SINK | VENTILATION | ETA 60
OutPort_13838536_1 | SOURCE | VENTILATION | ETA 60
InPort_13838536_2 | SINK | VENTILATION | ETA 60
OutPort_13838538_0 | SOURCE | VENTILATION | ETA 60
OutPort_13838537_1 | SOURCE | VENTILATION | ETA 60
InPort_13838538_1 | SINK | VENTILATION | ETA 60
OutPort_13974244_1 | SOURCE | VENTILATION | ETA 60
InPort_13838564_0 | SINK | VENTILATION | ETA 61
OutPort_13838563_1 | SOURCE | VENTILATION | ETA 61
InPort_13838563_2 | SINK | VENTILATION | ETA 61
OutPort_13838565_0 | SOURCE | VENTILATION | ETA 61
OutPort_13838564_1 | SOURCE | VENTILATION | ETA 61
InPort_13838565_1 | SINK | VENTILATION | ETA 61
OutPort_13974212_1 | SOURCE | VENTILATION | ETA 61
InPort_13838576_0 | SINK | VENTILATION | ETA 62
OutPort_13838575_1 | SOURCE | VENTILATION | ETA 62
InPort_13838575_2 | SINK | VENTILATION | ETA 62
OutPort_13838577_0 | SOURCE | VENTILATION | ETA 62
OutPort_13838576_1 | SOURCE | VENTILATION | ETA 62
InPort_13838577_1 | SINK | VENTILATION | ETA 62
OutPort_13974174_1 | SOURCE | VENTILATION | ETA 62
InPort_13838587_1 | SINK | VENTILATION | ETA 63
OutPort_13838588_0 | SOURCE | VENTILATION | ETA 63
InPort_13838589_0 | SINK | VENTILATION | ETA 63
OutPort_13838587_2 | SOURCE | VENTILATION | ETA 63
InPort_13838588_1 | SINK | VENTILATION | ETA 63
OutPort_13974554_1 | SOURCE | VENTILATION | ETA 63
OutPort_13838589_1 | SOURCE | VENTILATION | ETA 63
InPort_13838622_1 | SINK | VENTILATION | ETA 90
OutPort_13838624_0 | SOURCE | VENTILATION | ETA 90
InPort_13838623_0 | SINK | VENTILATION | ETA 90
OutPort_13838622_2 | SOURCE | VENTILATION | ETA 90
OutPort_13838623_1 | SOURCE | VENTILATION | ETA 90
InPort_13838624_1 | SINK | VENTILATION | ETA 90
OutPort_13990289_1 | SOURCE | VENTILATION | ETA 90
InPort_13838636_0 | SINK | VENTILATION | ETA 65
OutPort_13838634_1 | SOURCE | VENTILATION | ETA 65
InPort_13838634_2 | SINK | VENTILATION | ETA 65
OutPort_13838635_0 | SOURCE | VENTILATION | ETA 65
InPort_13838635_1 | SINK | VENTILATION | ETA 65
OutPort_14001959_1 | SOURCE | VENTILATION | ETA 65
OutPort_13838636_1 | SOURCE | VENTILATION | ETA 65
InPort_13867915_0 | SINK | VENTILATION | SUP 24
OutPort_13838765_1 | SOURCE | VENTILATION | SUP 24
InPort_13838765_2 | SINK | VENTILATION | SUP 24
OutPort_13868042_0 | SOURCE | VENTILATION | SUP 24
InPort_13838815_0 | SINK | VENTILATION | ETA 66
OutPort_13838813_1 | SOURCE | VENTILATION | ETA 66
InPort_13838813_2 | SINK | VENTILATION | ETA 66
OutPort_13838814_0 | SOURCE | VENTILATION | ETA 66
InPort_13838814_1 | SINK | VENTILATION | ETA 66
OutPort_13980216_1 | SOURCE | VENTILATION | ETA 66
OutPort_13838815_1 | SOURCE | VENTILATION | ETA 66
InPort_13838936_0 | SINK | VENTILATION | ETA 67
OutPort_13838841_1 | SOURCE | VENTILATION | ETA 67
InPort_13838841_2 | SINK | VENTILATION | ETA 67
OutPort_13838912_0 | SOURCE | VENTILATION | ETA 67
InPort_13838912_1 | SINK | VENTILATION | ETA 67
OutPort_13980604_1 | SOURCE | VENTILATION | ETA 67
OutPort_13838936_1 | SOURCE | VENTILATION | ETA 67
InPort_13839003_1 | SINK | VENTILATION | ETA 69
OutPort_14148649_1 | SOURCE | VENTILATION | ETA 69
InPort_13839005_0 | SINK | VENTILATION | ETA 69
OutPort_13839003_2 | SOURCE | VENTILATION | ETA 69
OutPort_13839005_1 | SOURCE | VENTILATION | ETA 69
InPort_13839037_1 | SINK | VENTILATION | ETA 70
OutPort_14148812_0 | SOURCE | VENTILATION | ETA 70
InPort_13839039_0 | SINK | VENTILATION | ETA 70
OutPort_13839037_2 | SOURCE | VENTILATION | ETA 70
OutPort_13839039_1 | SOURCE | VENTILATION | ETA 70
InPort_13839100_1 | SINK | VENTILATION | ETA 71
OutPort_13839102_0 | SOURCE | VENTILATION | ETA 71
InPort_13839101_0 | SINK | VENTILATION | ETA 71
OutPort_13839100_2 | SOURCE | VENTILATION | ETA 71
OutPort_13839101_1 | SOURCE | VENTILATION | ETA 71
InPort_13839102_1 | SINK | VENTILATION | ETA 71
OutPort_13982925_1 | SOURCE | VENTILATION | ETA 71
InPort_13839115_1 | SINK | VENTILATION | ETA 72
OutPort_14148860_0 | SOURCE | VENTILATION | ETA 72
InPort_13839116_0 | SINK | VENTILATION | ETA 72
OutPort_13839115_2 | SOURCE | VENTILATION | ETA 72
OutPort_13839116_1 | SOURCE | VENTILATION | ETA 72
InPort_13839232_0 | SINK | VENTILATION | ETA 73
OutPort_13839231_1 | SOURCE | VENTILATION | ETA 73
InPort_13839231_2 | SINK | VENTILATION | ETA 73
OutPort_13839233_0 | SOURCE | VENTILATION | ETA 73
OutPort_13839232_1 | SOURCE | VENTILATION | ETA 73
InPort_13839233_1 | SINK | VENTILATION | ETA 73
OutPort_13978978_1 | SOURCE | VENTILATION | ETA 73
InPort_13839368_0 | SINK | VENTILATION | ETA 74
OutPort_13839367_1 | SOURCE | VENTILATION | ETA 74
InPort_13839367_2 | SINK | VENTILATION | ETA 74
OutPort_13839369_0 | SOURCE | VENTILATION | ETA 74
OutPort_13839368_1 | SOURCE | VENTILATION | ETA 74
InPort_13839369_1 | SINK | VENTILATION | ETA 74
OutPort_13979078_1 | SOURCE | VENTILATION | ETA 74
InPort_13884550_0 | SINK | VENTILATION | SUP 24
OutPort_13839524_2 | SOURCE | VENTILATION | SUP 24
InPort_13839548_0 | SINK | VENTILATION | ETA 75
OutPort_13839547_1 | SOURCE | VENTILATION | ETA 75
InPort_13839547_2 | SINK | VENTILATION | ETA 75
OutPort_13839549_0 | SOURCE | VENTILATION | ETA 75
OutPort_13839548_1 | SOURCE | VENTILATION | ETA 75
InPort_13839549_1 | SINK | VENTILATION | ETA 75
OutPort_13979120_1 | SOURCE | VENTILATION | ETA 75
InPort_13839561_0 | SINK | VENTILATION | ETA 76
OutPort_13839560_1 | SOURCE | VENTILATION | ETA 76
InPort_13839560_2 | SINK | VENTILATION | ETA 76
OutPort_13839562_0 | SOURCE | VENTILATION | ETA 76
OutPort_13839561_1 | SOURCE | VENTILATION | ETA 76
InPort_13839562_1 | SINK | VENTILATION | ETA 76
OutPort_13979184_1 | SOURCE | VENTILATION | ETA 76
InPort_13839675_1 | SINK | VENTILATION | ETA 78
OutPort_14148753_1 | SOURCE | VENTILATION | ETA 78
InPort_13839677_0 | SINK | VENTILATION | ETA 78
OutPort_13839675_2 | SOURCE | VENTILATION | ETA 78
OutPort_13839677_1 | SOURCE | VENTILATION | ETA 78
InPort_13839690_1 | SINK | VENTILATION | ETA 79
OutPort_14149024_1 | SOURCE | VENTILATION | ETA 79
InPort_13839692_0 | SINK | VENTILATION | ETA 79
OutPort_13839690_2 | SOURCE | VENTILATION | ETA 79
OutPort_13839692_1 | SOURCE | VENTILATION | ETA 79
Port_13839718_1 | SOURCEANDSINK | VENTILATION | ETA 80
Port_13839719_0 | SOURCEANDSINK | VENTILATION | ETA 80
Port_13839718_2 | SOURCEANDSINK | VENTILATION | ETA 80
Port_13839720_0 | SOURCEANDSINK | VENTILATION | ETA 80
Port_13839719_1 | SOURCEANDSINK | VENTILATION | ETA 80
Port_13839720_1 | SOURCEANDSINK | VENTILATION | ETA 80
Port_13839751_1 | SOURCEANDSINK | VENTILATION | ETA 81
Port_13839752_0 | SOURCEANDSINK | VENTILATION | ETA 81
Port_13839751_2 | SOURCEANDSINK | VENTILATION | ETA 81
Port_13839753_0 | SOURCEANDSINK | VENTILATION | ETA 81
Port_13839752_1 | SOURCEANDSINK | VENTILATION | ETA 81
Port_13839753_1 | SOURCEANDSINK | VENTILATION | ETA 81
Port_13839764_1 | SOURCEANDSINK | VENTILATION | ETA 82
Port_13839765_0 | SOURCEANDSINK | VENTILATION | ETA 82
Port_13839764_2 | SOURCEANDSINK | VENTILATION | ETA 82
Port_13839766_0 | SOURCEANDSINK | VENTILATION | ETA 82
Port_13839765_1 | SOURCEANDSINK | VENTILATION | ETA 82
Port_13839766_1 | SOURCEANDSINK | VENTILATION | ETA 82
Port_13839777_1 | SOURCEANDSINK | VENTILATION | ETA 83
Port_13839778_0 | SOURCEANDSINK | VENTILATION | ETA 83
Port_13839777_2 | SOURCEANDSINK | VENTILATION | ETA 83
Port_13839779_0 | SOURCEANDSINK | VENTILATION | ETA 83
Port_13839778_1 | SOURCEANDSINK | VENTILATION | ETA 83
Port_13839779_1 | SOURCEANDSINK | VENTILATION | ETA 83
Port_13839810_1 | SOURCEANDSINK | VENTILATION | ETA 84
Port_13839811_0 | SOURCEANDSINK | VENTILATION | ETA 84
Port_13839810_2 | SOURCEANDSINK | VENTILATION | ETA 84
Port_13839812_0 | SOURCEANDSINK | VENTILATION | ETA 84
Port_13839811_1 | SOURCEANDSINK | VENTILATION | ETA 84
Port_13839812_1 | SOURCEANDSINK | VENTILATION | ETA 84
Port_13839823_1 | SOURCEANDSINK | VENTILATION | ETA 85
Port_13839824_0 | SOURCEANDSINK | VENTILATION | ETA 85
Port_13839823_2 | SOURCEANDSINK | VENTILATION | ETA 85
Port_13839825_0 | SOURCEANDSINK | VENTILATION | ETA 85
Port_13839824_1 | SOURCEANDSINK | VENTILATION | ETA 85
Port_13839825_1 | SOURCEANDSINK | VENTILATION | ETA 85
InPort_13911065_0 | SINK | VENTILATION | SUP 24
OutPort_13839869_1 | SOURCE | VENTILATION | SUP 24
InPort_13911014_0 | SINK | VENTILATION | SUP 24
OutPort_13839914_2 | SOURCE | VENTILATION | SUP 24
InPort_13840027_1 | SINK | VENTILATION | ETA 29
OutPort_13840028_0 | SOURCE | VENTILATION | ETA 29
InPort_13840029_0 | SINK | VENTILATION | ETA 29
OutPort_13840027_2 | SOURCE | VENTILATION | ETA 29
InPort_13840028_1 | SINK | VENTILATION | ETA 29
OutPort_13972789_1 | SOURCE | VENTILATION | ETA 29
InPort_13971416_1 | SINK | VENTILATION | ETA 29
OutPort_13840029_1 | SOURCE | VENTILATION | ETA 29
Port_13840483_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14109721_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13840483_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14109688_2 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13845460_0 | SINK | VENTILATION | ODA 14
OutPort_13845471_2 | SOURCE | VENTILATION | ODA 14
InPort_13863132_1 | SINK | VENTILATION | ODA 14
OutPort_13845460_1 | SOURCE | VENTILATION | ODA 14
InPort_13845474_0 | SINK | VENTILATION | ODA 14
OutPort_13863136_2 | SOURCE | VENTILATION | ODA 14
OutPort_13845474_1 | SOURCE | VENTILATION | ODA 14
InPort_13845605_1 | SINK | VENTILATION | ODA 14
OutPort_14145900_0 | SOURCE | VENTILATION | ODA 14
InPort_13846045_0 | SINK | VENTILATION | SUP 13
OutPort_13846244_3 | SOURCE | VENTILATION | SUP 13
InPort_13846525_1 | SINK | VENTILATION | SUP 13
OutPort_13846045_1 | SOURCE | VENTILATION | SUP 13
InPort_13846244_1 | SINK | VENTILATION | SUP 13
OutPort_13846246_0 | SOURCE | VENTILATION | SUP 13
InPort_13846246_1 | SINK | VENTILATION | SUP 13
OutPort_13863625_2 | SOURCE | VENTILATION | SUP 13
InPort_13846526_1 | SINK | VENTILATION | SUP 13
OutPort_13846525_2 | SOURCE | VENTILATION | SUP 13
InPort_13846541_1 | SINK | VENTILATION | SUP 13
OutPort_13846539_1 | SOURCE | VENTILATION | SUP 13
InPort_13846611_1 | SINK | VENTILATION | SUP 13
OutPort_13846541_0 | SOURCE | VENTILATION | SUP 13
InPort_13846672_1 | SINK | VENTILATION | ETA 3
OutPort_13846670_1 | SOURCE | VENTILATION | ETA 3
InPort_13846670_2 | SINK | VENTILATION | ETA 3
OutPort_13846867_0 | SOURCE | VENTILATION | ETA 3
InPort_14041170_2 | SINK | VENTILATION | ETA 3
OutPort_13846672_0 | SOURCE | VENTILATION | ETA 3
InPort_13846868_2 | SINK | VENTILATION | ETA 3
OutPort_13846865_1 | SOURCE | VENTILATION | ETA 3
InPort_13846865_3 | SINK | VENTILATION | ETA 3
OutPort_13847146_1 | SOURCE | VENTILATION | ETA 3
InPort_13846867_1 | SINK | VENTILATION | ETA 3
OutPort_13846868_1 | SOURCE | VENTILATION | ETA 3
InPort_13847146_2 | SINK | VENTILATION | ETA 3
OutPort_13846927_0 | SOURCE | VENTILATION | ETA 3
InPort_13846927_1 | SINK | VENTILATION | ETA 3
OutPort_13847170_2 | SOURCE | VENTILATION | ETA 3
InPort_13846941_0 | SINK | VENTILATION | ETA 3
OutPort_13847167_2 | SOURCE | VENTILATION | ETA 3
InPort_13847170_1 | SINK | VENTILATION | ETA 3
OutPort_13846941_1 | SOURCE | VENTILATION | ETA 3
InPort_13847076_0 | SINK | VENTILATION | ETA 3
OutPort_13847116_2 | SOURCE | VENTILATION | ETA 3
InPort_13847167_1 | SINK | VENTILATION | ETA 3
OutPort_13847076_1 | SOURCE | VENTILATION | ETA 3
InPort_13847116_1 | SINK | VENTILATION | ETA 3
OutPort_13863668_1 | SOURCE | VENTILATION | ETA 3
Port_13847405_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13847407_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13847407_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13874839_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13847754_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13847757_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13847809_1 | SINK | VENTILATION | SUP 18
OutPort_13847807_2 | SOURCE | VENTILATION | SUP 18
InPort_13866901_1 | SINK | VENTILATION | SUP 18
OutPort_13847809_0 | SOURCE | VENTILATION | SUP 18
InPort_13871108_0 | SINK | VENTILATION | SUP 13
OutPort_13848426_2 | SOURCE | VENTILATION | SUP 13
Port_13848457_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13848514_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13848512_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13848514_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13848717_1 | SINK | VENTILATION | SUP 24
OutPort_13848715_2 | SOURCE | VENTILATION | SUP 24
Port_13848764_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13848766_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13848825_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13848827_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13848862_1 | SINK | VENTILATION | SUP 24
OutPort_13848860_2 | SOURCE | VENTILATION | SUP 24
Port_13848914_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13848916_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13848948_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13848951_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13849901_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14147777_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13849901_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13849903_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13849950_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13876026_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13850037_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13850039_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13850051_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13850089_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13850053_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13850089_2 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13989211_2 | SINK | VENTILATION | SUP 4
OutPort_13850306_0 | SOURCE | VENTILATION | SUP 4
InPort_13850306_1 | SINK | VENTILATION | SUP 4
OutPort_13850308_0 | SOURCE | VENTILATION | SUP 4
InPort_13850308_1 | SINK | VENTILATION | SUP 4
OutPort_13963095_0 | SOURCE | VENTILATION | SUP 4
InPort_13850332_0 | SINK | VENTILATION | ETA 27
OutPort_14137900_2 | SOURCE | VENTILATION | ETA 27
InPort_14137887_2 | SINK | VENTILATION | ETA 27
OutPort_13850332_1 | SOURCE | VENTILATION | ETA 27
InPort_13850334_0 | SINK | VENTILATION | ETA 27
OutPort_14137901_0 | SOURCE | VENTILATION | ETA 27
Port_13850642_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13850769_2 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13850642_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13850772_2 | SOURCEANDSINK | VENTILATION | ETA 1
InPort_13853055_1 | SINK | VENTILATION | SUP 24
OutPort_13850984_2 | SOURCE | VENTILATION | SUP 24
InPort_13853073_1 | SINK | VENTILATION | SUP 24
OutPort_13853075_1 | SOURCE | VENTILATION | SUP 24
Port_13853494_1 | SOURCEANDSINK | VENTILATION | SUP 20
Port_13853519_0 | SOURCEANDSINK | VENTILATION | SUP 20
Port_13853494_2 | SOURCEANDSINK | VENTILATION | SUP 20
Port_13928777_0 | SOURCEANDSINK | VENTILATION | SUP 20
Port_13853517_1 | SOURCEANDSINK | VENTILATION | SUP 20
Port_14061732_0 | SOURCEANDSINK | VENTILATION | SUP 20
Port_13853517_2 | SOURCEANDSINK | VENTILATION | SUP 20
Port_13853519_1 | SOURCEANDSINK | VENTILATION | SUP 20
InPort_13853632_2 | SINK | VENTILATION | ODA 8
OutPort_13854744_0 | SOURCE | VENTILATION | ODA 8
InPort_13854334_0 | SINK | VENTILATION | ODA 8
OutPort_13855999_1 | SOURCE | VENTILATION | ODA 8
InPort_13968059_1 | SINK | VENTILATION | ODA 8
OutPort_13854334_1 | SOURCE | VENTILATION | ODA 8
InPort_13968543_2 | SINK | VENTILATION | ODA 8
OutPort_13854620_0 | SOURCE | VENTILATION | ODA 8
InPort_13854620_1 | SINK | VENTILATION | ODA 8
OutPort_14151429_1 | SOURCE | VENTILATION | ODA 8
InPort_13854744_1 | SINK | VENTILATION | ODA 8
OutPort_13854742_1 | SOURCE | VENTILATION | ODA 8
InPort_13855111_1 | SINK | EXHAUST | EHA 8
OutPort_13855116_2 | SOURCE | EXHAUST | EHA 8
InPort_14194087_1 | SINK | EXHAUST | EHA 8
OutPort_13855111_3 | SOURCE | EXHAUST | EHA 8
InPort_13855116_1 | SINK | EXHAUST | EHA 8
OutPort_13855113_1 | SOURCE | EXHAUST | EHA 8
InPort_13855466_1 | SINK | EXHAUST | EHA 10
OutPort_13855468_1 | SOURCE | EXHAUST | EHA 10
InPort_14008634_0 | SINK | EXHAUST | EHA 10
OutPort_13855466_3 | SOURCE | EXHAUST | EHA 10
InPort_13855468_0 | SINK | EXHAUST | EHA 10
InPort_13855528_1 | SINK | VENTILATION | ODA 3
OutPort_13855526_1 | SOURCE | VENTILATION | ODA 3
OutPort_13855528_0 | SOURCE | VENTILATION | ODA 3
InPort_14146297_1 | SINK | VENTILATION | ODA 3
OutPort_13855917_0 | SOURCE | VENTILATION | ODA 3
InPort_13855917_1 | SINK | VENTILATION | ODA 3
OutPort_14008423_1 | SOURCE | VENTILATION | ODA 3
InPort_13863442_0 | SINK | VENTILATION | SUP 13
OutPort_13862870_1 | SOURCE | VENTILATION | SUP 13
InPort_13862870_2 | SINK | VENTILATION
InPort_13862870_3 | SINK | VENTILATION | ETA 91
InPort_13863136_1 | SINK | VENTILATION | ODA 14
OutPort_13863132_2 | SOURCE | VENTILATION | ODA 14
InPort_13863625_1 | SINK | VENTILATION | SUP 13
OutPort_13863442_1 | SOURCE | VENTILATION | SUP 13
InPort_13863668_2 | SINK | VENTILATION | ETA 3
Port_13864021_0 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13864237_1 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13864021_1 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13865852_3 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13864192_0 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14106592_2 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13864192_1 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13864237_2 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13864334_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14061471_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13864334_1 | SOURCEANDSINK | VENTILATION | SUP 9
