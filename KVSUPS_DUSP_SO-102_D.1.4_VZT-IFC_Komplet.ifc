Properties of the parts of a building model (IFC4), part 18 of 45

# IfcBuildingElementProxy: Požární klapka hranatá.LH:500x280 (4)
Vazby - Připojení ELEKTRO: no; Připojení EPS: no; Připojení MaR: no
Fázování - Fáze vytvoření: Fáze 2
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 7; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0722396 m3; Velikost: 500 × 280-500 × 280
Jiné - Rodina: Požární klapka hranatá.LH; Id typu: 13917699; Rodina a typ: Požární klapka hranatá.LH: 500x280; Typ: 500x280
Name (Požární klapka hranatá.LH:500x280:...) | In | Podlaží | Výška od podlaží (mm) | Kód prvku | Označení
13917533 | 1.NP_SO-102 | 1.NP_SO-102 | 3028.08 | PK00.51.0301 | 0301
13917765 | 2.NP_SO-102 | 2.NP_SO-102 | 3000 | PK00.51.0302 | 0302
13917899 | 3.NP_SO-102 | 3.NP_SO-102 | 3095 | PK00.51.0303 | 0303 | Jiné - Páteřní trasa: yes
13917948 | 4.NP_SO-102 | 4.NP_SO-102 | 3060 | PK00.51.0304 | 0304

# IfcBuildingElementProxy: Požární klapka hranatá.LH:630x280, Požární klapka hranatá.LH:630x280:13817360
In: -1.PP_SO-102
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 630 mm; Jmenovitá velikost vstupu - výška: 280 mm; Jmenovitá velikost výstupu - šířka: 630 mm; Jmenovitá velikost výstupu - výška: 280 mm; Šířka: 630 mm; Šířka příruby: 30 mm; Tloušťka příruby: 5 mm; Výška: 280 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: 630x280; Označení typu: 23; Popis: Požářní klapka hranatá; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka hranatá.LH
Classification: PK00 Uniformat (Uniformat); Group: ODA 17
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.23982 m2; NetVolume: 0.0932276 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 630 mm × 280 mm-630 mm × 280 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 630 mm × 280 mm-630 mm × 280 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Připojení ELEKTRO: no; Připojení EPS: no; Připojení MaR: no; Výška od podlaží: 3000 mm
Fázování - Fáze vytvoření: Fáze 2
Mechanické - Typ systému: Čerstvý; Klasifikace systému: Přívod vzduchu; Název systému: ODA 17; Zkratka systému: ODA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0908816 m3; Velikost: 630 × 280-630 × 280
Identifikační data - Kód prvku: PK00.23.0044; Označení: 0044
Jiné - Páteřní trasa: yes; Rodina: Požární klapka hranatá.LH; Id typu: 13817343; Rodina a typ: Požární klapka hranatá.LH: 630x280; Typ: 630x280

# IfcBuildingElementProxy: Požární klapka hranatá.LH:630x500 (2)
In: -1.PP_SO-102
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 630 mm; Jmenovitá velikost vstupu - výška: 500 mm; Jmenovitá velikost výstupu - šířka: 630 mm; Jmenovitá velikost výstupu - výška: 500 mm; Šířka: 630 mm; Šířka příruby: 30 mm; Tloušťka příruby: 5 mm; Výška: 500 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: 630x500; Označení typu: 18; Popis: Požářní klapka hranatá; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka hranatá.LH
Classification: PK00 Uniformat (Uniformat); Group: ETA 7
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.96022 m2; NetVolume: 0.165564 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 630 mm × 500 mm-630 mm × 500 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 630 mm × 500 mm-630 mm × 500 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Připojení ELEKTRO: no; Připojení EPS: no; Připojení MaR: no; Výška od podlaží: 3080 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 7; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.1617 m3; Velikost: 630 × 500-630 × 500
Jiné - Páteřní trasa: yes; Rodina: Požární klapka hranatá.LH; Id typu: 13651901; Rodina a typ: Požární klapka hranatá.LH: 630x500; Typ: 630x500
Name (Požární klapka hranatá.LH:630x500:...) | Kód prvku | Označení
13810295 | PK00.18.0035 | 0035 | Mechanické – tok - Tlaková ztráta: 0 Pa
13814130 | PK00.18.0042 | 0042

# IfcBuildingElementProxy: Požární klapka hranatá.LH:710x500, Požární klapka hranatá.LH:710x500:13810018
In: -1.PP_SO-102
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 710 mm; Jmenovitá velikost vstupu - výška: 500 mm; Jmenovitá velikost výstupu - šířka: 710 mm; Jmenovitá velikost výstupu - výška: 500 mm; Šířka: 710 mm; Šířka příruby: 30 mm; Tloušťka příruby: 5 mm; Výška: 500 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: 710x500; Označení typu: 17; Popis: Požářní klapka hranatá; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka hranatá.LH
Classification: PK00 Uniformat (Uniformat); Group: ETA 7
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.48182 m2; NetVolume: 0.18646 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 710 mm × 500 mm-710 mm × 500 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 710 mm × 500 mm-710 mm × 500 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Připojení ELEKTRO: no; Připojení EPS: no; Připojení MaR: no; Výška od podlaží: 3080 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 7; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.182148 m3; Velikost: 710 × 500-710 × 500
Identifikační data - Kód prvku: PK00.17.0032; Označení: 0032
Jiné - Páteřní trasa: yes; Rodina: Požární klapka hranatá.LH; Id typu: 13809999; Rodina a typ: Požární klapka hranatá.LH: 710x500; Typ: 710x500

# IfcBuildingElementProxy: Požární klapka hranatá.LH:800x300 (2)
In: 1.NP_SO-102
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 800 mm; Jmenovitá velikost vstupu - výška: 300 mm; Jmenovitá velikost výstupu - šířka: 800 mm; Jmenovitá velikost výstupu - výška: 300 mm; Šířka: 800 mm; Šířka příruby: 30 mm; Tloušťka příruby: 5 mm; Výška: 300 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: 800x300; Označení typu: 61; Popis: Požářní klapka hranatá; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka hranatá.LH
Classification: PK00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 4.16462 m2; NetVolume: 0.126528 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 800 mm × 300 mm-800 mm × 300 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 800 mm × 300 mm-800 mm × 300 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Podlaží: 1.NP_SO-102; Připojení ELEKTRO: no; Připojení EPS: no; Připojení MaR: no; Výška od podlaží: 3200 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.123432 m3; Velikost: 800 × 300-800 × 300
Jiné - Rodina: Požární klapka hranatá.LH; Id typu: 13971393; Rodina a typ: Požární klapka hranatá.LH: 800x300; Typ: 800x300
Name (Požární klapka hranatá.LH:800x300:...) | Název systému = Group | Kód prvku | Označení
13971416 | ETA 29 | PK00.61.0364 | 0364
14068033 | ETA 6 | PK00.61.0437 | 0437 | Fázování - Bouráno ve FÁZI 2: yes

# IfcBuildingElementProxy: Požární klapka hranatá.LH:800x400 (2)
In: -1.PP_SO-102
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 800 mm; Jmenovitá velikost vstupu - výška: 400 mm; Jmenovitá velikost výstupu - šířka: 800 mm; Jmenovitá velikost výstupu - výška: 400 mm; Šířka: 800 mm; Šířka příruby: 30 mm; Tloušťka příruby: 5 mm; Výška: 400 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: 800x400; Označení typu: 13; Popis: Požářní klapka hranatá; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka hranatá.LH
Classification: PK00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 5.11662 m2; NetVolume: 0.168248 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 800 mm × 400 mm-800 mm × 400 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 800 mm × 400 mm-800 mm × 400 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Připojení ELEKTRO: no; Připojení EPS: no; Připojení MaR: no
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.164292 m3; Velikost: 800 × 400-800 × 400
Jiné - Páteřní trasa: yes; Rodina: Požární klapka hranatá.LH; Id typu: 13788765; Rodina a typ: Požární klapka hranatá.LH: 800x400; Typ: 800x400
Name (Požární klapka hranatá.LH:800x400:...) | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13788784 | 2400 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | PK00.13.0023 | 0023
13817542 | 3130 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | PK00.13.0045 | 0045

# IfcBuildingElementProxy: Požární klapka hranatá.LH:800x500 (2)
In: -1.PP_SO-102
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 800 mm; Jmenovitá velikost vstupu - výška: 500 mm; Jmenovitá velikost výstupu - šířka: 800 mm; Jmenovitá velikost výstupu - výška: 500 mm; Šířka: 800 mm; Šířka příruby: 30 mm; Tloušťka příruby: 5 mm; Výška: 500 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: 800x500; Označení typu: 06; Popis: Požářní klapka hranatá; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka hranatá.LH
Classification: PK00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.06862 m2; NetVolume: 0.209968 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 800 mm × 500 mm-800 mm × 500 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 800 mm × 500 mm-800 mm × 500 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF; Servopohon: no
Vazby - Podlaží: -1.PP_SO-102; Připojení ELEKTRO: no; Připojení EPS: no; Připojení MaR: no; Výška od podlaží: 3070 mm
Fázování - Fáze vytvoření: Fáze 2
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.205152 m3; Velikost: 800 × 500-800 × 500
Jiné - Páteřní trasa: yes; Id typu: 13650184; Rodina: Požární klapka hranatá.LH; Rodina a typ: Požární klapka hranatá.LH: 800x500; Typ: 800x500
Name (Požární klapka hranatá.LH:800x500:...) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13650201 | Odváděný | Zpětný vzduch | ETA 17 | ETA | PK00.06.0013 | 0013
13650265 | Přívodní | Přívod vzduchu | SUP 12 | SUP | PK00.06.0014 | 0014 | Mechanické – tok - Tlaková ztráta: 0 Pa

# IfcBuildingElementProxy: Požární klapka kruhová.LH:Standardní (40)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 400 mm; Jmenovitá velikost vstupu: 0 mm; Jmenovitá velikost výstupu: 0 mm; Průměr: 450 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: Standardní; Označení typu: 10; Popis: Požární klapka kruhová; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka kruhová.LH
Classification: PK00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Vazby - Připojení ELEKTRO: no; Připojení EPS: no; Připojení MaR: no
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Lgt1: 220.022 mm; Lgt2: 269.997 mm; Požární klapka, pol1: 36.5 mm
Jiné - Typ: Standardní; Id typu: 13624454; Rodina: Požární klapka kruhová.LH; Rodina a typ: Požární klapka kruhová.LH: Standardní
Name (Požární klapka kruhová.LH:Standardní:...) | In | NetSurfaceArea (m2) | NetVolume (m3) = Objem (m3) | Volná velikost | Tloušťka izolace (mm) | Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | DN (mm) = Průměr vedení (mm) | f (mm) | g (mm) | h (mm) | Poloměr potrubí (mm) = Vnější poloměr (mm) | Velikost | Kód prvku | Označení | Páteřní trasa
13742632 | -1.PP_SO-102 | 0.432543 | 0.0130017 | 200 mm-200 mm | 0 | 200 mm-200 mm | -1.PP_SO-102 | 3240 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 200 | 100 | 15 | 50 | 100 | 200-200 | PK00.10.0020 | 0020
13794995 | -1.PP_SO-102 | 0.935318 | 0.0508239 | 400 mm-400 mm | 0 | 400 mm-400 mm | -1.PP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 7 | SUP | 400 | 100 | 15 | 100 | 200 | 400-400 | PK00.10.0024 | 0024 | yes
13803588 | -1.PP_SO-102 | 0.811166 | 0.0401217 | 355 mm-355 mm | 0 | 355 mm-355 mm | -1.PP_SO-102 | 3077.14 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 355 | 100 | 15 | 88.75 | 177.5 | 355-355 | PK00.10.0025 | 0025 | yes | Mechanické – tok - Tlaková ztráta: 0 Pa
13803604 | -1.PP_SO-102 | 0.811166 | 0.0401217 | 355 mm-355 mm | 0 | 355 mm-355 mm | -1.PP_SO-102 | 3073.75 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 355 | 100 | 15 | 88.75 | 177.5 | 355-355 | PK00.10.0026 | 0026 | yes | Mechanické – tok - Tlaková ztráta: 0 Pa
13818065 | 1.NP_SO-102 | 0.546369 | 0.0201001 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-102 | 3200 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 250 | 100 | 15 | 62.5 | 125 | 250-250 | PK00.10.0046 | 0046
13818737 | 4.NP_SO-102 | 0.811166 | 0.0401217 | 355 mm-355 mm | 0 | 355 mm-355 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 355 | 100 | 15 | 88.75 | 177.5 | 355-355 | PK00.10.0047 | 0047 | yes
13819757 | 3.NP_SO-102 | 0.935318 | 0.0508239 | 400 mm-400 mm | 0 | 400 mm-400 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 400 | 100 | 15 | 100 | 200 | 400-400 | PK00.10.0048 | 0048 | yes
13820288 | 2.NP_SO-102 | 1.08069 | 0.064208 | 450 mm-450 mm | 0 | 450 mm-450 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 450 | 100 | 15 | 112.5 | 225 | 450-450 | PK00.10.0049 | 0049 | yes
13820356 | 2.NP_SO-102 | 0.811166 | 0.0401217 | 355 mm-355 mm | 0 | 355 mm-355 mm | 2.NP_SO-102 | 2940 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 355 | 100 | 15 | 88.75 | 177.5 | 355-355 | PK00.10.0050 | 0050 | yes
13820796 | 2.NP_SO-102 | 1.08069 | 0.064208 | 450 mm-450 mm | 0 | 450 mm-450 mm | 2.NP_SO-102 | 2764 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 450 | 100 | 15 | 112.5 | 225 | 450-450 | PK00.10.0054 | 0054 | yes | Mechanické – tok - Tlaková ztráta: 0 Pa
13820810 | 2.NP_SO-102 | 1.08069 | 0.064208 | 450 mm-450 mm | 0 | 450 mm-450 mm | 2.NP_SO-102 | 2764 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 450 | 100 | 15 | 112.5 | 225 | 450-450 | PK00.10.0055 | 0055 | yes | Mechanické – tok - Tlaková ztráta: 0 Pa
13847405 | 2.NP_SO-102 | 1.08069 | 0.064208 | 450 mm-450 mm | 0 | 450 mm-450 mm | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 450 | 100 | 15 | 112.5 | 225 | 450-450 | PK00.10.0111 | 0111 | yes
13847754 | 4.NP_SO-102 | 1.23395 | 0.0791623 | 500 mm-500 mm | 0 | 500 mm-500 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 500 | 100 | 15 | 125 | 250 | 500-500 | PK00.10.0112 | 0112 | yes
13847807 | 4.NP_SO-102 | 0.811166 | 0.0401217 | 355 mm-355 mm | 0 | 355 mm-355 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 355 | 100 | 15 | 88.75 | 177.5 | 355-355 | PK00.10.0113 | 0113 | yes | Mechanické – tok - Tlaková ztráta: 0 Pa
13848512 | 3.NP_SO-102 | 1.23395 | 0.0791623 | 500 mm-500 mm | 0 | 500 mm-500 mm | 3.NP_SO-102 | 3099.91 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 500 | 100 | 15 | 125 | 250 | 500-500 | PK00.10.0116 | 0116 | yes
13848764 | 4.NP_SO-102 | 1.08069 | 0.064208 | 450 mm-450 mm | 0 | 450 mm-450 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 450 | 100 | 15 | 112.5 | 225 | 450-450 | PK00.10.0118 | 0118 | yes
13848825 | 4.NP_SO-102 | 1.23395 | 0.0791623 | 500 mm-500 mm | 0 | 500 mm-500 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 500 | 100 | 15 | 125 | 250 | 500-500 | PK00.10.0119 | 0119 | yes
13848860 | 3.NP_SO-102 | 0.811166 | 0.0401217 | 355 mm-355 mm | 0 | 355 mm-355 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 355 | 100 | 15 | 88.75 | 177.5 | 355-355 | PK00.10.0120 | 0120 | yes | Mechanické – tok - Tlaková ztráta: 0 Pa
13848914 | 3.NP_SO-102 | 1.23395 | 0.0791623 | 500 mm-500 mm | 0 | 500 mm-500 mm | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 500 | 100 | 15 | 125 | 250 | 500-500 | PK00.10.0121 | 0121 | yes
13848948 | 3.NP_SO-102 | 1.42828 | 0.0991812 | 560 mm-560 mm | 0 | 560 mm-560 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 560 | 100 | 15 | 140 | 280 | 560-560 | PK00.10.0122 | 0122 | yes
13849901 | 2.NP_SO-102 | 1.08069 | 0.064208 | 450 mm-450 mm | 0 | 450 mm-450 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 450 | 100 | 15 | 112.5 | 225 | 450-450 | PK00.10.0123 | 0123 | yes
13850037 | 2.NP_SO-102 | 1.42828 | 0.0991812 | 560 mm-560 mm | 0 | 560 mm-560 mm | 2.NP_SO-102 | 3039.81 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 560 | 100 | 15 | 140 | 280 | 560-560 | PK00.10.0124 | 0124 | yes
13850051 | 2.NP_SO-102 | 1.08069 | 0.064208 | 450 mm-450 mm | 0 | 450 mm-450 mm | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 450 | 100 | 15 | 112.5 | 225 | 450-450 | PK00.10.0125 | 0125 | yes
13853517 | 1.NP_SO-102 | 0.432543 | 0.0130017 | 200 mm-200 mm | 0 | 200 mm-200 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 20 | SUP | 200 | 100 | 15 | 50 | 100 | 200-200 | PK00.10.0127 | 0127
13865528 | -1.PP_SO-102 | 0.432543 | 0.0130017 | 200 mm-200 mm | 0 | 200 mm-200 mm | -1.PP_SO-102 | 3070 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 200 | 100 | 15 | 50 | 100 | 200-200 | PK00.10.0140 | 0140 | Mechanické – tok - Tlaková ztráta: 0 Pa
13907368 | 1.NP_SO-102 | 0.706186 | 0.0316774 | 315 mm-315 mm | 15 | 345 mm-345 mm | 1.NP_SO-102 | 2650 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 315 | 100 | 15 | 78.75 | 157.5 | 315-315 | PK00.10.0277 | 0277 | yes | Mechanické – tok - Tlaková ztráta: 0 Pa; Izolace - Typ izolace: Protipožární
13911854 | 1.NP_SO-102 | 1.08069 | 0.064208 | 450 mm-450 mm | 0 | 450 mm-450 mm | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 450 | 100 | 15 | 112.5 | 225 | 450-450 | PK00.10.0295 | 0295 | yes | Mechanické – tok - Tlaková ztráta: 0 Pa
13911996 | 1.NP_SO-102 | 1.08069 | 0.064208 | 450 mm-450 mm | 0 | 450 mm-450 mm | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 450 | 100 | 15 | 112.5 | 225 | 450-450 | PK00.10.0296 | 0296 | yes
13935470 | 2.NP_SO-102 | 0.811166 | 0.0401217 | 355 mm-355 mm | 0 | 355 mm-355 mm | 2.NP_SO-102 | 2910 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 355 | 100 | 15 | 88.75 | 177.5 | 355-355 | PK00.10.0324 | 0324
13950070 | -1.PP_SO-102 | 0.546369 | 0.0201001 | 250 mm-250 mm | 0 | 250 mm-250 mm | -1.PP_SO-102 | 2700 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 250 | 100 | 15 | 62.5 | 125 | 250-250 | PK00.10.0339 | 0339
13953281 | -1.PP_SO-102 | 0.546369 | 0.0201001 | 250 mm-250 mm | 0 | 250 mm-250 mm | -1.PP_SO-102 | 2800 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 250 | 100 | 15 | 62.5 | 125 | 250-250 | PK00.10.0346 | 0346 | Mechanické – tok - Tlaková ztráta: 0 Pa
13984303 | 3.NP_SO-102 | 0.706186 | 0.0316774 | 315 mm-315 mm | 0 | 315 mm-315 mm | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 315 | 100 | 15 | 78.75 | 157.5 | 315-315 | PK00.10.0372 | 0372
13988327 | -1.PP_SO-102 | 0.811166 | 0.0401217 | 355 mm-355 mm | 0 | 355 mm-355 mm | -1.PP_SO-102 | 3150 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 18 | ETA | 355 | 100 | 15 | 88.75 | 177.5 | 355-355 | PK00.10.0377 | 0377 | yes
14008174 | -1.PP_SO-102 | 0.546369 | 0.0201001 | 250 mm-250 mm | 0 | 250 mm-250 mm | -1.PP_SO-102 | 3077.14 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 25 | SUP | 250 | 100 | 15 | 62.5 | 125 | 250-250 | PK00.10.0393 | 0393 | Mechanické – tok - Tlaková ztráta: 0 Pa
14061471 | 1.NP_SO-102 | 0.347235 | 0.00845517 | 160 mm-160 mm | 0 | 160 mm-160 mm | 1.NP_SO-102 | 3200.1 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 160 | 80 | 12 | 40 | 80 | 160-160 | PK00.10.0431 | 0431
14075614 | 1.NP_SO-102 | 0.546369 | 0.0201001 | 250 mm-250 mm | 0 | 250 mm-250 mm | 1.NP_SO-102 | 3200.01 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 250 | 100 | 15 | 62.5 | 125 | 250-250 | PK00.10.0440 | 0440
14076384 | 2.NP_SO-102 | 0.546369 | 0.0201001 | 250 mm-250 mm | 0 | 250 mm-250 mm | 2.NP_SO-102 | 2620 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 250 | 100 | 15 | 62.5 | 125 | 250-250 | PK00.10.0441 | 0441
14105796 | 1.NP_SO-102 | 1.23395 | 0.0791623 | 500 mm-500 mm | 0 | 500 mm-500 mm | 1.NP_SO-102 | 3095.01 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 500 | 100 | 15 | 125 | 250 | 500-500 | PK00.10.0450 | 0450 | yes
14108754 | -1.PP_SO-102 | 0.706186 | 0.0316774 | 315 mm-315 mm | 0 | 315 mm-315 mm | -1.PP_SO-102 | 3080 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 315 | 100 | 15 | 78.75 | 157.5 | 315-315 | PK00.10.0451 | 0451 | yes | Mechanické – tok - Tlaková ztráta: 0 Pa
14124647 | 1.NP_SO-102 | 0.706186 | 0.0316774 | 315 mm-315 mm | 0 | 315 mm-315 mm | 1.NP_SO-102 | 3150 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 315 | 100 | 15 | 78.75 | 157.5 | 315-315 | PK00.10.0455 | 0455 | yes

# IfcBuildingElementProxy: Požární klapka kruhová.LH:Standardní (6)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 400 mm; Jmenovitá velikost vstupu: 0 mm; Jmenovitá velikost výstupu: 0 mm; Průměr: 450 mm
Type - Identifikační data - ID kategorie: PK; Kód sestavy: PK00; Název typu: Standardní; Označení typu: 10; Popis: Požární klapka kruhová; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Příslušenství potrubí; Název rodiny: Požární klapka kruhová.LH
Classification: PK00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Elektroinstalace – zatížení - Napájecí napětí: 0 V
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Vazby - Připojení ELEKTRO: no; Připojení EPS: no; Připojení MaR: no
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Lgt1: 220.022 mm; Lgt2: 269.997 mm; Požární klapka, pol1: 36.5 mm
Jiné - Typ: Standardní; Id typu: 13624454; Rodina: Požární klapka kruhová.LH; Rodina a typ: Požární klapka kruhová.LH: Standardní
Name (Požární klapka kruhová.LH:Standardní:...) | In | NetSurfaceArea (m2) | NetVolume (m3) = Objem (m3) | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | DN (mm) = Průměr vedení (mm) | f (mm) | g (mm) | h (mm) | Poloměr potrubí (mm) = Vnější poloměr (mm) | Velikost | Kód prvku | Označení
13810138 | -1.PP_SO-102 | 0.488462 | 0.0163544 | 225 mm-225 mm | -1.PP_SO-102 | 3160 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 8 | ETA | 225 | 100 | 15 | 56.25 | 112.5 | 225-225 | PK00.10.0033 | 0033 | Jiné - Páteřní trasa: yes
13848715 | 4.NP_SO-102 | 0.488462 | 0.0163544 | 225 mm-225 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 225 | 100 | 15 | 56.25 | 112.5 | 225-225 | PK00.10.0117 | 0117
14008190 | -1.PP_SO-102 | 0.389246 | 0.0106026 | 180 mm-180 mm | -1.PP_SO-102 | 3071.86 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 180 | 90 | 13.5 | 45 | 90 | 180-180 | PK00.10.0394 | 0394
14049977 | 2.NP_SO-102 | 0.488462 | 0.0163544 | 225 mm-225 mm | 2.NP_SO-102 | 3010 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 225 | 100 | 15 | 56.25 | 112.5 | 225-225 | PK00.10.0414 | 0414
14050347 | 2.NP_SO-102 | 0.488462 | 0.0163544 | 225 mm-225 mm | 2.NP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 225 | 100 | 15 | 56.25 | 112.5 | 225-225 | PK00.10.0415 | 0415
14068086 | 1.NP_SO-102 | 0.389246 | 0.0106026 | 180 mm-180 mm | 1.NP_SO-102 | 3150 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 180 | 90 | 13.5 | 45 | 90 | 180-180 | PK00.10.0438 | 0438

# IfcBuildingElementProxy: Požární ventilátor:Požární ventilátor (5)
In: 4.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Mechanické - Klasifikace: Žádné
Type - Kóty - DÉLKA: 1495 mm; POTRUBÍ_ŠÍŘKA: 800 mm; POTRUBÍ_ŠÍŘKA 2: 630 mm; POTRUBÍ_VÝŠKA: 800 mm; POTRUBÍ_VÝŠKA 2: 630 mm; ŠÍŘKA: 1414 mm; VÝŠKA: 1051 mm
Type - Identifikační data - Cena: 0; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: VN02; Komentáře k typům: Požární radiální ventilátory; Název typu: Požární ventilátor; Označení typu: 09; Popis: Ventilátor; Popis sestavy: Radiální
Type - Jiné - Kategorie: Mechanické zařízení; HV: yes; Název rodiny: Požární ventilátor; Symbol: 1495 mm
Classification: VN02 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 10.3426 m2; NetVolume: 2.22174 m3
Mechanické – tok - PRŮTOK: 0 m3/s
Text - CCI Funkční systém: J; CCI Komponenta: MAA; CCI Technický systém: HF
Vazby - Hostitel: Podlaží : STŘECHA_SO-102; Podlaží: STŘECHA_SO-102
Mechanické - Klasifikace systému: Přívod vzduchu
Kóty - Objem: 2.22174 m3
Jiné - Páteřní trasa: yes; HVD: 747.5 mm; HVU: 90 deg; Id typu: 13800227; Rodina: Požární ventilátor; Rodina a typ: Požární ventilátor: Požární ventilátor; Typ: Požární ventilátor
Name (Požární ventilátor:Požární ventilátor:...) | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Fáze vytvoření | Název systému | Kód prvku | Komentáře | Označení | Group
13800247 | 1250 | Fáze 1 | ODA 12 | VN02.09.0009 | VZT č.29 Přívodní ventilátor CHÚC Vo=15400 m3/h dp=500 Pa P=4,0 kW | 0009 | ODA 12
13801707 | 1475.5 | Fáze 2 | ODA 21 | VN02.09.0010 | VZT č.31 Přívodní ventilátor CHÚC Vo=10600 m3/h dp=500 Pa P=2,7 kW | 0010 | ODA 21
13802202 | 1000 | Fáze 1 | ODA 10,ODA 4 | VN02.09.0011 | VZT č.30 Přívodní ventilátor CHÚC Vo=10300 m3/h dp=500 Pa P=2,6 kW | 0011 | ODA 10; ODA 4
13802895 | 1050 | Fáze 1 | EHA 3,ODA 23 | VN02.09.0012 | VZT č.27 Odvodní ventilátor Vo=1500 m3/h dp=200 Pa P=0,2 kW | 0012 | EHA 3; ODA 23
14003027 | 1240 | Fáze 1 | ODA 25 | VN02.09.0014 | VZT č.32 Přívodní ventilátor CHÚC Vo=5000 m3/h dp=500 Pa P=1,1 kW | 0014 | ODA 25 | Fázování - Bouráno ve FÁZI 2: yes

# IfcBuildingElementProxy: Regulátor průtoku vzduchu hranatý.LH:1120x315 (2)
In: 2.NP_SO-102
Type - Material: 0-0-255
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 1120 mm; Jmenovitá velikost vstupu - výška: 315 mm; Jmenovitá velikost výstupu - šířka: 1120 mm; Jmenovitá velikost výstupu - výška: 315 mm; Šířka: 1120 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 315 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 1120x315; Označení typu: 52; Popis: Regulátor průtoku hranatý; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu hranatý.LH
Classification: RG04 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.8795 m2; NetVolume: 0.180671 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1120 mm × 315 mm-1120 mm × 315 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1120 mm × 315 mm-1120 mm × 315 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Připojení ELEKTRO: no; Připojení MaR: no
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.180671 m3; Plocha: 2.04575 m2; Velikost: 1120 × 315-1120 × 315
Jiné - Páteřní trasa: yes; Id typu: 13934259; Rodina: Regulátor průtoku vzduchu hranatý.LH; Rodina a typ: Regulátor průtoku vzduchu hranatý.LH: 1120x315; Typ: 1120x315
Name (Regulátor průtoku vzduchu hranatý.LH:1120x315:...) | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13934313 | 2880 | Přívodní | Přívod vzduchu | SUP 9 | SUP | RG04.52.0320 | 0320
13935388 | 2920 | Odváděný | Zpětný vzduch | ETA 14 | ETA | RG04.52.0323 | 0323

# IfcBuildingElementProxy: Regulátor průtoku vzduchu hranatý.LH:1250x560, Regulátor průtoku vzduchu hranatý.LH:1250x560:14041170
In: 2.NP_SO-102
Type - Material: 255-0-0
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 1250 mm; Jmenovitá velikost vstupu - výška: 560 mm; Jmenovitá velikost výstupu - šířka: 1250 mm; Jmenovitá velikost výstupu - výška: 560 mm; Šířka: 1250 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 560 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 1250x560; Označení typu: 65; Popis: Regulátor průtoku hranatý; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu hranatý.LH
Classification: RG04 Uniformat (Uniformat); Group: ETA 3
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 6.4202 m2; NetVolume: 0.35793 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 1250 mm × 560 mm-1250 mm × 560 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 1250 mm × 560 mm-1250 mm × 560 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Připojení ELEKTRO: no; Připojení MaR: no; Výška od podlaží: 2800 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 3; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.35793 m3; Plocha: 3.3265 m2; Velikost: 1250 × 560-1250 × 560
Identifikační data - Kód prvku: RG04.65.0412; Označení: 0412
Jiné - Páteřní trasa: yes; Typ: 1250x560; Rodina: Regulátor průtoku vzduchu hranatý.LH; Id typu: 14041125; Rodina a typ: Regulátor průtoku vzduchu hranatý.LH: 1250x560

# IfcBuildingElementProxy: Regulátor průtoku vzduchu hranatý.LH:500x225 (2)
In: 2.NP_SO-102
Type - Material: 255-0-0
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 500 mm; Jmenovitá velikost vstupu - výška: 225 mm; Jmenovitá velikost výstupu - šířka: 500 mm; Jmenovitá velikost výstupu - výška: 225 mm; Šířka: 500 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 225 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 500x225; Označení typu: 62; Popis: Regulátor průtoku hranatý; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu hranatý.LH
Classification: RG04 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 1.5715 m2; NetVolume: 0.0577625 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 500 mm × 225 mm-500 mm × 225 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 500 mm × 225 mm-500 mm × 225 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Připojení ELEKTRO: no; Připojení MaR: no
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0577625 m3; Plocha: 0.84215 m2; Velikost: 500 × 225-500 × 225
Jiné - Páteřní trasa: yes; Rodina: Regulátor průtoku vzduchu hranatý.LH; Id typu: 14033145; Rodina a typ: Regulátor průtoku vzduchu hranatý.LH: 500x225; Typ: 500x225
Name (Regulátor průtoku vzduchu hranatý.LH:500x225:...) | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
14033241 | 2925 | Odváděný | Zpětný vzduch | ETA 14 | ETA | RG04.62.0401 | 0401
14037972 | 2880 | Přívodní | Přívod vzduchu | SUP 9 | SUP | RG04.62.0407 | 0407

# IfcBuildingElementProxy: Regulátor průtoku vzduchu hranatý.LH:630x500, Regulátor průtoku vzduchu hranatý.LH:630x500:13959763
In: -1.PP_SO-102
Type - Material: 255-0-0
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 630 mm; Jmenovitá velikost vstupu - výška: 500 mm; Jmenovitá velikost výstupu - šířka: 630 mm; Jmenovitá velikost výstupu - výška: 500 mm; Šířka: 630 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 500 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 630x500; Označení typu: 57; Popis: Regulátor průtoku hranatý; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu hranatý.LH
Classification: RG04 Uniformat (Uniformat); Group: ETA 7
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.2806 m2; NetVolume: 0.16124 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 630 mm × 500 mm-630 mm × 500 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 630 mm × 500 mm-630 mm × 500 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Připojení ELEKTRO: no; Připojení MaR: no; Výška od podlaží: 3080 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 7; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.16124 m3; Plocha: 1.7071 m2; Velikost: 630 × 500-630 × 500
Identifikační data - Kód prvku: RG04.57.0351; Označení: 0351
Jiné - Páteřní trasa: yes; Typ: 630x500; Rodina: Regulátor průtoku vzduchu hranatý.LH; Id typu: 13959717; Rodina a typ: Regulátor průtoku vzduchu hranatý.LH: 630x500

# IfcBuildingElementProxy: Regulátor průtoku vzduchu hranatý.LH:710x400, Regulátor průtoku vzduchu hranatý.LH:710x400:13959961
In: -1.PP_SO-102
Type - Material: 255-0-0
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu - šířka: 710 mm; Jmenovitá velikost vstupu - výška: 400 mm; Jmenovitá velikost výstupu - šířka: 710 mm; Jmenovitá velikost výstupu - výška: 400 mm; Šířka: 710 mm; Šířka příruby: 25 mm; Tloušťka příruby: 5 mm; Výška: 400 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 710x400; Označení typu: 59; Popis: Regulátor průtoku hranatý; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu hranatý.LH
Classification: RG04 Uniformat (Uniformat); Group: ETA 7
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 3.0702 m2; NetVolume: 0.14542 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 710 mm × 400 mm-710 mm × 400 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 710 mm × 400 mm-710 mm × 400 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Podlaží: -1.PP_SO-102; Připojení ELEKTRO: no; Připojení MaR: no; Výška od podlaží: 2500 mm
Fázování - Fáze vytvoření: Fáze 2
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Název systému: ETA 7; Zkratka systému: ETA
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.14542 m3; Plocha: 1.6083 m2; Velikost: 710 × 400-710 × 400
Identifikační data - Kód prvku: RG04.59.0354; Označení: 0354
Jiné - Rodina: Regulátor průtoku vzduchu hranatý.LH; Id typu: 13960215; Rodina a typ: Regulátor průtoku vzduchu hranatý.LH: 710x400; Typ: 710x400

# IfcBuildingElementProxy: Regulátor průtoku vzduchu kruhový.LH:125x500 (2)
Type - Material: 0-0-255
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu: 125 mm; Jmenovitá velikost výstupu: 125 mm; Průměr: 125 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 125x500; Označení typu: 50; Popis: Regulátor průtoku kruhový; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu kruhový.LH
Classification: RG04 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.22089 m2; NetVolume: 0.00613563 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 125 mm-125 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 125 mm-125 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Připojení ELEKTRO: no; Připojení MaR: no
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.00613563 m3; Plocha: 0.136845 m2; Velikost: 125-125
Jiné - Rodina: Regulátor průtoku vzduchu kruhový.LH; Id typu: 13622358; Rodina a typ: Regulátor průtoku vzduchu kruhový.LH: 125x500; Typ: 125x500
Name (Regulátor průtoku vzduchu kruhový.LH:125x500:...) | In | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13911165 | 1.NP_SO-102 | 1.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.50.0290 | 0290 | Jiné - Páteřní trasa: yes
14113506 | -1.PP_SO-102 | -1.PP_SO-102 | 2600 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | RG04.50.0453 | 0453

# IfcBuildingElementProxy: Regulátor průtoku vzduchu kruhový.LH:160x500 (24)
Type - Material: 0-0-255
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu: 160 mm; Jmenovitá velikost výstupu: 160 mm; Průměr: 160 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 160x500; Označení typu: 38; Popis: Regulátor průtoku kruhový; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu kruhový.LH
Classification: RG04 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.291534 m2; NetVolume: 0.0100526 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 160 mm-160 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 160 mm-160 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Připojení ELEKTRO: no; Připojení MaR: no
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0100526 m3; Plocha: 0.174967 m2; Velikost: 160-160
Jiné - Id typu: 13866723; Rodina: Regulátor průtoku vzduchu kruhový.LH; Rodina a typ: Regulátor průtoku vzduchu kruhový.LH: 160x500; Typ: 160x500
Name (Regulátor průtoku vzduchu kruhový.LH:160x500:...) | In | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13866687 | 4.NP_SO-102 | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | RG04.38.0141 | 0141
13868090 | 4.NP_SO-102 | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.38.0155 | 0155
13869296 | 4.NP_SO-102 | 4.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 41 | SUP | RG04.38.0164 | 0164
13871402 | 3.NP_SO-102 | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | RG04.38.0182 | 0182
13877783 | 2.NP_SO-102 | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.38.0222 | 0222 | Jiné - Páteřní trasa: yes
13878010 | 2.NP_SO-102 | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | RG04.38.0226 | 0226
13885815 | 3.NP_SO-102 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.38.0268 | 0268 | Jiné - Páteřní trasa: yes
13908796 | 1.NP_SO-102 | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | RG04.38.0281 | 0281
13911063 | 1.NP_SO-102 | 1.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.38.0288 | 0288
13911566 | 1.NP_SO-102 | 1.NP_SO-102 | 2820 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 9 | ETA | RG04.38.0291 | 0291
13926566 | 1.NP_SO-102 | 1.NP_SO-102 | 2895 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.38.0307 | 0307
13926588 | 1.NP_SO-102 | 1.NP_SO-102 | 2895 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.38.0308 | 0308
13926664 | 1.NP_SO-102 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 35 | SUP | RG04.38.0309 | 0309
13927092 | 1.NP_SO-102 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.38.0312 | 0312
13991580 | 3.NP_SO-102 | 3.NP_SO-102 | 3099.91 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | RG04.38.0382 | 0382
13991679 | 3.NP_SO-102 | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | RG04.38.0383 | 0383
14059093 | -1.PP_SO-102 | -1.PP_SO-102 | 2430 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.38.0427 | 0427
14064236 | 1.NP_SO-102 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.38.0433 | 0433
14064763 | 1.NP_SO-102 | 1.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.38.0435 | 0435
14078602 | 1.NP_SO-102 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.38.0444 | 0444
14079186 | 1.NP_SO-102 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.38.0447 | 0447
14110114 | -1.PP_SO-102 | -1.PP_SO-102 | 3150 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 22 | ETA | RG04.38.0452 | 0452
14137981 | -1.PP_SO-102 | -1.PP_SO-102 | 3050 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 15 | ETA | RG04.38.0456 | 0456
14139186 | -1.PP_SO-102 | -1.PP_SO-102 | 2550 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | RG04.38.0459 | 0459

# IfcBuildingElementProxy: Regulátor průtoku vzduchu kruhový.LH:180x500 (11)
Type - Material: 0-0-255
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu: 180 mm; Jmenovitá velikost výstupu: 180 mm; Průměr: 180 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 180x500; Označení typu: 41; Popis: Regulátor průtoku kruhový; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu kruhový.LH
Classification: RG04 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.33363 m2; NetVolume: 0.0127228 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 180 mm-180 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 180 mm-180 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Připojení ELEKTRO: no; Připojení MaR: no
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0127228 m3; Plocha: 0.197615 m2; Velikost: 180-180
Jiné - Rodina: Regulátor průtoku vzduchu kruhový.LH; Id typu: 13866605; Rodina a typ: Regulátor průtoku vzduchu kruhový.LH: 180x500; Typ: 180x500
Name (Regulátor průtoku vzduchu kruhový.LH:180x500:...) | In | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13867208 | 4.NP_SO-102 | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | RG04.41.0144 | 0144 | Jiné - Páteřní trasa: yes
13867712 | 4.NP_SO-102 | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.41.0151 | 0151 | Jiné - Páteřní trasa: yes
13868178 | 4.NP_SO-102 | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 3 | SUP | RG04.41.0156 | 0156 | Jiné - Páteřní trasa: yes
13868419 | 4.NP_SO-102 | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 36 | SUP | RG04.41.0158 | 0158
13868787 | 4.NP_SO-102 | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 38 | SUP | RG04.41.0161 | 0161
13868915 | 4.NP_SO-102 | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.41.0163 | 0163
13878151 | 2.NP_SO-102 | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | RG04.41.0228 | 0228
13886499 | 3.NP_SO-102 | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | RG04.41.0271 | 0271
13928574 | 1.NP_SO-102 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 8 | SUP | RG04.41.0313 | 0313
13929040 | 1.NP_SO-102 | 1.NP_SO-102 | 3150 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | RG04.41.0316 | 0316 | Jiné - Páteřní trasa: yes
13988603 | -1.PP_SO-102 | -1.PP_SO-102 | 3071.41 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | RG04.41.0378 | 0378

# IfcBuildingElementProxy: Regulátor průtoku vzduchu kruhový.LH:200x500 (19)
Type - Material: 0-0-255
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu: 200 mm; Jmenovitá velikost výstupu: 200 mm; Průměr: 200 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.75.70.11.14.21; ID kategorie: RP; Kód sestavy: RG04; Nadpis OmniClass: Guide Vanes; Název typu: 200x500; Označení typu: 43; Popis: Regulátor průtoku kruhový; Popis sestavy: Průtoku
Type - Jiné - Kategorie: Příslušenství potrubí; Celková hladina akustického tlaku A (dB): 0; Hladina akustického tlaku A 1000 Hz (dB): 0; Hladina akustického tlaku A 125 Hz (dB): 0; Hladina akustického tlaku A 2000 Hz (dB): 0; Hladina akustického tlaku A 250 Hz (dB): 0; Hladina akustického tlaku A 32 Hz (dB): 0; Hladina akustického tlaku A 4000 Hz (dB): 0; Hladina akustického tlaku A 500 Hz (dB): 0; Hladina akustického tlaku A 63 Hz (dB): 0; Hladina akustického tlaku A 8000 Hz (dB): 0; Název rodiny: Regulátor průtoku vzduchu kruhový.LH
Classification: RG04 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.376983 m2; NetVolume: 0.0157072 m3
Výstelka - Tloušťka výstelky: 0 mm; Volná velikost: 200 mm-200 mm
Izolace - Tloušťka izolace: 0 mm; Celková velikost: 200 mm-200 mm
Mechanické – tok - Doplňková tlaková ztráta: 0 Pa; Průtok vzduchu: 0 m3/s; Tlaková ztráta: 0 Pa
Text - Servopohon: no; CCI Funkční systém: J; CCI Komponenta: RNB; CCI Technický systém: HF
Vazby - Připojení ELEKTRO: no; Připojení MaR: no
Grafika - Použít měřítko poznámky: yes; Servisní prostor: no
Kóty - Levá rezerva pro servis: 0 mm; Pravá rezerva pro servis: 0 mm; Přední rezerva pro servis: 0 mm; Spodní rezerva pro servis: 0 mm; Vrchní rezerva pro servis: 0 mm; Zadní rezerva pro servis: 0 mm; Objem: 0.0157072 m3; Plocha: 0.220891 m2; Velikost: 200-200
Jiné - Rodina: Regulátor průtoku vzduchu kruhový.LH; Id typu: 13866550; Rodina a typ: Regulátor průtoku vzduchu kruhový.LH: 200x500; Typ: 200x500
Name (Regulátor průtoku vzduchu kruhový.LH:200x500:...) | In | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Kód prvku | Označení
13867370 | 4.NP_SO-102 | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | RG04.43.0147 | 0147
13867500 | 4.NP_SO-102 | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | RG04.43.0148 | 0148
13868040 | 4.NP_SO-102 | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.43.0154 | 0154 | Jiné - Páteřní trasa: yes
13870809 | 3.NP_SO-102 | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | RG04.43.0177 | 0177
13871546 | 3.NP_SO-102 | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | RG04.43.0183 | 0183
13876012 | 2.NP_SO-102 | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 49 | SUP | RG04.43.0209 | 0209 | Jiné - Páteřní trasa: yes
13876092 | 2.NP_SO-102 | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 46 | SUP | RG04.43.0210 | 0210
13876142 | 2.NP_SO-102 | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 47 | SUP | RG04.43.0211 | 0211
13876808 | 2.NP_SO-102 | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | RG04.43.0214 | 0214
13884908 | 3.NP_SO-102 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | RG04.43.0255 | 0255 | Jiné - Páteřní trasa: yes
13886709 | 3.NP_SO-102 | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | RG04.43.0272 | 0272
13935524 | 2.NP_SO-102 | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | RG04.43.0325 | 0325
13935929 | 2.NP_SO-102 | 2.NP_SO-102 | 2700 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 13 | ETA | RG04.43.0329 | 0329
13960004 | -1.PP_SO-102 | -1.PP_SO-102 | 2600 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | RG04.43.0355 | 0355
13960151 | -1.PP_SO-102 | -1.PP_SO-102 | 3240 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | RG04.43.0357 | 0357
13981795 | 4.NP_SO-102 | 4.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 28 | SUP | RG04.43.0369 | 0369
13984574 | 3.NP_SO-102 | 3.NP_SO-102 | 3099.91 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | RG04.43.0373 | 0373
13984657 | 3.NP_SO-102 | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | RG04.43.0374 | 0374
14138904 | -1.PP_SO-102 | -1.PP_SO-102 | 2404.86 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 1 | ETA | RG04.43.0458 | 0458 | Jiné - Páteřní trasa: yes

# IfcBuildingElementProxy: Regulátor průtoku vzduchu kruhový.LH:225x500 (12)
Type - Material: 0-0-255
Type - Mechanické – tok - Průtok vzduchu maximální: 0 m3/s; Průtok vzduchu minimální: 0 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Délka: 500 mm; Jmenovitá velikost vstupu: 225 mm; Jmenovitá velikost výstupu: 225 mm; Průměr: 225 mm
