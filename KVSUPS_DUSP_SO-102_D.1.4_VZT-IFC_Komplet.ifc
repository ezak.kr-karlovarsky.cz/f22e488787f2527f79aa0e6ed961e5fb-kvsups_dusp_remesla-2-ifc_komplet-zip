Properties of the parts of a building model (IFC4), part 27 of 45

# IfcDistributionPort (8507)
Name | FlowDirection | SystemType | Group
InPort_13994001_3 | SINK | VENTILATION | ETA 17
OutPort_13994092_1 | SOURCE | VENTILATION | ETA 17
InPort_13994001_4 | SINK | VENTILATION | ETA 17
OutPort_13994179_1 | SOURCE | VENTILATION | ETA 17
InPort_14165648_3 | SINK | VENTILATION | ETA 11
OutPort_13995779_1 | SOURCE | VENTILATION | ETA 11
Port_13996296_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13996538_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13996296_1 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_13996296_2 | SINK | VENTILATION | ETA 14
OutPort_13996428_1 | SOURCE | VENTILATION | ETA 14
InPort_13996296_3 | SINK | VENTILATION | ETA 14
OutPort_14035477_1 | SOURCE | VENTILATION | ETA 14
Port_13996538_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13996574_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13996574_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14035397_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13997247_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14034625_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13997263_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14034625_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13997263_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13997310_1 | SINK | VENTILATION | SUP 9
OutPort_13997263_2 | SOURCE | VENTILATION | SUP 9
Port_13997667_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13998158_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13997667_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13997961_1 | SINK | VENTILATION | SUP 9
OutPort_13997667_4 | SOURCE | VENTILATION | SUP 9
Port_13997695_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13998136_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13997695_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13997791_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13997695_3 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13998665_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13997720_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13997791_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13997720_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13997885_1 | SINK | VENTILATION | SUP 9
OutPort_13997720_2 | SOURCE | VENTILATION | SUP 9
InPort_13997907_1 | SINK | VENTILATION | SUP 9
OutPort_13998136_3 | SOURCE | VENTILATION | SUP 9
InPort_13997933_1 | SINK | VENTILATION | SUP 9
OutPort_13998136_2 | SOURCE | VENTILATION | SUP 9
Port_13998136_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13998158_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13998627_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13998665_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13999002_0 | SINK | VENTILATION | ETA 14
OutPort_14055194_2 | SOURCE | VENTILATION | ETA 14
OutPort_13999002_1 | SOURCE | VENTILATION | ETA 14
InPort_13999002_2 | SINK | VENTILATION | ETA 14
OutPort_13999062_1 | SOURCE | VENTILATION | ETA 14
InPort_13999002_3 | SINK | VENTILATION | ETA 14
OutPort_13999083_1 | SOURCE | VENTILATION | ETA 14
InPort_13999413_0 | SINK | VENTILATION | ETA 14
OutPort_14055303_2 | SOURCE | VENTILATION | ETA 14
InPort_14000917_2 | SINK | VENTILATION | ETA 14
OutPort_13999413_1 | SOURCE | VENTILATION | ETA 14
Port_13999665_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13999716_2 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_13999665_2 | SINK | VENTILATION | ETA 14
OutPort_13999816_1 | SOURCE | VENTILATION | ETA 14
InPort_13999665_3 | SINK | VENTILATION | ETA 14
OutPort_13999841_1 | SOURCE | VENTILATION | ETA 14
InPort_14000913_1 | SINK | VENTILATION | ETA 14
OutPort_14000399_0 | SOURCE | VENTILATION | ETA 14
InPort_14000399_1 | SINK | VENTILATION | ETA 14
OutPort_14000446_2 | SOURCE | VENTILATION | ETA 14
InPort_14000446_1 | SINK | VENTILATION | ETA 14
OutPort_14000438_0 | SOURCE | VENTILATION | ETA 14
InPort_14000438_1 | SINK | VENTILATION | ETA 14
OutPort_14049526_2 | SOURCE | VENTILATION | ETA 14
InPort_14055669_2 | SINK | VENTILATION | SUP 9
OutPort_14000526_0 | SOURCE | VENTILATION | SUP 9
InPort_14000526_1 | SINK | VENTILATION | SUP 9
OutPort_14000530_1 | SOURCE | VENTILATION | SUP 9
InPort_14000530_2 | SINK | VENTILATION | SUP 9
OutPort_14000528_0 | SOURCE | VENTILATION | SUP 9
InPort_14000528_1 | SINK | VENTILATION | SUP 9
OutPort_14000586_2 | SOURCE | VENTILATION | SUP 9
InPort_14050347_1 | SINK | VENTILATION | SUP 9
OutPort_14000578_0 | SOURCE | VENTILATION | SUP 9
InPort_14000578_1 | SINK | VENTILATION | SUP 9
OutPort_14051966_2 | SOURCE | VENTILATION | SUP 9
InPort_14000586_1 | SINK | VENTILATION | SUP 9
OutPort_14050349_0 | SOURCE | VENTILATION | SUP 9
InPort_14000640_0 | SINK | VENTILATION | SUP 9
OutPort_14055669_3 | SOURCE | VENTILATION | SUP 9
InPort_14000662_1 | SINK | VENTILATION | SUP 9
OutPort_14000640_1 | SOURCE | VENTILATION | SUP 9
InPort_14055255_1 | SINK | VENTILATION | SUP 9
OutPort_14000640_2 | SOURCE | VENTILATION | SUP 9
InPort_14055304_0 | SINK | VENTILATION | ETA 14
OutPort_14000913_2 | SOURCE | VENTILATION | ETA 14
InPort_14055131_0 | SINK | VENTILATION | ETA 14
OutPort_14000917_1 | SOURCE | VENTILATION | ETA 14
InPort_14065182_0 | SINK | VENTILATION | ETA 17
OutPort_14001172_1 | SOURCE | VENTILATION | ETA 17
Port_14001799_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14135894_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14001799_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14135907_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14002961_1 | SOURCEANDSINK | VENTILATION | ODA 10
Port_14002963_2 | SOURCEANDSINK | VENTILATION | ODA 10
Port_14002965_1 | SOURCEANDSINK | VENTILATION | ODA 10
Port_14002967_1 | SOURCEANDSINK | VENTILATION | ODA 10
Port_14003000_1 | SOURCEANDSINK | VENTILATION | ODA 10
Port_14003002_2 | SOURCEANDSINK | VENTILATION | ODA 10
InPort_14152109_1 | SINK | VENTILATION | ODA 25
OutPort_14003027_1 | SOURCE | VENTILATION | ODA 25
InPort_14003027_2 | SINK | VENTILATION | ODA 25
OutPort_14156070_1 | SOURCE | VENTILATION | ODA 25
InPort_14156070_2 | SINK | VENTILATION | ODA 25
OutPort_14003030_0 | SOURCE | VENTILATION | ODA 25
InPort_14003030_1 | SINK | VENTILATION | ODA 25
OutPort_14003230_1 | SOURCE | VENTILATION | ODA 25
Port_14003615_0 | SOURCEANDSINK | VENTILATION | SUP 5
Port_14065154_2 | SOURCEANDSINK | VENTILATION | SUP 5
Port_14003615_1 | SOURCEANDSINK | VENTILATION | SUP 5
InPort_14003738_1 | SINK | VENTILATION | SUP 5
OutPort_14003615_2 | SOURCE | VENTILATION | SUP 5
InPort_14003833_0 | SINK | VENTILATION | ETA 17
OutPort_14003829_1 | SOURCE | VENTILATION | ETA 17
InPort_14004377_0 | SINK | VENTILATION | SUP 5
OutPort_14116223_1 | SOURCE | VENTILATION | SUP 5
InPort_14186831_1 | SINK | VENTILATION | SUP 5
OutPort_14004377_1 | SOURCE | VENTILATION | SUP 5
InPort_14004379_1 | SINK | VENTILATION | SUP 5
OutPort_14186834_2 | SOURCE | VENTILATION | SUP 5
InPort_14004712_0 | SINK | VENTILATION | SUP 5
OutPort_14004720_2 | SOURCE | VENTILATION | SUP 5
InPort_14004731_2 | SINK | VENTILATION | SUP 5
OutPort_14004712_1 | SOURCE | VENTILATION | SUP 5
InPort_14004720_1 | SINK | VENTILATION | SUP 5
OutPort_14186834_0 | SOURCE | VENTILATION | SUP 5
InPort_14004723_0 | SINK | VENTILATION | SUP 5
OutPort_14004731_1 | SOURCE | VENTILATION | SUP 5
InPort_14115229_1 | SINK | VENTILATION | SUP 5
OutPort_14004723_1 | SOURCE | VENTILATION | SUP 5
InPort_14004785_1 | SINK | VENTILATION | SUP 5
OutPort_14115229_0 | SOURCE | VENTILATION | SUP 5
InPort_14004907_2 | SINK | VENTILATION | ETA 17
OutPort_14004898_0 | SOURCE | VENTILATION | ETA 17
InPort_14004898_1 | SINK | VENTILATION | ETA 17
OutPort_14004944_1 | SOURCE | VENTILATION | ETA 17
InPort_14004944_0 | SINK | VENTILATION | ETA 17
OutPort_14004942_1 | SOURCE | VENTILATION | ETA 17
InPort_14005091_2 | SINK | VENTILATION | ETA 17
OutPort_14005085_0 | SOURCE | VENTILATION | ETA 17
InPort_14005085_1 | SINK | VENTILATION | ETA 17
OutPort_14005140_1 | SOURCE | VENTILATION | ETA 17
InPort_14005140_0 | SINK | VENTILATION | ETA 17
OutPort_14005138_1 | SOURCE | VENTILATION | ETA 17
Port_14006291_1 | SOURCEANDSINK | VENTILATION | SUP 5
Port_14121850_1 | SOURCEANDSINK | VENTILATION | SUP 5
InPort_14006398_0 | SINK | VENTILATION | SUP 5
OutPort_14136036_2 | SOURCE | VENTILATION | SUP 5
InPort_14136386_1 | SINK | VENTILATION | SUP 5
OutPort_14006398_1 | SOURCE | VENTILATION | SUP 5
InPort_14006745_0 | SINK | VENTILATION | SUP 5
OutPort_14006950_2 | SOURCE | VENTILATION | SUP 5
InPort_14135982_1 | SINK | VENTILATION | SUP 5
OutPort_14006745_1 | SOURCE | VENTILATION | SUP 5
Port_14006810_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14006812_1 | SOURCEANDSINK | VENTILATION | ETA 17
InPort_14116782_0 | SINK | VENTILATION | SUP 12
OutPort_14006836_2 | SOURCE | VENTILATION | SUP 12
InPort_14006950_1 | SINK | VENTILATION | SUP 5
OutPort_14116783_0 | SOURCE | VENTILATION | SUP 5
InPort_14007117_1 | SINK | VENTILATION | SUP 5
OutPort_14116783_2 | SOURCE | VENTILATION | SUP 5
Port_14007234_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14007249_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14007234_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14007258_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14007246_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14007247_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14007246_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14007249_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14007253_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14007258_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14007253_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14116565_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14007378_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14116565_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14007378_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14116569_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14007721_2 | SOURCEANDSINK | VENTILATION | SUP 25
Port_14007735_0 | SOURCEANDSINK | VENTILATION | SUP 25
InPort_14007721_3 | SINK | VENTILATION | SUP 25
OutPort_14008176_0 | SOURCE | VENTILATION | SUP 25
Port_14007735_1 | SOURCEANDSINK | VENTILATION | SUP 25
InPort_14007963_1 | SINK | VENTILATION | SUP 25
OutPort_14007735_2 | SOURCE | VENTILATION | SUP 25
InPort_14008176_1 | SINK | VENTILATION | SUP 25
OutPort_14008174_2 | SOURCE | VENTILATION | SUP 25
InPort_14008190_2 | SINK | VENTILATION | ETA 27
OutPort_14008193_1 | SOURCE | VENTILATION | ETA 27
InPort_14008193_0 | SINK | VENTILATION | ETA 27
OutPort_14137887_1 | SOURCE | VENTILATION | ETA 27
InPort_14008423_2 | SINK | VENTILATION | ODA 3
OutPort_14008412_0 | SOURCE | VENTILATION | ODA 3
InPort_14008412_1 | SINK | VENTILATION | ODA 3
OutPort_14008499_1 | SOURCE | VENTILATION | ODA 3
InPort_14184116_2 | SINK | EXHAUST | EHA 10
OutPort_14008634_1 | SOURCE | EXHAUST | EHA 10
InPort_14009012_1 | SINK | EXHAUST | EHA 5
OutPort_14008719_0 | SOURCE | EXHAUST | EHA 5
InPort_14008719_1 | SINK | EXHAUST | EHA 5
OutPort_14184346_2 | SOURCE | EXHAUST | EHA 5
InPort_14146226_1 | SINK | VENTILATION | ODA 7
OutPort_14009745_0 | SOURCE | VENTILATION | ODA 7
InPort_14009745_1 | SINK | VENTILATION | ODA 7
OutPort_14009759_1 | SOURCE | VENTILATION | ODA 7
InPort_14009759_2 | SINK | VENTILATION | ODA 7
OutPort_14009754_0 | SOURCE | VENTILATION | ODA 7
InPort_14009754_1 | SINK | VENTILATION | ODA 7
OutPort_14009810_1 | SOURCE | VENTILATION | ODA 7
InPort_14145809_1 | SINK | VENTILATION | ODA 6
OutPort_14009919_0 | SOURCE | VENTILATION | ODA 6
InPort_14009919_1 | SINK | VENTILATION | ODA 6
OutPort_14009937_1 | SOURCE | VENTILATION | ODA 6
InPort_14009937_2 | SINK | VENTILATION | ODA 6
OutPort_14009932_0 | SOURCE | VENTILATION | ODA 6
InPort_14009932_1 | SINK | VENTILATION | ODA 6
OutPort_14010077_1 | SOURCE | VENTILATION | ODA 6
InPort_14145777_1 | SINK | VENTILATION | ODA 14
OutPort_14010138_0 | SOURCE | VENTILATION | ODA 14
InPort_14010138_1 | SINK | VENTILATION | ODA 14
OutPort_14010185_1 | SOURCE | VENTILATION | ODA 14
InPort_14010185_2 | SINK | VENTILATION | ODA 14
OutPort_14010149_0 | SOURCE | VENTILATION | ODA 14
InPort_14010149_1 | SINK | VENTILATION | ODA 14
OutPort_14010319_1 | SOURCE | VENTILATION | ODA 14
InPort_14010667_1 | SINK | VENTILATION | ETA 11
OutPort_14010723_2 | SOURCE | VENTILATION | ETA 11
InPort_14013227_1 | SINK | VENTILATION | SUP 11
OutPort_14010766_1 | SOURCE | VENTILATION | SUP 11
InPort_14010946_1 | SINK | VENTILATION | ETA 11
OutPort_14010900_0 | SOURCE | VENTILATION | ETA 11
InPort_14010900_1 | SINK | VENTILATION | ETA 11
OutPort_14012970_2 | SOURCE | VENTILATION | ETA 11
InPort_14012970_1 | SINK | VENTILATION | ETA 11
OutPort_14010914_0 | SOURCE | VENTILATION | ETA 11
InPort_14010914_1 | SINK | VENTILATION | ETA 11
OutPort_14083781_1 | SOURCE | VENTILATION | ETA 11
InPort_14030524_2 | SINK | VENTILATION | ETA 11
OutPort_14010946_0 | SOURCE | VENTILATION | ETA 11
InPort_14032915_2 | SINK | VENTILATION | SUP 11
OutPort_14011708_0 | SOURCE | VENTILATION | SUP 11
InPort_14011708_1 | SINK | VENTILATION | SUP 11
OutPort_14032929_1 | SOURCE | VENTILATION | SUP 11
InPort_14125321_0 | SINK | VENTILATION | SUP 11
OutPort_14012008_1 | SOURCE | VENTILATION | SUP 11
InPort_14012008_2 | SINK | VENTILATION | SUP 11
OutPort_14012010_1 | SOURCE | VENTILATION | SUP 11
InPort_14012010_0 | SINK | VENTILATION | SUP 11
OutPort_14032915_1 | SOURCE | VENTILATION | SUP 11
Port_14012063_0 | SOURCEANDSINK | VENTILATION | SUP 11
Port_14032834_2 | SOURCEANDSINK | VENTILATION | SUP 11
Port_14012063_1 | SOURCEANDSINK | VENTILATION | SUP 11
Port_14032671_2 | SOURCEANDSINK | VENTILATION | SUP 11
Port_14012065_1 | SOURCEANDSINK | VENTILATION | SUP 15
Port_14014354_0 | SOURCEANDSINK | VENTILATION | SUP 15
Port_14012065_2 | SOURCEANDSINK | VENTILATION | SUP 15
Port_14012066_0 | SOURCEANDSINK | VENTILATION | SUP 11
Port_14032834_1 | SOURCEANDSINK | VENTILATION | SUP 11
Port_14012066_1 | SOURCEANDSINK | VENTILATION | SUP 11
InPort_14016138_0 | SINK | VENTILATION | ETA 11
OutPort_14012769_1 | SOURCE | VENTILATION | ETA 11
InPort_14083822_2 | SINK | VENTILATION | ETA 11
OutPort_14012853_0 | SOURCE | VENTILATION | ETA 11
InPort_14012854_2 | SINK | VENTILATION | SUP 64
OutPort_14012853_1 | SOURCE | VENTILATION | SUP 64
InPort_14013309_0 | SINK | VENTILATION | ETA 11
OutPort_14012854_1 | SOURCE | VENTILATION | ETA 11
InPort_14049197_1 | SINK | VENTILATION | ETA 11
OutPort_14013309_1 | SOURCE | VENTILATION | ETA 11
Port_14014354_1 | SOURCEANDSINK | VENTILATION | SUP 15
Port_14014446_1 | SOURCEANDSINK | VENTILATION | SUP 15
Port_14014355_0 | SOURCEANDSINK | VENTILATION | SUP 15
Port_14014446_2 | SOURCEANDSINK | VENTILATION | SUP 15
Port_14014355_1 | SOURCEANDSINK | VENTILATION | SUP 15
Port_14182999_1 | SOURCEANDSINK | VENTILATION | SUP 15
InPort_14030551_1 | SINK | VENTILATION | ETA 11
OutPort_14015500_0 | SOURCE | VENTILATION | ETA 11
InPort_14015500_1 | SINK | VENTILATION | ETA 11
OutPort_14030562_1 | SOURCE | VENTILATION | ETA 11
InPort_14124622_1 | SINK | VENTILATION | ETA 11
OutPort_14016138_1 | SOURCE | VENTILATION | ETA 11
OutPort_14016684_1 | SOURCE | VENTILATION | ETA 14
InPort_14016855_0 | SINK | VENTILATION | ETA 7
OutPort_14017196_1 | SOURCE | VENTILATION | ETA 7
InPort_14016872_2 | SINK | VENTILATION | ETA 7
OutPort_14016855_1 | SOURCE | VENTILATION | ETA 7
InPort_14016862_0 | SINK | VENTILATION | ETA 7
OutPort_14016872_1 | SOURCE | VENTILATION | ETA 7
InPort_14017070_1 | SINK | VENTILATION | ETA 7
OutPort_14016862_1 | SOURCE | VENTILATION | ETA 7
InPort_14016983_0 | SINK | VENTILATION | ETA 7
OutPort_14017070_2 | SOURCE | VENTILATION | ETA 7
InPort_14017072_1 | SINK | VENTILATION | ETA 7
OutPort_14016983_1 | SOURCE | VENTILATION | ETA 7
Port_14017064_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14017065_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_14017064_3 | SINK | VENTILATION | ETA 7
OutPort_14017072_0 | SOURCE | VENTILATION | ETA 7
InPort_14017196_0 | SINK | VENTILATION | ETA 7
OutPort_14017191_1 | SOURCE | VENTILATION | ETA 7
Port_14017279_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14017439_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14017279_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14017429_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14017439_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14017429_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14017454_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14017439_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14017440_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14017446_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14017454_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14017446_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_14017446_2 | SINK | VENTILATION | ETA 7
OutPort_14017497_1 | SOURCE | VENTILATION | ETA 7
InPort_14017623_1 | SINK | VENTILATION | ETA 7
OutPort_14017615_0 | SOURCE | VENTILATION | ETA 7
InPort_14017615_1 | SINK | VENTILATION | ETA 7
OutPort_14017956_2 | SOURCE | VENTILATION | ETA 7
InPort_14017956_1 | SINK | VENTILATION | ETA 7
OutPort_14017948_0 | SOURCE | VENTILATION | ETA 7
InPort_14017948_1 | SINK | VENTILATION | ETA 7
OutPort_14018085_1 | SOURCE | VENTILATION | ETA 7
InPort_14017948_2 | SINK | VENTILATION | ETA 7
OutPort_14018051_1 | SOURCE | VENTILATION | ETA 7
InPort_14018085_0 | SINK | VENTILATION | ETA 7
OutPort_14018083_1 | SOURCE | VENTILATION | ETA 7
InPort_14056970_2 | SINK | VENTILATION | ODA 19
OutPort_14028699_1 | SOURCE | VENTILATION | ODA 19
InPort_14028699_2 | SINK | VENTILATION | SUP 14
OutPort_14039254_1 | SOURCE | VENTILATION | SUP 14
InPort_14028699_3 | SINK | VENTILATION | ETA 101
OutPort_14084629_2 | SOURCE | VENTILATION | ETA 101
InPort_14056401_1 | SINK | EXHAUST | ETA 23
OutPort_14028699_4 | SOURCE | EXHAUST | ETA 23
InPort_14029005_1 | SINK | VENTILATION | ODA 19
OutPort_14028937_0 | SOURCE | VENTILATION | ODA 19
InPort_14028937_1 | SINK | VENTILATION | ODA 19
OutPort_14029063_2 | SOURCE | VENTILATION | ODA 19
InPort_14028999_1 | SINK | VENTILATION | ODA 19
OutPort_14029005_2 | SOURCE | VENTILATION | ODA 19
InPort_14056968_1 | SINK | VENTILATION | ODA 19
OutPort_14028999_2 | SOURCE | VENTILATION | ODA 19
InPort_14056970_1 | SINK | VENTILATION | ODA 19
OutPort_14029001_0 | SOURCE | VENTILATION | ODA 19
InPort_14029001_1 | SINK | VENTILATION | ODA 19
OutPort_14110717_2 | SOURCE | VENTILATION | ODA 19
InPort_14029063_1 | SINK | VENTILATION | ODA 19
OutPort_14029055_0 | SOURCE | VENTILATION | ODA 19
InPort_14029055_1 | SINK | VENTILATION | ODA 19
OutPort_14029073_1 | SOURCE | VENTILATION | ODA 19
InPort_14029073_2 | SINK | VENTILATION | ODA 19
OutPort_14029065_1 | SOURCE | VENTILATION | ODA 19
InPort_14029103_0 | SINK | EXHAUST | EHA 12
OutPort_14029278_1 | SOURCE | EXHAUST | EHA 12
InPort_14029698_2 | SINK | EXHAUST | EHA 12
OutPort_14029103_1 | SOURCE | EXHAUST | EHA 12
InPort_14029278_2 | SINK | EXHAUST | EHA 12
OutPort_14029272_1 | SOURCE | EXHAUST | EHA 12
InPort_14029272_2 | SINK | EXHAUST | EHA 12
OutPort_14039104_1 | SOURCE | EXHAUST | EHA 12
InPort_14039104_2 | SINK | EXHAUST | EHA 12
OutPort_14029274_0 | SOURCE | EXHAUST | EHA 12
InPort_14029274_1 | SINK | EXHAUST | EHA 12
OutPort_14056895_2 | SOURCE | EXHAUST | EHA 12
InPort_14029374_0 | SINK | VENTILATION | ETA 23
OutPort_14029372_1 | SOURCE | VENTILATION | ETA 23
InPort_14029690_0 | SINK | EXHAUST | EHA 12
OutPort_14029698_1 | SOURCE | EXHAUST | EHA 12
InPort_14029773_1 | SINK | EXHAUST | EHA 12
OutPort_14029690_1 | SOURCE | EXHAUST | EHA 12
InPort_14029700_0 | SINK | EXHAUST | EHA 12
OutPort_14029898_2 | SOURCE | EXHAUST | EHA 12
InPort_14029902_1 | SINK | EXHAUST | EHA 12
OutPort_14029700_1 | SOURCE | EXHAUST | EHA 12
InPort_14029771_0 | SINK | EXHAUST | EHA 12
OutPort_14029773_2 | SOURCE | EXHAUST | EHA 12
InPort_14029898_1 | SINK | EXHAUST | EHA 12
OutPort_14029771_1 | SOURCE | EXHAUST | EHA 12
InPort_14030524_1 | SINK | VENTILATION | ETA 11
OutPort_14030551_2 | SOURCE | VENTILATION | ETA 11
InPort_14030562_2 | SINK | VENTILATION | ETA 11
OutPort_14030555_0 | SOURCE | VENTILATION | ETA 11
InPort_14030555_1 | SINK | VENTILATION | ETA 11
OutPort_14032231_1 | SOURCE | VENTILATION | ETA 11
InPort_14032231_2 | SINK | VENTILATION | ETA 11
OutPort_14030596_0 | SOURCE | VENTILATION | ETA 11
InPort_14030596_1 | SINK | VENTILATION | ETA 11
OutPort_14032232_2 | SOURCE | VENTILATION | ETA 11
InPort_14032941_1 | SINK | VENTILATION | SUP 11
OutPort_14032671_1 | SOURCE | VENTILATION | SUP 11
InPort_14032929_2 | SINK | VENTILATION | SUP 11
OutPort_14032928_0 | SOURCE | VENTILATION | SUP 11
InPort_14032928_1 | SINK | VENTILATION | SUP 11
OutPort_14032942_1 | SOURCE | VENTILATION | SUP 11
InPort_14032934_0 | SINK | VENTILATION | SUP 11
OutPort_14032941_2 | SOURCE | VENTILATION | SUP 11
InPort_14032942_2 | SINK | VENTILATION | SUP 11
OutPort_14032934_1 | SOURCE | VENTILATION | SUP 11
InPort_14033031_0 | SINK | VENTILATION | ETA 14
OutPort_14076594_1 | SOURCE | VENTILATION | ETA 14
InPort_14076596_1 | SINK | VENTILATION | ETA 14
OutPort_14033031_1 | SOURCE | VENTILATION | ETA 14
InPort_14036603_1 | SINK | VENTILATION | ETA 14
OutPort_14033047_0 | SOURCE | VENTILATION | ETA 14
InPort_14033047_1 | SINK | VENTILATION | ETA 14
OutPort_14033571_1 | SOURCE | VENTILATION | ETA 14
InPort_14033275_1 | SINK | VENTILATION | ETA 14
OutPort_14033241_1 | SOURCE | VENTILATION | ETA 14
InPort_14033241_2 | SINK | VENTILATION | ETA 14
OutPort_14033457_0 | SOURCE | VENTILATION | ETA 14
InPort_14076594_2 | SINK | VENTILATION | ETA 14
OutPort_14033275_0 | SOURCE | VENTILATION | ETA 14
InPort_14033458_2 | SINK | VENTILATION | ETA 14
OutPort_14033395_1 | SOURCE | VENTILATION | ETA 14
InPort_14033395_3 | SINK | VENTILATION | ETA 14
OutPort_14033537_1 | SOURCE | VENTILATION | ETA 14
InPort_14033457_1 | SINK | VENTILATION | ETA 14
OutPort_14033458_1 | SOURCE | VENTILATION | ETA 14
InPort_14033537_2 | SINK | VENTILATION | ETA 14
OutPort_14036605_0 | SOURCE | VENTILATION | ETA 14
InPort_14033571_2 | SINK | VENTILATION | ETA 14
OutPort_14033564_0 | SOURCE | VENTILATION | ETA 14
InPort_14033564_1 | SINK | VENTILATION | ETA 14
OutPort_14033654_1 | SOURCE | VENTILATION | ETA 14
InPort_14033654_2 | SINK | VENTILATION | ETA 14
OutPort_14033643_0 | SOURCE | VENTILATION | ETA 14
InPort_14033643_1 | SINK | VENTILATION | ETA 14
OutPort_14033691_1 | SOURCE | VENTILATION | ETA 14
Port_14033684_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14034476_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14033684_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14034478_2 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_14033691_2 | SINK | VENTILATION | ETA 14
OutPort_14034420_0 | SOURCE | VENTILATION | ETA 14
Port_14034420_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14034476_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14034420_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14035399_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14034478_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14034480_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14034684_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14035397_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14034684_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14035399_1 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_14036605_1 | SINK | VENTILATION | ETA 14
OutPort_14036603_2 | SOURCE | VENTILATION | ETA 14
InPort_14036702_2 | SINK | VENTILATION | SUP 9
OutPort_14036863_1 | SOURCE | VENTILATION | SUP 9
InPort_14036863_2 | SINK | VENTILATION | SUP 9
OutPort_14037060_0 | SOURCE | VENTILATION | SUP 9
InPort_14036882_1 | SINK | VENTILATION | SUP 9
OutPort_14036880_2 | SOURCE | VENTILATION | SUP 9
InPort_14037063_1 | SINK | VENTILATION | SUP 9
OutPort_14036882_0 | SOURCE | VENTILATION | SUP 9
InPort_14037061_2 | SINK | VENTILATION | SUP 9
OutPort_14037012_1 | SOURCE | VENTILATION | SUP 9
InPort_14037012_3 | SINK | VENTILATION | SUP 9
OutPort_14037063_2 | SOURCE | VENTILATION | SUP 9
InPort_14037060_1 | SINK | VENTILATION | SUP 9
OutPort_14037061_1 | SOURCE | VENTILATION | SUP 9
Port_14037276_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14037276_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_14037276_2 | SINK | VENTILATION | SUP 9
OutPort_14037530_0 | SOURCE | VENTILATION | SUP 9
Port_14037287_2 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_14037417_0 | SINK | VENTILATION | SUP 9
OutPort_14037547_1 | SOURCE | VENTILATION | SUP 9
InPort_14037530_1 | SINK | VENTILATION | SUP 9
OutPort_14037417_1 | SOURCE | VENTILATION | SUP 9
InPort_14037547_2 | SINK | VENTILATION | SUP 9
OutPort_14037549_0 | SOURCE | VENTILATION | SUP 9
InPort_14037549_1 | SINK | VENTILATION | SUP 9
OutPort_14037643_2 | SOURCE | VENTILATION | SUP 9
InPort_14037972_2 | SINK | VENTILATION | SUP 9
OutPort_14037636_0 | SOURCE | VENTILATION | SUP 9
InPort_14037636_1 | SINK | VENTILATION | SUP 9
OutPort_14050641_1 | SOURCE | VENTILATION | SUP 9
InPort_14037643_1 | SINK | VENTILATION | SUP 9
OutPort_14038115_0 | SOURCE | VENTILATION | SUP 9
InPort_14050644_2 | SINK | VENTILATION | SUP 9
OutPort_14037774_0 | SOURCE | VENTILATION | SUP 9
InPort_14037774_1 | SINK | VENTILATION | SUP 9
OutPort_14037805_2 | SOURCE | VENTILATION | SUP 9
InPort_14038032_1 | SINK | VENTILATION | SUP 9
OutPort_14037972_1 | SOURCE | VENTILATION | SUP 9
InPort_14038117_1 | SINK | VENTILATION | SUP 9
OutPort_14038032_0 | SOURCE | VENTILATION | SUP 9
InPort_14038116_2 | SINK | VENTILATION | SUP 9
OutPort_14038079_1 | SOURCE | VENTILATION | SUP 9
InPort_14038079_3 | SINK | VENTILATION | SUP 9
OutPort_14038117_2 | SOURCE | VENTILATION | SUP 9
InPort_14038115_1 | SINK | VENTILATION | SUP 9
OutPort_14038116_1 | SOURCE | VENTILATION | SUP 9
InPort_14055131_2 | SINK | VENTILATION | ETA 14
OutPort_14038239_1 | SOURCE | VENTILATION | ETA 14
InPort_14039160_0 | SINK | VENTILATION | SUP 14
OutPort_14039168_1 | SOURCE | VENTILATION | SUP 14
InPort_14039177_1 | SINK | VENTILATION | SUP 14
OutPort_14039160_1 | SOURCE | VENTILATION | SUP 14
InPort_14039171_0 | SINK | VENTILATION | SUP 14
OutPort_14056809_1 | SOURCE | VENTILATION | SUP 14
InPort_14039188_2 | SINK | VENTILATION | SUP 14
OutPort_14039171_1 | SOURCE | VENTILATION | SUP 14
InPort_14056805_0 | SINK | VENTILATION | SUP 14
OutPort_14039177_2 | SOURCE | VENTILATION | SUP 14
InPort_14039180_0 | SINK | VENTILATION | SUP 14
OutPort_14039188_1 | SOURCE | VENTILATION | SUP 14
InPort_14039257_2 | SINK | VENTILATION | SUP 14
OutPort_14039180_1 | SOURCE | VENTILATION | SUP 14
InPort_14039254_2 | SINK | VENTILATION | SUP 14
OutPort_14039238_0 | SOURCE | VENTILATION | SUP 14
InPort_14039238_1 | SINK | VENTILATION | SUP 14
OutPort_14039257_1 | SOURCE | VENTILATION | SUP 14
InPort_14039387_0 | SINK | VENTILATION | SUP 14
OutPort_14039401_1 | SOURCE | VENTILATION | SUP 14
InPort_14127343_2 | SINK | VENTILATION | SUP 14
OutPort_14039387_1 | SOURCE | VENTILATION | SUP 14
InPort_14039429_0 | SINK | VENTILATION | SUP 14
OutPort_14039436_1 | SOURCE | VENTILATION | SUP 14
InPort_14127344_2 | SINK | VENTILATION | SUP 14
OutPort_14039429_1 | SOURCE | VENTILATION | SUP 14
InPort_14039603_1 | SINK | VENTILATION | SUP 14
OutPort_14127343_1 | SOURCE | VENTILATION | SUP 14
InPort_14039676_1 | SINK | VENTILATION | SUP 14
OutPort_14127344_1 | SOURCE | VENTILATION | SUP 14
InPort_14039739_0 | SINK | VENTILATION | ETA 98
OutPort_14039737_1 | SOURCE | VENTILATION | ETA 98
InPort_14039737_2 | SINK | VENTILATION | ETA 98
OutPort_14039738_0 | SOURCE | VENTILATION | ETA 98
InPort_14039738_1 | SINK | VENTILATION | ETA 98
OutPort_14039740_1 | SOURCE | VENTILATION | ETA 98
OutPort_14039739_1 | SOURCE | VENTILATION | ETA 98
InPort_14039739_2 | SINK | VENTILATION | ETA 98
OutPort_14040367_0 | SOURCE | VENTILATION | ETA 98
InPort_14039861_1 | SINK | VENTILATION | SUP 24
OutPort_14039862_1 | SOURCE | VENTILATION | SUP 24
InPort_14039862_0 | SINK | VENTILATION | SUP 24
OutPort_14040580_2 | SOURCE | VENTILATION | SUP 24
InPort_14040447_1 | SINK | VENTILATION | ETA 98
OutPort_14040158_0 | SOURCE | VENTILATION | ETA 98
InPort_14040158_1 | SINK | VENTILATION | ETA 98
OutPort_14040492_1 | SOURCE | VENTILATION | ETA 98
InPort_14040618_2 | SINK | VENTILATION | SUP 24
OutPort_14040289_1 | SOURCE | VENTILATION | SUP 24
InPort_14040367_1 | SINK | VENTILATION | ETA 98
OutPort_14040449_0 | SOURCE | VENTILATION | ETA 98
InPort_14040449_1 | SINK | VENTILATION | ETA 98
OutPort_14040447_2 | SOURCE | VENTILATION | ETA 98
InPort_14040580_1 | SINK | VENTILATION | SUP 24
OutPort_14040582_1 | SOURCE | VENTILATION | SUP 24
InPort_14040582_2 | SINK | VENTILATION | SUP 24
OutPort_14040604_0 | SOURCE | VENTILATION | SUP 24
InPort_14040604_1 | SINK | VENTILATION | SUP 24
OutPort_14040608_1 | SOURCE | VENTILATION | SUP 24
InPort_14040608_2 | SINK | VENTILATION | SUP 24
OutPort_14040605_0 | SOURCE | VENTILATION | SUP 24
InPort_14040605_1 | SINK | VENTILATION | SUP 24
OutPort_14040618_1 | SOURCE | VENTILATION | SUP 24
InPort_14040837_1 | SINK | VENTILATION | ETA 3
OutPort_14040815_0 | SOURCE | VENTILATION | ETA 3
InPort_14040815_1 | SINK | VENTILATION | ETA 3
OutPort_14040912_1 | SOURCE | VENTILATION | ETA 3
InPort_14040833_2 | SINK | VENTILATION | ETA 3
OutPort_14040834_1 | SOURCE | VENTILATION | ETA 3
InPort_14040833_3 | SINK | VENTILATION | ETA 3
OutPort_14040837_0 | SOURCE | VENTILATION | ETA 3
InPort_14040912_0 | SINK | VENTILATION | ETA 3
OutPort_14040910_1 | SOURCE | VENTILATION | ETA 3
InPort_14041302_1 | SINK | VENTILATION | ETA 3
OutPort_14041170_1 | SOURCE | VENTILATION | ETA 3
InPort_14041520_1 | SINK | VENTILATION | ETA 3
OutPort_14041302_0 | SOURCE | VENTILATION | ETA 3
InPort_14041518_2 | SINK | VENTILATION | ETA 3
OutPort_14041467_1 | SOURCE | VENTILATION | ETA 3
InPort_14041467_3 | SINK | VENTILATION | ETA 3
OutPort_14041520_2 | SOURCE | VENTILATION | ETA 3
InPort_14041517_1 | SINK | VENTILATION | ETA 3
OutPort_14041518_1 | SOURCE | VENTILATION | ETA 3
InPort_14165921_0 | SINK | VENTILATION | ETA 11
OutPort_14049197_2 | SOURCE | VENTILATION | ETA 11
InPort_14165648_2 | SINK | VENTILATION | ETA 11
OutPort_14049247_1 | SOURCE | VENTILATION | ETA 11
InPort_14049526_1 | SINK | VENTILATION | ETA 14
OutPort_14049529_0 | SOURCE | VENTILATION | ETA 14
InPort_14049529_1 | SINK | VENTILATION | ETA 14
OutPort_14049593_1 | SOURCE | VENTILATION | ETA 14
InPort_14049598_2 | SINK | VENTILATION | ETA 14
OutPort_14049579_0 | SOURCE | VENTILATION | ETA 14
InPort_14049579_1 | SINK | VENTILATION | ETA 14
OutPort_14178728_1 | SOURCE | VENTILATION | ETA 14
InPort_14049593_2 | SINK | VENTILATION | ETA 14
OutPort_14049591_0 | SOURCE | VENTILATION | ETA 14
InPort_14049591_1 | SINK | VENTILATION | ETA 14
OutPort_14049598_1 | SOURCE | VENTILATION | ETA 14
InPort_14049662_0 | SINK | VENTILATION | ETA 14
OutPort_14178764_1 | SOURCE | VENTILATION | ETA 14
InPort_14178766_2 | SINK | VENTILATION | ETA 14
OutPort_14049662_1 | SOURCE | VENTILATION | ETA 14
InPort_14052766_1 | SINK | VENTILATION | ETA 14
OutPort_14049673_0 | SOURCE | VENTILATION | ETA 14
InPort_14049673_1 | SINK | VENTILATION | ETA 14
OutPort_14053223_2 | SOURCE | VENTILATION | ETA 14
InPort_14049977_1 | SINK | VENTILATION | ETA 14
OutPort_14052929_0 | SOURCE | VENTILATION | ETA 14
InPort_14049979_1 | SINK | VENTILATION | ETA 14
OutPort_14049977_2 | SOURCE | VENTILATION | ETA 14
InPort_14178764_2 | SINK | VENTILATION | ETA 14
OutPort_14049979_0 | SOURCE | VENTILATION | ETA 14
InPort_14050349_1 | SINK | VENTILATION | SUP 9
OutPort_14050347_2 | SOURCE | VENTILATION | SUP 9
InPort_14050372_0 | SINK | VENTILATION | SUP 9
OutPort_14051964_1 | SOURCE | VENTILATION | SUP 9
InPort_14051966_1 | SINK | VENTILATION | SUP 9
OutPort_14050372_1 | SOURCE | VENTILATION | SUP 9
InPort_14050641_2 | SINK | VENTILATION | SUP 9
OutPort_14050644_1 | SOURCE | VENTILATION | SUP 9
InPort_14051726_1 | SINK | VENTILATION | SUP 9
OutPort_14050883_0 | SOURCE | VENTILATION | SUP 9
InPort_14050883_1 | SINK | VENTILATION | SUP 9
OutPort_14051676_1 | SOURCE | VENTILATION | SUP 9
InPort_14051087_1 | SINK | VENTILATION | ETA 14
OutPort_14051225_0 | SOURCE | VENTILATION | ETA 14
InPort_14051119_1 | SINK | VENTILATION | ETA 14
OutPort_14051087_2 | SOURCE | VENTILATION | ETA 14
InPort_14052377_1 | SINK | VENTILATION | ETA 14
OutPort_14051119_0 | SOURCE | VENTILATION | ETA 14
InPort_14051201_1 | SINK | VENTILATION | ETA 14
OutPort_14053266_0 | SOURCE | VENTILATION | ETA 14
InPort_14051225_1 | SINK | VENTILATION | ETA 14
OutPort_14051201_2 | SOURCE | VENTILATION | ETA 14
InPort_14051661_0 | SINK | VENTILATION | SUP 9
OutPort_14051674_1 | SOURCE | VENTILATION | SUP 9
InPort_14051676_2 | SINK | VENTILATION | SUP 9
OutPort_14051661_1 | SOURCE | VENTILATION | SUP 9
Port_14051669_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14051670_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_14051674_0 | SINK | VENTILATION | SUP 9
OutPort_14051669_3 | SOURCE | VENTILATION | SUP 9
InPort_14051772_1 | SINK | VENTILATION | SUP 9
OutPort_14051726_2 | SOURCE | VENTILATION | SUP 9
InPort_14051854_1 | SINK | VENTILATION | SUP 9
OutPort_14051772_0 | SOURCE | VENTILATION | SUP 9
InPort_14051876_1 | SINK | VENTILATION | SUP 9
OutPort_14051854_2 | SOURCE | VENTILATION | SUP 9
InPort_14051964_2 | SINK | VENTILATION | SUP 9
OutPort_14051876_0 | SOURCE | VENTILATION | SUP 9
InPort_14052289_0 | SINK | VENTILATION | ETA 14
OutPort_14052008_2 | SOURCE | VENTILATION | ETA 14
InPort_14052218_1 | SINK | VENTILATION | ETA 14
OutPort_14052216_1 | SOURCE | VENTILATION | ETA 14
Port_14052275_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14052443_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14052275_1 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_14052275_2 | SINK | VENTILATION | ETA 14
OutPort_14053657_1 | SOURCE | VENTILATION | ETA 14
InPort_14052438_3 | SINK | VENTILATION | ETA 14
OutPort_14052289_1 | SOURCE | VENTILATION | ETA 14
Port_14052326_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14052438_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14052326_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14052405_2 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_14052326_2 | SINK | VENTILATION | ETA 14
OutPort_14054251_1 | SOURCE | VENTILATION | ETA 14
InPort_14052326_3 | SINK | VENTILATION | ETA 14
OutPort_14054560_1 | SOURCE | VENTILATION | ETA 14
InPort_14053216_0 | SINK | VENTILATION | ETA 14
OutPort_14052377_2 | SOURCE | VENTILATION | ETA 14
Port_14052395_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14052405_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14052395_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14053527_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14052438_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14052443_1 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_14052545_0 | SINK | VENTILATION | ETA 14
OutPort_14052537_1 | SOURCE | VENTILATION | ETA 14
InPort_14052788_1 | SINK | VENTILATION | ETA 14
OutPort_14052766_2 | SOURCE | VENTILATION | ETA 14
InPort_14052911_1 | SINK | VENTILATION | ETA 14
OutPort_14052788_0 | SOURCE | VENTILATION | ETA 14
InPort_14052929_1 | SINK | VENTILATION | ETA 14
OutPort_14052911_2 | SOURCE | VENTILATION | ETA 14
InPort_14053200_0 | SINK | VENTILATION | ETA 14
OutPort_14053215_3 | SOURCE | VENTILATION | ETA 14
InPort_14053223_1 | SINK | VENTILATION | ETA 14
OutPort_14053200_1 | SOURCE | VENTILATION | ETA 14
Port_14053215_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14120922_0 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_14053215_2 | SINK | VENTILATION | ETA 14
OutPort_14053216_1 | SOURCE | VENTILATION | ETA 14
Port_14053257_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14053276_3 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14053257_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14053265_3 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_14053266_1 | SINK | VENTILATION | ETA 14
OutPort_14053265_2 | SOURCE | VENTILATION | ETA 14
Port_14053276_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14053277_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14053277_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14053517_1 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_14053380_0 | SINK | VENTILATION | ETA 14
OutPort_14053373_1 | SOURCE | VENTILATION | ETA 14
Port_14053506_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14053525_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14053506_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14053529_2 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_14053506_2 | SINK | VENTILATION | ETA 14
OutPort_14053725_1 | SOURCE | VENTILATION | ETA 14
InPort_14053506_3 | SINK | VENTILATION | ETA 14
OutPort_14053807_1 | SOURCE | VENTILATION | ETA 14
Port_14053517_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14053525_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14053527_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14053529_1 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_14054914_0 | SINK | VENTILATION | SUP 5
OutPort_14120747_1 | SOURCE | VENTILATION | SUP 5
InPort_14055014_1 | SINK | VENTILATION | SUP 5
OutPort_14054914_1 | SOURCE | VENTILATION | SUP 5
InPort_14055008_1 | SINK | VENTILATION | SUP 5
OutPort_14055014_0 | SOURCE | VENTILATION | SUP 5
InPort_14055192_2 | SINK | VENTILATION | ETA 14
OutPort_14055131_1 | SOURCE | VENTILATION | ETA 14
InPort_14055178_0 | SINK | VENTILATION | ETA 14
OutPort_14055192_1 | SOURCE | VENTILATION | ETA 14
InPort_14055194_1 | SINK | VENTILATION | ETA 14
OutPort_14055178_1 | SOURCE | VENTILATION | ETA 14
InPort_14055303_3 | SINK | VENTILATION | ETA 14
OutPort_14055293_0 | SOURCE | VENTILATION | ETA 14
InPort_14055293_1 | SINK | VENTILATION | ETA 14
OutPort_14055610_1 | SOURCE | VENTILATION | ETA 14
InPort_14055303_1 | SINK | VENTILATION | ETA 14
OutPort_14055304_1 | SOURCE | VENTILATION | ETA 14
InPort_14055348_0 | SINK | VENTILATION | SUP 9
OutPort_14055363_2 | SOURCE | VENTILATION | SUP 9
InPort_14055539_1 | SINK | VENTILATION | SUP 9
OutPort_14055348_1 | SOURCE | VENTILATION | SUP 9
InPort_14055537_1 | SINK | VENTILATION | SUP 9
OutPort_14055539_0 | SOURCE | VENTILATION | SUP 9
InPort_14055610_0 | SINK | VENTILATION | ETA 14
OutPort_14055608_1 | SOURCE | VENTILATION | ETA 14
Port_14055669_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14055696_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14055678_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14055696_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14055678_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14055725_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14055725_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14055730_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14055730_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14055757_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14055749_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14055757_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14055749_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14055766_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14055760_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14055766_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14055760_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14055775_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14055769_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14055775_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14055769_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_14055833_1 | SINK | VENTILATION | SUP 9
OutPort_14055769_2 | SOURCE | VENTILATION | SUP 9
InPort_14055956_0 | SINK | VENTILATION | ETA 3
OutPort_14056061_1 | SOURCE | VENTILATION | ETA 3
InPort_14055988_2 | SINK | VENTILATION | ETA 3
OutPort_14055956_1 | SOURCE | VENTILATION | ETA 3
InPort_14055956_2 | SINK | VENTILATION | ETA 3
OutPort_14056139_1 | SOURCE | VENTILATION | ETA 3
InPort_14055986_1 | SINK | VENTILATION | ETA 3
OutPort_14055965_0 | SOURCE | VENTILATION | ETA 3
InPort_14055965_1 | SINK | VENTILATION | ETA 3
OutPort_14055988_1 | SOURCE | VENTILATION | ETA 3
InPort_14055982_1 | SINK | VENTILATION | ETA 3
OutPort_14055983_1 | SOURCE | VENTILATION | ETA 3
InPort_14055982_3 | SINK | VENTILATION | ETA 3
OutPort_14055986_0 | SOURCE | VENTILATION | ETA 3
InPort_14056061_0 | SINK | VENTILATION | ETA 3
OutPort_14056054_1 | SOURCE | VENTILATION | ETA 3
InPort_14056230_0 | SINK | EXHAUST | ETA 23
OutPort_14056663_1 | SOURCE | EXHAUST | ETA 23
InPort_14056631_3 | SINK | VENTILATION | ETA 23
OutPort_14056230_1 | SOURCE | EXHAUST | ETA 23
InPort_14056635_1 | SINK | EXHAUST | ETA 23
OutPort_14056238_0 | SOURCE | EXHAUST | ETA 23
InPort_14056238_1 | SINK | EXHAUST | ETA 23
OutPort_14056403_2 | SOURCE | EXHAUST | ETA 23
InPort_14056312_0 | SINK | EXHAUST | ETA 23
OutPort_14056401_2 | SOURCE | EXHAUST | ETA 23
InPort_14056403_1 | SINK | EXHAUST | ETA 23
OutPort_14056312_1 | SOURCE | EXHAUST | ETA 23
InPort_14056632_1 | SINK | VENTILATION | ETA 23
OutPort_14056631_2 | SOURCE | VENTILATION | ETA 23
InPort_14056659_0 | SINK | EXHAUST | ETA 23
OutPort_14056635_2 | SOURCE | EXHAUST | ETA 23
InPort_14056663_2 | SINK | EXHAUST | ETA 23
OutPort_14056657_1 | SOURCE | EXHAUST | ETA 23
InPort_14056657_2 | SINK | EXHAUST | ETA 23
OutPort_14056661_2 | SOURCE | EXHAUST | ETA 23
InPort_14056661_1 | SINK | EXHAUST | ETA 23
OutPort_14056659_1 | SOURCE | EXHAUST | ETA 23
InPort_14056809_2 | SINK | VENTILATION | SUP 14
OutPort_14056803_1 | SOURCE | VENTILATION | SUP 14
InPort_14056803_2 | SINK | VENTILATION | SUP 14
OutPort_14056807_2 | SOURCE | VENTILATION | SUP 14
InPort_14056807_1 | SINK | VENTILATION | SUP 14
OutPort_14056805_1 | SOURCE | VENTILATION | SUP 14
InPort_14056895_1 | SINK | EXHAUST | EHA 12
OutPort_14056885_0 | SOURCE | EXHAUST | EHA 12
InPort_14056885_1 | SINK | EXHAUST | EHA 12
OutPort_14084627_1 | SOURCE | EXHAUST | EHA 12
InPort_14084627_2 | SINK | EXHAUST | EHA 12
OutPort_14056898_0 | SOURCE | EXHAUST | EHA 12
InPort_14084629_1 | SINK | VENTILATION | ETA 101
OutPort_14056898_1 | SOURCE | EXHAUST | ETA 101
InPort_14110719_0 | SINK | VENTILATION | ODA 19
OutPort_14056968_2 | SOURCE | VENTILATION | ODA 19
InPort_14028699_1 | SINK | VENTILATION | ODA 19
OutPort_14056970_2 | SOURCE | VENTILATION | ODA 19
InPort_14057001_3 | SINK | VENTILATION | ETA 7
OutPort_14056995_0 | SOURCE | VENTILATION | ETA 7
InPort_14056995_1 | SINK | VENTILATION | ETA 7
OutPort_14057138_1 | SOURCE | VENTILATION | ETA 7
Port_14057001_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14058320_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14057001_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14057002_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_14057138_0 | SINK | VENTILATION | ETA 7
OutPort_14057132_1 | SOURCE | VENTILATION | ETA 7
InPort_14057460_1 | SINK | VENTILATION | SUP 9
OutPort_14057380_0 | SOURCE | VENTILATION | SUP 9
InPort_14057380_1 | SINK | VENTILATION | SUP 9
OutPort_14057462_1 | SOURCE | VENTILATION | SUP 9
InPort_14057389_0 | SINK | VENTILATION | SUP 9
OutPort_14057460_2 | SOURCE | VENTILATION | SUP 9
InPort_14057827_1 | SINK | VENTILATION | SUP 9
OutPort_14057389_1 | SOURCE | VENTILATION | SUP 9
InPort_14057462_2 | SINK | VENTILATION | SUP 9
OutPort_14057421_2 | SOURCE | VENTILATION | SUP 9
InPort_14057820_1 | SINK | VENTILATION | SUP 9
OutPort_14057827_0 | SOURCE | VENTILATION | SUP 9
InPort_14058068_1 | SINK | VENTILATION | SUP 24
OutPort_14058148_0 | SOURCE | VENTILATION | SUP 24
InPort_14058319_3 | SINK | VENTILATION | ETA 7
OutPort_14058311_0 | SOURCE | VENTILATION | ETA 7
InPort_14058311_1 | SINK | VENTILATION | ETA 7
OutPort_14058334_2 | SOURCE | VENTILATION | ETA 7
Port_14058319_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14058320_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_14058334_1 | SINK | VENTILATION | ETA 7
OutPort_14058326_0 | SOURCE | VENTILATION | ETA 7
InPort_14058326_1 | SINK | VENTILATION | ETA 7
OutPort_14058445_1 | SOURCE | VENTILATION | ETA 7
InPort_14058326_2 | SINK | VENTILATION | ETA 7
OutPort_14058383_1 | SOURCE | VENTILATION | ETA 7
InPort_14058445_0 | SINK | VENTILATION | ETA 7
OutPort_14058443_1 | SOURCE | VENTILATION | ETA 7
InPort_14058965_2 | SINK | VENTILATION | SUP 24
OutPort_14058932_1 | SOURCE | VENTILATION | SUP 24
InPort_14058932_2 | SINK | VENTILATION | SUP 24
OutPort_14059219_1 | SOURCE | VENTILATION | SUP 24
InPort_14059219_2 | SINK | VENTILATION | SUP 24
OutPort_14058960_0 | SOURCE | VENTILATION | SUP 24
InPort_14058960_1 | SINK | VENTILATION | SUP 24
OutPort_14059093_2 | SOURCE | VENTILATION | SUP 24
InPort_14059093_1 | SINK | VENTILATION | SUP 24
OutPort_14059095_1 | SOURCE | VENTILATION | SUP 24
InPort_14059095_0 | SINK | VENTILATION | SUP 24
OutPort_14123079_1 | SOURCE | VENTILATION | SUP 24
InPort_14059537_0 | SINK | VENTILATION | ETA 99
OutPort_14059535_1 | SOURCE | VENTILATION | ETA 99
InPort_14059535_2 | SINK | VENTILATION | ETA 99
OutPort_14059536_0 | SOURCE | VENTILATION | ETA 99
InPort_14059536_1 | SINK | VENTILATION | ETA 99
OutPort_14059538_1 | SOURCE | VENTILATION | ETA 99
OutPort_14059537_1 | SOURCE | VENTILATION | ETA 99
InPort_14189913_3 | SINK | VENTILATION | ETA 7
OutPort_14059602_0 | SOURCE | VENTILATION | ETA 7
InPort_14059602_1 | SINK | VENTILATION | ETA 7
OutPort_14060731_1 | SOURCE | VENTILATION | ETA 7
Port_14059628_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14114159_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14059628_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14059950_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14059871_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14114084_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14059950_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14060388_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14060388_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14114083_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_14139186_1 | SINK | VENTILATION | ETA 7
OutPort_14060507_0 | SOURCE | VENTILATION | ETA 7
InPort_14060507_1 | SINK | VENTILATION | ETA 7
OutPort_14190038_1 | SOURCE | VENTILATION | ETA 7
InPort_14060586_0 | SINK | VENTILATION | ETA 7
OutPort_14189913_2 | SOURCE | VENTILATION | ETA 7
InPort_14114089_1 | SINK | VENTILATION | ETA 7
OutPort_14060586_1 | SOURCE | VENTILATION | ETA 7
InPort_14060596_0 | SINK | VENTILATION | ETA 7
OutPort_14114089_2 | SOURCE | VENTILATION | ETA 7
InPort_14114091_1 | SINK | VENTILATION | ETA 7
OutPort_14060596_1 | SOURCE | VENTILATION | ETA 7
InPort_14060731_2 | SINK | VENTILATION | ETA 7
OutPort_14060729_0 | SOURCE | VENTILATION | ETA 7
InPort_14060729_1 | SINK | VENTILATION | ETA 7
OutPort_14060735_1 | SOURCE | VENTILATION | ETA 7
InPort_14060735_2 | SINK | VENTILATION | ETA 7
OutPort_14113524_0 | SOURCE | VENTILATION | ETA 7
InPort_14113857_1 | SINK | VENTILATION | ETA 7
OutPort_14060741_0 | SOURCE | VENTILATION | ETA 7
InPort_14060741_1 | SINK | VENTILATION | ETA 7
OutPort_14060763_2 | SOURCE | VENTILATION | ETA 7
InPort_14060763_1 | SINK | VENTILATION | ETA 7
OutPort_14060747_0 | SOURCE | VENTILATION | ETA 7
InPort_14060747_1 | SINK | VENTILATION | ETA 7
OutPort_14060867_1 | SOURCE | VENTILATION | ETA 7
InPort_14060871_2 | SINK | VENTILATION | ETA 7
OutPort_14060766_0 | SOURCE | VENTILATION | ETA 7
InPort_14060766_1 | SINK | VENTILATION | ETA 7
OutPort_14061085_1 | SOURCE | VENTILATION | ETA 7
InPort_14060766_2 | SINK | VENTILATION | ETA 7
OutPort_14061154_1 | SOURCE | VENTILATION | ETA 7
InPort_14060766_3 | SINK | VENTILATION | ETA 7
OutPort_14061233_1 | SOURCE | VENTILATION | ETA 7
InPort_14060867_2 | SINK | VENTILATION | ETA 7
OutPort_14060865_0 | SOURCE | VENTILATION | ETA 7
InPort_14060865_1 | SINK | VENTILATION | ETA 7
OutPort_14060871_1 | SOURCE | VENTILATION | ETA 7
InPort_14061085_0 | SINK | VENTILATION | ETA 7
OutPort_14061075_1 | SOURCE | VENTILATION | ETA 7
Port_14061471_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14061474_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_14061716_0 | SOURCEANDSINK | VENTILATION | SUP 20
Port_14061727_2 | SOURCEANDSINK | VENTILATION | SUP 20
Port_14061716_1 | SOURCEANDSINK | VENTILATION | SUP 20
Port_14061742_1 | SOURCEANDSINK | VENTILATION | SUP 20
Port_14061732_1 | SOURCEANDSINK | VENTILATION | SUP 20
Port_14061742_2 | SOURCEANDSINK | VENTILATION | SUP 20
InPort_14062051_0 | SINK | VENTILATION | ODA 12
OutPort_14158267_2 | SOURCE | VENTILATION | ODA 12
InPort_14067628_1 | SINK | VENTILATION | ODA 12
OutPort_14062051_1 | SOURCE | VENTILATION | ODA 12
InPort_14151034_0 | SINK | VENTILATION | ODA 12
OutPort_14062051_2 | SOURCE | VENTILATION | ODA 12
InPort_14157967_2 | SINK | VENTILATION | ODA 12
OutPort_14062774_0 | SOURCE | VENTILATION | ODA 12
InPort_14062774_1 | SINK | VENTILATION | ODA 12
OutPort_14158681_2 | SOURCE | VENTILATION | ODA 12
InPort_14063969_0 | SINK | VENTILATION | SUP 24
OutPort_14063982_3 | SOURCE | VENTILATION | SUP 24
InPort_14063997_2 | SINK | VENTILATION | SUP 24
OutPort_14063969_1 | SOURCE | VENTILATION | SUP 24
Port_14063982_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14079148_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14063982_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14063983_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14063983_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14078521_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_14063991_0 | SINK | VENTILATION | SUP 24
OutPort_14064236_2 | SOURCE | VENTILATION | SUP 24
InPort_14064008_1 | SINK | VENTILATION | SUP 24
OutPort_14063991_1 | SOURCE | VENTILATION | SUP 24
InPort_14064238_0 | SINK | VENTILATION | SUP 24
OutPort_14063997_1 | SOURCE | VENTILATION | SUP 24
InPort_14064000_0 | SINK | VENTILATION | SUP 24
OutPort_14064136_1 | SOURCE | VENTILATION | SUP 24
Port_14064000_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_14064335_1 | SINK | VENTILATION | SUP 24
OutPort_14064000_2 | SOURCE | VENTILATION | SUP 24
InPort_14064385_1 | SINK | VENTILATION | SUP 24
OutPort_14064000_3 | SOURCE | VENTILATION | SUP 24
InPort_14064553_1 | SINK | VENTILATION | SUP 24
OutPort_14064000_4 | SOURCE | VENTILATION | SUP 24
InPort_14064160_0 | SINK | VENTILATION | SUP 24
OutPort_14064008_2 | SOURCE | VENTILATION | SUP 24
InPort_14064136_2 | SINK | VENTILATION | SUP 24
OutPort_14064160_1 | SOURCE | VENTILATION | SUP 24
InPort_14064236_1 | SINK | VENTILATION | SUP 24
OutPort_14064238_1 | SOURCE | VENTILATION | SUP 24
InPort_14120116_2 | SINK | VENTILATION | SUP 24
OutPort_14064750_0 | SOURCE | VENTILATION | SUP 24
InPort_14064750_1 | SINK | VENTILATION | SUP 24
OutPort_14120108_3 | SOURCE | VENTILATION | SUP 24
InPort_14064752_0 | SINK | VENTILATION | SUP 24
OutPort_14064763_2 | SOURCE | VENTILATION | SUP 24
InPort_14064758_1 | SINK | VENTILATION | SUP 24
OutPort_14064752_1 | SOURCE | VENTILATION | SUP 24
InPort_14064756_0 | SINK | VENTILATION | SUP 24
OutPort_14064760_1 | SOURCE | VENTILATION | SUP 24
Port_14064756_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_14064968_1 | SINK | VENTILATION | SUP 24
OutPort_14064756_2 | SOURCE | VENTILATION | SUP 24
InPort_14065014_1 | SINK | VENTILATION | SUP 24
OutPort_14064756_3 | SOURCE | VENTILATION | SUP 24
InPort_14064761_0 | SINK | VENTILATION | SUP 24
OutPort_14064758_2 | SOURCE | VENTILATION | SUP 24
InPort_14064760_2 | SINK | VENTILATION | SUP 24
OutPort_14064761_1 | SOURCE | VENTILATION | SUP 24
InPort_14064763_1 | SINK | VENTILATION | SUP 24
OutPort_14064764_1 | SOURCE | VENTILATION | SUP 24
InPort_14064764_0 | SINK | VENTILATION | SUP 24
OutPort_14120116_1 | SOURCE | VENTILATION | SUP 24
InPort_14065331_0 | SINK | VENTILATION | ETA 17
OutPort_14065329_1 | SOURCE | VENTILATION | ETA 17
InPort_14065920_1 | SINK | VENTILATION | ETA 7
OutPort_14065403_0 | SOURCE | VENTILATION | ETA 7
InPort_14065403_1 | SINK | VENTILATION | ETA 7
OutPort_14172815_1 | SOURCE | VENTILATION | ETA 7
InPort_14173005_0 | SINK | VENTILATION | ETA 7
OutPort_14065520_1 | SOURCE | VENTILATION | ETA 7
InPort_14172813_2 | SINK | VENTILATION | ETA 7
OutPort_14065654_0 | SOURCE | VENTILATION | ETA 7
InPort_14065654_1 | SINK | VENTILATION | ETA 7
OutPort_14172933_1 | SOURCE | VENTILATION | ETA 7
InPort_14065654_2 | SINK | VENTILATION | ETA 7
OutPort_14149259_1 | SOURCE | VENTILATION | ETA 7
InPort_14065654_3 | SINK | VENTILATION | ETA 7
OutPort_14150524_1 | SOURCE | VENTILATION | ETA 7
InPort_14065654_4 | SINK | VENTILATION | ETA 7
OutPort_14150595_1 | SOURCE | VENTILATION | ETA 7
InPort_14110116_0 | SINK | VENTILATION | ETA 7
OutPort_14065920_2 | SOURCE | VENTILATION | ETA 7
Port_14065924_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14110120_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14065924_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14065963_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14065940_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14110298_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14065940_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14065963_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_14110297_1 | SINK | VENTILATION | ETA 7
OutPort_14065957_1 | SOURCE | VENTILATION | ETA 7
Port_14065957_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14065958_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14065957_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14110298_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14065958_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14110299_2 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_14066192_0 | SINK | VENTILATION | ODA 12
OutPort_14066261_3 | SOURCE | VENTILATION | ODA 12
InPort_14066238_2 | SINK | VENTILATION | ODA 12
OutPort_14066192_1 | SOURCE | VENTILATION | ODA 12
InPort_14066239_2 | SINK | VENTILATION | ODA 12
OutPort_14066238_1 | SOURCE | VENTILATION | ODA 12
InPort_14066286_0 | SINK | VENTILATION | ODA 12
OutPort_14066261_2 | SOURCE | VENTILATION | ODA 12
InPort_14067857_1 | SINK | VENTILATION | ODA 12
OutPort_14066286_1 | SOURCE | VENTILATION | ODA 12
InPort_14066492_1 | SINK | VENTILATION | ODA 12
OutPort_14121171_1 | SOURCE | VENTILATION | ODA 12
InPort_14067813_2 | SINK | VENTILATION | ODA 12
OutPort_14067814_1 | SOURCE | VENTILATION | ODA 12
InPort_14068033_2 | SINK | VENTILATION | ETA 6
OutPort_14068035_1 | SOURCE | VENTILATION | ETA 6
InPort_14068088_1 | SINK | VENTILATION | SUP 13
OutPort_14068086_2 | SOURCE | VENTILATION | SUP 13
InPort_14146245_2 | SINK | VENTILATION | ODA 7
OutPort_14068663_0 | SOURCE | VENTILATION | ODA 7
InPort_14068663_1 | SINK | VENTILATION | ODA 7
OutPort_14146226_2 | SOURCE | VENTILATION | ODA 7
InPort_14145825_2 | SINK | VENTILATION | ODA 6
OutPort_14068767_0 | SOURCE | VENTILATION | ODA 6
InPort_14068767_1 | SINK | VENTILATION | ODA 6
OutPort_14145809_2 | SOURCE | VENTILATION | ODA 6
InPort_14145874_2 | SINK | VENTILATION | ODA 14
OutPort_14068907_0 | SOURCE | VENTILATION | ODA 14
InPort_14068907_1 | SINK | VENTILATION | ODA 14
OutPort_14145777_2 | SOURCE | VENTILATION | ODA 14
Port_14075519_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14076355_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14075519_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14075580_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14075567_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14075580_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14075567_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14075594_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14075586_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14075614_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14075586_1 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_14075586_2 | SINK | VENTILATION | ETA 14
OutPort_14075740_1 | SOURCE | VENTILATION | ETA 14
InPort_14075586_3 | SINK | VENTILATION | ETA 14
OutPort_14075873_1 | SOURCE | VENTILATION | ETA 14
InPort_14075586_4 | SINK | VENTILATION | ETA 14
OutPort_14075941_1 | SOURCE | VENTILATION | ETA 14
Port_14075594_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14075616_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14075614_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14075616_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14076144_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14120577_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14076238_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14120353_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14076238_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14120638_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14076262_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14076384_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14076262_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14076355_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14076384_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14076386_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14076386_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14120353_2 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_14076895_0 | SINK | VENTILATION | ETA 14
OutPort_14076906_2 | SOURCE | VENTILATION | ETA 14
InPort_14077783_1 | SINK | VENTILATION | ETA 14
OutPort_14076895_1 | SOURCE | VENTILATION | ETA 14
InPort_14076985_0 | SINK | VENTILATION | SUP 9
OutPort_14078296_1 | SOURCE | VENTILATION | SUP 9
InPort_14078255_1 | SINK | VENTILATION | SUP 9
OutPort_14076985_1 | SOURCE | VENTILATION | SUP 9
InPort_14077577_0 | SINK | VENTILATION | ETA 14
OutPort_14077783_2 | SOURCE | VENTILATION | ETA 14
InPort_14078018_2 | SINK | VENTILATION | ETA 14
OutPort_14077577_1 | SOURCE | VENTILATION | ETA 14
Port_14077940_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14078019_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14077940_3 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14078020_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14077942_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14078017_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14077942_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14078019_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14078020_2 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_14078256_1 | SINK | VENTILATION | SUP 9
OutPort_14078255_2 | SOURCE | VENTILATION | SUP 9
InPort_14078289_1 | SINK | VENTILATION | SUP 9
OutPort_14078291_1 | SOURCE | VENTILATION | SUP 9
InPort_14078296_2 | SINK | VENTILATION | SUP 9
OutPort_14078289_3 | SOURCE | VENTILATION | SUP 9
InPort_14078291_0 | SINK | VENTILATION | SUP 9
OutPort_14148090_2 | SOURCE | VENTILATION | SUP 9
Port_14078521_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14078577_0 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_14078602_1 | SINK | VENTILATION | SUP 24
OutPort_14078549_0 | SOURCE | VENTILATION | SUP 24
InPort_14078549_1 | SINK | VENTILATION | SUP 24
OutPort_14078584_1 | SOURCE | VENTILATION | SUP 24
InPort_14078559_1 | SINK | VENTILATION | SUP 24
OutPort_14078604_0 | SOURCE | VENTILATION | SUP 24
InPort_14078628_0 | SINK | VENTILATION | SUP 24
OutPort_14078559_2 | SOURCE | VENTILATION | SUP 24
InPort_14078562_0 | SINK | VENTILATION | SUP 24
OutPort_14078576_3 | SOURCE | VENTILATION | SUP 24
InPort_14078584_2 | SINK | VENTILATION | SUP 24
OutPort_14078562_1 | SOURCE | VENTILATION | SUP 24
Port_14078576_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14078577_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_14078604_1 | SINK | VENTILATION | SUP 24
OutPort_14078602_2 | SOURCE | VENTILATION | SUP 24
InPort_14078626_2 | SINK | VENTILATION | SUP 24
OutPort_14078628_1 | SOURCE | VENTILATION | SUP 24
InPort_14078943_2 | SINK | VENTILATION | SUP 24
OutPort_14078963_1 | SOURCE | VENTILATION | SUP 24
InPort_14079186_1 | SINK | VENTILATION | SUP 24
OutPort_14079100_0 | SOURCE | VENTILATION | SUP 24
InPort_14079100_1 | SINK | VENTILATION | SUP 24
OutPort_14079155_1 | SOURCE | VENTILATION | SUP 24
InPort_14079106_1 | SINK | VENTILATION | SUP 24
OutPort_14079188_0 | SOURCE | VENTILATION | SUP 24
InPort_14079137_0 | SINK | VENTILATION | SUP 24
OutPort_14079147_3 | SOURCE | VENTILATION | SUP 24
InPort_14079155_2 | SINK | VENTILATION | SUP 24
OutPort_14079137_1 | SOURCE | VENTILATION | SUP 24
Port_14079147_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14120109_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14079147_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14079148_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_14079188_1 | SINK | VENTILATION | SUP 24
OutPort_14079186_2 | SOURCE | VENTILATION | SUP 24
Port_14080667_2 | SOURCEANDSINK | VENTILATION | SUP 7
Port_14080669_1 | SOURCEANDSINK | VENTILATION | SUP 7
InPort_14080764_2 | SINK | VENTILATION | SUP 4
OutPort_14080755_1 | SOURCE | VENTILATION | SUP 4
InPort_14080755_2 | SINK | VENTILATION | SUP 4
OutPort_14080762_2 | SOURCE | VENTILATION | SUP 4
InPort_14080762_1 | SINK | VENTILATION | SUP 4
OutPort_14080757_1 | SOURCE | VENTILATION | SUP 4
InPort_14151429_2 | SINK | VENTILATION | ODA 8
OutPort_14080866_0 | SOURCE | VENTILATION | ODA 8
InPort_14080866_1 | SINK | VENTILATION | ODA 8
InPort_14081772_1 | SINK | VENTILATION | ETA 2
OutPort_14080993_0 | SOURCE | VENTILATION | ETA 2
InPort_14080993_1 | SINK | VENTILATION | ETA 2
OutPort_14081417_2 | SOURCE | VENTILATION | ETA 2
InPort_14081136_0 | SINK | VENTILATION | ETA 2
