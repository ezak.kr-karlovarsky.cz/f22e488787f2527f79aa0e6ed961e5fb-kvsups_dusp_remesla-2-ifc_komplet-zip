Properties of the parts of a building model (IFC4), part 15 of 45

# IfcAirTerminal: Dýzy:AJD-315 (20)
Name (Dýzy:AJD-315:...) | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Název systému = Group | Kód prvku | Označení
13894565 | 2763.94 | SUP 11 | VV.05.0194 | 0194
13894568 | 2763.94 | SUP 11 | VV.05.0195 | 0195
13924796 | 2758.94 | SUP 11 | VV.05.0265 | 0265
14132088 | 2748.94 | SUP 11 | VV.05.0586 | 0586
14132098 | 2729.94 | SUP 11 | VV.05.0587 | 0587
14132490 | 2805.39 | SUP 11 | VV.05.0588 | 0588
14132498 | 2808.94 | SUP 11 | VV.05.0589 | 0589
14181635 | 2749 | SUP 15 | VV.05.0603 | 0603
14181636 | 2749 | SUP 15 | VV.05.0604 | 0604
14181637 | 2789 | SUP 15 | VV.05.0605 | 0605
14181638 | 2770 | SUP 15 | VV.05.0606 | 0606
14181807 | 2816.6 | SUP 15 | VV.05.0607 | 0607
14181808 | 2879 | SUP 15 | VV.05.0608 | 0608
14181809 | 2880 | SUP 15 | VV.05.0609 | 0609
14182360 | 2756.6 | SUP 26 | VV.05.0610 | 0610
14182361 | 2811.6 | SUP 15 | VV.05.0611 | 0611
14182362 | 2815 | SUP 15 | VV.05.0612 | 0612

# IfcAirTerminal: Mřížka - odvod:TRS-K, H 75, L 225-1225 (275)
Type - Material: 255-0-0
Type - Požární ochrana - Požární odolnost: A1
Type - Mechanické – tok - Max. průtok: 0.008 m3/s; Min. průtok: 0.0015 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Tloušťka panelu: 7 mm; Výška: 27 mm
Type - Identifikační data - Kód sestavy: VV07; Model: TRS - K; Název typu: TRS-K, H 75, L 225-1225; Označení typu: 01; Popis sestavy: Mřížka; Výrobce: TROX
Type - Jiné - Kategorie: Vyústky vzduchotechniky; Název rodiny: Mřížka - odvod
Classification: VV07 Uniformat (Uniformat)
Mechanické – tok - Proudění vzduchu: 0 m3/s; Průtok: 0 m3/s; Tlakový spád: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: NAC; CCI Technický systém: HF
Mechanické - Typ systému: Odváděný; Klasifikace systému: Zpětný vzduch; Zkratka systému: ETA
Kóty - Průměr vedení: 250 mm; Výška mřížky T: 94 mm
Jiné - Id typu: 13431859; Rodina: Mřížka - odvod; Rodina a typ: Mřížka - odvod: TRS-K, H 75, L 225-1225; Typ: TRS-K, H 75, L 225-1225
Name (Mřížka - odvod:TRS-K, H 75, L 225-1225:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Délka (mm) = Délka L (mm) = Šířka potrubí (mm) | Délka mřížky (mm) | Objem (m3) | Plocha (m2) | Šířka (mm) = Šířka H (mm) = Výška potrubí (mm) | Šířka mřížky (mm) | Velikost | Kód prvku | Označení | Délka 1 (mm)
13629460 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3047.53 | Fáze 1 | ETA 8 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0001 | 0001 | 11.25 | Identifikační data - Komentáře: VZT 28
13629484 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3047.53 | Fáze 1 | ETA 8 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0002 | 0002 | 11.25 | Identifikační data - Komentáře: VZT 28
13629528 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3080.03 | Fáze 1 | ETA 8 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0003 | 0003 | 11.25 | Identifikační data - Komentáře: VZT 28
13629568 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3047.5 | Fáze 1 | ETA 8 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0004 | 0004 | 11.25 | Identifikační data - Komentáře: VZT 28
13629667 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3160 | Fáze 1 | ETA 8 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0005 | 0005 | 11.25 | Identifikační data - Komentáře: VZT 28
13629699 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3048.72 | Fáze 1 | ETA 8 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0006 | 0006 | 11.25 | Identifikační data - Komentáře: VZT 28
13712068 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2800 | Fáze 1 | ETA 3 | 630 | 684 | 0.0300576 | 0.485912 | 500 | 554 | 630 × 500 | VV07.01.0007 | 0007 | 31.5
13712413 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3050 | Fáze 1 | ETA 7 | 630 | 684 | 0.016946 | 0.314752 | 280 | 334 | 630 × 280 | VV07.01.0008 | 0008 | 31.5
13712464 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3050 | Fáze 1 | ETA 7 | 630 | 684 | 0.016946 | 0.314752 | 280 | 334 | 630 × 280 | VV07.01.0009 | 0009 | 31.5
13743397 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2827.52 | Fáze 1 | ETA 3 | 630 | 684 | 0.0300576 | 0.485912 | 500 | 554 | 630 × 500 | VV07.01.0010 | 0010 | 31.5
13743893 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2710.11 | Fáze 1 | ETA 3 | 630 | 684 | 0.0300576 | 0.485912 | 500 | 554 | 630 × 500 | VV07.01.0011 | 0011 | 31.5
13744745 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3000 | Fáze 1 | ETA 3 | 630 | 684 | 0.0300576 | 0.485912 | 500 | 554 | 630 × 500 | VV07.01.0012 | 0012 | 31.5
13769955 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2807.72 | Fáze 1 | ETA 7 | 630 | 684 | 0.016946 | 0.314752 | 280 | 334 | 630 × 280 | VV07.01.0014 | 0014 | 31.5
13770336 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2800 | Fáze 1 | ETA 7 | 500 | 554 | 0.0134753 | 0.259112 | 280 | 334 | 500 × 280 | VV07.01.0015 | 0015 | 25
13806768 | -2.PP_SO-102 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 3120.94 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0026 | 0026 | 11.25
13806794 | -2.PP_SO-102 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 3120.94 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0027 | 0027 | 11.25
13806838 | -2.PP_SO-102 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | 3120.94 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0028 | 0028 | 11.25
13869453 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2950 | Fáze 2 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0034 | 0034 | 11.25
13869489 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2950 | Fáze 2 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0035 | 0035 | 11.25
13869660 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2950 | Fáze 2 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0036 | 0036 | 11.25
13869684 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2950 | Fáze 2 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0037 | 0037 | 11.25
13869772 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3150 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0038 | 0038 | 11.25
13869800 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3150 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0039 | 0039 | 11.25
13869828 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3150 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0040 | 0040 | 11.25
13869895 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3000 | Fáze 1 | ETA 34 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0041 | 0041 | 11.25
13869919 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3000 | Fáze 1 | ETA 34 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0042 | 0042 | 11.25
13869943 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3000 | Fáze 1 | ETA 34 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0043 | 0043 | 11.25
13871945 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3100 | Fáze 2 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0044 | 0044 | 11.25
13871989 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3100 | Fáze 2 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0045 | 0045 | 11.25
13872203 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3100 | Fáze 2 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0046 | 0046 | 11.25
13872261 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3100 | Fáze 2 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0047 | 0047 | 11.25
13872493 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2995.73 | Fáze 1 | ETA 34 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0048 | 0048 | 11.25
13872571 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2995.73 | Fáze 1 | ETA 34 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0049 | 0049 | 11.25
13872664 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2995.73 | Fáze 1 | ETA 34 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0050 | 0050 | 11.25
13872737 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3020 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0051 | 0051 | 11.25
13872761 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3020 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0052 | 0052 | 11.25
13872781 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3020 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0053 | 0053 | 11.25
13873758 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3100 | Fáze 2 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0054 | 0054 | 11.25
13873814 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3100 | Fáze 2 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0055 | 0055 | 11.25
13873856 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3100 | Fáze 2 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0056 | 0056 | 11.25
13873931 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3100 | Fáze 2 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0057 | 0057 | 11.25
13874039 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3100 | Fáze 2 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0058 | 0058 | 11.25
13874320 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 1 | ETA 34 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0059 | 0059 | 11.25
13874398 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 1 | ETA 34 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0060 | 0060 | 11.25
13874453 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 1 | ETA 34 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0061 | 0061 | 11.25
13874598 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0062 | 0062 | 11.25
13874634 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0063 | 0063 | 11.25
13874728 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0064 | 0064 | 11.25
13892065 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2700 | Fáze 1 | ETA 12 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0183 | 0183 | 11.25
13892182 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2700 | Fáze 1 | ETA 12 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0184 | 0184 | 11.25
13892252 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2700 | Fáze 1 | ETA 12 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0185 | 0185 | 11.25
13892359 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2620 | Fáze 1 | ETA 12 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0186 | 0186 | 11.25
13892567 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2700 | Fáze 1 | ETA 12 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0187 | 0187 | 11.25
13901899 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2600 | Fáze 2 | ETA 17 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0196 | 0196 | 11.25
13902051 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2600 | Fáze 2 | ETA 17 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0197 | 0197 | 11.25
13902101 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2600 | Fáze 2 | ETA 17 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0198 | 0198 | 11.25
13903816 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3070 | Fáze 2 | ETA 17 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0201 | 0201 | 21.25
13906442 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3060 | Fáze 2 | ETA 7 | 525 | 579 | 0.0114077 | 0.232797 | 225 | 279 | 525 × 225 | VV07.01.0202 | 0202 | 26.25
13906801 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3095 | Fáze 2 | ETA 7 | 525 | 579 | 0.0114077 | 0.232797 | 225 | 279 | 525 × 225 | VV07.01.0203 | 0203 | 26.25
13906985 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3000 | Fáze 2 | ETA 7 | 525 | 579 | 0.0114077 | 0.232797 | 225 | 279 | 525 × 225 | VV07.01.0204 | 0204 | 26.25
13907159 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3028.08 | Fáze 2 | ETA 7 | 525 | 579 | 0.0114077 | 0.232797 | 225 | 279 | 525 × 225 | VV07.01.0205 | 0205 | 26.25
13907567 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3100 | Fáze 2 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0206 | 0206 | 11.25
13907591 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3100 | Fáze 2 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0207 | 0207 | 11.25
13907680 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3100 | Fáze 2 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0208 | 0208 | 11.25
13907714 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3100 | Fáze 2 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0209 | 0209 | 11.25
13909703 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3250 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0210 | 0210 | 11.25
13909834 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3250 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0211 | 0211 | 11.25
13909891 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3250 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0212 | 0212 | 11.25
13913438 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3250 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0222 | 0222 | 11.25
13913462 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3250 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0223 | 0223 | 11.25
13913490 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3250 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0224 | 0224 | 11.25
13914724 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2700 | Fáze 1 | ETA 12 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0231 | 0231 | 16.25
13914774 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2700 | Fáze 1 | ETA 12 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0232 | 0232 | 16.25
13924324 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3150 | Fáze 1 | ETA 18 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0261 | 0261 | 21.25
13924344 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3150 | Fáze 1 | ETA 18 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0262 | 0262 | 21.25
13924368 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3150 | Fáze 1 | ETA 18 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0263 | 0263 | 21.25
13924388 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3150 | Fáze 1 | ETA 18 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0264 | 0264 | 21.25
13936493 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2610 | Fáze 1 | ETA 12 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0295 | 0295 | 11.25
13938178 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2850 | Fáze 1 | ETA 12 | 425 | 479 | 0.00925486 | 0.195497 | 225 | 279 | 425 × 225 | VV07.01.0296 | 0296 | 21.25
13938357 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2851.43 | Fáze 1 | ETA 12 | 425 | 479 | 0.00925486 | 0.195497 | 225 | 279 | 425 × 225 | VV07.01.0297 | 0297 | 21.25
13938428 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2851.43 | Fáze 1 | ETA 12 | 425 | 479 | 0.00925486 | 0.195497 | 225 | 279 | 425 × 225 | VV07.01.0298 | 0298 | 21.25
13938479 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2902.86 | Fáze 1 | ETA 12 | 425 | 479 | 0.00925486 | 0.195497 | 225 | 279 | 425 × 225 | VV07.01.0299 | 0299 | 21.25
13938540 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2901.43 | Fáze 1 | ETA 12 | 425 | 479 | 0.00925486 | 0.195497 | 225 | 279 | 425 × 225 | VV07.01.0300 | 0300 | 21.25
13938830 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2829.72 | Fáze 1 | ETA 12 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0301 | 0301 | 21.25
13938885 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2829.72 | Fáze 1 | ETA 12 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0302 | 0302 | 21.25
13939219 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2909.72 | Fáze 1 | ETA 12 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0303 | 0303 | 11.25
13941110 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2260 | Fáze 1 | ETA 27 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0307 | 0307 | 16.25
13941418 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2677.23 | Fáze 1 | ETA 27 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0308 | 0308 | 16.25
13941825 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2287.5 | Fáze 1 | ETA 27 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0309 | 0309 | 16.25
13942022 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2260 | Fáze 1 | ETA 27 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0310 | 0310 | 16.25
13942967 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2270 | Fáze 1 | ETA 27 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0311 | 0311 | 16.25
13943385 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2270 | Fáze 1 | ETA 27 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0312 | 0312 | 16.25
13943657 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2270 | Fáze 1 | ETA 27 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0313 | 0313 | 16.25
13943892 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2855 | Fáze 1 | ETA 1 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.01.0314 | 0314 | 26.25
13943990 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2855 | Fáze 1 | ETA 1 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.01.0315 | 0315 | 26.25
13944055 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2855 | Fáze 1 | ETA 1 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.01.0316 | 0316 | 26.25
13944113 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2855 | Fáze 1 | ETA 1 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.01.0317 | 0317 | 26.25
13944189 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2855 | Fáze 1 | ETA 1 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.01.0318 | 0318 | 26.25
13944238 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2855 | Fáze 1 | ETA 1 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.01.0319 | 0319 | 26.25
13944283 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2780 | Fáze 1 | ETA 1 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.01.0320 | 0320 | 26.25
13944330 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2780 | Fáze 1 | ETA 1 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.01.0321 | 0321 | 26.25
13944382 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2780 | Fáze 1 | ETA 1 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.01.0322 | 0322 | 26.25
13944427 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2780 | Fáze 1 | ETA 1 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.01.0323 | 0323 | 26.25
13944481 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2780 | Fáze 1 | ETA 1 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.01.0324 | 0324 | 26.25
13944539 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2780 | Fáze 1 | ETA 1 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.01.0325 | 0325 | 26.25
13945619 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2840 | Fáze 1 | ETA 1 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.01.0326 | 0326 | 26.25
13945678 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2840 | Fáze 1 | ETA 1 | 525 | 579 | 0.00643486 | 0.165497 | 125 | 179 | 525 × 125 | VV07.01.0327 | 0327 | 26.25
13946640 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 1 | ETA 97 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0328 | 0328 | 21.25
13946670 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 1 | ETA 97 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0329 | 0329 | 21.25
13946748 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 1 | ETA 97 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0330 | 0330 | 21.25
13946784 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 1 | ETA 97 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0331 | 0331 | 21.25
13946814 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 1 | ETA 97 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0332 | 0332 | 21.25
13947019 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3150 | Fáze 1 | ETA 18 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0333 | 0333 | 21.25
13948158 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 2 | ETA 97 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0336 | 0336 | 21.25
13948182 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 2 | ETA 97 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0337 | 0337 | 21.25
13948245 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 2 | ETA 97 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0338 | 0338 | 21.25
13948283 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2483.11 | Fáze 2 | ETA 4 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0339 | 0339 | 21.25
13948313 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2427.06 | Fáze 2 | ETA 4 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0340 | 0340 | 21.25
13948385 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 1 | ETA 97 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0341 | 0341 | 21.25
13948415 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 1 | ETA 97 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0342 | 0342 | 21.25
13948485 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 1 | ETA 97 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0343 | 0343 | 21.25
13948513 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | Fáze 1 | ETA 97 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0344 | 0344 | 21.25
13954357 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 1 | ETA 23 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0345 | 0345 | 11.25
13956104 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3150 | Fáze 1 | ETA 18 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0350 | 0350 | 11.25
13956812 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2350 | Fáze 1 | ETA 27 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0355 | 0355 | 16.25
13957772 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2580 | Fáze 1 | ETA 14 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0356 | 0356 | 11.25
13960261 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3300 | Fáze 2 | ETA 17 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0357 | 0357 | 16.25
13962133 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2977.62 | Fáze 1 | ETA 27 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0359 | 0359 | 16.25
13962406 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3067.62 | Fáze 1 | ETA 27 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0360 | 0360 | 16.25
13962919 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2989.6 | Fáze 1 | ETA 27 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0361 | 0361 | 16.25
13962975 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2989.6 | Fáze 1 | ETA 27 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0362 | 0362 | 16.25
13964719 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3070 | Fáze 1 | ETA 27 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0363 | 0363 | 11.25
13965075 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3069.6 | Fáze 1 | ETA 27 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0364 | 0364 | 11.25
13966209 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3067.64 | Fáze 1 | ETA 27 | 225 | 279 | 0.00279646 | 0.083597 | 125 | 179 | 225 × 125 | VV07.01.0365 | 0365 | 11.25
13966264 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3067.64 | Fáze 1 | ETA 27 | 225 | 279 | 0.00279646 | 0.083597 | 125 | 179 | 225 × 125 | VV07.01.0366 | 0366 | 11.25
13970217 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2903.77 | Fáze 1 | ETA 7 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0385 | 0385 | 16.25
13970370 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2903.77 | Fáze 1 | ETA 7 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0386 | 0386 | 16.25
13970563 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2903.77 | Fáze 1 | ETA 7 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0387 | 0387 | 21.25
13970652 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2903.77 | Fáze 1 | ETA 7 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0388 | 0388 | 21.25
13972789 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3200 | Fáze 1 | ETA 29 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0389 | 0389 | 40
13973127 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3200 | Fáze 1 | ETA 6 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0390 | 0390 | 40 | Fázování - Bouráno ve FÁZI 2: yes
13973525 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3200 | Fáze 1 | ETA 92 | 500 | 554 | 0.0144228 | 0.272072 | 300 | 354 | 500 × 300 | VV07.01.0391 | 0391 | 25
13973655 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3200 | Fáze 1 | ETA 93 | 500 | 554 | 0.0144228 | 0.272072 | 300 | 354 | 500 × 300 | VV07.01.0392 | 0392 | 25
13973833 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3200 | Fáze 1 | ETA 94 | 500 | 554 | 0.0144228 | 0.272072 | 300 | 354 | 500 × 300 | VV07.01.0393 | 0393 | 25
13973861 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3200 | Fáze 1 | ETA 95 | 500 | 554 | 0.0144228 | 0.272072 | 300 | 354 | 500 × 300 | VV07.01.0394 | 0394 | 25
13974174 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3200 | Fáze 1 | ETA 62 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0395 | 0395 | 40
13974212 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3200 | Fáze 1 | ETA 61 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0396 | 0396 | 40
13974244 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3200 | Fáze 1 | ETA 60 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0397 | 0397 | 40
13974296 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3200 | Fáze 1 | ETA 59 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0398 | 0398 | 40
13974326 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3200 | Fáze 1 | ETA 58 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0399 | 0399 | 40
13974384 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3200 | Fáze 1 | ETA 57 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0400 | 0400 | 40
13974554 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3200 | Fáze 1 | ETA 63 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0401 | 0401 | 40
13975298 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3200 | Fáze 1 | ETA 48 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0402 | 0402 | 40
13975328 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3200 | Fáze 1 | ETA 47 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0403 | 0403 | 40
13975358 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3200 | Fáze 1 | ETA 45 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0404 | 0404 | 40
13975384 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3200 | Fáze 1 | ETA 46 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0405 | 0405 | 40
13975442 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3200 | Fáze 1 | ETA 44 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0406 | 0406 | 40
13975715 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3200 | Fáze 1 | ETA 43 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0407 | 0407 | 40
13975804 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3200 | Fáze 1 | ETA 42 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0408 | 0408 | 40
13976969 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3200 | Fáze 1 | ETA 51 | 500 | 554 | 0.00968501 | 0.207272 | 200 | 254 | 500 × 200 | VV07.01.0412 | 0412 | 25
13977031 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3100 | Fáze 1 | ETA 50 | 500 | 554 | 0.0144228 | 0.272072 | 300 | 354 | 500 × 300 | VV07.01.0413 | 0413 | 25
13977088 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3200 | Fáze 1 | ETA 49 | 500 | 554 | 0.0144228 | 0.272072 | 300 | 354 | 500 × 300 | VV07.01.0414 | 0414 | 25
13977173 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3200 | Fáze 1 | ETA 53 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0415 | 0415 | 40
13977215 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3200 | Fáze 1 | ETA 53 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0416 | 0416 | 40
13978125 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3200 | Fáze 1 | ETA 41 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0419 | 0419 | 40
13978207 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3200 | Fáze 1 | ETA 40 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0420 | 0420 | 40
13978337 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3200 | Fáze 1 | ETA 38 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0421 | 0421 | 40
13978439 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3200 | Fáze 1 | ETA 39 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0422 | 0422 | 40
13978872 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2827.52 | Fáze 1 | ETA 3 | 160 | 214 | 0.00393539 | 0.104352 | 250 | 304 | 160 × 250 | VV07.01.0423 | 0423 | 8
13978978 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3200 | Fáze 2 | ETA 73 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0424 | 0424 | 40
13979078 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3200 | Fáze 2 | ETA 74 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0425 | 0425 | 40
13979120 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3200 | Fáze 2 | ETA 75 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0426 | 0426 | 40
13979184 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3200 | Fáze 2 | ETA 76 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0427 | 0427 | 40
13979640 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3200 | Fáze 2 | ETA 78 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0429 | 0429 | 40
13979703 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3200 | Fáze 2 | ETA 79 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0430 | 0430 | 40
13979812 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3200 | Fáze 2 | ETA 33 | 500 | 554 | 0.0144228 | 0.272072 | 300 | 354 | 500 × 300 | VV07.01.0431 | 0431 | 25
13980216 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3200 | Fáze 2 | ETA 66 | 500 | 554 | 0.0144228 | 0.272072 | 300 | 354 | 500 × 300 | VV07.01.0432 | 0432 | 25
13980669 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3200 | Fáze 2 | ETA 67 | 500 | 554 | 0.00968501 | 0.207272 | 200 | 254 | 500 × 200 | VV07.01.0433 | 0433 | 25
13981123 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3200 | Fáze 2 | ETA 68 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0434 | 0434 | 40
13981608 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3200 | Fáze 1 | ETA 55 | 500 | 554 | 0.0144228 | 0.272072 | 300 | 354 | 500 × 300 | VV07.01.0435 | 0435 | 25
13981652 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3200 | Fáze 1 | ETA 56 | 500 | 554 | 0.0144228 | 0.272072 | 300 | 354 | 500 × 300 | VV07.01.0436 | 0436 | 25
13982925 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3200 | Fáze 2 | ETA 71 | 500 | 554 | 0.0144228 | 0.272072 | 300 | 354 | 500 × 300 | VV07.01.0440 | 0440 | 25
13982996 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3200 | Fáze 2 | ETA 72 | 500 | 554 | 0.0144228 | 0.272072 | 300 | 354 | 500 × 300 | VV07.01.0441 | 0441 | 25
13983093 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3200 | Fáze 2 | ETA 70 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0442 | 0442 | 40
13983139 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3200 | Fáze 2 | ETA 69 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0443 | 0443 | 40
13983666 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3200 | Fáze 1 | ETA 54 | 800 | 854 | 0.0229962 | 0.406472 | 300 | 354 | 800 × 300 | VV07.01.0444 | 0444 | 40
13985599 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3200 | Fáze 2 | ETA 89 | 500 | 554 | 0.0144228 | 0.272072 | 300 | 354 | 500 × 300 | VV07.01.0453 | 0453 | 25
13990289 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3200 | Fáze 1 | ETA 90 | 500 | 554 | 0.0144228 | 0.272072 | 300 | 354 | 500 × 300 | VV07.01.0455 | 0455 | 25
13990509 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2900 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0456 | 0456 | 11.25
13990660 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3200 | Fáze 1 | ETA 64 | 500 | 554 | 0.00968501 | 0.207272 | 200 | 254 | 500 × 200 | VV07.01.0457 | 0457 | 25
13991051 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2800 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0460 | 0460 | 11.25
13991074 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2800 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0461 | 0461 | 11.25
13992958 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2740 | Fáze 2 | ETA 17 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.01.0464 | 0464 | 26.25
13993056 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2740 | Fáze 2 | ETA 17 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.01.0465 | 0465 | 26.25
13993114 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2740 | Fáze 2 | ETA 17 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.01.0466 | 0466 | 26.25
13993179 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2740 | Fáze 2 | ETA 17 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.01.0467 | 0467 | 26.25
13993246 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2740 | Fáze 2 | ETA 17 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.01.0468 | 0468 | 26.25
13993276 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2740 | Fáze 2 | ETA 17 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.01.0469 | 0469 | 26.25
13993807 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2740 | Fáze 2 | ETA 17 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0470 | 0470 | 11.25
13994068 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2740 | Fáze 2 | ETA 17 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.01.0472 | 0472 | 26.25
13994092 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2740 | Fáze 2 | ETA 17 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.01.0473 | 0473 | 26.25
13994179 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2740 | Fáze 2 | ETA 17 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.01.0474 | 0474 | 26.25
13994248 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2820 | Fáze 2 | ETA 10 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0475 | 0475 | 21.25
13994272 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2820 | Fáze 2 | ETA 10 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0476 | 0476 | 21.25
13995423 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2850 | Fáze 1 | ETA 11 | 1025 | 1079 | 0.0308772 | 0.524867 | 315 | 369 | 1025 × 315 | VV07.01.0477 | 0477 | 51.25
13995779 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2975 | Fáze 1 | ETA 11 | 1025 | 1079 | 0.0308772 | 0.524867 | 315 | 369 | 1025 × 315 | VV07.01.0478 | 0478 | 51.25
13996428 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3100 | Fáze 1 | ETA 14 | 650 | 704 | 0.00948781 | 0.219572 | 150 | 204 | 650 × 150 | VV07.01.0479 | 0479 | 32.5
13998288 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3100 | Fáze 1 | ETA 14 | 800 | 854 | 0.0116595 | 0.264272 | 150 | 204 | 800 × 150 | VV07.01.0488 | 0488 | 40
13998324 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3100 | Fáze 1 | ETA 14 | 800 | 854 | 0.0116595 | 0.264272 | 150 | 204 | 800 × 150 | VV07.01.0489 | 0489 | 40
13999062 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3000 | Fáze 1 | ETA 14 | 425 | 479 | 0.00522206 | 0.138197 | 125 | 179 | 425 × 125 | VV07.01.0490 | 0490 | 21.25
13999083 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3000 | Fáze 1 | ETA 14 | 425 | 479 | 0.00522206 | 0.138197 | 125 | 179 | 425 × 125 | VV07.01.0491 | 0491 | 21.25
13999816 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2910 | Fáze 1 | ETA 14 | 625 | 679 | 0.00764766 | 0.192797 | 125 | 179 | 625 × 125 | VV07.01.0492 | 0492 | 31.25
13999841 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2910 | Fáze 1 | ETA 14 | 625 | 679 | 0.00764766 | 0.192797 | 125 | 179 | 625 × 125 | VV07.01.0493 | 0493 | 31.25
13999865 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2910 | Fáze 1 | ETA 14 | 625 | 679 | 0.00764766 | 0.192797 | 125 | 179 | 625 × 125 | VV07.01.0494 | 0494 | 31.25
14001007 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3300 | Fáze 2 | ETA 17 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0495 | 0495 | 16.25
14001172 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3300 | Fáze 2 | ETA 17 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0496 | 0496 | 16.25
14001959 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 3200 | Fáze 1 | ETA 65 | 500 | 554 | 0.0144228 | 0.272072 | 300 | 354 | 500 × 300 | VV07.01.0497 | 0497 | 25
14003829 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2600 | Fáze 2 | ETA 17 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0502 | 0502 | 11.25
14004942 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2600 | Fáze 2 | ETA 17 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0505 | 0505 | 11.25
14005138 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2600 | Fáze 2 | ETA 17 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0506 | 0506 | 11.25
14017191 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2739.7 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0519 | 0519 | 11.25
14017497 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2900 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0520 | 0520 | 11.25
14018051 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2950 | Fáze 2 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0521 | 0521 | 11.25
14018083 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 2950 | Fáze 2 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0522 | 0522 | 11.25
14029372 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 1 | ETA 23 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0523 | 0523 | 11.25
14035477 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3100 | Fáze 1 | ETA 14 | 650 | 704 | 0.00948781 | 0.219572 | 150 | 204 | 650 × 150 | VV07.01.0524 | 0524 | 32.5
14038239 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3000 | Fáze 1 | ETA 14 | 425 | 479 | 0.00522206 | 0.138197 | 125 | 179 | 425 × 125 | VV07.01.0525 | 0525 | 21.25
14039740 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3200 | Fáze 1 | ETA 98 | 500 | 554 | 0.0144228 | 0.272072 | 300 | 354 | 500 × 300 | VV07.01.0531 | 0531 | 25
14040492 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3200 | Fáze 1 | ETA 98 | 500 | 554 | 0.0144228 | 0.272072 | 300 | 354 | 500 × 300 | VV07.01.0533 | 0533 | 25
14040910 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2800 | Fáze 1 | ETA 3 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0534 | 0534 | 11.25
14048925 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2850 | Fáze 1 | ETA 11 | 1025 | 1079 | 0.0308772 | 0.524867 | 315 | 369 | 1025 × 315 | VV07.01.0535 | 0535 | 51.25
14048933 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2850 | Fáze 1 | ETA 11 | 1025 | 1079 | 0.0308772 | 0.524867 | 315 | 369 | 1025 × 315 | VV07.01.0536 | 0536 | 51.25
14049247 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2975 | Fáze 1 | ETA 11 | 1025 | 1079 | 0.0308772 | 0.524867 | 315 | 369 | 1025 × 315 | VV07.01.0537 | 0537 | 51.25
14049255 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3145 | Fáze 1 | ETA 11 | 1025 | 1079 | 0.0308772 | 0.524867 | 315 | 369 | 1025 × 315 | VV07.01.0538 | 0538 | 51.25
14052537 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2580 | Fáze 1 | ETA 14 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0540 | 0540 | 11.25
14053373 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2910 | Fáze 1 | ETA 14 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0541 | 0541 | 11.25
14053657 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2580 | Fáze 1 | ETA 14 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0542 | 0542 | 16.25
14053725 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2580 | Fáze 1 | ETA 14 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0543 | 0543 | 16.25
14053807 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2580 | Fáze 1 | ETA 14 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0544 | 0544 | 16.25
14053858 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2910 | Fáze 1 | ETA 14 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0545 | 0545 | 16.25
14053950 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2580 | Fáze 1 | ETA 14 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0546 | 0546 | 11.25
14054046 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2580 | Fáze 1 | ETA 14 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0547 | 0547 | 16.25
14054083 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2580 | Fáze 1 | ETA 14 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0548 | 0548 | 16.25
14054134 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2580 | Fáze 1 | ETA 14 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0549 | 0549 | 16.25
14054251 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2580 | Fáze 1 | ETA 14 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0550 | 0550 | 16.25
14054560 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2580 | Fáze 1 | ETA 14 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0551 | 0551 | 16.25
14055608 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3100 | Fáze 1 | ETA 14 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0555 | 0555 | 11.25
14056054 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2900 | Fáze 1 | ETA 3 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0557 | 0557 | 11.25
14056139 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 2900 | Fáze 1 | ETA 3 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0558 | 0558 | 11.25
14056567 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3095 | Fáze 1 | ETA 23 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0559 | 0559 | 11.25
14057132 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2903.77 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0560 | 0560 | 11.25
14058383 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2903.77 | Fáze 1 | ETA 7 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0563 | 0563 | 16.25
14058443 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2903.77 | Fáze 1 | ETA 7 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0564 | 0564 | 16.25
14059538 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3200 | Fáze 1 | ETA 99 | 500 | 554 | 0.0144228 | 0.272072 | 300 | 354 | 500 × 300 | VV07.01.0567 | 0567 | 25
14061075 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3000 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0568 | 0568 | 11.25
14061154 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3000 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0569 | 0569 | 11.25
14061233 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3000 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0570 | 0570 | 11.25
14065329 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3270 | Fáze 2 | ETA 17 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0576 | 0576 | 16.25
14065520 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2763.77 | Fáze 2 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0577 | 0577 | 11.25
14075740 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3200.01 | Fáze 1 | ETA 14 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.01.0579 | 0579 | 26.25
14075873 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3200.01 | Fáze 1 | ETA 14 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.01.0580 | 0580 | 26.25
14075941 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 3200.01 | Fáze 1 | ETA 14 | 525 | 579 | 0.00394846 | 0.131847 | 75 | 129 | 525 × 75 | VV07.01.0581 | 0581 | 26.25
14081649 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3300 | Fáze 2 | ETA 2 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0583 | 0583 | 11.25
14081846 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3300 | Fáze 2 | ETA 2 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0584 | 0584 | 11.25
14082208 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3300 | Fáze 2 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0585 | 0585 | 11.25
14136278 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 3250 | Fáze 2 | ETA 17 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0590 | 0590 | 11.25
14137160 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2270 | Fáze 1 | ETA 27 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0592 | 0592 | 16.25
14137351 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2270.35 | Fáze 1 | ETA 27 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0593 | 0593 | 16.25
14139103 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2404.86 | Fáze 1 | ETA 1 | 625 | 679 | 0.00469126 | 0.154147 | 75 | 129 | 625 × 75 | VV07.01.0595 | 0595 | 31.25
14149259 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2763.77 | Fáze 2 | ETA 7 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0596 | 0596 | 21.25
14150524 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2763.77 | Fáze 2 | ETA 7 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.01.0597 | 0597 | 21.25
14150595 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | 2763.77 | Fáze 2 | ETA 7 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0598 | 0598 | 16.25
14152392 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | 2725 | Fáze 1 | ETA 12 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.01.0599 | 0599 | 16.25
14165237 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3230 | Fáze 1 | ETA 7 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0602 | 0602 | 11.25
14187160 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2600 | Fáze 2 | ETA 17 | 225 | 279 | 0.00172006 | 0.064947 | 75 | 129 | 225 × 75 | VV07.01.0613 | 0613 | 11.25

# IfcAirTerminal: Mřížka - odvod:TRS-K, H 75, L 225-1225, Mřížka - odvod:TRS-K, H 75, L 225-1225:13916309
In: 2.NP_SO-102
Type - Material: <Unnamed>
Type - Požární ochrana - Požární odolnost: A1
Type - Mechanické – tok - Max. průtok: 0.008 m3/s; Min. průtok: 0.0015 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Tloušťka panelu: 7 mm; Výška: 27 mm
Type - Identifikační data - Kód sestavy: VV07; Model: TRS - K; Název typu: TRS-K, H 75, L 225-1225; Označení typu: 01; Popis sestavy: Mřížka; Výrobce: TROX
Type - Jiné - Kategorie: Vyústky vzduchotechniky; Název rodiny: Mřížka - odvod
Classification: VV07 Uniformat (Uniformat)
Mechanické – tok - Proudění vzduchu: 0 m3/s; Průtok: 0 m3/s; Tlakový spád: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: NAC; CCI Technický systém: HF
Vazby - Podlaží: 2.NP_SO-102; Hostitel: Podlaží : 2.NP_SO-102; Odsazení od hostitele: 1179.38 mm; Výška od podlaží: 1179.38 mm
Fázování - Fáze vytvoření: Fáze 1
Mechanické - Klasifikace systému: Zpětný vzduch
Kóty - Délka: 630 mm; Délka L: 630 mm; Délka mřížky: 684 mm; Objem: 0.0240978 m3; Plocha: 0.408112 m2; Průměr vedení: 250 mm; Šířka: 400 mm; Šířka H: 400 mm; Šířka mřížky: 454 mm; Šířka potrubí: 630 mm; Velikost: 630 × 400; Výška mřížky T: 94 mm; Výška potrubí: 400 mm
Identifikační data - Kód prvku: VV07.01.0248; Označení: 0248
Jiné - Id typu: 13431859; Rodina: Mřížka - odvod; Rodina a typ: Mřížka - odvod: TRS-K, H 75, L 225-1225; Typ: TRS-K, H 75, L 225-1225; Délka 1: 31.5 mm

# IfcAirTerminal: Mřížka - přívod:TRS-K, H 75, L 225-1225 (276)
Type - Material: 0-0-255
Type - Požární ochrana - Požární odolnost: A1
Type - Mechanické – tok - Max. průtok: 0.008 m3/s; Min. průtok: 0.0015 m3/s
Type - Vazby - Výchozí výška: 0 mm
Type - Kóty - Tloušťka panelu: 7 mm; Výška: 27 mm
Type - Identifikační data - Kód sestavy: VV07; Model: TRS - K; Název typu: TRS-K, H 75, L 225-1225; Označení typu: 04; Popis sestavy: Mřížka; Výrobce: TROX
Type - Jiné - Kategorie: Vyústky vzduchotechniky; Název rodiny: Mřížka - přívod
Classification: VV07 Uniformat (Uniformat)
Mechanické – tok - Proudění vzduchu: 0 m3/s; Průtok: 0 m3/s; Tlakový spád: 0 Pa
Text - CCI Funkční systém: J; CCI Komponenta: NAC; CCI Technický systém: HF
Mechanické - Typ systému: Přívodní; Klasifikace systému: Přívod vzduchu; Zkratka systému: SUP
Kóty - Průměr vedení: 250 mm; Výška mřížky T: 94 mm
Jiné - Typ: TRS-K, H 75, L 225-1225; Id typu: 13433494; Rodina: Mřížka - přívod; Rodina a typ: Mřížka - přívod: TRS-K, H 75, L 225-1225
Name (Mřížka - přívod:TRS-K, H 75, L 225-1225:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Fáze vytvoření | Název systému = Group | Délka (mm) = Délka L (mm) = Šířka potrubí (mm) | Délka mřížky (mm) | Objem (m3) | Plocha (m2) | Šířka (mm) = Šířka H (mm) = Výška potrubí (mm) | Šířka mřížky (mm) | Velikost | Kód prvku | Označení | Délka 1 (mm)
13880191 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0065 | 0065 | 16.25
13880223 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0066 | 0066 | 16.25
13880488 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0067 | 0067 | 16.25
13880512 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0068 | 0068 | 16.25
13880726 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0069 | 0069 | 21.25
13880785 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0070 | 0070 | 21.25
13880809 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 2 | SUP 24 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0071 | 0071 | 21.25
13880978 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 1 | SUP 24 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0072 | 0072 | 21.25
13881002 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 1 | SUP 24 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0073 | 0073 | 21.25
13881144 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 1 | SUP 21 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0074 | 0074 | 21.25
13881176 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 1 | SUP 21 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0075 | 0075 | 21.25
13881200 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 1 | SUP 21 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0076 | 0076 | 21.25
13881340 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 1 | SUP 39 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0077 | 0077 | 21.25
13881376 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 1 | SUP 39 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0078 | 0078 | 21.25
13881404 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 1 | SUP 39 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0079 | 0079 | 21.25
13881535 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 1 | SUP 24 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0080 | 0080 | 21.25
13881563 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 1 | SUP 24 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0081 | 0081 | 21.25
13881591 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 1 | SUP 24 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0082 | 0082 | 21.25
13881819 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 1 | SUP 13 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0083 | 0083 | 21.25
13881847 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 1 | SUP 13 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0084 | 0084 | 21.25
13881867 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 1 | SUP 13 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0085 | 0085 | 21.25
13881924 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3180 | Fáze 1 | SUP 40 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0086 | 0086 | 16.25
13881948 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3180 | Fáze 1 | SUP 40 | 325 | 379 | 0.00246286 | 0.087247 | 75 | 129 | 325 × 75 | VV07.04.0087 | 0087 | 16.25
13882091 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 2 | SUP 18 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0088 | 0088 | 21.25
13882115 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 2 | SUP 18 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0089 | 0089 | 21.25
13882371 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 2 | SUP 18 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0090 | 0090 | 21.25
13882395 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 2 | SUP 18 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0091 | 0091 | 21.25
13882523 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 2 | SUP 18 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0092 | 0092 | 21.25
13882591 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 2 | SUP 18 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0093 | 0093 | 21.25
13882637 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 2 | SUP 18 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0094 | 0094 | 21.25
13882745 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 2 | SUP 18 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0095 | 0095 | 21.25
13882769 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 2 | SUP 18 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0096 | 0096 | 21.25
13882797 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 3095 | Fáze 2 | SUP 18 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0097 | 0097 | 21.25
13883058 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3040 | Fáze 1 | SUP 1 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0098 | 0098 | 21.25
13883082 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3040 | Fáze 1 | SUP 1 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0099 | 0099 | 21.25
13883110 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | 3040 | Fáze 1 | SUP 1 | 425 | 479 | 0.00320566 | 0.109547 | 75 | 129 | 425 × 75 | VV07.04.0100 | 0100 | 21.25
