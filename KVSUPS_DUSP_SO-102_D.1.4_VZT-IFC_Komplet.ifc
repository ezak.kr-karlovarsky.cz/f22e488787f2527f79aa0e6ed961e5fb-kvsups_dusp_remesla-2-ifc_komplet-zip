Properties of the parts of a building model (IFC4), part 22 of 45

# IfcDistributionPort (8507)
Name | FlowDirection | SystemType | Group
InPort_13889124_1 | SINK | VENTILATION | SUP 24
OutPort_13156216_4 | SOURCE | VENTILATION | SUP 24
InPort_13877598_1 | SINK | VENTILATION | SUP 24
OutPort_13156225_0 | SOURCE | VENTILATION | SUP 24
InPort_13156225_1 | SINK | VENTILATION | SUP 24
OutPort_13156257_1 | SOURCE | VENTILATION | SUP 24
InPort_13156231_1 | SINK | VENTILATION | SUP 24
OutPort_13876931_0 | SOURCE | VENTILATION | SUP 24
InPort_13876967_0 | SINK | VENTILATION | SUP 24
OutPort_13156231_2 | SOURCE | VENTILATION | SUP 24
InPort_13156234_0 | SINK | VENTILATION | SUP 24
OutPort_13156249_3 | SOURCE | VENTILATION | SUP 24
InPort_13156257_2 | SINK | VENTILATION | SUP 24
OutPort_13156234_1 | SOURCE | VENTILATION | SUP 24
InPort_13156249_2 | SINK | VENTILATION | SUP 24
OutPort_13156250_1 | SOURCE | VENTILATION | SUP 24
InPort_13156250_0 | SINK | VENTILATION | SUP 24
OutPort_13156320_2 | SOURCE | VENTILATION | SUP 24
Port_13156261_0 | SOURCEANDSINK | VENTILATION | SUP 55
Port_13877828_1 | SOURCEANDSINK | VENTILATION | SUP 55
Port_13156261_1 | SOURCEANDSINK | VENTILATION | SUP 55
InPort_13889162_1 | SINK | VENTILATION | SUP 55
OutPort_13156261_2 | SOURCE | VENTILATION | SUP 55
InPort_13889188_1 | SINK | VENTILATION | SUP 55
OutPort_13156261_3 | SOURCE | VENTILATION | SUP 55
InPort_13889212_1 | SINK | VENTILATION | SUP 55
OutPort_13156261_4 | SOURCE | VENTILATION | SUP 55
Port_13156279_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13156292_3 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13156279_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877365_2 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13156320_1 | SINK | VENTILATION | SUP 24
OutPort_13156292_1 | SOURCE | VENTILATION | SUP 24
Port_13156292_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13156293_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13156293_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13820288_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13156340_0 | SOURCEANDSINK | VENTILATION | SUP 57
Port_13877897_1 | SOURCEANDSINK | VENTILATION | SUP 57
Port_13156340_1 | SOURCEANDSINK | VENTILATION | SUP 57
InPort_13889302_1 | SINK | VENTILATION | SUP 57
OutPort_13156340_2 | SOURCE | VENTILATION | SUP 57
InPort_13889328_1 | SINK | VENTILATION | SUP 57
OutPort_13156340_3 | SOURCE | VENTILATION | SUP 57
InPort_13889360_1 | SINK | VENTILATION | SUP 57
OutPort_13156340_4 | SOURCE | VENTILATION | SUP 57
Port_13156349_0 | SOURCEANDSINK | VENTILATION | SUP 57
Port_13877662_1 | SOURCEANDSINK | VENTILATION | SUP 57
Port_13156349_1 | SOURCEANDSINK | VENTILATION | SUP 57
Port_13712965_1 | SOURCEANDSINK | VENTILATION | SUP 57
Port_13156358_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877294_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13156358_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877285_3 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13156371_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877285_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13156371_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13877205_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13156887_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157246_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13156887_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13156922_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13156897_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868724_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13156897_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13197384_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13156922_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13818739_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13156980_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868626_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13156980_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13880978_1 | SINK | VENTILATION | SUP 24
OutPort_13156980_2 | SOURCE | VENTILATION | SUP 24
InPort_13881002_1 | SINK | VENTILATION | SUP 24
OutPort_13156980_3 | SOURCE | VENTILATION | SUP 24
Port_13157102_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14123627_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157102_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157130_0 | SOURCEANDSINK | VENTILATION | SUP 39
Port_13868661_1 | SOURCEANDSINK | VENTILATION | SUP 39
Port_13157130_1 | SOURCEANDSINK | VENTILATION | SUP 39
Port_13868706_1 | SOURCEANDSINK | VENTILATION | SUP 39
Port_13157139_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868793_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157139_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868732_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157165_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13818737_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157165_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13868760_2 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13868887_1 | SINK | VENTILATION | SUP 24
OutPort_13157192_0 | SOURCE | VENTILATION | SUP 24
InPort_13157192_1 | SINK | VENTILATION | SUP 24
OutPort_13157207_2 | SOURCE | VENTILATION | SUP 24
InPort_13868921_1 | SINK | VENTILATION | SUP 24
OutPort_13157201_0 | SOURCE | VENTILATION | SUP 24
InPort_13157201_1 | SINK | VENTILATION | SUP 24
OutPort_13157254_1 | SOURCE | VENTILATION | SUP 24
InPort_13157207_1 | SINK | VENTILATION | SUP 24
OutPort_13868917_0 | SOURCE | VENTILATION | SUP 24
InPort_13157236_0 | SINK | VENTILATION | SUP 24
OutPort_13157246_3 | SOURCE | VENTILATION | SUP 24
InPort_13157254_2 | SINK | VENTILATION | SUP 24
OutPort_13157236_1 | SOURCE | VENTILATION | SUP 24
Port_13157246_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13479475_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157276_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157650_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157276_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157315_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157294_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13635396_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157294_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157651_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157315_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157606_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157338_1 | SOURCEANDSINK | VENTILATION | SUP 1
Port_13157338_2 | SOURCEANDSINK | VENTILATION | SUP 1
Port_13819759_0 | SOURCEANDSINK | VENTILATION | SUP 1
InPort_13837936_0 | SINK | VENTILATION | SUP 1
OutPort_13157382_1 | SOURCE | VENTILATION | SUP 1
InPort_13157382_2 | SINK | VENTILATION | SUP 1
InPort_13837770_2 | SINK | VENTILATION | SUP 1
OutPort_13157387_0 | SOURCE | VENTILATION | SUP 1
InPort_13157387_1 | SINK | VENTILATION | SUP 1
OutPort_13837935_1 | SOURCE | VENTILATION | SUP 1
InPort_13157431_0 | SINK | VENTILATION | SUP 1
OutPort_13884951_1 | SOURCE | VENTILATION | SUP 1
Port_13157431_1 | SOURCEANDSINK | VENTILATION | SUP 1
InPort_13883058_1 | SINK | VENTILATION | SUP 1
OutPort_13157431_2 | SOURCE | VENTILATION | SUP 1
InPort_13883082_1 | SINK | VENTILATION | SUP 1
OutPort_13157431_3 | SOURCE | VENTILATION | SUP 1
InPort_13883110_1 | SINK | VENTILATION | SUP 1
OutPort_13157431_4 | SOURCE | VENTILATION | SUP 1
InPort_13157493_0 | SINK | VENTILATION | SUP 1
OutPort_13885164_2 | SOURCE | VENTILATION | SUP 1
Port_13157493_1 | SOURCEANDSINK | VENTILATION | SUP 1
InPort_13883175_1 | SINK | VENTILATION | SUP 1
OutPort_13157493_2 | SOURCE | VENTILATION | SUP 1
InPort_13883199_1 | SINK | VENTILATION | SUP 1
OutPort_13157493_3 | SOURCE | VENTILATION | SUP 1
InPort_13883227_1 | SINK | VENTILATION | SUP 1
OutPort_13157493_4 | SOURCE | VENTILATION | SUP 1
InPort_13885168_2 | SINK | VENTILATION | SUP 1
OutPort_13157502_0 | SOURCE | VENTILATION | SUP 1
InPort_13157502_1 | SINK | VENTILATION | SUP 1
OutPort_13837776_2 | SOURCE | VENTILATION | SUP 1
InPort_13157535_0 | SINK | VENTILATION | SUP 1
OutPort_13885621_1 | SOURCE | VENTILATION | SUP 1
Port_13157535_1 | SOURCEANDSINK | VENTILATION | SUP 1
InPort_13883490_1 | SINK | VENTILATION | SUP 1
OutPort_13157535_2 | SOURCE | VENTILATION | SUP 1
InPort_13883518_1 | SINK | VENTILATION | SUP 1
OutPort_13157535_3 | SOURCE | VENTILATION | SUP 1
InPort_13883546_1 | SINK | VENTILATION | SUP 1
OutPort_13157535_4 | SOURCE | VENTILATION | SUP 1
InPort_13885409_1 | SINK | VENTILATION | SUP 1
OutPort_13157544_0 | SOURCE | VENTILATION | SUP 1
InPort_13157544_1 | SINK | VENTILATION | SUP 1
OutPort_13157571_1 | SOURCE | VENTILATION | SUP 1
InPort_13157550_1 | SINK | VENTILATION | SUP 1
OutPort_13885405_0 | SOURCE | VENTILATION | SUP 1
InPort_13885617_0 | SINK | VENTILATION | SUP 1
OutPort_13157550_2 | SOURCE | VENTILATION | SUP 1
InPort_13157553_0 | SINK | VENTILATION | SUP 1
OutPort_13157563_3 | SOURCE | VENTILATION | SUP 1
InPort_13157571_2 | SINK | VENTILATION | SUP 1
OutPort_13157553_1 | SOURCE | VENTILATION | SUP 1
Port_13157563_1 | SOURCEANDSINK | VENTILATION | SUP 1
Port_13157563_2 | SOURCEANDSINK | VENTILATION | SUP 1
Port_13157564_1 | SOURCEANDSINK | VENTILATION | SUP 1
Port_13157564_0 | SOURCEANDSINK | VENTILATION | SUP 1
Port_13819757_1 | SOURCEANDSINK | VENTILATION | SUP 1
InPort_13885651_1 | SINK | VENTILATION | SUP 1
OutPort_13157575_0 | SOURCE | VENTILATION | SUP 1
InPort_13157575_1 | SINK | VENTILATION | SUP 1
OutPort_13157590_2 | SOURCE | VENTILATION | SUP 1
InPort_13885482_1 | SINK | VENTILATION | SUP 1
OutPort_13157584_0 | SOURCE | VENTILATION | SUP 1
InPort_13157584_1 | SINK | VENTILATION | SUP 1
OutPort_13157613_1 | SOURCE | VENTILATION | SUP 1
InPort_13157590_1 | SINK | VENTILATION | SUP 1
OutPort_13885443_0 | SOURCE | VENTILATION | SUP 1
Port_13157593_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157605_3 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157593_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157605_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157605_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157606_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13157613_2 | SINK | VENTILATION | SUP 1
InPort_13885683_1 | SINK | VENTILATION | SUP 1
OutPort_13157617_0 | SOURCE | VENTILATION | SUP 1
InPort_13157617_1 | SINK | VENTILATION | SUP 1
OutPort_13157632_2 | SOURCE | VENTILATION | SUP 1
InPort_13885575_2 | SINK | VENTILATION | SUP 1
OutPort_13157626_0 | SOURCE | VENTILATION | SUP 1
InPort_13157626_1 | SINK | VENTILATION | SUP 1
OutPort_14147910_1 | SOURCE | VENTILATION | SUP 1
InPort_13157632_1 | SINK | VENTILATION | SUP 1
OutPort_13885547_0 | SOURCE | VENTILATION | SUP 1
InPort_14147910_2 | SINK | VENTILATION | SUP 1
OutPort_13157635_0 | SOURCE | VENTILATION | SUP 1
InPort_13157635_1 | SINK | VENTILATION | SUP 1
Port_13157650_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157651_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13157650_3 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13885760_1 | SINK | VENTILATION | SUP 24
OutPort_13157662_0 | SOURCE | VENTILATION | SUP 24
InPort_13157662_1 | SINK | VENTILATION | SUP 24
OutPort_13157722_2 | SOURCE | VENTILATION | SUP 24
InPort_13885838_1 | SINK | VENTILATION | SUP 24
OutPort_13157712_0 | SOURCE | VENTILATION | SUP 24
InPort_13157712_1 | SINK | VENTILATION | SUP 24
OutPort_13157791_1 | SOURCE | VENTILATION | SUP 24
InPort_13157722_1 | SINK | VENTILATION | SUP 24
OutPort_13885817_0 | SOURCE | VENTILATION | SUP 24
InPort_13157772_0 | SINK | VENTILATION | SUP 24
OutPort_13635347_1 | SOURCE | VENTILATION | SUP 24
InPort_13157791_2 | SINK | VENTILATION | SUP 24
OutPort_13157772_1 | SOURCE | VENTILATION | SUP 24
InPort_13157783_0 | SINK | VENTILATION | SUP 24
OutPort_13849011_1 | SOURCE | VENTILATION | SUP 24
InPort_13635347_2 | SINK | VENTILATION | SUP 24
OutPort_13157783_1 | SOURCE | VENTILATION | SUP 24
InPort_13429963_2 | SINK | VENTILATION | SUP 24
OutPort_13159250_0 | SOURCE | VENTILATION | SUP 24
InPort_13159250_1 | SINK | VENTILATION | SUP 24
OutPort_14079106_2 | SOURCE | VENTILATION | SUP 24
InPort_13159258_0 | SINK | VENTILATION | SUP 24
OutPort_14078943_1 | SOURCE | VENTILATION | SUP 24
InPort_13971154_1 | SINK | VENTILATION | SUP 24
OutPort_13159258_1 | SOURCE | VENTILATION | SUP 24
InPort_13160177_0 | SINK | VENTILATION | SUP 13
OutPort_13708506_3 | SOURCE | VENTILATION | SUP 13
InPort_13838113_2 | SINK | VENTILATION | SUP 13
OutPort_13160177_1 | SOURCE | VENTILATION | SUP 13
InPort_13160724_0 | SINK | VENTILATION | SUP 13
OutPort_13878277_1 | SOURCE | VENTILATION | SUP 13
Port_13160724_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13890270_1 | SINK | VENTILATION | SUP 13
OutPort_13160724_2 | SOURCE | VENTILATION | SUP 13
InPort_13890290_1 | SINK | VENTILATION | SUP 13
OutPort_13160724_3 | SOURCE | VENTILATION | SUP 13
Port_13160736_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13874840_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13160736_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13713657_0 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13713529_0 | SINK | VENTILATION | SUP 13
OutPort_13160736_3 | SOURCE | VENTILATION | SUP 13
InPort_14068086_1 | SINK | VENTILATION | SUP 13
OutPort_13161020_0 | SOURCE | VENTILATION | SUP 13
InPort_13161020_1 | SINK | VENTILATION | SUP 13
OutPort_13161035_1 | SOURCE | VENTILATION | SUP 13
InPort_13161035_2 | SINK | VENTILATION | SUP 13
OutPort_13929070_0 | SOURCE | VENTILATION | SUP 13
Port_13168448_0 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168988_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168448_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168491_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168458_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168458_2 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168989_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168481_0 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168862_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168481_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168514_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168491_2 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168863_0 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168494_0 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168514_2 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168494_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168558_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168548_0 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168558_2 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168548_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13747974_3 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168846_0 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168862_3 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168846_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13748236_3 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168862_2 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168863_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168978_0 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168988_3 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168978_1 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13769873_2 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168988_2 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13168989_0 | SOURCEANDSINK | VENTILATION | ETA 34
Port_13169015_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169023_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169015_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13765763_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169023_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13169023_2 | SINK | VENTILATION | ETA 7
OutPort_13169024_1 | SOURCE | VENTILATION | ETA 7
InPort_13169024_0 | SINK | VENTILATION | ETA 7
OutPort_14181086_1 | SOURCE | VENTILATION | ETA 7
Port_13169134_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13928644_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13169134_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13817828_2 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13929040_1 | SINK | VENTILATION | SUP 13
OutPort_13169156_0 | SOURCE | VENTILATION | SUP 13
InPort_13169156_1 | SINK | VENTILATION | SUP 13
OutPort_13817713_2 | SOURCE | VENTILATION | SUP 13
Port_13169199_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13702823_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169199_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169203_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169201_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169225_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169201_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169207_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169203_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169226_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169205_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169219_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169205_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169211_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169207_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169220_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169209_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169211_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169209_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169215_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169213_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169215_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169213_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13747875_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169217_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169219_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169217_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13748163_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169219_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169220_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169223_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169225_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169223_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769801_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169225_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169226_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13169472_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13169486_3 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13169472_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13169497_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13169486_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13228187_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13169486_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13169504_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13169487_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13817820_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13169487_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13169504_2 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13169843_0 | SINK | VENTILATION | SUP 12
OutPort_13908872_2 | SOURCE | VENTILATION | SUP 12
InPort_13914384_2 | SINK | VENTILATION | SUP 12
OutPort_13169843_1 | SOURCE | VENTILATION | SUP 12
Port_13170554_0 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13908144_1 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13170554_1 | SOURCEANDSINK | VENTILATION | SUP 12
Port_14176254_1 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13170618_0 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13914082_2 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13170618_1 | SOURCEANDSINK | VENTILATION | SUP 12
InPort_13913997_1 | SINK | VENTILATION | SUP 12
OutPort_13170618_2 | SOURCE | VENTILATION | SUP 12
Port_13170667_0 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13908144_2 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13170667_1 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13908110_1 | SOURCEANDSINK | VENTILATION | SUP 12
InPort_13913831_1 | SINK | VENTILATION | SUP 12
OutPort_13170667_2 | SOURCE | VENTILATION | SUP 12
InPort_13913895_1 | SINK | VENTILATION | SUP 12
OutPort_13170667_3 | SOURCE | VENTILATION | SUP 12
InPort_13908401_1 | SINK | VENTILATION | SUP 12
OutPort_13170795_0 | SOURCE | VENTILATION | SUP 12
InPort_13170795_1 | SINK | VENTILATION | SUP 12
OutPort_13911795_2 | SOURCE | VENTILATION | SUP 12
Port_13170808_1 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13914082_1 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13170808_2 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13170809_1 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13170808_3 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13908073_0 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13170809_0 | SOURCEANDSINK | VENTILATION | SUP 12
Port_13908110_2 | SOURCEANDSINK | VENTILATION | SUP 12
InPort_13913944_1 | SINK | VENTILATION | SUP 12
OutPort_13170809_2 | SOURCE | VENTILATION | SUP 12
InPort_13170925_0 | SINK | VENTILATION | SUP 12
OutPort_13908744_1 | SOURCE | VENTILATION | SUP 12
Port_13170925_1 | SOURCEANDSINK | VENTILATION | SUP 12
InPort_13924929_1 | SINK | VENTILATION | SUP 12
OutPort_13170925_2 | SOURCE | VENTILATION | SUP 12
InPort_13924957_1 | SINK | VENTILATION | SUP 12
OutPort_13170925_3 | SOURCE | VENTILATION | SUP 12
Port_13171125_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13713955_3 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13171125_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13714031_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13171197_0 | SOURCEANDSINK | VENTILATION | SUP 50
Port_13875045_1 | SOURCEANDSINK | VENTILATION | SUP 50
Port_13171197_1 | SOURCEANDSINK | VENTILATION | SUP 50
InPort_13969305_1 | SINK | VENTILATION | SUP 50
OutPort_13171197_2 | SOURCE | VENTILATION | SUP 50
InPort_13969335_1 | SINK | VENTILATION | SUP 50
OutPort_13171197_3 | SOURCE | VENTILATION | SUP 50
InPort_13969363_1 | SINK | VENTILATION | SUP 50
OutPort_13171197_4 | SOURCE | VENTILATION | SUP 50
Port_13171217_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13171225_3 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13171217_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13200015_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13171225_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13171226_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13171225_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13849950_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13171226_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13713955_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13171337_0 | SOURCEANDSINK | VENTILATION | SUP 22
Port_13875629_1 | SOURCEANDSINK | VENTILATION | SUP 22
Port_13171337_1 | SOURCEANDSINK | VENTILATION | SUP 22
InPort_13969205_1 | SINK | VENTILATION | SUP 22
OutPort_13171337_2 | SOURCE | VENTILATION | SUP 22
InPort_13969225_1 | SINK | VENTILATION | SUP 22
OutPort_13171337_3 | SOURCE | VENTILATION | SUP 22
InPort_13969245_1 | SINK | VENTILATION | SUP 22
OutPort_13171337_4 | SOURCE | VENTILATION | SUP 22
Port_13171512_0 | SOURCEANDSINK | VENTILATION | SUP 22
Port_13875902_1 | SOURCEANDSINK | VENTILATION | SUP 22
Port_13171512_1 | SOURCEANDSINK | VENTILATION | SUP 22
Port_13708172_2 | SOURCEANDSINK | VENTILATION | SUP 22
InPort_13171603_0 | SINK | VENTILATION | SUP 24
OutPort_13969148_2 | SOURCE | VENTILATION | SUP 24
Port_13171603_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13968888_1 | SINK | VENTILATION | SUP 24
OutPort_13171603_2 | SOURCE | VENTILATION | SUP 24
InPort_13968922_1 | SINK | VENTILATION | SUP 24
OutPort_13171603_3 | SOURCE | VENTILATION | SUP 24
InPort_13968950_1 | SINK | VENTILATION | SUP 24
OutPort_13171603_4 | SOURCE | VENTILATION | SUP 24
InPort_13884652_1 | SINK | VENTILATION | SUP 24
OutPort_13172049_0 | SOURCE | VENTILATION | SUP 24
InPort_13172049_1 | SINK | VENTILATION | SUP 24
OutPort_13172053_1 | SOURCE | VENTILATION | SUP 24
InPort_13172053_2 | SINK | VENTILATION | SUP 24
OutPort_13884263_0 | SOURCE | VENTILATION | SUP 24
InPort_13172217_0 | SINK | VENTILATION | SUP 24
OutPort_13884576_1 | SOURCE | VENTILATION | SUP 24
Port_13172217_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13887108_1 | SINK | VENTILATION | SUP 24
OutPort_13172217_2 | SOURCE | VENTILATION | SUP 24
InPort_13887132_1 | SINK | VENTILATION | SUP 24
OutPort_13172217_3 | SOURCE | VENTILATION | SUP 24
InPort_13887166_1 | SINK | VENTILATION | SUP 24
OutPort_13172217_4 | SOURCE | VENTILATION | SUP 24
InPort_13884434_1 | SINK | VENTILATION | SUP 24
OutPort_13172226_0 | SOURCE | VENTILATION | SUP 24
InPort_13172226_1 | SINK | VENTILATION | SUP 24
OutPort_13884404_1 | SOURCE | VENTILATION | SUP 24
InPort_13172235_0 | SINK | VENTILATION | SUP 24
OutPort_13172245_3 | SOURCE | VENTILATION | SUP 24
InPort_13884404_2 | SINK | VENTILATION | SUP 24
OutPort_13172235_1 | SOURCE | VENTILATION | SUP 24
InPort_13172245_1 | SINK | VENTILATION | SUP 24
OutPort_13714189_0 | SOURCE | VENTILATION | SUP 24
InPort_13884458_1 | SINK | VENTILATION | SUP 24
OutPort_13172245_2 | SOURCE | VENTILATION | SUP 24
InPort_13884460_2 | SINK | VENTILATION | SUP 24
OutPort_13172246_0 | SOURCE | VENTILATION | SUP 24
InPort_13172246_1 | SINK | VENTILATION | SUP 24
OutPort_13884458_2 | SOURCE | VENTILATION | SUP 24
InPort_13867540_1 | SINK | VENTILATION | SUP 18
OutPort_13172740_0 | SOURCE | VENTILATION | SUP 18
InPort_13172740_1 | SINK | VENTILATION | SUP 18
OutPort_13879904_2 | SOURCE | VENTILATION | SUP 18
InPort_13879779_1 | SINK | VENTILATION | SUP 18
OutPort_13172742_0 | SOURCE | VENTILATION | SUP 18
InPort_13172742_1 | SINK | VENTILATION | SUP 18
OutPort_13866943_1 | SOURCE | VENTILATION | SUP 18
InPort_13172766_0 | SINK | VENTILATION | SUP 24
OutPort_13867751_1 | SOURCE | VENTILATION | SUP 24
Port_13172766_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13880191_1 | SINK | VENTILATION | SUP 24
OutPort_13172766_2 | SOURCE | VENTILATION | SUP 24
InPort_13880223_1 | SINK | VENTILATION | SUP 24
OutPort_13172766_3 | SOURCE | VENTILATION | SUP 24
InPort_13879740_1 | SINK | VENTILATION | SUP 18
OutPort_13172796_0 | SOURCE | VENTILATION | SUP 18
InPort_13172796_1 | SINK | VENTILATION | SUP 18
OutPort_13879787_1 | SOURCE | VENTILATION | SUP 18
InPort_13172800_0 | SINK | VENTILATION | SUP 18
OutPort_13867312_1 | SOURCE | VENTILATION | SUP 18
Port_13172800_1 | SOURCEANDSINK | VENTILATION | SUP 18
InPort_13882523_1 | SINK | VENTILATION | SUP 18
OutPort_13172800_2 | SOURCE | VENTILATION | SUP 18
InPort_13882591_1 | SINK | VENTILATION | SUP 18
OutPort_13172800_3 | SOURCE | VENTILATION | SUP 18
InPort_13882637_1 | SINK | VENTILATION | SUP 18
OutPort_13172800_4 | SOURCE | VENTILATION | SUP 18
InPort_13172869_0 | SINK | VENTILATION | SUP 24
OutPort_13714845_2 | SOURCE | VENTILATION | SUP 24
InPort_13714810_1 | SINK | VENTILATION | SUP 24
OutPort_13172869_1 | SOURCE | VENTILATION | SUP 24
InPort_13172882_0 | SINK | VENTILATION | SUP 24
OutPort_13867919_1 | SOURCE | VENTILATION | SUP 24
Port_13172882_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13880726_1 | SINK | VENTILATION | SUP 24
OutPort_13172882_2 | SOURCE | VENTILATION | SUP 24
InPort_13880785_1 | SINK | VENTILATION | SUP 24
OutPort_13172882_3 | SOURCE | VENTILATION | SUP 24
InPort_13880809_1 | SINK | VENTILATION | SUP 24
OutPort_13172882_4 | SOURCE | VENTILATION | SUP 24
InPort_13172900_0 | SINK | VENTILATION | SUP 24
OutPort_13880569_1 | SOURCE | VENTILATION | SUP 24
Port_13172900_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13880488_1 | SINK | VENTILATION | SUP 24
OutPort_13172900_2 | SOURCE | VENTILATION | SUP 24
InPort_13880512_1 | SINK | VENTILATION | SUP 24
OutPort_13172900_3 | SOURCE | VENTILATION | SUP 24
Port_13197339_0 | SOURCEANDSINK | VENTILATION | SUP 21
Port_13868527_1 | SOURCEANDSINK | VENTILATION | SUP 21
Port_13197339_1 | SOURCEANDSINK | VENTILATION | SUP 21
InPort_13881144_1 | SINK | VENTILATION | SUP 21
OutPort_13197339_2 | SOURCE | VENTILATION | SUP 21
InPort_13881176_1 | SINK | VENTILATION | SUP 21
OutPort_13197339_3 | SOURCE | VENTILATION | SUP 21
InPort_13881200_1 | SINK | VENTILATION | SUP 21
OutPort_13197339_4 | SOURCE | VENTILATION | SUP 21
Port_13197360_0 | SOURCEANDSINK | VENTILATION | SUP 21
Port_13868425_1 | SOURCEANDSINK | VENTILATION | SUP 21
Port_13197360_1 | SOURCEANDSINK | VENTILATION | SUP 21
Port_13706098_1 | SOURCEANDSINK | VENTILATION | SUP 21
Port_13197366_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13197384_3 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13197366_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13706018_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13197384_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14123656_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13867568_1 | SINK | VENTILATION | SUP 13
OutPort_13197465_0 | SOURCE | VENTILATION | SUP 13
InPort_13197465_1 | SINK | VENTILATION | SUP 13
OutPort_13867447_1 | SOURCE | VENTILATION | SUP 13
Port_13197535_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13869144_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13197535_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13198443_2 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13867718_1 | SINK | VENTILATION | SUP 24
OutPort_13197801_0 | SOURCE | VENTILATION | SUP 24
InPort_13197801_1 | SINK | VENTILATION | SUP 24
OutPort_13714810_2 | SOURCE | VENTILATION | SUP 24
InPort_13197813_1 | SINK | VENTILATION | SUP 24
OutPort_13867714_0 | SOURCE | VENTILATION | SUP 24
InPort_13867753_0 | SINK | VENTILATION | SUP 24
OutPort_13197813_2 | SOURCE | VENTILATION | SUP 24
InPort_13198072_0 | SINK | VENTILATION | SUP 18
OutPort_13867281_1 | SOURCE | VENTILATION | SUP 18
Port_13198072_1 | SOURCEANDSINK | VENTILATION | SUP 18
InPort_13882371_1 | SINK | VENTILATION | SUP 18
OutPort_13198072_2 | SOURCE | VENTILATION | SUP 18
InPort_13882395_1 | SINK | VENTILATION | SUP 18
OutPort_13198072_3 | SOURCE | VENTILATION | SUP 18
InPort_13198095_0 | SINK | VENTILATION | SUP 18
OutPort_13867161_1 | SOURCE | VENTILATION | SUP 18
Port_13198095_1 | SOURCEANDSINK | VENTILATION | SUP 18
InPort_13882091_1 | SINK | VENTILATION | SUP 18
OutPort_13198095_2 | SOURCE | VENTILATION | SUP 18
InPort_13882115_1 | SINK | VENTILATION | SUP 18
OutPort_13198095_3 | SOURCE | VENTILATION | SUP 18
InPort_13867208_1 | SINK | VENTILATION | SUP 18
OutPort_13198110_0 | SOURCE | VENTILATION | SUP 18
InPort_13198110_1 | SINK | VENTILATION | SUP 18
OutPort_13866987_2 | SOURCE | VENTILATION | SUP 18
Port_13198426_0 | SOURCEANDSINK | VENTILATION | SUP 40
Port_13198451_1 | SOURCEANDSINK | VENTILATION | SUP 40
Port_13198426_1 | SOURCEANDSINK | VENTILATION | SUP 40
InPort_13881924_1 | SINK | VENTILATION | SUP 40
OutPort_13198426_2 | SOURCE | VENTILATION | SUP 40
InPort_13881948_1 | SINK | VENTILATION | SUP 40
OutPort_13198426_3 | SOURCE | VENTILATION | SUP 40
Port_13198433_0 | SOURCEANDSINK | VENTILATION | SUP 40
Port_13869356_1 | SOURCEANDSINK | VENTILATION | SUP 40
Port_13198433_1 | SOURCEANDSINK | VENTILATION | SUP 40
Port_13198451_2 | SOURCEANDSINK | VENTILATION | SUP 40
Port_13198443_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13847757_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13198443_3 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13982697_0 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13198558_0 | SINK | VENTILATION | SUP 24
OutPort_13884378_2 | SOURCE | VENTILATION | SUP 24
InPort_13839524_1 | SINK | VENTILATION | SUP 24
OutPort_13198558_1 | SOURCE | VENTILATION | SUP 24
InPort_13198657_0 | SINK | VENTILATION | SUP 24
OutPort_13884554_1 | SOURCE | VENTILATION | SUP 24
Port_13198657_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13886879_1 | SINK | VENTILATION | SUP 24
OutPort_13198657_2 | SOURCE | VENTILATION | SUP 24
InPort_13886907_1 | SINK | VENTILATION | SUP 24
OutPort_13198657_3 | SOURCE | VENTILATION | SUP 24
InPort_13886998_1 | SINK | VENTILATION | SUP 24
OutPort_13198657_4 | SOURCE | VENTILATION | SUP 24
InPort_13198810_0 | SINK | VENTILATION | SUP 13
OutPort_13871764_1 | SOURCE | VENTILATION | SUP 13
Port_13198810_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13888495_1 | SINK | VENTILATION | SUP 13
OutPort_13198810_2 | SOURCE | VENTILATION | SUP 13
InPort_13888582_1 | SINK | VENTILATION | SUP 13
OutPort_13198810_3 | SOURCE | VENTILATION | SUP 13
InPort_13888614_1 | SINK | VENTILATION | SUP 13
OutPort_13198810_4 | SOURCE | VENTILATION | SUP 13
InPort_13848426_1 | SINK | VENTILATION | SUP 13
OutPort_13198824_1 | SOURCE | VENTILATION | SUP 13
Port_13198824_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13198825_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13198824_3 | SINK | VENTILATION | SUP 13
OutPort_13198916_0 | SOURCE | VENTILATION | SUP 13
Port_13198825_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13871502_2 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13198916_1 | SINK | VENTILATION | SUP 13
OutPort_13198930_1 | SOURCE | VENTILATION | SUP 13
InPort_13870819_1 | SINK | VENTILATION | SUP 13
OutPort_13198924_0 | SOURCE | VENTILATION | SUP 13
InPort_13198924_1 | SINK | VENTILATION | SUP 13
OutPort_13198943_2 | SOURCE | VENTILATION | SUP 13
InPort_13198930_2 | SINK | VENTILATION | SUP 13
OutPort_13870815_0 | SOURCE | VENTILATION | SUP 13
InPort_13870853_1 | SINK | VENTILATION | SUP 13
OutPort_13198933_0 | SOURCE | VENTILATION | SUP 13
InPort_13198933_1 | SINK | VENTILATION | SUP 13
InPort_13888340_1 | SINK | VENTILATION | SUP 13
OutPort_13198933_2 | SOURCE | VENTILATION | SUP 13
InPort_13888380_1 | SINK | VENTILATION | SUP 13
OutPort_13198933_3 | SOURCE | VENTILATION | SUP 13
InPort_13888404_1 | SINK | VENTILATION | SUP 13
OutPort_13198933_4 | SOURCE | VENTILATION | SUP 13
InPort_13198943_1 | SINK | VENTILATION | SUP 13
OutPort_13870855_0 | SOURCE | VENTILATION | SUP 13
InPort_13871226_1 | SINK | VENTILATION | SUP 13
OutPort_13199019_0 | SOURCE | VENTILATION | SUP 13
InPort_13199019_1 | SINK | VENTILATION | SUP 13
OutPort_13871107_2 | SOURCE | VENTILATION | SUP 13
InPort_13199027_0 | SINK | VENTILATION | SUP 13
OutPort_13870990_1 | SOURCE | VENTILATION | SUP 13
Port_13199027_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13888201_1 | SINK | VENTILATION | SUP 13
OutPort_13199027_2 | SOURCE | VENTILATION | SUP 13
InPort_13888229_1 | SINK | VENTILATION | SUP 13
OutPort_13199027_3 | SOURCE | VENTILATION | SUP 13
InPort_13888259_1 | SINK | VENTILATION | SUP 13
OutPort_13199027_4 | SOURCE | VENTILATION | SUP 13
InPort_13886374_1 | SINK | VENTILATION | SUP 13
OutPort_13199231_0 | SOURCE | VENTILATION | SUP 13
InPort_13199231_1 | SINK | VENTILATION | SUP 13
OutPort_13199251_1 | SOURCE | VENTILATION | SUP 13
InPort_13886723_1 | SINK | VENTILATION | SUP 13
OutPort_13199240_0 | SOURCE | VENTILATION | SUP 13
InPort_13199240_1 | SINK | VENTILATION | SUP 13
OutPort_13199275_2 | SOURCE | VENTILATION | SUP 13
InPort_13199251_2 | SINK | VENTILATION | SUP 13
OutPort_13886719_0 | SOURCE | VENTILATION | SUP 13
InPort_13199254_0 | SINK | VENTILATION | SUP 13
OutPort_13199271_3 | SOURCE | VENTILATION | SUP 13
InPort_13199275_1 | SINK | VENTILATION | SUP 13
OutPort_13199254_1 | SOURCE | VENTILATION | SUP 13
Port_13199271_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13199356_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13199271_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13199272_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13199272_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13708506_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13199313_0 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13199313_1 | SINK | VENTILATION | SUP 13
OutPort_13199363_2 | SOURCE | VENTILATION | SUP 13
InPort_13990872_1 | SINK | VENTILATION | SUP 13
OutPort_13199313_2 | SOURCE | VENTILATION | SUP 13
InPort_13990924_1 | SINK | VENTILATION | SUP 13
OutPort_13199313_3 | SOURCE | VENTILATION | SUP 13
InPort_13199322_0 | SINK | VENTILATION | SUP 13
OutPort_13991945_1 | SOURCE | VENTILATION | SUP 13
InPort_13199363_1 | SINK | VENTILATION | SUP 13
OutPort_13199322_1 | SOURCE | VENTILATION | SUP 13
Port_13199355_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13819911_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13199355_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13848568_2 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13199405_1 | SINK | VENTILATION | SUP 13
OutPort_13199355_3 | SOURCE | VENTILATION | SUP 13
Port_13199356_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13848568_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13199383_0 | SINK | VENTILATION | SUP 13
OutPort_13991989_1 | SOURCE | VENTILATION | SUP 13
InPort_13991415_1 | SINK | VENTILATION | SUP 13
OutPort_13199383_1 | SOURCE | VENTILATION | SUP 13
InPort_13991602_0 | SINK | VENTILATION | SUP 13
OutPort_13199404_1 | SOURCE | VENTILATION | SUP 13
InPort_13199404_2 | SINK | VENTILATION | SUP 13
OutPort_13199405_0 | SOURCE | VENTILATION | SUP 13
InPort_13991819_0 | SINK | VENTILATION | SUP 13
OutPort_13199404_3 | SOURCE | VENTILATION | SUP 13
Port_13199442_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13199636_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13199442_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13634309_2 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13199582_0 | SINK | VENTILATION | SUP 13
OutPort_13984190_1 | SOURCE | VENTILATION | SUP 13
Port_13199582_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13984908_1 | SINK | VENTILATION | SUP 13
OutPort_13199582_2 | SOURCE | VENTILATION | SUP 13
InPort_13984932_1 | SINK | VENTILATION | SUP 13
OutPort_13199582_3 | SOURCE | VENTILATION | SUP 13
InPort_13984964_1 | SINK | VENTILATION | SUP 13
OutPort_13199582_4 | SOURCE | VENTILATION | SUP 13
Port_13199636_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13819737_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13199636_3 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13984192_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13199809_1 | SINK | VENTILATION | SUP 1
OutPort_13884910_0 | SOURCE | VENTILATION | SUP 1
InPort_13884947_0 | SINK | VENTILATION | SUP 1
OutPort_13199809_2 | SOURCE | VENTILATION | SUP 1
Port_13200003_0 | SOURCEANDSINK | VENTILATION | SUP 45
Port_13876231_1 | SOURCEANDSINK | VENTILATION | SUP 45
Port_13200003_1 | SOURCEANDSINK | VENTILATION | SUP 45
Port_13200028_1 | SOURCEANDSINK | VENTILATION | SUP 45
Port_13200015_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13876106_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13200018_0 | SOURCEANDSINK | VENTILATION | SUP 45
Port_13875206_1 | SOURCEANDSINK | VENTILATION | SUP 45
Port_13200018_1 | SOURCEANDSINK | VENTILATION | SUP 45
InPort_13969482_1 | SINK | VENTILATION | SUP 45
OutPort_13200018_2 | SOURCE | VENTILATION | SUP 45
InPort_13969510_1 | SINK | VENTILATION | SUP 45
OutPort_13200018_3 | SOURCE | VENTILATION | SUP 45
InPort_13969534_1 | SINK | VENTILATION | SUP 45
OutPort_13200018_4 | SOURCE | VENTILATION | SUP 45
Port_13200028_2 | SOURCEANDSINK | VENTILATION | SUP 45
Port_13875226_0 | SOURCEANDSINK | VENTILATION | SUP 45
InPort_13200232_0 | SINK | VENTILATION | SUP 24
OutPort_13875507_2 | SOURCE | VENTILATION | SUP 24
InPort_13707531_2 | SINK | VENTILATION | SUP 24
OutPort_13200232_1 | SOURCE | VENTILATION | SUP 24
InPort_13875848_1 | SINK | VENTILATION | SUP 24
OutPort_13200240_0 | SOURCE | VENTILATION | SUP 24
InPort_13200240_1 | SINK | VENTILATION | SUP 24
OutPort_13707531_1 | SOURCE | VENTILATION | SUP 24
InPort_13200249_0 | SINK | VENTILATION | SUP 24
OutPort_13875505_2 | SOURCE | VENTILATION | SUP 24
InPort_13200350_3 | SINK | VENTILATION | SUP 24
OutPort_13200249_1 | SOURCE | VENTILATION | SUP 24
Port_13200350_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13707788_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13200350_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13875548_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13875800_1 | SINK | VENTILATION | SUP 24
OutPort_13200386_0 | SOURCE | VENTILATION | SUP 24
InPort_13200386_1 | SINK | VENTILATION | SUP 24
OutPort_13875484_2 | SOURCE | VENTILATION | SUP 24
Port_13200703_0 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13915173_2 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13200703_1 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13915147_2 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13219373_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_14079428_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13219373_1 | SOURCEANDSINK | VENTILATION | ETA 1
InPort_13219373_2 | SINK | VENTILATION | ETA 1
OutPort_13943892_1 | SOURCE | VENTILATION | ETA 1
InPort_13219373_3 | SINK | VENTILATION | ETA 1
OutPort_13944055_1 | SOURCE | VENTILATION | ETA 1
InPort_13219373_4 | SINK | VENTILATION | ETA 1
OutPort_13944189_1 | SOURCE | VENTILATION | ETA 1
InPort_14123977_2 | SINK | VENTILATION | SUP 24
OutPort_13221637_0 | SOURCE | VENTILATION | SUP 24
InPort_13221637_1 | SINK | VENTILATION | SUP 24
OutPort_14123979_1 | SOURCE | VENTILATION | SUP 24
InPort_13221690_0 | SINK | VENTILATION | SUP 24
OutPort_14124009_1 | SOURCE | VENTILATION | SUP 24
InPort_14123979_0 | SINK | VENTILATION | SUP 24
OutPort_13221690_1 | SOURCE | VENTILATION | SUP 24
Port_13221798_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14123797_2 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_14123799_1 | SINK | VENTILATION | SUP 24
OutPort_13221798_1 | SOURCE | VENTILATION | SUP 24
Port_13221798_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14147727_0 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13846539_2 | SINK | VENTILATION | SUP 13
OutPort_13223136_0 | SOURCE | VENTILATION | SUP 13
InPort_13223136_1 | SINK | VENTILATION | SUP 13
OutPort_13846522_1 | SOURCE | VENTILATION | SUP 13
Port_13225596_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13817542_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13225596_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13742239_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13225996_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769400_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13225996_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13226156_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13226148_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769305_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13226148_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13226248_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13226156_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769306_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13226238_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769505_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13226238_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14081181_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13226248_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13769506_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13226251_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14081181_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13226251_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14081190_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13226308_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14173904_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13226308_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14174116_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13227170_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13809205_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13227170_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13789192_2 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13959387_1 | SINK | VENTILATION | ETA 7
OutPort_13227280_0 | SOURCE | VENTILATION | ETA 7
InPort_13227280_1 | SINK | VENTILATION | ETA 7
OutPort_13818255_1 | SOURCE | VENTILATION | ETA 7
InPort_14108511_0 | SINK | VENTILATION | ETA 7
OutPort_13227297_0 | SOURCE | VENTILATION | ETA 7
InPort_13227297_1 | SINK | VENTILATION | ETA 7
OutPort_14180998_1 | SOURCE | VENTILATION | ETA 7
Port_13227803_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13227879_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13227803_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13794184_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13227879_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13430045_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_14040289_0 | SINK | VENTILATION | SUP 24
OutPort_13227879_3 | SOURCE | VENTILATION | SUP 24
Port_13227939_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13430037_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13227939_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13227940_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13227940_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13430045_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13228187_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13636107_2 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13908872_1 | SINK | VENTILATION | SUP 12
OutPort_13301985_0 | SOURCE | VENTILATION | SUP 12
InPort_13301985_1 | SINK | VENTILATION | SUP 12
OutPort_13908906_3 | SOURCE | VENTILATION | SUP 12
InPort_13911838_1 | SINK | VENTILATION | SUP 12
OutPort_13302069_0 | SOURCE | VENTILATION | SUP 12
InPort_13302069_1 | SINK | VENTILATION | SUP 12
OutPort_14117546_1 | SOURCE | VENTILATION | SUP 12
InPort_13908746_0 | SINK | VENTILATION | SUP 12
OutPort_13302298_1 | SOURCE | VENTILATION | SUP 12
InPort_13302298_2 | SINK | VENTILATION | SUP 12
OutPort_13908798_0 | SOURCE | VENTILATION | SUP 12
Port_13302533_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13911572_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13302533_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13302548_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13302542_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13302548_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13302542_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13302588_3 | SOURCEANDSINK | VENTILATION | ETA 17
InPort_13914139_1 | SINK | VENTILATION | ETA 17
OutPort_13302551_0 | SOURCE | VENTILATION | ETA 17
InPort_13302551_1 | SINK | VENTILATION | ETA 17
OutPort_13993999_1 | SOURCE | VENTILATION | ETA 17
InPort_13302588_1 | SINK | VENTILATION | ETA 17
OutPort_13912111_1 | SOURCE | VENTILATION | ETA 17
Port_13302588_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13302612_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13302612_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13912084_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13302632_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13993746_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13302632_1 | SOURCEANDSINK | VENTILATION | ETA 17
InPort_13302632_2 | SINK | VENTILATION | ETA 17
OutPort_13992958_1 | SOURCE | VENTILATION | ETA 17
InPort_13302632_4 | SINK | VENTILATION | ETA 17
OutPort_13993056_1 | SOURCE | VENTILATION | ETA 17
InPort_13302632_5 | SINK | VENTILATION | ETA 17
OutPort_13993114_1 | SOURCE | VENTILATION | ETA 17
Port_13302656_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13302668_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13302656_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13628036_0 | SOURCEANDSINK | VENTILATION | ETA 17
InPort_13911665_0 | SINK | VENTILATION | ETA 17
OutPort_13302656_3 | SOURCE | VENTILATION | ETA 17
Port_13302668_1 | SOURCEANDSINK | VENTILATION | ETA 17
InPort_13302668_2 | SINK | VENTILATION | ETA 17
OutPort_13993246_1 | SOURCE | VENTILATION | ETA 17
Port_13302811_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13911979_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13302811_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13911938_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13324216_0 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13967323_1 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13324216_1 | SOURCEANDSINK | VENTILATION | ETA 27
InPort_13324216_3 | SINK | VENTILATION | ETA 27
OutPort_13941825_1 | SOURCE | VENTILATION | ETA 27
InPort_13711722_2 | SINK | VENTILATION | ETA 27
OutPort_13324226_0 | SOURCE | VENTILATION | ETA 27
InPort_13324226_1 | SINK | VENTILATION | ETA 27
OutPort_14137462_1 | SOURCE | VENTILATION | ETA 27
InPort_13324226_2 | SINK | VENTILATION | ETA 27
OutPort_13943385_1 | SOURCE | VENTILATION | ETA 27
InPort_13324226_3 | SINK | VENTILATION | ETA 27
OutPort_13943657_1 | SOURCE | VENTILATION | ETA 27
Port_13324236_0 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13967122_3 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13324236_1 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13324246_2 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13324240_0 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13967323_2 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13324240_1 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13967507_2 | SOURCEANDSINK | VENTILATION | ETA 27
InPort_13324240_2 | SINK | VENTILATION | ETA 27
OutPort_13941110_1 | SOURCE | VENTILATION | ETA 27
InPort_13324240_3 | SINK | VENTILATION | ETA 27
OutPort_13942022_1 | SOURCE | VENTILATION | ETA 27
Port_13324246_1 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13940365_0 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13324268_0 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13356639_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13324268_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_14147165_1 | SOURCEANDSINK | VENTILATION | SUP 4
InPort_13947519_1 | SINK | VENTILATION | SUP 4
OutPort_13324268_3 | SOURCE | VENTILATION | SUP 4
Port_13356637_0 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13356639_2 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13356637_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13952549_2 | SOURCEANDSINK | VENTILATION | SUP 4
InPort_13356658_0 | SINK | VENTILATION | ETA 27
OutPort_13964147_1 | SOURCE | VENTILATION | ETA 27
OutPort_13356658_1 | SOURCE | VENTILATION | ETA 27
InPort_13356658_2 | SINK | VENTILATION | ETA 27
OutPort_13962919_1 | SOURCE | VENTILATION | ETA 27
InPort_13356658_3 | SINK | VENTILATION | ETA 27
OutPort_13962975_1 | SOURCE | VENTILATION | ETA 27
InPort_13631784_0 | SINK | VENTILATION | SUP 4
OutPort_13372822_1 | SOURCE | VENTILATION | SUP 4
InPort_13372822_2 | SINK | VENTILATION | ODA 1
OutPort_13631329_0 | SOURCE | VENTILATION | ODA 1
InPort_13372822_3 | SINK | VENTILATION | ETA 27
OutPort_13631822_0 | SOURCE | VENTILATION | ETA 27
InPort_13951647_0 | SINK | EXHAUST | EHA 9
OutPort_13372822_4 | SOURCE | EXHAUST | EHA 9
InPort_13629980_0 | SINK | VENTILATION | SUP 7
OutPort_13389183_1 | SOURCE | VENTILATION | SUP 7
InPort_13389183_2 | SINK | VENTILATION | ODA 2
OutPort_13391172_0 | SOURCE | VENTILATION | ODA 2
InPort_13389183_3 | SINK | VENTILATION | ETA 18
OutPort_13629832_0 | SOURCE | VENTILATION | ETA 18
InPort_13391133_0 | SINK | EXHAUST | EHA 2
OutPort_13389183_4 | SOURCE | EXHAUST | EHA 2
Port_13390136_0 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13947132_1 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13390136_1 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13947134_1 | SOURCEANDSINK | VENTILATION | SUP 7
InPort_13916505_1 | SINK | VENTILATION | SUP 7
OutPort_13390136_2 | SOURCE | VENTILATION | SUP 7
InPort_13916525_1 | SINK | VENTILATION | SUP 7
OutPort_13390136_3 | SOURCE | VENTILATION | SUP 7
Port_13390156_0 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13947134_2 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13390156_1 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13955802_2 | SOURCEANDSINK | VENTILATION | SUP 7
InPort_13916479_1 | SINK | VENTILATION | SUP 7
OutPort_13390156_3 | SOURCE | VENTILATION | SUP 7
InPort_13955842_1 | SINK | VENTILATION | SUP 7
OutPort_13390156_4 | SOURCE | VENTILATION | SUP 7
Port_13390228_0 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13947132_2 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13390228_1 | SOURCEANDSINK | VENTILATION | SUP 7
InPort_13916549_1 | SINK | VENTILATION | SUP 7
OutPort_13390228_2 | SOURCE | VENTILATION | SUP 7
InPort_13916579_1 | SINK | VENTILATION | SUP 7
OutPort_13390228_3 | SOURCE | VENTILATION | SUP 7
Port_13390319_0 | SOURCEANDSINK | VENTILATION | ETA 18
Port_14110484_2 | SOURCEANDSINK | VENTILATION | ETA 18
Port_13390319_1 | SOURCEANDSINK | VENTILATION | ETA 18
InPort_13390319_2 | SINK | VENTILATION | ETA 18
OutPort_13924368_1 | SOURCE | VENTILATION | ETA 18
InPort_13390319_3 | SINK | VENTILATION | ETA 18
OutPort_13924388_1 | SOURCE | VENTILATION | ETA 18
InPort_13810507_0 | SINK | EXHAUST | EHA 2
OutPort_13391133_1 | SOURCE | EXHAUST | EHA 2
InPort_13391172_1 | SINK | VENTILATION | ODA 2
OutPort_13810481_0 | SOURCE | VENTILATION | ODA 2
Port_13429106_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13810240_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13429106_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13805164_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13429111_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13792559_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13429111_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13792574_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13429118_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13810242_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13429118_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13792559_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13429370_0 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13966792_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13429370_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13989148_2 | SOURCEANDSINK | VENTILATION | SUP 4
InPort_14008100_1 | SINK | VENTILATION | SUP 4
OutPort_13429370_2 | SOURCE | VENTILATION | SUP 4
InPort_13631329_1 | SINK | VENTILATION | ODA 1
OutPort_13429380_0 | SOURCE | VENTILATION | ODA 1
InPort_13429380_1 | SINK | VENTILATION | ODA 1
OutPort_13951987_2 | SOURCE | VENTILATION | ODA 1
InPort_13429413_0 | SINK | VENTILATION | ETA 27
OutPort_14114234_1 | SOURCE | VENTILATION | ETA 27
InPort_13631822_1 | SINK | VENTILATION | ETA 27
OutPort_13429413_1 | SOURCE | VENTILATION | ETA 27
InPort_13429748_0 | SINK | VENTILATION | SUP 24
OutPort_13911213_2 | SOURCE | VENTILATION | SUP 24
InPort_13429782_1 | SINK | VENTILATION | SUP 24
OutPort_13429748_1 | SOURCE | VENTILATION | SUP 24
InPort_13429774_0 | SINK | VENTILATION | SUP 24
OutPort_13911116_1 | SOURCE | VENTILATION | SUP 24
Port_13429774_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13924991_1 | SINK | VENTILATION | SUP 24
OutPort_13429774_2 | SOURCE | VENTILATION | SUP 24
InPort_13925021_1 | SINK | VENTILATION | SUP 24
OutPort_13429774_3 | SOURCE | VENTILATION | SUP 24
InPort_13911118_0 | SINK | VENTILATION | SUP 24
OutPort_13429782_2 | SOURCE | VENTILATION | SUP 24
InPort_13429794_0 | SINK | VENTILATION | SUP 24
OutPort_13911018_1 | SOURCE | VENTILATION | SUP 24
Port_13429794_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13925057_1 | SINK | VENTILATION | SUP 24
OutPort_13429794_2 | SOURCE | VENTILATION | SUP 24
InPort_13925085_1 | SINK | VENTILATION | SUP 24
OutPort_13429794_3 | SOURCE | VENTILATION | SUP 24
InPort_13429803_0 | SINK | VENTILATION | SUP 24
OutPort_13911063_2 | SOURCE | VENTILATION | SUP 24
InPort_13839914_1 | SINK | VENTILATION | SUP 24
OutPort_13429803_1 | SOURCE | VENTILATION | SUP 24
InPort_13429814_0 | SINK | VENTILATION | SUP 24
OutPort_13429828_3 | SOURCE | VENTILATION | SUP 24
InPort_13839869_2 | SINK | VENTILATION | SUP 24
OutPort_13429814_1 | SOURCE | VENTILATION | SUP 24
InPort_13911201_1 | SINK | VENTILATION | SUP 24
OutPort_13429828_1 | SOURCE | VENTILATION | SUP 24
InPort_13429828_2 | SINK | VENTILATION | SUP 24
OutPort_14180040_0 | SOURCE | VENTILATION | SUP 24
InPort_13429829_0 | SINK | VENTILATION | SUP 24
OutPort_14120170_2 | SOURCE | VENTILATION | SUP 24
InPort_14180328_1 | SINK | VENTILATION | SUP 24
OutPort_13429829_1 | SOURCE | VENTILATION | SUP 24
InPort_14078963_0 | SINK | VENTILATION | SUP 24
OutPort_13429963_1 | SOURCE | VENTILATION | SUP 24
Port_13440181_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13440238_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13440181_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13636103_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13440194_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13636234_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13440194_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13440238_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13440195_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13848800_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13440195_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13636300_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13440247_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14005515_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13440247_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_14006812_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13458454_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13636308_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13458454_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13636234_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13459207_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746580_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13459207_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13746629_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13459243_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14109452_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13459243_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14109686_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13459752_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13805546_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13459752_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13459867_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13459856_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13459867_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13459856_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13809353_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13460055_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13809788_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13460055_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13809404_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13460055_2 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14123339_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13479475_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13635158_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13479482_0 | SOURCEANDSINK | VENTILATION | SUP 24
Port_14147992_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13479482_1 | SOURCEANDSINK | VENTILATION | SUP 24
Port_13793845_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13628035_3 | SINK | VENTILATION | ETA 17
OutPort_13628020_0 | SOURCE | VENTILATION | ETA 17
InPort_13628020_1 | SINK | VENTILATION | ETA 17
OutPort_13993809_1 | SOURCE | VENTILATION | ETA 17
Port_13628035_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13628036_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13628035_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13993728_0 | SOURCEANDSINK | VENTILATION | ETA 17
InPort_13628036_2 | SINK | VENTILATION | ETA 17
OutPort_13993179_1 | SOURCE | VENTILATION | ETA 17
InPort_13628036_3 | SINK | VENTILATION | ETA 17
OutPort_13993276_1 | SOURCE | VENTILATION | ETA 17
InPort_13628395_0 | SINK | EXHAUST | ETA 8
OutPort_13628626_1 | SOURCE | EXHAUST | ETA 8
InPort_13902833_1 | SINK | EXHAUST | ETA 8
OutPort_13628395_1 | SOURCE | EXHAUST | ETA 8
InPort_13628863_2 | SINK | EXHAUST | ETA 8
OutPort_13628554_0 | SOURCE | EXHAUST | ETA 8
InPort_13628554_1 | SINK | EXHAUST | ETA 8
OutPort_13628702_1 | SOURCE | EXHAUST | ETA 8
InPort_13628554_2 | SINK | EXHAUST | ETA 8
OutPort_13629699_1 | SOURCE | VENTILATION | ETA 8
Port_13628588_1 | SOURCEANDSINK | EXHAUST | ETA 8
Port_13792986_0 | SOURCEANDSINK | VENTILATION | ETA 8
Port_13628588_2 | SOURCEANDSINK | EXHAUST | ETA 8
Port_14082517_1 | SOURCEANDSINK | EXHAUST | ETA 8
InPort_13628588_3 | SINK | EXHAUST | ETA 8
OutPort_13628864_0 | SOURCE | EXHAUST | ETA 8
Port_13628596_0 | SOURCEANDSINK | VENTILATION | ETA 8
Port_14082517_2 | SOURCEANDSINK | EXHAUST | ETA 8
Port_13628596_1 | SOURCEANDSINK | VENTILATION | ETA 8
InPort_13628596_2 | SINK | VENTILATION | ETA 8
OutPort_13629528_1 | SOURCE | VENTILATION | ETA 8
InPort_13628626_2 | SINK | EXHAUST | ETA 8
OutPort_13628705_0 | SOURCE | EXHAUST | ETA 8
InPort_13628696_0 | SINK | EXHAUST | ETA 8
OutPort_13629080_1 | SOURCE | EXHAUST | ETA 8
InPort_13628715_1 | SINK | EXHAUST | ETA 8
OutPort_13628696_1 | SOURCE | EXHAUST | ETA 8
InPort_13628702_2 | SINK | EXHAUST | ETA 8
OutPort_13629094_0 | SOURCE | EXHAUST | ETA 8
InPort_13628705_1 | SINK | EXHAUST | ETA 8
OutPort_13628715_2 | SOURCE | EXHAUST | ETA 8
InPort_13628810_1 | SINK | EXHAUST | ETA 8
OutPort_13628817_2 | SOURCE | EXHAUST | ETA 8
InPort_13628814_2 | SINK | EXHAUST | ETA 8
OutPort_13628810_2 | SOURCE | EXHAUST | ETA 8
InPort_13629098_1 | SINK | EXHAUST | ETA 8
OutPort_13628812_0 | SOURCE | EXHAUST | ETA 8
InPort_13628812_1 | SINK | EXHAUST | ETA 8
OutPort_13628814_1 | SOURCE | EXHAUST | ETA 8
InPort_13810141_0 | SINK | EXHAUST | ETA 8
OutPort_13628817_1 | SOURCE | EXHAUST | ETA 8
InPort_13628817_2 | SINK | EXHAUST | ETA 8
OutPort_13628810_1 | SOURCE | EXHAUST | ETA 8
InPort_13628863_3 | SINK | EXHAUST | ETA 8
OutPort_13628857_0 | SOURCE | EXHAUST | ETA 8
InPort_13628857_1 | SINK | EXHAUST | ETA 8
OutPort_13629669_1 | SOURCE | EXHAUST | ETA 8
InPort_13628864_1 | SINK | EXHAUST | ETA 8
OutPort_13628863_1 | SOURCE | EXHAUST | ETA 8
InPort_13629080_2 | SINK | EXHAUST | ETA 8
OutPort_13629073_1 | SOURCE | EXHAUST | ETA 8
