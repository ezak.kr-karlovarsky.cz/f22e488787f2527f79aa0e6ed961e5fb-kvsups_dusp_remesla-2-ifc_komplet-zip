Properties of the parts of a building model (IFC4), part 26 of 45

# IfcDistributionPort (8507)
Name | FlowDirection | SystemType | Group
Port_13915173_1 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13915174_1 | SOURCEANDSINK | VENTILATION | SUP 17
InPort_13915312_0 | SINK | VENTILATION | SUP 17
OutPort_14152535_2 | SOURCE | VENTILATION | SUP 17
InPort_14152838_1 | SINK | VENTILATION | SUP 17
OutPort_13915312_1 | SOURCE | VENTILATION | SUP 17
InPort_13915400_1 | SINK | VENTILATION | SUP 17
OutPort_13915312_2 | SOURCE | VENTILATION | SUP 17
InPort_13915323_0 | SINK | VENTILATION | SUP 17
OutPort_13915325_2 | SOURCE | VENTILATION | SUP 17
InPort_13915330_1 | SINK | VENTILATION | SUP 17
OutPort_13915323_1 | SOURCE | VENTILATION | SUP 17
InPort_14152536_0 | SINK | VENTILATION | SUP 17
OutPort_13915330_2 | SOURCE | VENTILATION | SUP 17
OutPort_13916309_1 | SOURCE | VENTILATION
InPort_13917221_0 | SINK | VENTILATION | ODA 12
OutPort_14066239_1 | SOURCE | VENTILATION | ODA 12
InPort_13917256_1 | SINK | VENTILATION | ODA 12
OutPort_13917221_1 | SOURCE | VENTILATION | ODA 12
InPort_13917535_1 | SINK | VENTILATION | ETA 7
OutPort_13917533_1 | SOURCE | VENTILATION | ETA 7
InPort_13917767_1 | SINK | VENTILATION | ETA 7
OutPort_13917765_1 | SOURCE | VENTILATION | ETA 7
InPort_13917901_1 | SINK | VENTILATION | ETA 7
OutPort_13917899_1 | SOURCE | VENTILATION | ETA 7
InPort_13917950_1 | SINK | VENTILATION | ETA 7
OutPort_13917948_1 | SOURCE | VENTILATION | ETA 7
InPort_13918531_2 | SINK | VENTILATION | ODA 21
OutPort_13918301_1 | SOURCE | VENTILATION | ODA 21
InPort_14127341_2 | SINK | VENTILATION | ODA 21
OutPort_13918457_0 | SOURCE | VENTILATION | ODA 21
InPort_13918457_1 | SINK | VENTILATION | ODA 21
OutPort_13918509_1 | SOURCE | VENTILATION | ODA 21
InPort_13918458_1 | SINK | VENTILATION | ODA 21
OutPort_14127341_1 | SOURCE | VENTILATION | ODA 21
InPort_13919002_1 | SINK | EXHAUST | EHA 7
OutPort_13918743_0 | SOURCE | EXHAUST | EHA 7
InPort_13918743_1 | SINK | EXHAUST | EHA 7
OutPort_13919394_1 | SOURCE | EXHAUST | EHA 7
InPort_13919394_2 | SINK | EXHAUST | EHA 7
OutPort_13918765_0 | SOURCE | EXHAUST | EHA 7
InPort_13918765_1 | SINK | EXHAUST | EHA 7
OutPort_13919411_1 | SOURCE | EXHAUST | EHA 7
InPort_13918946_0 | SINK | EXHAUST | EHA 7
OutPort_13919002_2 | SOURCE | EXHAUST | EHA 7
InPort_13985640_1 | SINK | EXHAUST | EHA 7
OutPort_13918946_1 | SOURCE | EXHAUST | EHA 7
InPort_13919410_1 | SINK | EXHAUST | EHA 7
OutPort_13919409_2 | SOURCE | EXHAUST | EHA 7
InPort_14155851_1 | SINK | VENTILATION | ODA 25
OutPort_13921635_0 | SOURCE | VENTILATION | ODA 25
InPort_13921635_1 | SINK | VENTILATION | ODA 25
OutPort_14156187_1 | SOURCE | VENTILATION | ODA 25
InPort_14155817_2 | SINK | VENTILATION | ODA 25
OutPort_13921643_0 | SOURCE | VENTILATION | ODA 25
InPort_13921643_1 | SINK | VENTILATION | ODA 25
OutPort_14155851_2 | SOURCE | VENTILATION | ODA 25
InPort_13922170_1 | SINK | VENTILATION | ODA 12
OutPort_13921778_0 | SOURCE | VENTILATION | ODA 12
InPort_13921778_1 | SINK | VENTILATION | ODA 12
InPort_13922246_1 | SINK | VENTILATION | ODA 12
OutPort_13922245_0 | SOURCE | VENTILATION | ODA 12
InPort_13922245_1 | SINK | VENTILATION | ODA 12
OutPort_14151034_1 | SOURCE | VENTILATION | ODA 12
InPort_13922371_1 | SINK | VENTILATION | ODA 18
OutPort_14121622_0 | SOURCE | VENTILATION | ODA 18
InPort_13922567_1 | SINK | VENTILATION | ODA 12
OutPort_14066492_0 | SOURCE | VENTILATION | ODA 12
InPort_13923230_1 | SINK | VENTILATION | ODA 13
OutPort_13923338_2 | SOURCE | VENTILATION | ODA 13
Port_13923338_1 | SOURCEANDSINK | VENTILATION | ODA 13
InPort_13924548_2 | SINK | VENTILATION | ETA 18
OutPort_13924324_1 | SOURCE | VENTILATION | ETA 18
Port_13924548_0 | SOURCEANDSINK | VENTILATION | ETA 18
Port_13987653_2 | SOURCEANDSINK | VENTILATION | ETA 18
Port_13924548_1 | SOURCEANDSINK | VENTILATION | ETA 18
Port_14110455_2 | SOURCEANDSINK | VENTILATION | ETA 18
InPort_13924796_1 | SINK | VENTILATION | SUP 11
OutPort_14170845_1 | SOURCE | VENTILATION | SUP 11
InPort_13925516_1 | SINK | VENTILATION | SUP 24
OutPort_13926849_3 | SOURCE | VENTILATION | SUP 24
InPort_13925540_1 | SINK | VENTILATION | SUP 24
OutPort_13926849_2 | SOURCE | VENTILATION | SUP 24
InPort_14039168_2 | SINK | VENTILATION | SUP 14
OutPort_13925969_0 | SOURCE | VENTILATION | SUP 14
InPort_13925969_1 | SINK | VENTILATION | SUP 14
OutPort_13954764_1 | SOURCE | VENTILATION | SUP 14
InPort_14039401_0 | SINK | VENTILATION | SUP 14
OutPort_13925969_2 | SOURCE | VENTILATION | SUP 14
InPort_14039436_0 | SINK | VENTILATION | SUP 14
OutPort_13925969_4 | SOURCE | VENTILATION | SUP 14
InPort_14056631_1 | SINK | VENTILATION | ETA 23
OutPort_13926116_0 | SOURCE | VENTILATION | ETA 23
InPort_13926116_1 | SINK | VENTILATION | ETA 23
OutPort_14029374_1 | SOURCE | VENTILATION | ETA 23
InPort_13926311_2 | SINK | VENTILATION | SUP 24
OutPort_13926313_1 | SOURCE | VENTILATION | SUP 24
InPort_13926313_0 | SINK | VENTILATION | SUP 24
OutPort_13926566_2 | SOURCE | VENTILATION | SUP 24
InPort_13926333_2 | SINK | VENTILATION | SUP 24
OutPort_13926335_1 | SOURCE | VENTILATION | SUP 24
InPort_13926335_0 | SINK | VENTILATION | SUP 24
OutPort_13926588_2 | SOURCE | VENTILATION | SUP 24
InPort_13926566_1 | SINK | VENTILATION | SUP 24
OutPort_13926568_1 | SOURCE | VENTILATION | SUP 24
InPort_13926568_0 | SINK | VENTILATION | SUP 24
OutPort_14039861_2 | SOURCE | VENTILATION | SUP 24
InPort_13926588_1 | SINK | VENTILATION | SUP 24
OutPort_13926590_0 | SOURCE | VENTILATION | SUP 24
InPort_13926590_1 | SINK | VENTILATION | SUP 24
OutPort_14039861_3 | SOURCE | VENTILATION | SUP 24
InPort_13926664_1 | SINK | VENTILATION | SUP 35
InPort_13926767_2 | SINK | VENTILATION | SUP 35
OutPort_13926664_2 | SOURCE | VENTILATION | SUP 35
Port_13926666_1 | SOURCEANDSINK | VENTILATION | SUP 2
Port_13926668_1 | SOURCEANDSINK | VENTILATION | SUP 2
Port_13926668_2 | SOURCEANDSINK | VENTILATION | SUP 2
InPort_13926789_0 | SINK | VENTILATION | SUP 35
OutPort_13926765_1 | SOURCE | VENTILATION | SUP 35
InPort_13926793_2 | SINK | VENTILATION | SUP 35
OutPort_13926787_1 | SOURCE | VENTILATION | SUP 35
InPort_13926787_2 | SINK | VENTILATION | SUP 35
OutPort_13926791_2 | SOURCE | VENTILATION | SUP 35
InPort_13926791_1 | SINK | VENTILATION | SUP 35
OutPort_13926789_1 | SOURCE | VENTILATION | SUP 35
InPort_13926847_1 | SINK | VENTILATION | SUP 24
OutPort_13926853_2 | SOURCE | VENTILATION | SUP 24
InPort_13926851_2 | SINK | VENTILATION | SUP 24
OutPort_13926847_2 | SOURCE | VENTILATION | SUP 24
Port_13926849_0 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_13926849_1 | SINK | VENTILATION | SUP 24
OutPort_13926851_1 | SOURCE | VENTILATION | SUP 24
InPort_13927098_1 | SINK | VENTILATION | SUP 24
OutPort_13926878_0 | SOURCE | VENTILATION | SUP 24
InPort_13926878_1 | SINK | VENTILATION | SUP 24
OutPort_13927055_1 | SOURCE | VENTILATION | SUP 24
InPort_13927053_1 | SINK | VENTILATION | SUP 24
OutPort_13927094_0 | SOURCE | VENTILATION | SUP 24
InPort_13927092_1 | SINK | VENTILATION | SUP 24
OutPort_13927098_2 | SOURCE | VENTILATION | SUP 24
InPort_13927096_2 | SINK | VENTILATION | SUP 24
OutPort_13927092_2 | SOURCE | VENTILATION | SUP 24
InPort_13927094_1 | SINK | VENTILATION | SUP 24
OutPort_13927096_1 | SOURCE | VENTILATION | SUP 24
InPort_13928480_0 | SINK | VENTILATION | ETA 11
OutPort_14165726_2 | SOURCE | VENTILATION | ETA 11
OutPort_13928480_1 | SOURCE | VENTILATION | ETA 11
InPort_13928480_4 | SINK | VENTILATION | ETA 11
OutPort_14049255_1 | SOURCE | VENTILATION | ETA 11
InPort_13928574_1 | SINK | VENTILATION | SUP 8
OutPort_13928574_2 | SOURCE | VENTILATION | SUP 8
Port_13928638_0 | SOURCEANDSINK | VENTILATION | SUP 20
Port_13928870_1 | SOURCEANDSINK | VENTILATION | SUP 20
Port_13928638_1 | SOURCEANDSINK | VENTILATION | SUP 20
Port_13928642_1 | SOURCEANDSINK | VENTILATION | SUP 20
Port_13928642_2 | SOURCEANDSINK | VENTILATION | SUP 20
Port_13928644_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13928761_1 | SOURCEANDSINK | VENTILATION | SUP 20
Port_13928870_2 | SOURCEANDSINK | VENTILATION | SUP 20
Port_13928761_2 | SOURCEANDSINK | VENTILATION | SUP 20
Port_13928872_2 | SOURCEANDSINK | VENTILATION | SUP 20
Port_13928777_1 | SOURCEANDSINK | VENTILATION | SUP 20
Port_13928872_1 | SOURCEANDSINK | VENTILATION | SUP 20
InPort_13928945_1 | SINK | VENTILATION | SUP 13
OutPort_13928970_2 | SOURCE | VENTILATION | SUP 13
InPort_13928967_2 | SINK | VENTILATION | SUP 13
OutPort_13928945_2 | SOURCE | VENTILATION | SUP 13
Port_13928965_0 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13928965_1 | SINK | VENTILATION | SUP 13
OutPort_13928967_1 | SOURCE | VENTILATION | SUP 13
InPort_13929206_1 | SINK | VENTILATION | SUP 13
OutPort_13928965_2 | SOURCE | VENTILATION | SUP 13
InPort_13929288_1 | SINK | VENTILATION | SUP 13
OutPort_13928965_3 | SOURCE | VENTILATION | SUP 13
InPort_13929325_1 | SINK | VENTILATION | SUP 13
OutPort_13928965_4 | SOURCE | VENTILATION | SUP 13
InPort_13928970_1 | SINK | VENTILATION | SUP 13
OutPort_14068088_0 | SOURCE | VENTILATION | SUP 13
InPort_13929070_1 | SINK | VENTILATION | SUP 13
OutPort_13929040_2 | SOURCE | VENTILATION | SUP 13
InPort_13930796_1 | SINK | VENTILATION | SUP 9
OutPort_13930930_1 | SOURCE | VENTILATION | SUP 9
InPort_13931067_0 | SINK | VENTILATION | SUP 9
OutPort_13930796_2 | SOURCE | VENTILATION | SUP 9
InPort_13957309_0 | SINK | VENTILATION | SUP 9
OutPort_13931023_1 | SOURCE | VENTILATION | SUP 9
InPort_13931023_2 | SINK | VENTILATION | SUP 9
OutPort_13931067_1 | SOURCE | VENTILATION | SUP 9
InPort_13934451_2 | SINK | VENTILATION | SUP 9
OutPort_13934313_1 | SOURCE | VENTILATION | SUP 9
InPort_13934313_2 | SINK | VENTILATION | SUP 9
OutPort_13934453_2 | SOURCE | VENTILATION | SUP 9
InPort_14037805_3 | SINK | VENTILATION | SUP 9
OutPort_13934449_0 | SOURCE | VENTILATION | SUP 9
InPort_13934449_1 | SINK | VENTILATION | SUP 9
OutPort_13934451_1 | SOURCE | VENTILATION | SUP 9
InPort_13934453_1 | SINK | VENTILATION | SUP 9
OutPort_13934874_0 | SOURCE | VENTILATION | SUP 9
InPort_13934875_2 | SINK | VENTILATION | SUP 9
OutPort_13934840_1 | SOURCE | VENTILATION | SUP 9
InPort_13934840_3 | SINK | VENTILATION | SUP 9
OutPort_13934877_2 | SOURCE | VENTILATION | SUP 9
InPort_13934874_1 | SINK | VENTILATION | SUP 9
OutPort_13934875_1 | SOURCE | VENTILATION | SUP 9
InPort_13935325_2 | SINK | VENTILATION | ETA 14
OutPort_13935294_1 | SOURCE | VENTILATION | ETA 14
InPort_13935294_3 | SINK | VENTILATION | ETA 14
OutPort_13935327_2 | SOURCE | VENTILATION | ETA 14
InPort_13935322_1 | SINK | VENTILATION | ETA 14
OutPort_13935325_1 | SOURCE | VENTILATION | ETA 14
InPort_13935327_1 | SINK | VENTILATION | ETA 14
OutPort_13935414_0 | SOURCE | VENTILATION | ETA 14
InPort_13935415_2 | SINK | VENTILATION | ETA 14
OutPort_13935388_1 | SOURCE | VENTILATION | ETA 14
InPort_13935388_2 | SINK | VENTILATION | ETA 14
OutPort_14084168_1 | SOURCE | VENTILATION | ETA 14
InPort_13935414_1 | SINK | VENTILATION | ETA 14
OutPort_13935415_1 | SOURCE | VENTILATION | ETA 14
Port_13935470_2 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13935472_1 | SOURCEANDSINK | VENTILATION | ETA 14
InPort_13935524_1 | SINK | VENTILATION | SUP 17
OutPort_13935542_1 | SOURCE | VENTILATION | SUP 17
InPort_13935838_0 | SINK | VENTILATION | SUP 17
OutPort_13935524_2 | SOURCE | VENTILATION | SUP 17
InPort_13935714_1 | SINK | VENTILATION | SUP 17
OutPort_13935722_2 | SOURCE | VENTILATION | SUP 17
InPort_13935720_2 | SINK | VENTILATION | SUP 17
OutPort_13935714_2 | SOURCE | VENTILATION | SUP 17
InPort_13935716_1 | SINK | VENTILATION | SUP 17
OutPort_13935720_1 | SOURCE | VENTILATION | SUP 17
InPort_13935722_1 | SINK | VENTILATION | SUP 17
OutPort_13935803_0 | SOURCE | VENTILATION | SUP 17
InPort_13935801_1 | SINK | VENTILATION | SUP 17
OutPort_13935807_2 | SOURCE | VENTILATION | SUP 17
InPort_13935805_2 | SINK | VENTILATION | SUP 17
OutPort_13935801_2 | SOURCE | VENTILATION | SUP 17
InPort_13935803_1 | SINK | VENTILATION | SUP 17
OutPort_13935805_1 | SOURCE | VENTILATION | SUP 17
InPort_13935842_2 | SINK | VENTILATION | SUP 17
OutPort_13935836_1 | SOURCE | VENTILATION | SUP 17
InPort_13935836_2 | SINK | VENTILATION | SUP 17
OutPort_13935840_2 | SOURCE | VENTILATION | SUP 17
InPort_13935840_1 | SINK | VENTILATION | SUP 17
OutPort_13935838_1 | SOURCE | VENTILATION | SUP 17
InPort_13935929_1 | SINK | VENTILATION | ETA 13
OutPort_13935929_2 | SOURCE | VENTILATION | ETA 13
Port_13935931_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13936000_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13935931_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13935933_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13935933_2 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13935936_1 | SOURCEANDSINK | VENTILATION | ETA 16
Port_13935936_2 | SOURCEANDSINK | VENTILATION | ETA 16
Port_13935994_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13936000_2 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13935994_2 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13936678_2 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13935996_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13936424_2 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13935996_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13936462_2 | SOURCEANDSINK | VENTILATION | ETA 12
InPort_13936122_1 | SINK | VENTILATION | ETA 12
OutPort_14124597_2 | SOURCE | VENTILATION | ETA 12
Port_13936122_2 | SOURCEANDSINK | VENTILATION | ETA 12
Port_14114713_1 | SOURCEANDSINK | VENTILATION | ETA 12
InPort_13939370_1 | SINK | VENTILATION | ETA 12
OutPort_13936294_0 | SOURCE | VENTILATION | ETA 12
InPort_13936294_1 | SINK | VENTILATION | ETA 12
OutPort_13937483_3 | SOURCE | VENTILATION | ETA 12
Port_13936454_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13936462_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13936454_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13936676_1 | SOURCEANDSINK | VENTILATION | ETA 12
InPort_13936454_2 | SINK | VENTILATION | ETA 12
OutPort_13936493_1 | SOURCE | VENTILATION | ETA 12
Port_13936660_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13936676_2 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13936660_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13936678_1 | SOURCEANDSINK | VENTILATION | ETA 12
InPort_13936808_1 | SINK | VENTILATION | ETA 12
OutPort_13939366_0 | SOURCE | VENTILATION | ETA 12
InPort_14124597_1 | SINK | VENTILATION | ETA 12
OutPort_13936808_2 | SOURCE | VENTILATION | ETA 12
Port_13937319_0 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14121026_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13937319_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_14121039_1 | SOURCEANDSINK | VENTILATION | ETA 14
Port_13937461_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13938609_2 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13937461_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13937610_1 | SOURCEANDSINK | VENTILATION | ETA 12
InPort_13937461_2 | SINK | VENTILATION | ETA 12
OutPort_13937763_0 | SOURCE | VENTILATION | ETA 12
Port_13937483_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13938609_1 | SOURCEANDSINK | VENTILATION | ETA 12
InPort_13937483_2 | SINK | VENTILATION | ETA 12
OutPort_13937498_0 | SOURCE | VENTILATION | ETA 12
InPort_13937498_1 | SINK | VENTILATION | ETA 12
OutPort_13938718_1 | SOURCE | VENTILATION | ETA 12
InPort_13937498_2 | SINK | VENTILATION | ETA 12
OutPort_13937786_0 | SOURCE | VENTILATION | ETA 12
InPort_13937498_3 | SINK | VENTILATION | ETA 12
OutPort_14152392_1 | SOURCE | VENTILATION | ETA 12
Port_13937599_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13937610_2 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13937599_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13937956_2 | SOURCEANDSINK | VENTILATION | ETA 12
InPort_13937599_2 | SINK | VENTILATION | ETA 12
OutPort_13937736_0 | SOURCE | VENTILATION | ETA 12
Port_13937613_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13937958_2 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13937613_1 | SOURCEANDSINK | VENTILATION | ETA 12
InPort_13937613_3 | SINK | VENTILATION | ETA 12
OutPort_13937943_0 | SOURCE | VENTILATION | ETA 12
InPort_13937943_1 | SINK | VENTILATION | ETA 12
OutPort_13937664_0 | SOURCE | VENTILATION | ETA 12
InPort_13937664_1 | SINK | VENTILATION | ETA 12
OutPort_13938263_2 | SOURCE | VENTILATION | ETA 12
InPort_13937736_1 | SINK | VENTILATION | ETA 12
OutPort_13937731_0 | SOURCE | VENTILATION | ETA 12
InPort_13937731_1 | SINK | VENTILATION | ETA 12
OutPort_14129241_2 | SOURCE | VENTILATION | ETA 12
InPort_13937763_1 | SINK | VENTILATION | ETA 12
OutPort_13937754_0 | SOURCE | VENTILATION | ETA 12
InPort_13937754_1 | SINK | VENTILATION | ETA 12
OutPort_14129242_2 | SOURCE | VENTILATION | ETA 12
InPort_13937786_1 | SINK | VENTILATION | ETA 12
OutPort_13937781_0 | SOURCE | VENTILATION | ETA 12
InPort_13937781_1 | SINK | VENTILATION | ETA 12
OutPort_14129243_2 | SOURCE | VENTILATION | ETA 12
Port_13937893_0 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13937956_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13937893_1 | SOURCEANDSINK | VENTILATION | ETA 12
Port_13937958_1 | SOURCEANDSINK | VENTILATION | ETA 12
InPort_13937893_2 | SINK | VENTILATION | ETA 12
OutPort_13937979_0 | SOURCE | VENTILATION | ETA 12
InPort_13937979_1 | SINK | VENTILATION | ETA 12
OutPort_13937974_0 | SOURCE | VENTILATION | ETA 12
InPort_13937974_1 | SINK | VENTILATION | ETA 12
OutPort_14129240_2 | SOURCE | VENTILATION | ETA 12
InPort_13938263_1 | SINK | VENTILATION | ETA 12
OutPort_13938178_1 | SOURCE | VENTILATION | ETA 12
InPort_14129240_1 | SINK | VENTILATION | ETA 12
OutPort_13938357_1 | SOURCE | VENTILATION | ETA 12
InPort_14129241_1 | SINK | VENTILATION | ETA 12
OutPort_13938428_1 | SOURCE | VENTILATION | ETA 12
InPort_14129242_1 | SINK | VENTILATION | ETA 12
OutPort_13938479_1 | SOURCE | VENTILATION | ETA 12
InPort_14129243_1 | SINK | VENTILATION | ETA 12
OutPort_13938540_1 | SOURCE | VENTILATION | ETA 12
InPort_13938718_2 | SINK | VENTILATION | ETA 12
OutPort_13938728_0 | SOURCE | VENTILATION | ETA 12
InPort_13938728_1 | SINK | VENTILATION | ETA 12
OutPort_13939226_1 | SOURCE | VENTILATION | ETA 12
InPort_13938728_2 | SINK | VENTILATION | ETA 12
OutPort_13938830_1 | SOURCE | VENTILATION | ETA 12
InPort_13938728_3 | SINK | VENTILATION | ETA 12
OutPort_13938885_1 | SOURCE | VENTILATION | ETA 12
InPort_13939226_0 | SINK | VENTILATION | ETA 12
OutPort_13939219_1 | SOURCE | VENTILATION | ETA 12
InPort_13939364_1 | SINK | VENTILATION | ETA 12
OutPort_13939370_2 | SOURCE | VENTILATION | ETA 12
InPort_13939366_1 | SINK | VENTILATION | ETA 12
OutPort_13939364_2 | SOURCE | VENTILATION | ETA 12
Port_13939450_0 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13939580_1 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13939450_1 | SOURCEANDSINK | VENTILATION | SUP 17
InPort_13939635_1 | SINK | VENTILATION | SUP 17
OutPort_13939450_2 | SOURCE | VENTILATION | SUP 17
InPort_13939689_1 | SINK | VENTILATION | SUP 17
OutPort_13939450_3 | SOURCE | VENTILATION | SUP 17
Port_13939463_1 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13939464_1 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13939463_3 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13939574_0 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13939574_1 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13939578_1 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13939575_0 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13939578_2 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13939575_1 | SOURCEANDSINK | VENTILATION | SUP 17
Port_13939580_2 | SOURCEANDSINK | VENTILATION | SUP 17
InPort_13939810_0 | SINK | VENTILATION | SUP 17
OutPort_13939816_1 | SOURCE | VENTILATION | SUP 17
InPort_13939900_1 | SINK | VENTILATION | SUP 17
OutPort_13939810_1 | SOURCE | VENTILATION | SUP 17
InPort_13939898_1 | SINK | VENTILATION | SUP 17
OutPort_13939900_0 | SOURCE | VENTILATION | SUP 17
Port_13940281_1 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13965302_1 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13940281_2 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13940367_2 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13940365_1 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13940367_1 | SOURCEANDSINK | VENTILATION | ETA 27
InPort_14189241_2 | SINK | VENTILATION | ETA 27
OutPort_13941418_1 | SOURCE | VENTILATION | ETA 27
Port_13942223_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13942257_2 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13942223_2 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13966593_2 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13942257_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_14146900_0 | SOURCEANDSINK | VENTILATION | SUP 4
InPort_14136703_2 | SINK | VENTILATION | ETA 27
OutPort_13942967_1 | SOURCE | VENTILATION | ETA 27
InPort_13943748_1 | SINK | VENTILATION | ETA 27
OutPort_13943500_1 | SOURCE | VENTILATION | ETA 27
InPort_13943500_3 | SINK | VENTILATION | ETA 27
OutPort_13956812_1 | SOURCE | VENTILATION | ETA 27
InPort_13943579_2 | SINK | VENTILATION | ETA 27
OutPort_13943571_0 | SOURCE | VENTILATION | ETA 27
InPort_13943571_1 | SINK | VENTILATION | ETA 27
OutPort_13943748_2 | SOURCE | VENTILATION | ETA 27
InPort_13967158_1 | SINK | VENTILATION | ETA 27
OutPort_13943579_1 | SOURCE | VENTILATION | ETA 27
InPort_13944772_7 | SINK | VENTILATION | ETA 1
OutPort_13943990_1 | SOURCE | VENTILATION | ETA 1
InPort_13944772_6 | SINK | VENTILATION | ETA 1
OutPort_13944113_1 | SOURCE | VENTILATION | ETA 1
InPort_13944772_5 | SINK | VENTILATION | ETA 1
OutPort_13944238_1 | SOURCE | VENTILATION | ETA 1
InPort_13947292_4 | SINK | VENTILATION | ETA 1
OutPort_13944283_1 | SOURCE | VENTILATION | ETA 1
InPort_13947276_2 | SINK | VENTILATION | ETA 1
OutPort_13944330_1 | SOURCE | VENTILATION | ETA 1
InPort_13947292_3 | SINK | VENTILATION | ETA 1
OutPort_13944382_1 | SOURCE | VENTILATION | ETA 1
InPort_13947276_3 | SINK | VENTILATION | ETA 1
OutPort_13944427_1 | SOURCE | VENTILATION | ETA 1
InPort_13947292_2 | SINK | VENTILATION | ETA 1
OutPort_13944481_1 | SOURCE | VENTILATION | ETA 1
InPort_13947276_4 | SINK | VENTILATION | ETA 1
OutPort_13944539_1 | SOURCE | VENTILATION | ETA 1
Port_13944601_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13947292_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13944601_2 | SOURCEANDSINK | VENTILATION | ETA 1
Port_14079454_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13944601_3 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13945051_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13944623_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_14079454_2 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13944623_1 | SOURCEANDSINK | VENTILATION | ETA 1
InPort_13944623_2 | SINK | VENTILATION | ETA 1
OutPort_13945619_1 | SOURCE | VENTILATION | ETA 1
InPort_13944623_3 | SINK | VENTILATION | ETA 1
OutPort_13945678_1 | SOURCE | VENTILATION | ETA 1
Port_13944772_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13947311_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13944772_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13945050_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13945051_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13945050_3 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13947276_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13945967_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14059950_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13946425_1 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13946467_1 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13946425_2 | SOURCEANDSINK | VENTILATION | ETA 97
Port_14173338_0 | SOURCEANDSINK | VENTILATION | ETA 97
Port_13947276_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13947311_2 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13947292_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_14079428_2 | SOURCEANDSINK | VENTILATION | ETA 1
InPort_13947479_1 | SINK | VENTILATION | SUP 4
OutPort_14146900_2 | SOURCE | VENTILATION | SUP 4
Port_13950070_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13966781_0 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13950070_2 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13966662_0 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13950072_0 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13966666_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13950072_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13966593_1 | SOURCEANDSINK | VENTILATION | SUP 4
InPort_13950529_0 | SINK | VENTILATION | SUP 7
OutPort_13950316_2 | SOURCE | VENTILATION | SUP 7
Port_13950340_0 | SOURCEANDSINK | VENTILATION | SUP 7
Port_14080667_1 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13950340_1 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13950941_3 | SOURCEANDSINK | VENTILATION | SUP 7
InPort_13950527_2 | SINK | VENTILATION | SUP 7
OutPort_13950529_1 | SOURCE | VENTILATION | SUP 7
InPort_13950858_1 | SINK | VENTILATION | ETA 18
OutPort_13950656_0 | SOURCE | VENTILATION | ETA 18
InPort_13950656_1 | SINK | VENTILATION | ETA 18
OutPort_13951019_2 | SOURCE | VENTILATION | ETA 18
InPort_13950844_2 | SINK | VENTILATION | ETA 18
OutPort_13950834_0 | SOURCE | VENTILATION | ETA 18
InPort_13950834_1 | SINK | VENTILATION | ETA 18
OutPort_13950848_2 | SOURCE | VENTILATION | ETA 18
InPort_13950848_1 | SINK | VENTILATION | ETA 18
OutPort_13950860_0 | SOURCE | VENTILATION | ETA 18
InPort_13950860_1 | SINK | VENTILATION | ETA 18
OutPort_13950858_2 | SOURCE | VENTILATION | ETA 18
Port_13950941_2 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13952813_1 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13950959_0 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13952813_2 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13950959_1 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13956166_2 | SOURCEANDSINK | VENTILATION | SUP 7
InPort_13951019_1 | SINK | VENTILATION | ETA 18
OutPort_13955990_0 | SOURCE | VENTILATION | ETA 18
Port_13951022_0 | SOURCEANDSINK | VENTILATION | ETA 18
Port_13987762_2 | SOURCEANDSINK | VENTILATION | ETA 18
Port_13951022_1 | SOURCEANDSINK | VENTILATION | ETA 18
Port_13987790_2 | SOURCEANDSINK | VENTILATION | ETA 18
InPort_13951649_0 | SINK | EXHAUST | EHA 9
OutPort_13951851_1 | SOURCE | EXHAUST | EHA 9
InPort_13951853_1 | SINK | EXHAUST | EHA 9
OutPort_13951649_1 | SOURCE | EXHAUST | EHA 9
InPort_13951911_0 | SINK | EXHAUST | EHA 9
OutPort_13951853_2 | SOURCE | EXHAUST | EHA 9
InPort_13951909_1 | SINK | EXHAUST | EHA 9
OutPort_13951913_0 | SOURCE | EXHAUST | EHA 9
InPort_13952178_0 | SINK | EXHAUST | EHA 9
OutPort_13951909_3 | SOURCE | EXHAUST | EHA 9
InPort_13951913_1 | SINK | EXHAUST | EHA 9
OutPort_13951911_1 | SOURCE | EXHAUST | EHA 9
InPort_13952433_1 | SINK | VENTILATION | ODA 1
OutPort_13951991_0 | SOURCE | VENTILATION | ODA 1
InPort_13951991_1 | SINK | VENTILATION | ODA 1
OutPort_13952434_1 | SOURCE | VENTILATION | ODA 1
InPort_13951999_2 | SINK | VENTILATION | ODA 1
OutPort_13952071_0 | SOURCE | VENTILATION | ODA 1
InPort_13952073_0 | SINK | VENTILATION | ODA 1
OutPort_13952069_1 | SOURCE | VENTILATION | ODA 1
InPort_13952069_3 | SINK | VENTILATION | ODA 1
OutPort_13952433_0 | SOURCE | VENTILATION | ODA 1
InPort_13952071_1 | SINK | VENTILATION | ODA 1
OutPort_13952073_1 | SOURCE | VENTILATION | ODA 1
InPort_13952420_0 | SINK | VENTILATION | ODA 1
OutPort_13952422_2 | SOURCE | VENTILATION | ODA 1
InPort_13952434_2 | SINK | VENTILATION | ODA 1
OutPort_13952420_1 | SOURCE | VENTILATION | ODA 1
Port_13952539_0 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13952549_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13952539_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13952566_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13952552_0 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13952566_2 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13952552_1 | SOURCEANDSINK | VENTILATION | SUP 4
InPort_13956453_1 | SINK | VENTILATION | SUP 4
OutPort_13952552_2 | SOURCE | VENTILATION | SUP 4
InPort_13956532_1 | SINK | VENTILATION | SUP 4
OutPort_13952552_3 | SOURCE | VENTILATION | SUP 4
InPort_13956623_1 | SINK | VENTILATION | SUP 4
OutPort_13952552_4 | SOURCE | VENTILATION | SUP 4
InPort_13953281_1 | SINK | VENTILATION | ETA 27
OutPort_13965234_0 | SOURCE | VENTILATION | ETA 27
InPort_13966929_0 | SINK | VENTILATION | ETA 27
OutPort_13953281_2 | SOURCE | VENTILATION | ETA 27
InPort_13954319_3 | SINK | VENTILATION | ETA 23
OutPort_13954311_0 | SOURCE | VENTILATION | ETA 23
InPort_13954311_1 | SINK | VENTILATION | ETA 23
OutPort_13954359_1 | SOURCE | VENTILATION | ETA 23
InPort_13954320_0 | SINK | VENTILATION | ETA 23
OutPort_13954319_1 | SOURCE | VENTILATION | ETA 23
InPort_13954319_2 | SINK | VENTILATION | ETA 23
OutPort_14056632_0 | SOURCE | VENTILATION | ETA 23
OutPort_13954320_1 | SOURCE | VENTILATION | ETA 23
InPort_13954320_3 | SINK | VENTILATION | ETA 23
OutPort_14056567_1 | SOURCE | VENTILATION | ETA 23
InPort_13954359_0 | SINK | VENTILATION | ETA 23
OutPort_13954357_1 | SOURCE | VENTILATION | ETA 23
InPort_13954764_0 | SINK | VENTILATION | SUP 14
OutPort_13954762_1 | SOURCE | VENTILATION | SUP 14
InPort_13954762_2 | SINK | VENTILATION | SUP 14
InPort_13954879_1 | SINK | VENTILATION | SUP 14
Port_13955574_0 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13955582_1 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13955574_1 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13955800_1 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13955731_0 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13955800_2 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13955731_1 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13955802_1 | SOURCEANDSINK | VENTILATION | SUP 7
InPort_13955989_3 | SINK | VENTILATION | ETA 18
OutPort_13955981_0 | SOURCE | VENTILATION | ETA 18
InPort_13955981_1 | SINK | VENTILATION | ETA 18
OutPort_13956006_1 | SOURCE | VENTILATION | ETA 18
Port_13955989_1 | SOURCEANDSINK | VENTILATION | ETA 18
Port_13987762_1 | SOURCEANDSINK | VENTILATION | ETA 18
InPort_13955990_1 | SINK | VENTILATION | ETA 18
OutPort_13955989_2 | SOURCE | VENTILATION | ETA 18
InPort_13956006_2 | SINK | VENTILATION | ETA 18
OutPort_13956000_0 | SOURCE | VENTILATION | ETA 18
InPort_13956000_1 | SINK | VENTILATION | ETA 18
OutPort_13956015_1 | SOURCE | VENTILATION | ETA 18
InPort_13956015_2 | SINK | VENTILATION | ETA 18
OutPort_13956009_0 | SOURCE | VENTILATION | ETA 18
InPort_13956009_1 | SINK | VENTILATION | ETA 18
OutPort_13956114_1 | SOURCE | VENTILATION | ETA 18
InPort_13956114_0 | SINK | VENTILATION | ETA 18
OutPort_13956104_1 | SOURCE | VENTILATION | ETA 18
Port_13956158_0 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13956166_1 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13956158_1 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13956175_1 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13956169_0 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13956175_2 | SOURCEANDSINK | VENTILATION | SUP 7
Port_13956169_1 | SOURCEANDSINK | VENTILATION | SUP 7
InPort_13956206_1 | SINK | VENTILATION | SUP 7
OutPort_13956169_2 | SOURCE | VENTILATION | SUP 7
Port_13957139_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13957319_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13957139_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13957464_2 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_14050963_1 | SINK | VENTILATION | SUP 9
OutPort_13957139_2 | SOURCE | VENTILATION | SUP 9
Port_13957300_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13957323_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13957300_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13957308_3 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13957308_1 | SINK | VENTILATION | SUP 9
OutPort_13957309_1 | SOURCE | VENTILATION | SUP 9
Port_13957317_0 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13957319_2 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13957317_1 | SOURCEANDSINK | VENTILATION | SUP 9
Port_13957323_1 | SOURCEANDSINK | VENTILATION | SUP 9
InPort_13957564_0 | SINK | VENTILATION | ETA 14
OutPort_14052218_2 | SOURCE | VENTILATION | ETA 14
InPort_14052008_1 | SINK | VENTILATION | ETA 14
OutPort_13957564_1 | SOURCE | VENTILATION | ETA 14
InPort_13957564_4 | SINK | VENTILATION | ETA 14
OutPort_14054046_1 | SOURCE | VENTILATION | ETA 14
InPort_13957564_5 | SINK | VENTILATION | ETA 14
OutPort_14054083_1 | SOURCE | VENTILATION | ETA 14
InPort_14052008_3 | SINK | VENTILATION | ETA 14
OutPort_13957600_0 | SOURCE | VENTILATION | ETA 14
InPort_13957600_1 | SINK | VENTILATION | ETA 14
OutPort_14052545_1 | SOURCE | VENTILATION | ETA 14
InPort_13957600_3 | SINK | VENTILATION | ETA 14
OutPort_14054134_1 | SOURCE | VENTILATION | ETA 14
InPort_14052216_2 | SINK | VENTILATION | ETA 14
OutPort_13957652_0 | SOURCE | VENTILATION | ETA 14
InPort_13957652_1 | SINK | VENTILATION | ETA 14
OutPort_13957708_2 | SOURCE | VENTILATION | ETA 14
InPort_13957652_3 | SINK | VENTILATION | ETA 14
OutPort_14053950_1 | SOURCE | VENTILATION | ETA 14
InPort_13957708_1 | SINK | VENTILATION | ETA 14
OutPort_13957702_0 | SOURCE | VENTILATION | ETA 14
InPort_13957702_1 | SINK | VENTILATION | ETA 14
OutPort_13957781_1 | SOURCE | VENTILATION | ETA 14
InPort_13957781_0 | SINK | VENTILATION | ETA 14
OutPort_13957772_1 | SOURCE | VENTILATION | ETA 14
Port_13959230_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13959232_0 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13959230_3 | SOURCEANDSINK | VENTILATION | ETA 1
Port_14122739_2 | SOURCEANDSINK | VENTILATION | ETA 1
Port_13959232_1 | SOURCEANDSINK | VENTILATION | ETA 1
Port_14122399_2 | SOURCEANDSINK | VENTILATION | ETA 1
InPort_13959379_1 | SINK | VENTILATION | ETA 7
OutPort_13959387_2 | SOURCE | VENTILATION | ETA 7
InPort_14171754_1 | SINK | VENTILATION | ETA 7
OutPort_13959379_2 | SOURCE | VENTILATION | ETA 7
InPort_13959381_0 | SINK | VENTILATION | ETA 7
OutPort_14171754_2 | SOURCE | VENTILATION | ETA 7
InPort_14171805_1 | SINK | VENTILATION | ETA 7
OutPort_13959381_1 | SOURCE | VENTILATION | ETA 7
InPort_13959413_1 | SINK | VENTILATION | ETA 7
OutPort_14108511_1 | SOURCE | VENTILATION | ETA 7
InPort_13959417_2 | SINK | VENTILATION | ETA 7
OutPort_13959413_2 | SOURCE | VENTILATION | ETA 7
InPort_14108754_1 | SINK | VENTILATION | ETA 7
OutPort_13959415_0 | SOURCE | VENTILATION | ETA 7
InPort_13959415_1 | SINK | VENTILATION | ETA 7
OutPort_13959417_1 | SOURCE | VENTILATION | ETA 7
InPort_13959464_1 | SINK | VENTILATION | ETA 7
OutPort_14108756_0 | SOURCE | VENTILATION | ETA 7
InPort_13959466_0 | SINK | VENTILATION | ETA 7
OutPort_13959464_2 | SOURCE | VENTILATION | ETA 7
InPort_14181187_2 | SINK | VENTILATION | ETA 7
OutPort_13959466_1 | SOURCE | VENTILATION | ETA 7
InPort_13959763_2 | SINK | VENTILATION | ETA 7
OutPort_13959765_1 | SOURCE | VENTILATION | ETA 7
InPort_13959765_0 | SINK | VENTILATION | ETA 7
OutPort_13959882_3 | SOURCE | VENTILATION | ETA 7
InPort_13959882_1 | SINK | VENTILATION | ETA 7
OutPort_13959884_1 | SOURCE | VENTILATION | ETA 7
InPort_13959918_1 | SINK | VENTILATION | ETA 7
OutPort_14175103_1 | SOURCE | VENTILATION | ETA 7
InPort_14172561_1 | SINK | VENTILATION | ETA 7
OutPort_13959918_2 | SOURCE | VENTILATION | ETA 7
InPort_13959920_0 | SINK | VENTILATION | ETA 7
OutPort_14172561_2 | SOURCE | VENTILATION | ETA 7
InPort_14172563_2 | SINK | VENTILATION | ETA 7
OutPort_13959920_1 | SOURCE | VENTILATION | ETA 7
InPort_13959963_1 | SINK | VENTILATION | ETA 7
OutPort_13959961_1 | SOURCE | VENTILATION | ETA 7
InPort_13960004_1 | SINK | VENTILATION | ETA 17
OutPort_13960045_0 | SOURCE | VENTILATION | ETA 17
InPort_13960043_1 | SINK | VENTILATION | ETA 17
OutPort_13960049_2 | SOURCE | VENTILATION | ETA 17
InPort_13960047_2 | SINK | VENTILATION | ETA 17
OutPort_13960043_2 | SOURCE | VENTILATION | ETA 17
InPort_13960045_1 | SINK | VENTILATION | ETA 17
OutPort_13960047_1 | SOURCE | VENTILATION | ETA 17
InPort_13960153_1 | SINK | VENTILATION | SUP 5
OutPort_13960151_2 | SOURCE | VENTILATION | SUP 5
InPort_13960183_1 | SINK | VENTILATION | SUP 5
OutPort_13960153_0 | SOURCE | VENTILATION | SUP 5
InPort_13960177_1 | SINK | VENTILATION | SUP 5
OutPort_13960183_2 | SOURCE | VENTILATION | SUP 5
InPort_13960181_2 | SINK | VENTILATION | SUP 5
OutPort_13960177_2 | SOURCE | VENTILATION | SUP 5
InPort_13960179_1 | SINK | VENTILATION | SUP 5
OutPort_13960181_1 | SOURCE | VENTILATION | SUP 5
InPort_14116901_1 | SINK | VENTILATION | SUP 5
OutPort_13960179_2 | SOURCE | VENTILATION | SUP 5
InPort_13960600_0 | SINK | VENTILATION | ETA 27
OutPort_13988603_2 | SOURCE | VENTILATION | ETA 27
InPort_13966360_1 | SINK | VENTILATION | ETA 27
OutPort_13960600_1 | SOURCE | VENTILATION | ETA 27
InPort_13960615_0 | SINK | VENTILATION | ETA 27
OutPort_14008190_1 | SOURCE | VENTILATION | ETA 27
InPort_13961090_2 | SINK | VENTILATION | ETA 27
OutPort_13960615_1 | SOURCE | VENTILATION | ETA 27
InPort_13960623_0 | SINK | VENTILATION | ETA 27
OutPort_13989022_1 | SOURCE | VENTILATION | ETA 27
InPort_13988985_1 | SINK | VENTILATION | ETA 27
OutPort_13960623_1 | SOURCE | VENTILATION | ETA 27
InPort_13960632_0 | SINK | VENTILATION | ETA 27
OutPort_13966154_2 | SOURCE | VENTILATION | ETA 27
InPort_13988969_2 | SINK | VENTILATION | ETA 27
OutPort_13960632_1 | SOURCE | VENTILATION | ETA 27
InPort_13960632_2 | SINK | VENTILATION | ETA 27
OutPort_13966209_1 | SOURCE | VENTILATION | ETA 27
InPort_13988620_0 | SINK | VENTILATION | ETA 27
OutPort_13961090_1 | SOURCE | VENTILATION | ETA 27
InPort_13961166_0 | SINK | VENTILATION | ETA 27
OutPort_13988985_2 | SOURCE | VENTILATION | ETA 27
InPort_13961930_1 | SINK | VENTILATION | ETA 27
OutPort_13961166_1 | SOURCE | VENTILATION | ETA 27
InPort_13964551_0 | SINK | VENTILATION | ETA 27
OutPort_13961930_2 | SOURCE | VENTILATION | ETA 27
InPort_13961932_1 | SINK | VENTILATION | ETA 27
OutPort_13961975_1 | SOURCE | VENTILATION | ETA 27
InPort_13964148_0 | SINK | VENTILATION | ETA 27
OutPort_13961932_2 | SOURCE | VENTILATION | ETA 27
InPort_13961975_0 | SINK | VENTILATION | ETA 27
OutPort_13964550_1 | SOURCE | VENTILATION | ETA 27
InPort_13964551_3 | SINK | VENTILATION | ETA 27
OutPort_13962133_1 | SOURCE | VENTILATION | ETA 27
InPort_13964551_2 | SINK | VENTILATION | ETA 27
OutPort_13962406_1 | SOURCE | VENTILATION | ETA 27
InPort_13963095_1 | SINK | VENTILATION | SUP 4
OutPort_13963098_0 | SOURCE | VENTILATION | SUP 4
InPort_13963098_1 | SINK | VENTILATION | SUP 4
OutPort_13963210_0 | SOURCE | VENTILATION | SUP 4
InPort_13963193_0 | SINK | VENTILATION | SUP 4
OutPort_14080764_1 | SOURCE | VENTILATION | SUP 4
InPort_13963208_2 | SINK | VENTILATION | SUP 4
OutPort_13963193_1 | SOURCE | VENTILATION | SUP 4
InPort_13963200_0 | SINK | VENTILATION | SUP 4
OutPort_13963208_1 | SOURCE | VENTILATION | SUP 4
InPort_13963220_1 | SINK | VENTILATION | SUP 4
OutPort_13963200_1 | SOURCE | VENTILATION | SUP 4
InPort_13963210_1 | SINK | VENTILATION | SUP 4
OutPort_13963220_2 | SOURCE | VENTILATION | SUP 4
InPort_13963352_0 | SINK | VENTILATION | SUP 25
OutPort_13989500_2 | SOURCE | VENTILATION | SUP 25
InPort_13989556_1 | SINK | VENTILATION | SUP 25
OutPort_13963352_1 | SOURCE | VENTILATION | SUP 25
InPort_14008174_1 | SINK | VENTILATION | SUP 25
OutPort_13963433_0 | SOURCE | VENTILATION | SUP 25
InPort_13963433_1 | SINK | VENTILATION | SUP 25
OutPort_13989783_1 | SOURCE | VENTILATION | SUP 25
Port_13963453_0 | SOURCEANDSINK | VENTILATION | SUP 25
Port_14007721_1 | SOURCEANDSINK | VENTILATION | SUP 25
Port_13963453_1 | SOURCEANDSINK | VENTILATION | SUP 25
InPort_14007848_1 | SINK | VENTILATION | SUP 25
OutPort_13963453_2 | SOURCE | VENTILATION | SUP 25
InPort_13964147_3 | SINK | VENTILATION | ETA 27
OutPort_13964135_0 | SOURCE | VENTILATION | ETA 27
InPort_13964135_1 | SINK | VENTILATION | ETA 27
OutPort_13965084_1 | SOURCE | VENTILATION | ETA 27
InPort_13964147_2 | SINK | VENTILATION | ETA 27
OutPort_13964148_1 | SOURCE | VENTILATION | ETA 27
InPort_13964550_3 | SINK | VENTILATION | ETA 27
OutPort_13964544_0 | SOURCE | VENTILATION | ETA 27
InPort_13964544_1 | SINK | VENTILATION | ETA 27
OutPort_13964729_1 | SOURCE | VENTILATION | ETA 27
InPort_13964550_2 | SINK | VENTILATION | ETA 27
OutPort_13964551_1 | SOURCE | VENTILATION | ETA 27
InPort_13964729_0 | SINK | VENTILATION | ETA 27
OutPort_13964719_1 | SOURCE | VENTILATION | ETA 27
InPort_13965084_0 | SINK | VENTILATION | ETA 27
OutPort_13965075_1 | SOURCE | VENTILATION | ETA 27
InPort_13965234_1 | SINK | VENTILATION | ETA 27
OutPort_14178436_2 | SOURCE | VENTILATION | ETA 27
Port_13965302_2 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13965341_0 | SOURCEANDSINK | VENTILATION | ETA 27
InPort_13965321_1 | SINK | VENTILATION | ETA 27
InPort_14178208_1 | SINK | VENTILATION | ETA 27
OutPort_13965321_2 | SOURCE | VENTILATION | ETA 27
Port_13965341_1 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13965343_1 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13965343_2 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13965747_1 | SOURCEANDSINK | EXHAUST | EHA 17
Port_13965828_0 | SOURCEANDSINK | EXHAUST | EHA 17
Port_13965826_1 | SOURCEANDSINK | EXHAUST | EHA 17
Port_13965828_1 | SOURCEANDSINK | EXHAUST | EHA 17
InPort_13966154_1 | SINK | VENTILATION | ETA 27
OutPort_13966052_0 | SOURCE | VENTILATION | ETA 27
InPort_13966052_1 | SINK | VENTILATION | ETA 27
OutPort_13966273_1 | SOURCE | VENTILATION | ETA 27
InPort_13966273_0 | SINK | VENTILATION | ETA 27
OutPort_13966264_1 | SOURCE | VENTILATION | ETA 27
InPort_13989046_0 | SINK | VENTILATION | ETA 27
OutPort_13966360_2 | SOURCE | VENTILATION | ETA 27
InPort_13966616_1 | SINK | VENTILATION | SUP 27
OutPort_13966616_2 | SOURCE | VENTILATION | SUP 27
Port_13966662_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13966664_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13966664_2 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13966666_2 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13966781_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13966802_2 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13966790_0 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13966792_2 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13966790_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13966802_1 | SOURCEANDSINK | VENTILATION | SUP 4
InPort_14137775_1 | SINK | VENTILATION | ETA 27
OutPort_13966929_1 | SOURCE | VENTILATION | ETA 27
Port_13967122_1 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13967208_2 | SOURCEANDSINK | VENTILATION | ETA 27
InPort_14188902_0 | SINK | VENTILATION | ETA 27
OutPort_13967158_2 | SOURCE | VENTILATION | ETA 27
Port_13967208_1 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13967497_0 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13967507_1 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13967497_1 | SOURCEANDSINK | VENTILATION | ETA 27
Port_14137512_1 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13967539_0 | SOURCEANDSINK | VENTILATION | ETA 27
Port_14137512_2 | SOURCEANDSINK | VENTILATION | ETA 27
Port_13967539_1 | SOURCEANDSINK | VENTILATION | ETA 27
OutPort_13968059_2 | SOURCE | VENTILATION | ODA 8
Port_13968226_0 | SOURCEANDSINK | VENTILATION | ETA 1
InPort_13968405_1 | SINK | VENTILATION | ODA 8
OutPort_13968543_1 | SOURCE | VENTILATION | ODA 8
InPort_14057002_3 | SINK | VENTILATION | ETA 7
OutPort_13970563_1 | SOURCE | VENTILATION | ETA 7
InPort_14057002_2 | SINK | VENTILATION | ETA 7
OutPort_13970652_1 | SOURCE | VENTILATION | ETA 7
InPort_13971146_0 | SINK | VENTILATION | SUP 24
OutPort_13971154_2 | SOURCE | VENTILATION | SUP 24
InPort_14058148_1 | SINK | VENTILATION | SUP 24
OutPort_13971146_1 | SOURCE | VENTILATION | SUP 24
InPort_14078827_1 | SINK | VENTILATION | SUP 24
OutPort_13971146_2 | SOURCE | VENTILATION | SUP 24
InPort_13971995_0 | SINK | VENTILATION | ETA 29
OutPort_13971416_2 | SOURCE | VENTILATION | ETA 29
InPort_13971572_1 | SINK | VENTILATION | ETA 53
OutPort_13971567_0 | SOURCE | VENTILATION | ETA 53
InPort_13971567_1 | SINK | VENTILATION | ETA 53
OutPort_13977173_1 | SOURCE | VENTILATION | ETA 53
OutPort_13971995_1 | SOURCE | VENTILATION | ETA 29
InPort_14148458_0 | SINK | VENTILATION | ETA 51
OutPort_13976969_1 | SOURCE | VENTILATION | ETA 51
InPort_14148347_0 | SINK | VENTILATION | ETA 50
OutPort_13977031_1 | SOURCE | VENTILATION | ETA 50
InPort_14148423_1 | SINK | VENTILATION | ETA 49
OutPort_13977088_1 | SOURCE | VENTILATION | ETA 49
Port_13977611_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13977937_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13977611_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13977736_1 | SINK | VENTILATION | SUP 13
OutPort_13977611_2 | SOURCE | VENTILATION | SUP 13
InPort_13977774_1 | SINK | VENTILATION | SUP 13
OutPort_13977611_3 | SOURCE | VENTILATION | SUP 13
Port_13977922_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13977926_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13977923_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13977926_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13977923_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13977939_2 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13978791_2 | SINK | VENTILATION | ETA 3
OutPort_13978664_0 | SOURCE | VENTILATION | ETA 3
InPort_13978664_1 | SINK | VENTILATION | ETA 3
OutPort_13978872_1 | SOURCE | VENTILATION | ETA 3
InPort_13978671_1 | SINK | VENTILATION | ETA 3
OutPort_13978754_0 | SOURCE | VENTILATION | ETA 3
InPort_13978754_1 | SINK | VENTILATION | ETA 3
OutPort_13978791_1 | SOURCE | VENTILATION | ETA 3
InPort_14148753_0 | SINK | VENTILATION | ETA 78
OutPort_13979640_1 | SOURCE | VENTILATION | ETA 78
InPort_14149024_0 | SINK | VENTILATION | ETA 79
OutPort_13979703_1 | SOURCE | VENTILATION | ETA 79
InPort_13979810_1 | SINK | VENTILATION | ETA 33
OutPort_14148993_0 | SOURCE | VENTILATION | ETA 33
InPort_13979811_0 | SINK | VENTILATION | ETA 33
OutPort_13979810_2 | SOURCE | VENTILATION | ETA 33
InPort_13979909_1 | SINK | VENTILATION | ETA 33
OutPort_13979811_1 | SOURCE | VENTILATION | ETA 33
InPort_14148993_1 | SINK | VENTILATION | ETA 33
OutPort_13979812_1 | SOURCE | VENTILATION | ETA 33
InPort_13979904_0 | SINK | VENTILATION | ETA 33
OutPort_13979909_2 | SOURCE | VENTILATION | ETA 33
OutPort_13979904_1 | SOURCE | VENTILATION | ETA 33
InPort_13980604_2 | SINK | VENTILATION | ETA 67
OutPort_13980599_0 | SOURCE | VENTILATION | ETA 67
InPort_13980599_1 | SINK | VENTILATION | ETA 67
OutPort_13980669_1 | SOURCE | VENTILATION | ETA 67
InPort_13981245_0 | SINK | VENTILATION | ETA 68
OutPort_13981207_2 | SOURCE | VENTILATION | ETA 68
OutPort_13981245_1 | SOURCE | VENTILATION | ETA 68
InPort_14148586_0 | SINK | VENTILATION | ETA 55
OutPort_13981608_1 | SOURCE | VENTILATION | ETA 55
InPort_14148617_0 | SINK | VENTILATION | ETA 56
OutPort_13981652_1 | SOURCE | VENTILATION | ETA 56
Port_13981727_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13981807_0 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13981795_1 | SINK | VENTILATION | SUP 28
OutPort_13981795_2 | SOURCE | VENTILATION | SUP 28
Port_13981807_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13981809_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13981809_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13981811_1 | SOURCEANDSINK | VENTILATION | SUP 23
Port_13981906_0 | SOURCEANDSINK | VENTILATION | SUP 23
Port_13981811_2 | SOURCEANDSINK | VENTILATION | SUP 23
Port_13981906_1 | SOURCEANDSINK | VENTILATION | SUP 23
Port_13981920_2 | SOURCEANDSINK | VENTILATION | SUP 23
Port_13981912_0 | SOURCEANDSINK | VENTILATION | SUP 23
Port_13982167_1 | SOURCEANDSINK | VENTILATION | SUP 23
Port_13981912_1 | SOURCEANDSINK | VENTILATION | SUP 23
InPort_13982264_1 | SINK | VENTILATION | SUP 23
OutPort_13981912_2 | SOURCE | VENTILATION | SUP 23
InPort_13982296_1 | SINK | VENTILATION | SUP 23
OutPort_13981912_3 | SOURCE | VENTILATION | SUP 23
InPort_13982320_1 | SINK | VENTILATION | SUP 23
OutPort_13981912_4 | SOURCE | VENTILATION | SUP 23
Port_13981920_1 | SOURCEANDSINK | VENTILATION | SUP 23
Port_13982163_0 | SOURCEANDSINK | VENTILATION | SUP 23
Port_13982139_1 | SOURCEANDSINK | VENTILATION | SUP 23
Port_13982167_2 | SOURCEANDSINK | VENTILATION | SUP 23
Port_13982139_2 | SOURCEANDSINK | VENTILATION | SUP 23
Port_13982165_2 | SOURCEANDSINK | VENTILATION | SUP 23
Port_13982163_1 | SOURCEANDSINK | VENTILATION | SUP 23
Port_13982165_1 | SOURCEANDSINK | VENTILATION | SUP 23
OutPort_13982426_1 | SOURCE | VENTILATION | ETA 56
Port_13982697_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13982811_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13982795_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13982826_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13982795_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13982830_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13982809_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13982811_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13982809_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13982830_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13982820_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13982822_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13982820_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13982826_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_14148860_1 | SINK | VENTILATION | ETA 72
OutPort_13982996_1 | SOURCE | VENTILATION | ETA 72
InPort_14148812_1 | SINK | VENTILATION | ETA 70
OutPort_13983093_1 | SOURCE | VENTILATION | ETA 70
InPort_14148649_0 | SINK | VENTILATION | ETA 69
OutPort_13983139_1 | SOURCE | VENTILATION | ETA 69
InPort_14148528_1 | SINK | VENTILATION | ETA 54
OutPort_13983666_1 | SOURCE | VENTILATION | ETA 54
InPort_13984190_2 | SINK | VENTILATION | SUP 13
OutPort_13984588_0 | SOURCE | VENTILATION | SUP 13
Port_13984192_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13984303_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13984303_2 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13984305_1 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13984305_0 | SOURCEANDSINK | VENTILATION | SUP 13
Port_13984357_2 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13984357_3 | SINK | VENTILATION | SUP 13
OutPort_13984346_0 | SOURCE | VENTILATION | SUP 13
InPort_13984346_1 | SINK | VENTILATION | SUP 13
OutPort_13984374_2 | SOURCE | VENTILATION | SUP 13
InPort_13984503_1 | SINK | VENTILATION | SUP 13
OutPort_13984357_1 | SOURCE | VENTILATION | SUP 13
InPort_13984592_1 | SINK | VENTILATION | SUP 13
OutPort_13984358_0 | SOURCE | VENTILATION | SUP 13
InPort_13984358_1 | SINK | VENTILATION | SUP 13
OutPort_13984503_2 | SOURCE | VENTILATION | SUP 13
InPort_13984846_1 | SINK | VENTILATION | SUP 13
OutPort_13984366_0 | SOURCE | VENTILATION | SUP 13
InPort_13984366_1 | SINK | VENTILATION | SUP 13
OutPort_13985038_1 | SOURCE | VENTILATION | SUP 13
InPort_13984374_1 | SINK | VENTILATION | SUP 13
OutPort_13984681_0 | SOURCE | VENTILATION | SUP 13
InPort_13984574_1 | SINK | VENTILATION | SUP 13
OutPort_13984592_2 | SOURCE | VENTILATION | SUP 13
InPort_13984590_2 | SINK | VENTILATION | SUP 13
OutPort_13984574_2 | SOURCE | VENTILATION | SUP 13
InPort_13984588_1 | SINK | VENTILATION | SUP 13
OutPort_13984590_1 | SOURCE | VENTILATION | SUP 13
InPort_13984657_1 | SINK | VENTILATION | SUP 13
OutPort_13984685_2 | SOURCE | VENTILATION | SUP 13
InPort_13984683_2 | SINK | VENTILATION | SUP 13
OutPort_13984657_2 | SOURCE | VENTILATION | SUP 13
InPort_13984681_1 | SINK | VENTILATION | SUP 13
OutPort_13984683_1 | SOURCE | VENTILATION | SUP 13
InPort_13984685_1 | SINK | VENTILATION | SUP 13
OutPort_13984848_0 | SOURCE | VENTILATION | SUP 13
InPort_13984848_1 | SINK | VENTILATION | SUP 13
OutPort_13984846_2 | SOURCE | VENTILATION | SUP 13
InPort_13985038_2 | SINK | VENTILATION | SUP 13
OutPort_13985028_0 | SOURCE | VENTILATION | SUP 13
InPort_13985028_1 | SINK | VENTILATION | SUP 13
OutPort_13985048_2 | SOURCE | VENTILATION | SUP 13
InPort_13985048_1 | SINK | VENTILATION | SUP 13
OutPort_13985410_0 | SOURCE | VENTILATION | SUP 13
InPort_13985140_1 | SINK | VENTILATION | SUP 13
OutPort_13985410_2 | SOURCE | VENTILATION | SUP 13
InPort_13985168_1 | SINK | VENTILATION | SUP 13
OutPort_13985410_3 | SOURCE | VENTILATION | SUP 13
InPort_13985192_1 | SINK | VENTILATION | SUP 13
OutPort_13985410_4 | SOURCE | VENTILATION | SUP 13
InPort_13985470_2 | SINK | VENTILATION | SUP 13
OutPort_13985318_0 | SOURCE | VENTILATION | SUP 13
InPort_13985318_1 | SINK | VENTILATION | SUP 13
InPort_13985492_1 | SINK | VENTILATION | SUP 13
OutPort_13985318_2 | SOURCE | VENTILATION | SUP 13
InPort_13985516_1 | SINK | VENTILATION | SUP 13
OutPort_13985318_3 | SOURCE | VENTILATION | SUP 13
InPort_13985410_1 | SINK | VENTILATION | SUP 13
OutPort_13985470_1 | SOURCE | VENTILATION | SUP 13
InPort_13985597_1 | SINK | VENTILATION | ETA 89
OutPort_14148892_1 | SOURCE | VENTILATION | ETA 89
InPort_13985598_0 | SINK | VENTILATION | ETA 89
OutPort_13985597_2 | SOURCE | VENTILATION | ETA 89
OutPort_13985598_1 | SOURCE | VENTILATION | ETA 89
InPort_14148892_0 | SINK | VENTILATION | ETA 89
OutPort_13985599_1 | SOURCE | VENTILATION | ETA 89
InPort_14123079_2 | SINK | VENTILATION | SUP 24
OutPort_13986735_0 | SOURCE | VENTILATION | SUP 24
InPort_13986735_1 | SINK | VENTILATION | SUP 24
OutPort_14123350_1 | SOURCE | VENTILATION | SUP 24
InPort_13986742_0 | SINK | VENTILATION | SUP 24
OutPort_14058965_1 | SOURCE | VENTILATION | SUP 24
Port_13986742_1 | SOURCEANDSINK | VENTILATION | SUP 24
InPort_14059327_1 | SINK | VENTILATION | SUP 24
OutPort_13986742_2 | SOURCE | VENTILATION | SUP 24
InPort_14059356_1 | SINK | VENTILATION | SUP 24
OutPort_13986742_3 | SOURCE | VENTILATION | SUP 24
Port_13987653_1 | SOURCEANDSINK | VENTILATION | ETA 18
Port_13988329_0 | SOURCEANDSINK | VENTILATION | ETA 18
Port_13987766_0 | SOURCEANDSINK | VENTILATION | ETA 18
Port_13988327_1 | SOURCEANDSINK | VENTILATION | ETA 18
Port_13987766_1 | SOURCEANDSINK | VENTILATION | ETA 18
Port_13987790_1 | SOURCEANDSINK | VENTILATION | ETA 18
Port_13988327_2 | SOURCEANDSINK | VENTILATION | ETA 18
Port_13988329_1 | SOURCEANDSINK | VENTILATION | ETA 18
InPort_13988603_1 | SINK | VENTILATION | ETA 27
OutPort_13988620_1 | SOURCE | VENTILATION | ETA 27
InPort_13988959_0 | SINK | VENTILATION | ETA 27
OutPort_13988969_1 | SOURCE | VENTILATION | ETA 27
InPort_13988993_1 | SINK | VENTILATION | ETA 27
OutPort_13988959_1 | SOURCE | VENTILATION | ETA 27
InPort_13988985_3 | SINK | VENTILATION | ETA 27
OutPort_13988971_0 | SOURCE | VENTILATION | ETA 27
InPort_13988971_1 | SINK | VENTILATION | ETA 27
OutPort_13988993_2 | SOURCE | VENTILATION | ETA 27
InPort_13989022_2 | SINK | VENTILATION | ETA 27
OutPort_13989046_1 | SOURCE | VENTILATION | ETA 27
Port_13989138_0 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13989148_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13989138_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13989219_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13989201_0 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13989211_3 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13989201_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13989219_2 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13989211_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13989264_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13989264_2 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13989322_0 | SOURCEANDSINK | VENTILATION | SUP 4
InPort_13989320_1 | SINK | VENTILATION | SUP 25
InPort_13989500_1 | SINK | VENTILATION | SUP 25
OutPort_13989320_2 | SOURCE | VENTILATION | SUP 25
Port_13989322_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13989324_1 | SOURCEANDSINK | VENTILATION | SUP 4
Port_13989324_2 | SOURCEANDSINK | VENTILATION | SUP 4
InPort_13989524_1 | SINK | VENTILATION | SUP 25
OutPort_13989556_2 | SOURCE | VENTILATION | SUP 25
InPort_13989783_2 | SINK | VENTILATION | SUP 25
OutPort_13989524_2 | SOURCE | VENTILATION | SUP 25
InPort_13989798_0 | SINK | VENTILATION | ETA 7
OutPort_14060501_2 | SOURCE | VENTILATION | ETA 7
InPort_14191505_1 | SINK | VENTILATION | ETA 7
OutPort_13989798_1 | SOURCE | VENTILATION | ETA 7
Port_13989800_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13990464_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13989800_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13992189_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13989866_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14114159_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13990465_1 | SINK | VENTILATION | ETA 7
OutPort_13990464_2 | SOURCE | VENTILATION | ETA 7
Port_13990464_3 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14017440_0 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_14060501_1 | SINK | VENTILATION | ETA 7
OutPort_13990465_0 | SOURCE | VENTILATION | ETA 7
InPort_14017279_2 | SINK | VENTILATION | ETA 7
OutPort_13990509_1 | SOURCE | VENTILATION | ETA 7
InPort_13990588_1 | SINK | VENTILATION | ETA 64
OutPort_13990660_1 | SOURCE | VENTILATION | ETA 64
InPort_13992189_3 | SINK | VENTILATION | ETA 7
OutPort_13990996_0 | SOURCE | VENTILATION | ETA 7
InPort_13990996_1 | SINK | VENTILATION | ETA 7
OutPort_13991017_2 | SOURCE | VENTILATION | ETA 7
InPort_13990996_2 | SINK | VENTILATION | ETA 7
OutPort_13991074_1 | SOURCE | VENTILATION | ETA 7
InPort_13991017_1 | SINK | VENTILATION | ETA 7
OutPort_13991009_0 | SOURCE | VENTILATION | ETA 7
InPort_13991009_1 | SINK | VENTILATION | ETA 7
OutPort_13991053_1 | SOURCE | VENTILATION | ETA 7
InPort_13991053_0 | SINK | VENTILATION | ETA 7
OutPort_13991051_1 | SOURCE | VENTILATION | ETA 7
InPort_13991402_0 | SINK | VENTILATION | SUP 13
OutPort_13991415_2 | SOURCE | VENTILATION | SUP 13
InPort_13991426_2 | SINK | VENTILATION | SUP 13
OutPort_13991402_1 | SOURCE | VENTILATION | SUP 13
InPort_13991418_0 | SINK | VENTILATION | SUP 13
OutPort_13991426_1 | SOURCE | VENTILATION | SUP 13
Port_13991418_1 | SOURCEANDSINK | VENTILATION | SUP 13
InPort_13991475_1 | SINK | VENTILATION | SUP 13
OutPort_13991418_2 | SOURCE | VENTILATION | SUP 13
InPort_13991502_1 | SINK | VENTILATION | SUP 13
OutPort_13991418_3 | SOURCE | VENTILATION | SUP 13
InPort_13991580_1 | SINK | VENTILATION | SUP 13
OutPort_13991602_1 | SOURCE | VENTILATION | SUP 13
InPort_13991967_0 | SINK | VENTILATION | SUP 13
OutPort_13991580_2 | SOURCE | VENTILATION | SUP 13
InPort_13991679_1 | SINK | VENTILATION | SUP 13
OutPort_13991697_1 | SOURCE | VENTILATION | SUP 13
InPort_13992001_0 | SINK | VENTILATION | SUP 13
OutPort_13991679_2 | SOURCE | VENTILATION | SUP 13
InPort_13991697_0 | SINK | VENTILATION | SUP 13
OutPort_13991847_1 | SOURCE | VENTILATION | SUP 13
InPort_13991847_2 | SINK | VENTILATION | SUP 13
OutPort_13991819_1 | SOURCE | VENTILATION | SUP 13
InPort_13991945_2 | SINK | VENTILATION | SUP 13
OutPort_13991967_1 | SOURCE | VENTILATION | SUP 13
InPort_13991989_2 | SINK | VENTILATION | SUP 13
OutPort_13992001_1 | SOURCE | VENTILATION | SUP 13
Port_13992189_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13992197_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13992197_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14114735_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13992210_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14114731_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13992210_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14114735_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13992221_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_14114731_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13992221_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13992242_1 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13992234_0 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13992242_2 | SOURCEANDSINK | VENTILATION | ETA 7
Port_13992234_1 | SOURCEANDSINK | VENTILATION | ETA 7
InPort_13992234_3 | SINK | VENTILATION | ETA 7
OutPort_14165237_1 | SOURCE | VENTILATION | ETA 7
InPort_13992397_1 | SINK | VENTILATION | ODA 10
OutPort_13992408_2 | SOURCE | VENTILATION | ODA 10
Port_13992544_0 | SOURCEANDSINK | VENTILATION | ODA 10
Port_14002961_2 | SOURCEANDSINK | VENTILATION | ODA 10
Port_13992544_1 | SOURCEANDSINK | VENTILATION | ODA 10
Port_14002965_2 | SOURCEANDSINK | VENTILATION | ODA 10
Port_13992568_0 | SOURCEANDSINK | VENTILATION | ODA 10
Port_14003000_2 | SOURCEANDSINK | VENTILATION | ODA 10
Port_13992568_1 | SOURCEANDSINK | VENTILATION | ODA 10
Port_14003005_1 | SOURCEANDSINK | VENTILATION | ODA 10
Port_13993728_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13993748_2 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13993736_0 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13993746_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13993736_1 | SOURCEANDSINK | VENTILATION | ETA 17
Port_13993748_1 | SOURCEANDSINK | VENTILATION | ETA 17
InPort_13993809_0 | SINK | VENTILATION | ETA 17
OutPort_13993807_1 | SOURCE | VENTILATION | ETA 17
InPort_13993999_2 | SINK | VENTILATION | ETA 17
OutPort_13993988_0 | SOURCE | VENTILATION | ETA 17
InPort_13993988_1 | SINK | VENTILATION | ETA 17
OutPort_13994012_2 | SOURCE | VENTILATION | ETA 17
InPort_13994012_1 | SINK | VENTILATION | ETA 17
OutPort_13994001_0 | SOURCE | VENTILATION | ETA 17
Port_13994001_1 | SOURCEANDSINK | VENTILATION | ETA 17
InPort_13994001_2 | SINK | VENTILATION | ETA 17
OutPort_13994068_1 | SOURCE | VENTILATION | ETA 17
