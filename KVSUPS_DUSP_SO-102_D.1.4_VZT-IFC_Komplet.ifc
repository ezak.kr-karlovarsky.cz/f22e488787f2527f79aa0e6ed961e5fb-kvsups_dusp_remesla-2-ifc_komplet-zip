Properties of the parts of a building model (IFC4), part 34 of 45

# IfcDuctFitting: M_Kulatý přechod, úhel:45 stupňů (127)
Name (M_Kulatý přechod, úhel:45 stupňů:...) | In | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Odsazení šířky od základny (mm) | Odsazení výšky od základny (mm) | Rozdíl odsazení (mm) | Dočas. šířka odsazení | Dočas. výška odsazení | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Poloměr potrubí 1 (mm) | Poloměr potrubí 2 (mm) | Rozdíl poloměrů (mm) | Velikost | Vypočítaná délka (mm) | Kód prvku | Označení | Páteřní trasa | Délka 3 (mm) | Číslo 1 | Číslo 2 | Číslo 3 | Číslo 5 | Délka 1 (mm) | Délka 2 (mm) | Tlaková ztráta (Pa)
14110118 | -1.PP_SO-102 | 180 mm-160 mm | -1.PP_SO-102 | 3150 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.1194 | 1194 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
14110120 | -1.PP_SO-102 | 180 mm-160 mm | -1.PP_SO-102 | 3150 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.1195 | 1195 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
14110455 | -1.PP_SO-102 | 355 mm-250 mm | -1.PP_SO-102 | 3150 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 18 | ETA | 3100.5 | 3048 | 52.5 | 0.0493056 | 0.0347222 | 0.00762158 | 177.5 | 125 | 0.117694 | 125 | 177.5 | 52.5 | 355-250 | 105 | TA03.01.1201 | 1201 | yes | 52.5 | 4.2 | 0 | 4.2 | 4.2 | 105 | 0
14110484 | -1.PP_SO-102 | 250 mm-200 mm | -1.PP_SO-102 | 3150 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 18 | ETA | 3073 | 3048 | 25 | 0.0416667 | 0.0347222 | 0.00199602 | 150 | 125 | 0.0506179 | 125 | 100 | 25 | 250-200 | 50 | TA03.01.1202 | 1202 | yes | 25 | 2 | 0 | 2 | 2 | 50 | 0
14117734 | -1.PP_SO-102 | 200 mm-160 mm | -1.PP_SO-102 | 2600 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 3048 | 3048 | 0 | 0.0222222 | 0.0222222 | 0.00123354 | 80 | 80 | 0.0344984 | 80 | 100 | 20 | 200-160 | 48.2843 | TA03.01.1250 | 1250 | no | 0 | 0.8 | 0.8 | 1.6 | 1.93137 | 20 | 20 | 0
14122086 | -1.PP_SO-102 | 180 mm-160 mm | -1.PP_SO-102 | 3240 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.1276 | 1276 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
14124597 | 2.NP_SO-102 | 450 mm-355 mm | 2.NP_SO-102 | 2850 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 3048 | 3046.57 | 1.43175 | 0.0493056 | 0.0497033 | 0.0146584 | 177.5 | 178.932 | 0.178361 | 177.5 | 225 | 47.5 | 450-355 | 114.675 | TA03.01.1296 | 1296 | yes | 0 | 1.9 | 1.9 | 3.8 | 4.58701 | 47.5 | 47.5 | 0
14137887 | -1.PP_SO-102 | 355 mm-180 mm | -1.PP_SO-102 | 3069.67 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 3048 | 3047.37 | 0.627288 | 0.025 | 0.0251742 | 0.0122947 | 90 | 90.6273 | 0.15731 | 90 | 177.5 | 87.5 | 355-180 | 211.244 | TA03.01.1323 | 1323 | yes | 0 | 3.5 | 3.5 | 7 | 8.44975 | 87.5 | 87.5 | 0
14137985 | -1.PP_SO-102 | 180 mm-160 mm | -1.PP_SO-102 | 3050 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.1325 | 1325 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
14137987 | -1.PP_SO-102 | 180 mm-160 mm | -1.PP_SO-102 | 3080 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 0 | 0.025 | 0.025 | 0.000548535 | 90 | 90 | 0.0230465 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.1326 | 1326 | no | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10
14171754 | -1.PP_SO-102 | 315 mm-250 mm | -1.PP_SO-102 | 3080 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 0 | 0.0347222 | 0.0347222 | 0.00493936 | 125 | 125 | 0.0865885 | 125 | 157.5 | 32.5 | 315-250 | 78.4619 | TA03.01.1417 | 1417 |  | 0 | 1.3 | 1.3 | 2.6 | 3.13848 | 32.5 | 32.5 | 0
14172561 | -1.PP_SO-102 | 315 mm-250 mm | -1.PP_SO-102 | 2900 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3048 | 0 | 0.0347222 | 0.0347222 | 0.00493936 | 125 | 125 | 0.0865885 | 125 | 157.5 | 32.5 | 315-250 | 78.4619 | TA03.01.1420 | 1420 | yes | 0 | 1.3 | 1.3 | 2.6 | 3.13848 | 32.5 | 32.5 | 0
14172815 | 1.NP_SO-102 | 180 mm-160 mm | 1.NP_SO-102 | 2579.63 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 2613.12 | 434.885 | 0.025 | 0.145801 | 0.000548535 | 90 | 524.885 | 0.0919688 | 90 | 80 | 10 | 180-160 | 24.1421 | TA03.01.1423 | 1423 |  | 0 | 0.4 | 0.4 | 0.8 | 0.965685 | 10 | 10 | 0
14178208 | -1.PP_SO-102 | 250 mm-225 mm | -1.PP_SO-102 | 2350.04 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 3048 | 3048.04 | -0.00000186703 | 0.03125 | 0.0312392 | 0.00133805 | 112.5 | 112.461 | 0.0432044 | 112.5 | 125 | 12.5 | 250-225 | 30.1777 | TA03.01.1446 | 1446 |  | 0.00000186703 | 0.5 | 0.5 | 1 | 1.20711 | 12.5 | 12.5 | 0
14181187 | -1.PP_SO-102 | 315 mm-315 mm | -1.PP_SO-102 | 3100 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 3048 | 3068 | 0 | 0.04375 | 0.0381944 | 0.00613679 | 157.5 | 137.5 | 0.100013 | 157.5 | 157.5 | 0 | 315-315 | 78.75 | TA03.01.1461 | 1461 |  | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0

# IfcDuctFitting: M_Kulatý spoj T:Standardní (71)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA06; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 02; Popis sestavy: Spojka
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulatý spoj T
Classification: TA06 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Grafika - Použít měřítko poznámky: yes
Jiné - Id typu: 1446011; Rodina: M_Kulatý spoj T; Rodina a typ: M_Kulatý spoj T: Standardní; Typ: Standardní
Name (M_Kulatý spoj T:Standardní:...) | In | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Délka potrubí 1 (mm) | Délka potrubí 3 (mm) | Objem (m3) | Poloměr potrubí 1 (mm) | Poloměr potrubí 3 (mm) | Velikost | Kód prvku | Označení | Páteřní trasa
13095866 | 2.NP_SO-102 | 400 mm-315 mm-315 mm | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 500 | 207.5 | 0.0507801 | 157.5 | 200 | 400-315-315 | TA06.02.0005 | 0005 | yes
13154814 | 1.NP_SO-102 | 355 mm-355 mm-125 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 225 | 227.5 | 0.0229172 | 177.5 | 62.5 | 355-355-125 | TA06.02.0034 | 0034 | yes
13154858 | 1.NP_SO-102 | 355 mm-355 mm-180 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 280 | 227.5 | 0.0291356 | 177.5 | 90 | 355-355-180 | TA06.02.0035 | 0035 | yes
13155859 | 2.NP_SO-102 | 560 mm-560 mm-280 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 380 | 330 | 0.0972292 | 280 | 140 | 560-560-280 | TA06.02.0037 | 0037 | yes
13156249 | 2.NP_SO-102 | 400 mm-400 mm-280 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 380 | 250 | 0.051637 | 200 | 140 | 400-400-280 | TA06.02.0041 | 0041 | yes
13156292 | 2.NP_SO-102 | 450 mm-450 mm-280 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 380 | 275 | 0.0642183 | 225 | 140 | 450-450-280 | TA06.02.0043 | 0043 | yes
13157246 | 4.NP_SO-102 | 450 mm-450 mm-225 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 325 | 275 | 0.0539622 | 225 | 112.5 | 450-450-225 | TA06.02.0047 | 0047 | yes
13157563 | 3.NP_SO-102 | 400 mm-400 mm-250 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 350 | 250 | 0.0469396 | 200 | 125 | 400-400-250 | TA06.02.0054 | 0054 | yes
13157605 | 3.NP_SO-102 | 450 mm-450 mm-280 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 380 | 275 | 0.0642183 | 225 | 140 | 450-450-280 | TA06.02.0057 | 0057 | yes
13157650 | 3.NP_SO-102 | 500 mm-500 mm-280 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 380 | 300 | 0.0783161 | 250 | 140 | 500-500-280 | TA06.02.0060 | 0060 | yes
13160736 | 2.NP_SO-102 | 450 mm-450 mm-180 mm | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 280 | 275 | 0.0459181 | 225 | 90 | 450-450-180 | TA06.02.0063 | 0063 | yes
13169486 | 1.NP_SO-102 | 315 mm-315 mm-200 mm | 1.NP_SO-102 | 3150 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 300 | 207.5 | 0.0252128 | 157.5 | 100 | 315-315-200 | TA06.02.0078 | 0078 | yes
13170808 | 1.NP_SO-102 | 355 mm-280 mm-280 mm | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 455 | 190 | 0.0368251 | 140 | 177.5 | 355-280-280 | TA06.02.0081 | 0081 | no
13171225 | 2.NP_SO-102 | 400 mm-400 mm-225 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 325 | 250 | 0.0431541 | 200 | 112.5 | 400-400-225 | TA06.02.0082 | 0082 | yes
13172245 | 3.NP_SO-102 | 315 mm-315 mm-280 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 380 | 207.5 | 0.0337816 | 157.5 | 140 | 315-315-280 | TA06.02.0084 | 0084 | yes
13197384 | 4.NP_SO-102 | 280 mm-280 mm-225 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 325 | 190 | 0.022495 | 140 | 112.5 | 280-280-225 | TA06.02.0085 | 0085 | yes
13198443 | 4.NP_SO-102 | 500 mm-500 mm-180 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 280 | 300 | 0.0563505 | 250 | 90 | 500-500-180 | TA06.02.0087 | 0087 | yes
13198824 | 3.NP_SO-102 | 400 mm-400 mm-225 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 325 | 250 | 0.0431541 | 200 | 112.5 | 400-400-225 | TA06.02.0089 | 0089 | yes
13199271 | 3.NP_SO-102 | 400 mm-400 mm-225 mm | 3.NP_SO-102 | 3099.91 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 325 | 250 | 0.0431541 | 200 | 112.5 | 400-400-225 | TA06.02.0093 | 0093 | yes
13199355 | 3.NP_SO-102 | 450 mm-450 mm-160 mm | 3.NP_SO-102 | 3099.91 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 260 | 275 | 0.0424262 | 225 | 80 | 450-450-160 | TA06.02.0095 | 0095 | yes
13199636 | 3.NP_SO-102 | 500 mm-500 mm-315 mm | 3.NP_SO-102 | 3099.91 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 415 | 300 | 0.0863973 | 250 | 157.5 | 500-500-315 | TA06.02.0098 | 0098 | yes
13200350 | 2.NP_SO-102 | 400 mm-400 mm-315 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 415 | 250 | 0.0573709 | 200 | 157.5 | 400-400-315 | TA06.02.0102 | 0102 | yes
13227879 | 1.NP_SO-102 | 500 mm-500 mm-180 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 280 | 300 | 0.0563505 | 250 | 90 | 500-500-180 | TA06.02.0105 | 0105 | yes
13227939 | 1.NP_SO-102 | 450 mm-450 mm-180 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 280 | 275 | 0.0459181 | 225 | 90 | 450-450-180 | TA06.02.0106 | 0106 | yes
13302588 | 1.NP_SO-102 | 355 mm-355 mm-180 mm | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 280 | 227.5 | 0.0291356 | 177.5 | 90 | 355-355-180 | TA06.02.0109 | 0109 | yes
13651802 | 1.NP_SO-102 | 450 mm-450 mm-355 mm | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 455 | 275 | 0.0792122 | 225 | 177.5 | 450-450-355 | TA06.02.0174 | 0174 | yes
13707787 | 2.NP_SO-102 | 450 mm-400 mm-400 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 550 | 250 | 0.0837743 | 200 | 225 | 450-400-400 | TA06.02.0188 | 0188 | yes
13708506 | 3.NP_SO-102 | 400 mm-400 mm-180 mm | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 280 | 250 | 0.0365879 | 200 | 90 | 400-400-180 | TA06.02.0191 | 0191 | yes
13713179 | 2.NP_SO-102 | 560 mm-560 mm-560 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 660 | 330 | 0.185291 | 280 | 280 | 560-560-560 | TA06.02.0199 | 0199 | yes
13713656 | 2.NP_SO-102 | 400 mm-400 mm-250 mm | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 350 | 250 | 0.0469396 | 200 | 125 | 400-400-250 | TA06.02.0205 | 0205 | yes
13713955 | 2.NP_SO-102 | 400 mm-400 mm-225 mm | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 325 | 250 | 0.0431541 | 200 | 112.5 | 400-400-225 | TA06.02.0208 | 0208 | yes
13714188 | 3.NP_SO-102 | 355 mm-315 mm-315 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 455 | 207.5 | 0.0437117 | 157.5 | 177.5 | 355-315-315 | TA06.02.0211 | 0211 | yes
13714618 | 4.NP_SO-102 | 200 mm-200 mm-180 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 280 | 150 | 0.010363 | 100 | 90 | 200-200-180 | TA06.02.0212 | 0212 | yes
13714819 | 4.NP_SO-102 | 225 mm-225 mm-160 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 260 | 162.5 | 0.0114964 | 112.5 | 80 | 225-225-160 | TA06.02.0214 | 0214 | yes
13717444 | 2.NP_SO-102 | 250 mm-225 mm-225 mm | 2.NP_SO-102 | 2937.5 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 350 | 162.5 | 0.0174978 | 112.5 | 125 | 250-225-225 | TA06.02.0217 | 0217 | yes
13718777 | 2.NP_SO-102 | 355 mm-355 mm-250 mm | 2.NP_SO-102 | 2940 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 350 | 227.5 | 0.0376759 | 177.5 | 125 | 355-355-250 | TA06.02.0225 | 0225 | no
13803148 | 2.NP_SO-102 | 400 mm-400 mm-200 mm | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 300 | 250 | 0.0394701 | 200 | 100 | 400-400-200 | TA06.02.0347 | 0347 | yes
13817820 | 1.NP_SO-102 | 250 mm-250 mm-200 mm | 1.NP_SO-102 | 3150 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 300 | 175 | 0.0166428 | 125 | 100 | 250-250-200 | TA06.02.0385 | 0385 | yes
13819910 | 3.NP_SO-102 | 450 mm-450 mm-160 mm | 3.NP_SO-102 | 3099.91 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 260 | 275 | 0.0424262 | 225 | 80 | 450-450-160 | TA06.02.0393 | 0393 | yes
13837770 | 3.NP_SO-102 | 355 mm-355 mm-250 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 350 | 227.5 | 0.0376759 | 177.5 | 125 | 355-355-250 | TA06.02.0401 | 0401 | yes
13837935 | 3.NP_SO-102 | 355 mm-355 mm-250 mm | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 1 | SUP | 350 | 227.5 | 0.0376759 | 177.5 | 125 | 355-355-250 | TA06.02.0404 | 0404 | yes
13866901 | 4.NP_SO-102 | 355 mm-355 mm-250 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 350 | 227.5 | 0.0376759 | 177.5 | 125 | 355-355-250 | TA06.02.0458 | 0458 | yes
13867462 | 4.NP_SO-102 | 355 mm-355 mm-225 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 325 | 227.5 | 0.0345297 | 177.5 | 112.5 | 355-355-225 | TA06.02.0468 | 0468 | yes
13868724 | 4.NP_SO-102 | 280 mm-280 mm-225 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 325 | 190 | 0.022495 | 140 | 112.5 | 280-280-225 | TA06.02.0486 | 0486 | yes
13869144 | 4.NP_SO-102 | 500 mm-500 mm-225 mm | 4.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 325 | 300 | 0.0660556 | 250 | 112.5 | 500-500-225 | TA06.02.0493 | 0493 | yes
13871502 | 3.NP_SO-102 | 400 mm-400 mm-225 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 325 | 250 | 0.0431541 | 200 | 112.5 | 400-400-225 | TA06.02.0506 | 0506 | yes
13874839 | 2.NP_SO-102 | 450 mm-450 mm-160 mm | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 260 | 275 | 0.0424262 | 225 | 80 | 450-450-160 | TA06.02.0511 | 0511 | yes
13876778 | 2.NP_SO-102 | 315 mm-315 mm-225 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 325 | 207.5 | 0.0277445 | 157.5 | 112.5 | 315-315-225 | TA06.02.0534 | 0534 | yes
13877285 | 2.NP_SO-102 | 500 mm-500 mm-280 mm | 2.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 380 | 300 | 0.0783161 | 250 | 140 | 500-500-280 | TA06.02.0539 | 0539 | yes
13879779 | 4.NP_SO-102 | 280 mm-280 mm-250 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 18 | SUP | 350 | 190 | 0.0247855 | 140 | 125 | 280-280-250 | TA06.02.0569 | 0569 | yes
13908072 | 1.NP_SO-102 | 355 mm-355 mm-160 mm | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 260 | 227.5 | 0.0268319 | 177.5 | 80 | 355-355-160 | TA06.02.0644 | 0644 | no
13908906 | 1.NP_SO-102 | 355 mm-355 mm-180 mm | 1.NP_SO-102 | 3100 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 280 | 227.5 | 0.0291356 | 177.5 | 90 | 355-355-180 | TA06.02.0651 | 0651 | yes
13915173 | 2.NP_SO-102 | 180 mm-180 mm-160 mm | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 260 | 140 | 0.00782455 | 90 | 80 | 180-180-160 | TA06.02.0696 | 0696 | no
13939463 | 2.NP_SO-102 | 200 mm-200 mm-160 mm | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 260 | 150 | 0.00935046 | 100 | 80 | 200-200-160 | TA06.02.0760 | 0760 | yes
13950941 | -1.PP_SO-102 | 400 mm-400 mm-400 mm | -1.PP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 7 | SUP | 500 | 250 | 0.07291 | 200 | 200 | 400-400-400 | TA06.02.0778 | 0778 | yes
13957308 | 2.NP_SO-102 | 355 mm-355 mm-160 mm | 2.NP_SO-102 | 2940 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 260 | 227.5 | 0.0268319 | 177.5 | 80 | 355-355-160 | TA06.02.0812 | 0812 | yes
13964550 | -1.PP_SO-102 | 180 mm-180 mm-160 mm | -1.PP_SO-102 | 3069.99 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 260 | 140 | 0.00782455 | 90 | 80 | 180-180-160 | TA06.02.0831 | 0831 | no
13984357 | 3.NP_SO-102 | 315 mm-315 mm-225 mm | 3.NP_SO-102 | 3099.91 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 325 | 207.5 | 0.0277445 | 157.5 | 112.5 | 315-315-225 | TA06.02.0875 | 0875 | no
13988985 | -1.PP_SO-102 | 180 mm-180 mm-160 mm | -1.PP_SO-102 | 3067.64 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 260 | 140 | 0.00782455 | 90 | 80 | 180-180-160 | TA06.02.0889 | 0889 | no
13989211 | -1.PP_SO-102 | 355 mm-355 mm-250 mm | -1.PP_SO-102 | 3077.14 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 350 | 227.5 | 0.0376759 | 177.5 | 125 | 355-355-250 | TA06.02.0892 | 0892 | yes
13997247 | 3.NP_SO-102 | 355 mm-315 mm-315 mm | 3.NP_SO-102 | 3145.16 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 455 | 207.5 | 0.0437117 | 157.5 | 177.5 | 355-315-315 | TA06.02.0915 | 0915 | no
13997695 | 4.NP_SO-102 | 280 mm-280 mm-280 mm | 4.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 380 | 190 | 0.0277795 | 140 | 140 | 280-280-280 | TA06.02.0916 | 0916 | no
14007721 | -1.PP_SO-102 | 250 mm-160 mm-160 mm | -1.PP_SO-102 | 3077.14 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 25 | SUP | 350 | 130 | 0.0110412 | 80 | 125 | 250-160-160 | TA06.02.0949 | 0949 | no
14052008 | 2.NP_SO-102 | 180 mm-180 mm-160 mm | 2.NP_SO-102 | 2580 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 260 | 140 | 0.00782455 | 90 | 80 | 180-180-160 | TA06.02.1046 | 1046 | no
14053215 | 2.NP_SO-102 | 355 mm-355 mm-225 mm | 2.NP_SO-102 | 2910 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 325 | 227.5 | 0.0345297 | 177.5 | 112.5 | 355-355-225 | TA06.02.1054 | 1054 | yes
14053265 | 2.NP_SO-102 | 355 mm-355 mm-180 mm | 2.NP_SO-102 | 2910 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 280 | 227.5 | 0.0291356 | 177.5 | 90 | 355-355-180 | TA06.02.1056 | 1056 | yes
14055303 | 3.NP_SO-102 | 225 mm-225 mm-160 mm | 3.NP_SO-102 | 3100 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 260 | 162.5 | 0.0114964 | 112.5 | 80 | 225-225-160 | TA06.02.1066 | 1066 | no
14055669 | 3.NP_SO-102 | 225 mm-225 mm-200 mm | 3.NP_SO-102 | 3145.16 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 300 | 162.5 | 0.0138958 | 112.5 | 100 | 225-225-200 | TA06.02.1070 | 1070 | no
14057421 | 2.NP_SO-102 | 250 mm-250 mm-250 mm | 2.NP_SO-102 | -800 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 350 | 175 | 0.0205617 | 125 | 125 | 250-250-250 | TA06.02.1093 | 1093 | no
14078576 | 1.NP_SO-102 | 355 mm-355 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 260 | 227.5 | 0.0268319 | 177.5 | 80 | 355-355-160 | TA06.02.1149 | 1149 | yes
14137900 | -1.PP_SO-102 | 355 mm-355 mm-250 mm | -1.PP_SO-102 | 3070.56 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 350 | 227.5 | 0.0376759 | 177.5 | 125 | 355-355-250 | TA06.02.1324 | 1324 | yes

# IfcDuctFitting: M_Kulatý spoj T:Standardní (60)
Type - Material: 255-0-0
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Číslo OmniClass: 23.75.70.14; Kód sestavy: TA06; Nadpis OmniClass: Air Ductwork; Název typu: Standardní; Označení typu: 02; Popis sestavy: Spojka
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Kulatý spoj T
Classification: TA06 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: WPA; CCI Technický systém: HF
Grafika - Použít měřítko poznámky: yes
Jiné - Id typu: 1446011; Rodina: M_Kulatý spoj T; Rodina a typ: M_Kulatý spoj T: Standardní; Typ: Standardní
Name (M_Kulatý spoj T:Standardní:...) | In | Volná velikost = Celková velikost | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Délka potrubí 1 (mm) | Délka potrubí 3 (mm) | Objem (m3) | Poloměr potrubí 1 (mm) | Poloměr potrubí 3 (mm) | Velikost | Kód prvku | Označení | Páteřní trasa
12891593 | 2.NP_SO-102 | 160 mm-160 mm-160 mm | 2.NP_SO-102 | 2700 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0002 | 0002 | no
13168862 | 3.NP_SO-102 | 250 mm-250 mm-160 mm | 3.NP_SO-102 | 2995.73 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 34 | ETA | 260 | 175 | 0.0139037 | 125 | 80 | 250-250-160 | TA06.02.0069 | 0069 | yes
13168988 | 2.NP_SO-102 | 280 mm-280 mm-160 mm | 2.NP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 34 | ETA | 260 | 190 | 0.0171342 | 140 | 80 | 280-280-160 | TA06.02.0070 | 0070 | yes
13169023 | 1.NP_SO-102 | 315 mm-315 mm-160 mm | 1.NP_SO-102 | 3250 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 207.5 | 0.0213721 | 157.5 | 80 | 315-315-160 | TA06.02.0071 | 0071 | yes
13169219 | 3.NP_SO-102 | 250 mm-250 mm-160 mm | 3.NP_SO-102 | 3020 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 175 | 0.0139037 | 125 | 80 | 250-250-160 | TA06.02.0076 | 0076 | yes
13169225 | 2.NP_SO-102 | 280 mm-280 mm-160 mm | 2.NP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 190 | 0.0171342 | 140 | 80 | 280-280-160 | TA06.02.0077 | 0077 | yes
13199404 | 3.NP_SO-102 | 160 mm-160 mm-160 mm | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0097 | 0097 | no
13302656 | 1.NP_SO-102 | 355 mm-180 mm-180 mm | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 455 | 140 | 0.021068 | 90 | 177.5 | 355-180-180 | TA06.02.0110 | 0110 | yes
13429828 | 1.NP_SO-102 | 250 mm-250 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 260 | 175 | 0.0139037 | 125 | 80 | 250-250-160 | TA06.02.0115 | 0115 | yes
13628035 | 1.NP_SO-102 | 180 mm-180 mm-125 mm | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 225 | 140 | 0.00641021 | 90 | 62.5 | 180-180-125 | TA06.02.0122 | 0122 | yes
13628588 | -1.PP_SO-102 | 225 mm-225 mm-225 mm | -1.PP_SO-102 | 3160 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 8 | ETA | 325 | 162.5 | 0.0155859 | 112.5 | 112.5 | 225-225-225 | TA06.02.0123 | 0123 | no | Identifikační data - Komentáře: VZT 28
13628863 | -1.PP_SO-102 | 225 mm-225 mm-225 mm | -1.PP_SO-102 | 3160 | Fáze 1 | Odváděný | Odváděný vzduch | ETA 8 | ETA | 325 | 162.5 | 0.0155859 | 112.5 | 112.5 | 225-225-225 | TA06.02.0129 | 0129 | no | Identifikační data - Komentáře: VZT 28
13651374 | 1.NP_SO-102 | 450 mm-450 mm-450 mm | 1.NP_SO-102 | 2740 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 550 | 275 | 0.100826 | 225 | 225 | 450-450-450 | TA06.02.0173 | 0173 | yes
13702597 | 1.NP_SO-102 | 160 mm-160 mm-160 mm | 1.NP_SO-102 | 3250 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0181 | 0181 | no
13702823 | 1.NP_SO-102 | 315 mm-315 mm-160 mm | 1.NP_SO-102 | 3250 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 207.5 | 0.0213721 | 157.5 | 80 | 315-315-160 | TA06.02.0182 | 0182 | yes
13711722 | -1.PP_SO-102 | 160 mm-160 mm-160 mm | -1.PP_SO-102 | 2350 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0194 | 0194 | no
13714845 | 4.NP_SO-102 | 225 mm-225 mm-225 mm | 4.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 325 | 162.5 | 0.0155859 | 112.5 | 112.5 | 225-225-225 | TA06.02.0215 | 0215 | yes
13747875 | 4.NP_SO-102 | 160 mm-160 mm-160 mm | 4.NP_SO-102 | 3150 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0242 | 0242 | no
13747974 | 4.NP_SO-102 | 160 mm-160 mm-160 mm | 4.NP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 34 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0245 | 0245 | no
13748163 | 3.NP_SO-102 | 160 mm-160 mm-160 mm | 3.NP_SO-102 | 3020 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0250 | 0250 | no
13748236 | 3.NP_SO-102 | 160 mm-160 mm-160 mm | 3.NP_SO-102 | 2995.73 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 34 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0251 | 0251 | no
13765763 | 1.NP_SO-102 | 160 mm-160 mm-160 mm | 1.NP_SO-102 | 3250 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0259 | 0259 | no
13769141 | 2.NP_SO-102 | 160 mm-160 mm-160 mm | 2.NP_SO-102 | 3100 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0276 | 0276 | no
13769305 | 2.NP_SO-102 | 280 mm-280 mm-160 mm | 2.NP_SO-102 | 3100 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 190 | 0.0171342 | 140 | 80 | 280-280-160 | TA06.02.0278 | 0278 | yes
13769356 | 1.NP_SO-102 | 160 mm-160 mm-160 mm | 1.NP_SO-102 | 3100 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0279 | 0279 | no
13769400 | 1.NP_SO-102 | 315 mm-315 mm-160 mm | 1.NP_SO-102 | 3100 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 207.5 | 0.0213721 | 157.5 | 80 | 315-315-160 | TA06.02.0280 | 0280 | yes
13769476 | 3.NP_SO-102 | 160 mm-160 mm-160 mm | 3.NP_SO-102 | 3100 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0281 | 0281 | no
13769505 | 3.NP_SO-102 | 250 mm-250 mm-160 mm | 3.NP_SO-102 | 3100 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 175 | 0.0139037 | 125 | 80 | 250-250-160 | TA06.02.0282 | 0282 | yes
13769616 | 4.NP_SO-102 | 160 mm-160 mm-160 mm | 4.NP_SO-102 | 2950 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0284 | 0284 | no
13769801 | 2.NP_SO-102 | 160 mm-160 mm-160 mm | 2.NP_SO-102 | 3000 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0288 | 0288 | no
13864346 | 1.NP_SO-102 | 250 mm-250 mm-160 mm | 1.NP_SO-102 | 3200.1 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 260 | 175 | 0.0139037 | 125 | 80 | 250-250-160 | TA06.02.0452 | 0452 | no
13871107 | 3.NP_SO-102 | 250 mm-250 mm-160 mm | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 260 | 175 | 0.0139037 | 125 | 80 | 250-250-160 | TA06.02.0501 | 0501 | yes
13901865 | -1.PP_SO-102 | 160 mm-160 mm-160 mm | -1.PP_SO-102 | 2600 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0638 | 0638 | no
13914394 | 2.NP_SO-102 | 160 mm-160 mm-160 mm | 2.NP_SO-102 | 2700 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0688 | 0688 | no
13914529 | 2.NP_SO-102 | 160 mm-160 mm-160 mm | 2.NP_SO-102 | 2700 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0693 | 0693 | no
13937483 | 2.NP_SO-102 | 400 mm-250 mm-250 mm | 2.NP_SO-102 | 2850 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 500 | 175 | 0.0372222 | 125 | 200 | 400-250-250 | TA06.02.0746 | 0746 | yes
13954319 | 1.NP_SO-102 | 160 mm-160 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 23 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0798 | 0798 | yes
13955989 | -1.PP_SO-102 | 400 mm-400 mm-160 mm | -1.PP_SO-102 | 3150 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 18 | ETA | 260 | 250 | 0.0337576 | 200 | 80 | 400-400-160 | TA06.02.0805 | 0805 | yes
13964147 | -1.PP_SO-102 | 160 mm-160 mm-160 mm | -1.PP_SO-102 | 3069.6 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0830 | 0830 | no
13967122 | -1.PP_SO-102 | 250 mm-200 mm-200 mm | -1.PP_SO-102 | 2350 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 27 | ETA | 350 | 150 | 0.0147776 | 100 | 125 | 250-200-200 | TA06.02.0847 | 0847 | no
13990464 | 2.NP_SO-102 | 160 mm-160 mm-160 mm | 2.NP_SO-102 | 2900 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0899 | 0899 | no
13992189 | 3.NP_SO-102 | 160 mm-160 mm-160 mm | 3.NP_SO-102 | 2800 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0905 | 0905 | no
14017439 | 2.NP_SO-102 | 160 mm-160 mm-160 mm | 2.NP_SO-102 | 2900 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.0967 | 0967 | no
14039861 | 1.NP_SO-102 | 160 mm-160 mm-160 mm | 1.NP_SO-102 | 2895 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.1024 | 1024 | no
14052438 | 2.NP_SO-102 | 180 mm-180 mm-180 mm | 2.NP_SO-102 | 2580 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 280 | 140 | 0.00874329 | 90 | 90 | 180-180-180 | TA06.02.1051 | 1051 | no
14053276 | 2.NP_SO-102 | 180 mm-160 mm-160 mm | 2.NP_SO-102 | 2910 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 280 | 130 | 0.00733146 | 80 | 90 | 180-160-160 | TA06.02.1057 | 1057 | no
14056631 | 1.NP_SO-102 | 160 mm-160 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 23 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.1082 | 1082 | yes
14057001 | 1.NP_SO-102 | 160 mm-160 mm-160 mm | 1.NP_SO-102 | 2903.77 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.1091 | 1091 | no
14058319 | 1.NP_SO-102 | 160 mm-160 mm-160 mm | 1.NP_SO-102 | 2903.77 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.1098 | 1098 | no
14063982 | 1.NP_SO-102 | 315 mm-315 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 260 | 207.5 | 0.0213721 | 157.5 | 80 | 315-315-160 | TA06.02.1114 | 1114 | yes
14076144 | 2.NP_SO-102 | 355 mm-355 mm-355 mm | 2.NP_SO-102 | 2910 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 14 | ETA | 455 | 227.5 | 0.0526383 | 177.5 | 177.5 | 355-355-355 | TA06.02.1132 | 1132 | yes
14079147 | 1.NP_SO-102 | 315 mm-315 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 260 | 207.5 | 0.0213721 | 157.5 | 80 | 315-315-160 | TA06.02.1152 | 1152 | yes
14081190 | 4.NP_SO-102 | 160 mm-160 mm-160 mm | 4.NP_SO-102 | 2950 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.1161 | 1161 | yes
14081772 | 4.NP_SO-102 | 160 mm-160 mm-160 mm | 4.NP_SO-102 | 3300 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 2 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.1165 | 1165 | no
14082137 | 3.NP_SO-102 | 160 mm-160 mm-160 mm | 3.NP_SO-102 | 3100 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.1172 | 1172 | no
14120108 | 1.NP_SO-102 | 315 mm-315 mm-160 mm | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 260 | 207.5 | 0.0213721 | 157.5 | 80 | 315-315-160 | TA06.02.1255 | 1255 | yes
14152535 | 2.NP_SO-102 | 160 mm-160 mm-160 mm | 2.NP_SO-102 | 2900 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.1366 | 1366 | no
14154909 | 2.NP_SO-102 | 355 mm-355 mm-355 mm | 2.NP_SO-102 | 2940 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 455 | 227.5 | 0.0526383 | 177.5 | 177.5 | 355-355-355 | TA06.02.1369 | 1369 | no
14186850 | -1.PP_SO-102 | 160 mm-160 mm-160 mm | -1.PP_SO-102 | 2600 | Fáze 2 | Odváděný | Zpětný vzduch | ETA 17 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.1510 | 1510
14189913 | -1.PP_SO-102 | 160 mm-160 mm-160 mm | -1.PP_SO-102 | 3250 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 7 | ETA | 260 | 130 | 0.00647577 | 80 | 80 | 160-160-160 | TA06.02.1519 | 1519

# IfcDuctFitting: M_Přechod, hranaté na kulaté, úhel:45 stupňů (55)
Type - Material: 0-0-255
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Cena: 10; Číslo OmniClass: 23.75.70.14; ID kategorie: R; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 05; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Přechod, hranaté na kulaté, úhel
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Grafika - Použít měřítko poznámky: yes
Jiné - Číslo 4: 1; Typ: 45 stupňů; Číslo 9: 1; Id typu: 1559786; Rodina: M_Přechod, hranaté na kulaté, úhel; Rodina a typ: M_Přechod, hranaté na kulaté, úhel: 45 stupňů
Name (M_Přechod, hranaté na kulaté, úhel:45 stupňů:...) | In | Volná velikost = Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Fáze vytvoření | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Délka01 (mm) | Delta 1 (mm) | Delta 2 (mm) | Dočas. šířka odsazení | Dočas. výška odsazení | Objem (m3) | Odskok – šířka | Odskok – výška | Plocha (m2) | Poloměr potrubí (mm) | Průměr vedení (mm) | Šířka odsazení od základny (mm) | Šířka potrubí (mm) | Velikost | Výška odsazení od základny (mm) | Výška potrubí (mm) | Kód prvku | Označení | Páteřní trasa | Délka 3 (mm) | Délka 5 (mm) | Délka 7 (mm) | Číslo 1 | Číslo 10 | Číslo 2 | Číslo 3 | Číslo 5 | Číslo 6 | Číslo 7 | Číslo 8 | Délka 1 (mm) | Délka 2 (mm) | Délka 4 (mm) | Délka 6 (mm) | Délka 8 (mm) | Polovina Š0 (mm) | Polovina V0 (mm)
13096317 | 2.NP_SO-102 | 500 mm × 450 mm-450 mm | 0 | 2.NP_SO-102 | 2764 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 60.3553 | 25 | 0 | -0.0694444 | 0.0625 | 0.0120267 | 250 | 225 | 0.163823 | 225 | 450 | 3048 | 500 | 500 × 450-450 | 3048 | 450 | TA00.05.0009 | 0009 | yes | 0 | 0 | 0 | 1 | 0 | 1 | 2 | 2.41421 | 0 | 0 | 0 | 25 | 25 | 0 | 0 | 60.3553 | 250 | 225
13097709 | 2.NP_SO-102 | 500 mm × 450 mm-450 mm | 0 | 2.NP_SO-102 | 2764 | Fáze 1 | Odváděný | Zpětný vzduch | ETA 12 | ETA | 60.3553 | 25 | 0 | -0.0694444 | 0.0625 | 0.0120267 | 250 | 225 | 0.163823 | 225 | 450 | 3048 | 500 | 500 × 450-450 | 3048 | 450 | TA00.05.0016 | 0016 | yes | 0 | 0 | 0 | 1 | 0 | 1 | 2 | 2.41421 | 0 | 0 | 0 | 25 | 25 | 0 | 0 | 60.3553 | 250 | 225
13107182 | 2.NP_SO-102 | 355 mm × 400 mm-355 mm | 0 | 2.NP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 362.132 | 0 | 22.5 | -0.0493056 | 0.0722222 | 0.0452656 | 177.5 | 260 | 0.333488 | 177.5 | 355 | 3048 | 355 | 355 × 400-355 | 2988 | 400 | TA00.05.0024 | 0024 | yes | 0 | 82.5 | 362.132 | 0 | 14.4853 | 6 | 12 | 14.4853 | 3.3 | -1.5 | 1.8 | 0 | 0 | 60 | -37.5 | 362.132 | 177.5 | 200
13440238 | 2.NP_SO-102 | 560 mm × 450 mm-315 mm |  | 2.NP_SO-102 | 2735 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 295.741 | 122.5 | 67.5 | -0.0777778 | 0.0625 | 0.0482064 | 280 | 225 | 0.336638 | 157.5 | 315 | 3048 | 560 | 560 × 450-315 | 3048 | 450 | TA00.05.0120 | 0120 | yes | 0 | 67.5 | 162.959 | 4.9 | 6.51838 | 4.9 | 9.8 | 11.8296 | 2.7 | 2.7 | 5.4 | 122.5 | 122.5 | 0 | 67.5 | 295.741 | 280 | 225
13631784 | -1.PP_SO-102 | 500 mm × 250 mm-355 mm | 0 | -1.PP_SO-102 | 3077.14 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 4 | SUP | 175.03 | 72.5 | 52.5 | -0.0694444 | 0.0347222 | 0.0208347 | 250 | 125 | 0.194356 | 177.5 | 355 | 3048 | 500 | 500 × 250-355 | 3048 | 250 | TA00.05.0138 | 0138 | yes | 0 | 52.5 | 126.746 | 2.9 | 5.06985 | 2.9 | 5.8 | 7.00122 | 2.1 | 2.1 | 4.2 | 72.5 | 72.5 | 0 | 52.5 | 175.03 | 250 | 125
13635433 | 3.NP_SO-102 | 560 mm × 560 mm-560 mm |  | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 140 | 0 | 0 | -0.0777778 | 0.0777778 | 0.0407634 | 280 | 280 | 0.3136 | 280 | 560 | 3048 | 560 | 560 × 560-560 | 3048 | 560 | TA00.05.0144 | 0144 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 280 | 280
13636245 | 2.NP_SO-102 | 450 mm × 450 mm-450 mm |  | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 112.5 | 0 | 0 | -0.0627829 | 0.0625 | 0.0211516 | 226.018 | 225 | 0.202502 | 225 | 450 | 3049.02 | 450 | 450 × 450-450 | 3048 | 450 | TA00.05.0148 | 0148 | yes | 1.01844 | 0 | 0 | 0.0407375 | 0 | -0.0407375 | 0 | 0 | 0 | 0 | 0 | 1.01844 | -1.01844 | 0 | 0 | 0 | 225 | 225
13636300 | 3.NP_SO-102 | 560 mm × 450 mm-400 mm |  | 3.NP_SO-102 | 3489.07 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 193.137 | 80 | 25 | -0.0777778 | 0.0625 | 0.0373182 | 280 | 225 | 0.281557 | 200 | 400 | 3048 | 560 | 560 × 450-400 | 3048 | 450 | TA00.05.0149 | 0149 | yes | 0 | 25 | 60.3553 | 3.2 | 2.41421 | 3.2 | 6.4 | 7.72548 | 1 | 1 | 2 | 80 | 80 | 0 | 25 | 193.137 | 280 | 225
13746714 | 2.NP_SO-102 | 560 mm × 560 mm-560 mm |  | 2.NP_SO-102 | 2700 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 140 | 0 | 0 | -0.0777778 | 0.0777778 | 0.0407634 | 280 | 280 | 0.3136 | 280 | 560 | 3048 | 560 | 560 × 560-560 | 3048 | 560 | TA00.05.0236 | 0236 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 280 | 280
13746804 | 2.NP_SO-102 | 560 mm × 560 mm-560 mm |  | 2.NP_SO-102 | 2700 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 140 | 0 | 0 | -0.0777778 | 0.0777778 | 0.0407634 | 280 | 280 | 0.3136 | 280 | 560 | 3048 | 560 | 560 × 560-560 | 3048 | 560 | TA00.05.0239 | 0239 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 280 | 280
13793845 | 4.NP_SO-102 | 500 mm × 710 mm-450 mm |  | 4.NP_SO-102 | 363.026 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 313.848 | 25 | 130 | -0.0700483 | 0.09861 | 0.0822588 | 252.174 | 354.996 | 0.476919 | 225 | 450 | 3050.17 | 500 | 500 × 710-450 | 3048 | 710 | TA00.05.0315 | 0315 | yes | 2.174 | 130.004 | 313.848 | 1.08696 | 12.5539 | 0.91304 | 2 | 2.41154 | 5.20017 | 5.19983 | 10.4 | 27.174 | 22.826 | 0.00414546 | 129.996 | 60.2884 | 250 | 355
13793893 | 3.NP_SO-102 | 560 mm × 560 mm-560 mm |  | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 140 | 0 | 0 | -0.0777778 | 0.0777778 | 0.0407634 | 280 | 280 | 0.3136 | 280 | 560 | 3048 | 560 | 560 × 560-560 | 3048 | 560 | TA00.05.0317 | 0317 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 280 | 280
13793894 | 3.NP_SO-102 | 500 mm × 560 mm-560 mm |  | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 72.4264 | 30 | 0 | -0.0694444 | 0.0777776 | 0.0198714 | 250 | 279.999 | 0.229016 | 280 | 560 | 3048 | 500 | 500 × 560-560 | 3048 | 560 | TA00.05.0318 | 0318 | yes | 0.000041182 | 0.0006401 | 0 | 1.2 | 0 | 1.2 | 2.4 | 2.89706 | 0.000025604 | -0.000025604 | 0 | 30 | 30 | 0.0006401 | -0.0006401 | 72.4264 | 250 | 280
13793967 | 2.NP_SO-102 | 500 mm × 560 mm-560 mm |  | 2.NP_SO-102 | 3039.77 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 72.4264 | 30 | 0 | -0.0694444 | 0.0777778 | 0.0198714 | 250 | 280 | 0.229016 | 280 | 560 | 3048 | 500 | 500 × 560-560 | 3048 | 560 | TA00.05.0321 | 0321 | yes | 0 | 0 | 0 | 1.2 | 0 | 1.2 | 2.4 | 2.89706 | 0 | 0 | 0 | 30 | 30 | 0 | 0 | 72.4264 | 250 | 280
13794186 | 1.NP_SO-102 | 500 mm × 500 mm-500 mm |  | 1.NP_SO-102 | 3095.08 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 125 | 0 | 0 | -0.0714221 | 0.0694257 | 0.0290146 | 257.12 | 249.933 | 0.250101 | 250 | 500 | 3055.12 | 500 | 500 × 500-500 | 3048.07 | 500 | TA00.05.0325 | 0325 | yes | 7.11952 | 0.067352 | 0 | 0.284781 | 0 | -0.284781 | 0 | 0 | 0.00269408 | -0.00269408 | 0 | 7.11952 | -7.11952 | 0.067352 | -0.067352 | 0 | 250 | 250
13848486 | 3.NP_SO-102 | 450 mm × 450 mm-500 mm |  | 3.NP_SO-102 | 3099.91 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 60.3553 | 25 | 25 | -0.0634539 | 0.0625 | 0.0125509 | 228.434 | 225 | 0.172866 | 250 | 500 | 3051.43 | 450 | 450 × 450-500 | 3048 | 450 | TA00.05.0426 | 0426 | yes | 3.43401 | 25 | 60.3553 | 1.13736 | 2.41421 | 0.86264 | 2 | 2.40753 | 1 | 1 | 2 | 28.434 | 21.566 | 0 | 25 | 60.1882 | 225 | 225
13849011 | 3.NP_SO-102 | 560 mm × 560 mm-180 mm | 0 | 3.NP_SO-102 | 3040 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 458.701 | 190 | 190 | -0.0777778 | 0.0777778 | 0.0672527 | 280 | 280 | 0.439922 | 90 | 180 | 3048 | 560 | 560 × 560-180 | 3048 | 560 | TA00.05.0430 | 0430 | yes | 0 | 190 | 458.701 | 7.6 | 18.348 | 7.6 | 15.2 | 18.348 | 7.6 | 7.6 | 15.2 | 190 | 190 | 0 | 190 | 458.701 | 280 | 280
13939900 | 2.NP_SO-102 | 200 mm-225 mm × 75 mm | 0 | 2.NP_SO-102 | 3180 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 17 | SUP | 150.888 | 12.5 | 62.5 | -0.03125 | 0.0104167 | 0.00393773 | 112.5 | 37.5 | 0.0683861 | 100 | 200 | 3048 | 225 | 200-225 × 75 | 3048 | 75 | TA00.05.0764 | 0764 | yes | 0 | 62.5 | 150.888 | 0.5 | 6.03553 | 0.5 | 1 | 1.20711 | 2.5 | 2.5 | 5 | 12.5 | 12.5 | 0 | 62.5 | 30.1777 | 112.5 | 37.5
13954764 | 1.NP_SO-102 | 160 mm × 160 mm-160 mm | 0 | 1.NP_SO-102 | 3095 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 14 | SUP | 40 | 0 | 0 | -0.0222222 | 0.0222222 | 0.000950749 | 80 | 80 | 0.0256 | 80 | 160 | 3048 | 160 | 160 × 160-160 | 3048 | 160 | TA00.05.0801 | 0801 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 80 | 80
14036862 | 2.NP_SO-102 | 450 mm-500 mm × 225 mm | 0 | 2.NP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 260.845 | 25 | 112.5 | -0.0694444 | 0.0472222 | 0.0377937 | 250 | 170 | 0.304371 | 225 | 450 | 3048 | 500 | 450-500 × 225 | 2990.5 | 225 | TA00.05.1005 | 1005 | yes | 0 | 170 | 260.845 | 1 | 10.4338 | 1 | 2 | 2.41421 | 6.8 | 2.2 | 9 | 25 | 25 | 57.5 | 55 | 60.3553 | 250 | 112.5
14038190 | 3.NP_SO-102 | 500 mm × 400 mm-355 mm |  | 3.NP_SO-102 | 3145.16 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 175.03 | 72.5 | 22.5 | -0.0694444 | 0.0555556 | 0.0267639 | 250 | 200 | 0.225436 | 177.5 | 355 | 3048 | 500 | 500 × 400-355 | 3048 | 400 | TA00.05.1015 | 1015 | yes | 0 | 22.5 | 54.3198 | 2.9 | 2.17279 | 2.9 | 5.8 | 7.00122 | 0.9 | 0.9 | 1.8 | 72.5 | 72.5 | 0 | 22.5 | 175.03 | 250 | 200
14051674 | 2.NP_SO-102 | 225 mm × 315 mm-225 mm | 0 | 2.NP_SO-102 | 2880 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 108.64 | 0 | 45 | -0.03125 | 0.04375 | 0.00620643 | 112.5 | 157.5 | 0.0851586 | 112.5 | 225 | 3048 | 225 | 225 × 315-225 | 3048 | 315 | TA00.05.1042 | 1042 | no | 0 | 45 | 108.64 | 0 | 4.34558 | 0 | 0 | 0 | 1.8 | 1.8 | 3.6 | 0 | 0 | 0 | 45 | 0 | 112.5 | 157.5
14055539 | 3.NP_SO-102 | 200 mm-225 mm × 75 mm | 0 | 3.NP_SO-102 | 3145.16 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 150.888 | 12.5 | 62.5 | -0.03125 | 0.0104167 | 0.00393773 | 112.5 | 37.5 | 0.0683861 | 100 | 200 | 3048 | 225 | 200-225 × 75 | 3048 | 75 | TA00.05.1068 | 1068 | no | 0 | 62.5 | 150.888 | 0.5 | 6.03553 | 0.5 | 1 | 1.20711 | 2.5 | 2.5 | 5 | 12.5 | 12.5 | 0 | 62.5 | 30.1777 | 112.5 | 37.5
14115229 | -1.PP_SO-102 | 225 mm × 160 mm-160 mm | 0 | -1.PP_SO-102 | 2980 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 78.4619 | 32.5 | 0 | -0.03125 | 0.0222222 | 0.00227294 | 112.5 | 80 | 0.043575 | 80 | 160 | 3048 | 225 | 225 × 160-160 | 3048 | 160 | TA00.05.1219 | 1219 | no | 0 | 0 | 0 | 1.3 | 0 | 1.3 | 2.6 | 3.13848 | 0 | 0 | 0 | 32.5 | 32.5 | 0 | 0 | 78.4619 | 112.5 | 80
14117548 | -1.PP_SO-102 | 560 mm × 630 mm-450 mm | 0 | -1.PP_SO-102 | 3070 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 12 | SUP | 217.279 | 55 | 90 | -0.0777778 | 0.0875 | 0.0564631 | 280 | 315 | 0.372252 | 225 | 450 | 3048 | 560 | 560 × 630-450 | 3048 | 630 | TA00.05.1246 | 1246 | yes | 0 | 90 | 217.279 | 2.2 | 8.69117 | 2.2 | 4.4 | 5.31127 | 3.6 | 3.6 | 7.2 | 55 | 55 | 0 | 90 | 132.782 | 280 | 315
14123354 | -1.PP_SO-102 | 160 mm × 500 mm-160 mm | 0 | -1.PP_SO-102 | 3070 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 410.416 | 0 | 170 | -0.0222222 | 0.0694444 | 0.0209184 | 80 | 250 | 0.230209 | 80 | 160 | 3048 | 160 | 160 × 500-160 | 3048 | 500 | TA00.05.1285 | 1285 | no | 0 | 170 | 410.416 | 0 | 16.4167 | 0 | 0 | 0 | 6.8 | 6.8 | 13.6 | 0 | 0 | 0 | 170 | 0 | 80 | 250
14123979 | 4.NP_SO-102 | 280 mm × 630 mm-280 mm | 0 | 4.NP_SO-102 | -205 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 422.487 | 0 | 175 | -0.0388869 | 0.0875 | 0.0514555 | 139.993 | 315 | 0.379102 | 140 | 280 | 3047.99 | 280 | 280 × 630-280 | 3048 | 630 | TA00.05.1293 | 1293 | yes | 0.00723902 | 175 | 422.487 | 0.000289561 | 16.8995 | -0.000289561 | 0 | 0 | 7 | 7 | 14 | 0.00723902 | -0.00723902 | 0 | 175 | 0 | 140 | 315
14124017 | 3.NP_SO-102 | 280 mm × 355 mm-355 mm | 0 | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 90.533 | 37.5 | 0 | -0.0388895 | 0.0493056 | 0.00938804 | 140.002 | 177.5 | 0.118564 | 177.5 | 355 | 3048 | 280 | 280 × 355-355 | 3048 | 355 | TA00.05.1295 | 1295 | yes | 0.00228963 | 0.0000060117 | 0 | 1.50009 | 0 | 1.49991 | 3 | 3.62132 | 2.40468e-07 | -2.40468e-07 | 0 | 37.5023 | 37.4977 | 0.0000060117 | -0.0000060117 | 90.533 | 140 | 177.5
14136386 | -1.PP_SO-102 | 200 mm-225 mm × 75 mm | 0 | -1.PP_SO-102 | 3250 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 5 | SUP | 150.888 | 12.5 | 62.5 | -0.03125 | 0.0104167 | 0.00393773 | 112.5 | 37.5 | 0.0683861 | 100 | 200 | 3048 | 225 | 200-225 × 75 | 3048 | 75 | TA00.05.1318 | 1318 | no | 0 | 62.5 | 150.888 | 0.5 | 6.03553 | 0.5 | 1 | 1.20711 | 2.5 | 2.5 | 5 | 12.5 | 12.5 | 0 | 62.5 | 30.1777 | 112.5 | 37.5
14147777 | 2.NP_SO-102 | 400 mm × 400 mm-450 mm |  | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 24 | SUP | 60.3553 | 25 | 25 | -0.0555556 | 0.0555556 | 0.01004 | 200 | 200 | 0.14404 | 225 | 450 | 3048 | 400 | 400 × 400-450 | 3048 | 400 | TA00.05.1348 | 1348 | yes | 0 | 25 | 60.3553 | 1 | 2.41421 | 1 | 2 | 2.41421 | 1 | 1 | 2 | 25 | 25 | 0 | 25 | 60.3553 | 200 | 200
14164774 | 4.NP_SO-102 | 500 mm × 250 mm-280 mm |  | 4.NP_SO-102 | 122.837 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 9 | SUP | 265.563 | 110 | 15 | -0.0694444 | 0.0347222 | 0.0258106 | 250 | 125 | 0.227776 | 140 | 280 | 3048 | 500 | 500 × 250-280 | 3048 | 250 | TA00.05.1391 | 1391 | yes | 0 | 15 | 36.2132 | 4.4 | 1.44853 | 4.4 | 8.8 | 10.6225 | 0.6 | 0.6 | 1.2 | 110 | 110 | 0 | 15 | 265.563 | 250 | 125
14168515 | 1.NP_SO-102 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-102 | 3043.24 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 11 | SUP | 78.75 | 0 | 0 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 3048 | 315 | 315 × 315-315 | 3048 | 315 | TA00.05.1395 | 1395 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 157.5 | 157.5
14169149 | 1.NP_SO-102 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-102 | 2983.24 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 11 | SUP | 78.75 | 0 | 0 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 3048 | 315 | 315 × 315-315 | 3048 | 315 | TA00.05.1397 | 1397 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 157.5 | 157.5
14169988 | 1.NP_SO-102 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-102 | 3039.69 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 11 | SUP | 78.75 | 0 | 0 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 3048 | 315 | 315 × 315-315 | 3048 | 315 | TA00.05.1399 | 1399 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 157.5 | 157.5
14170265 | 1.NP_SO-102 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-102 | 2998.24 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 11 | SUP | 78.75 | 0 | 0 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 3048 | 315 | 315 × 315-315 | 3048 | 315 | TA00.05.1401 | 1401 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 157.5 | 157.5
14170426 | 1.NP_SO-102 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-102 | 2998.24 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 11 | SUP | 78.75 | 0 | 0 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 3048 | 315 | 315 × 315-315 | 3048 | 315 | TA00.05.1403 | 1403 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 157.5 | 157.5
14170506 | 1.NP_SO-102 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-102 | 2956.64 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 11 | SUP | 78.75 | 0 | 0 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 3048 | 315 | 315 × 315-315 | 3048 | 315 | TA00.05.1405 | 1405 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 157.5 | 157.5
14170622 | 1.NP_SO-102 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-102 | 2958.24 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 11 | SUP | 78.75 | 0 | 0 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 3048 | 315 | 315 × 315-315 | 3048 | 315 | TA00.05.1407 | 1407 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 157.5 | 157.5
14170728 | 1.NP_SO-102 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-102 | 2993.24 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 11 | SUP | 78.75 | 0 | 0 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 3048 | 315 | 315 × 315-315 | 3048 | 315 | TA00.05.1409 | 1409 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 157.5 | 157.5
14170845 | 1.NP_SO-102 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-102 | 2993.24 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 11 | SUP | 78.75 | 0 | 0 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 3048 | 315 | 315 × 315-315 | 3048 | 315 | TA00.05.1411 | 1411 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 157.5 | 157.5
14171117 | 1.NP_SO-102 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-102 | 2964.24 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 11 | SUP | 78.75 | 0 | 0 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 3048 | 315 | 315 × 315-315 | 3048 | 315 | TA00.05.1413 | 1413 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 157.5 | 157.5
14181644 | 1.NP_SO-102 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-102 | 3023.3 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 15 | SUP | 78.75 | 0 | 0 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 3048 | 315 | 315 × 315-315 | 3048 | 315 | TA00.05.1463 | 1463 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 157.5 | 157.5
14181647 | 1.NP_SO-102 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-102 | 2983.3 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 15 | SUP | 78.75 | 0 | 0 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 3048 | 315 | 315 × 315-315 | 3048 | 315 | TA00.05.1465 | 1465 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 157.5 | 157.5
14181649 | 1.NP_SO-102 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-102 | 2983.3 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 15 | SUP | 78.75 | 0 | 0 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 3048 | 315 | 315 × 315-315 | 3048 | 315 | TA00.05.1467 | 1467 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 157.5 | 157.5
14181651 | 1.NP_SO-102 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-102 | 3004.3 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 15 | SUP | 78.75 | 0 | 0 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 3048 | 315 | 315 × 315-315 | 3048 | 315 | TA00.05.1469 | 1469 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 157.5 | 157.5
14181814 | 1.NP_SO-102 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-102 | 3113.3 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 15 | SUP | 78.75 | 0 | 0 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 3048 | 315 | 315 × 315-315 | 3048 | 315 | TA00.05.1474 | 1474 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 157.5 | 157.5
14181819 | 1.NP_SO-102 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-102 | 3114.3 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 15 | SUP | 78.75 | 0 | 0 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 3048 | 315 | 315 × 315-315 | 3048 | 315 | TA00.05.1477 | 1477 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 157.5 | 157.5
14182366 | 1.NP_SO-102 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-102 | 3045.9 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 15 | SUP | 78.75 | 0 | 0 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 3048 | 315 | 315 × 315-315 | 3048 | 315 | TA00.05.1481 | 1481 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 157.5 | 157.5
14182369 | 1.NP_SO-102 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-102 | 2990.9 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 26 | SUP | 78.75 | 0 | 0 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 3048 | 315 | 315 × 315-315 | 3048 | 315 | TA00.05.1483 | 1483 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 157.5 | 157.5
14182371 | 1.NP_SO-102 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-102 | 3049.3 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 15 | SUP | 78.75 | 0 | 0 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 3048 | 315 | 315 × 315-315 | 3048 | 315 | TA00.05.1485 | 1485 | yes | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 157.5 | 157.5
14183103 | 1.NP_SO-102 | 315 mm × 315 mm-315 mm | 0 | 1.NP_SO-102 | 3050.9 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 15 | SUP | 78.75 | 0 | 0 | -0.04375 | 0.04375 | 0.007255 | 157.5 | 157.5 | 0.099225 | 157.5 | 315 | 3048 | 315 | 315 × 315-315 | 3048 | 315 | TA00.05.1493 | 1493 |  | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 0 | 157.5 | 157.5
14195706 | 3.NP_SO-102 | 400 mm-500 mm × 160 mm |  | 3.NP_SO-102 | 3100 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 289.706 | 50 | 120 | -0.0694444 | 0.0221976 | 0.0326077 | 250 | 79.9114 | 0.277448 | 200 | 400 | 3048 | 500 | 400-500 × 160 | 3048.09 | 160 | TA00.05.1532 | 1532 |  | 0 | 120.089 | 289.706 | 2 | 11.5882 | 2 | 4 | 4.82843 | 4.80354 | 4.79646 | 9.6 | 50 | 50 | 0.0885755 | 119.911 | 120.711 | 250 | 80
14196114 | 3.NP_SO-102 | 400 mm-500 mm × 160 mm |  | 3.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 289.706 | 50 | 120 | -0.0694444 | 0.0222222 | 0.0326077 | 250 | 80 | 0.277455 | 200 | 400 | 3048 | 500 | 400-500 × 160 | 3048 | 160 | TA00.05.1534 | 1534 |  | 0 | 120 | 289.706 | 2 | 11.5882 | 2 | 4 | 4.82843 | 4.8 | 4.8 | 9.6 | 50 | 50 | 0 | 120 | 120.711 | 250 | 80
14196280 | 2.NP_SO-102 | 400 mm-500 mm × 160 mm |  | 2.NP_SO-102 | 3095 | Fáze 2 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 289.706 | 50 | 120 | -0.0694444 | 0.0222222 | 0.0326077 | 250 | 80 | 0.277455 | 200 | 400 | 3048 | 500 | 400-500 × 160 | 3048 | 160 | TA00.05.1536 | 1536 |  | 0 | 120 | 289.706 | 2 | 11.5882 | 2 | 4 | 4.82843 | 4.8 | 4.8 | 9.6 | 50 | 50 | 0 | 120 | 120.711 | 250 | 80
14196687 | 2.NP_SO-102 | 400 mm-500 mm × 160 mm |  | 2.NP_SO-102 | 3080 | Fáze 1 | Přívodní | Přívod vzduchu | SUP 13 | SUP | 289.706 | 50 | 120 | -0.0694444 | 0.0222147 | 0.0326077 | 250 | 79.9729 | 0.277453 | 200 | 400 | 3048 | 500 | 400-500 × 160 | 3048.03 | 160 | TA00.05.1539 | 1539 |  | 0 | 120.027 | 289.706 | 2 | 11.5882 | 2 | 4 | 4.82843 | 4.80108 | 4.79892 | 9.6 | 50 | 50 | 0.0270845 | 119.973 | 120.711 | 250 | 80

# IfcDuctFitting: M_Přechod, hranaté na kulaté, úhel:45 stupňů (10)
Type - Material: 0-128-64
Type - Vazby - Výchozí výška: 0 mm; Úhel: 45 deg
Type - Identifikační data - Cena: 10; Číslo OmniClass: 23.75.70.14; ID kategorie: R; Kód sestavy: TA00; Nadpis OmniClass: Air Ductwork; Název typu: 45 stupňů; Označení typu: 05; Popis: Redukce; Popis sestavy: Obecný prvek
Type - Jiné - Kategorie: Tvarovky potrubí; Název rodiny: M_Přechod, hranaté na kulaté, úhel
Classification: TA00 Uniformat (Uniformat)
Výstelka - Tloušťka výstelky: 0 mm
Izolace - Tloušťka izolace: 0 mm
Text - CCI Funkční systém: J; CCI Komponenta: XMB; CCI Technický systém: HF
Fázování - Fáze vytvoření: Fáze 1
Grafika - Použít měřítko poznámky: yes
Kóty - Výška odsazení od základny: 3048 mm
Jiné - Páteřní trasa: yes; Číslo 4: 1; Typ: 45 stupňů; Číslo 9: 1; Délka 4: 0 mm; Id typu: 1559786; Rodina: M_Přechod, hranaté na kulaté, úhel; Rodina a typ: M_Přechod, hranaté na kulaté, úhel: 45 stupňů
Name (M_Přechod, hranaté na kulaté, úhel:45 stupňů:...) | In | Volná velikost = Celková velikost | Tlaková ztráta (Pa) | Podlaží | Výška od podlaží (mm) | Typ systému | Klasifikace systému | Název systému = Group | Zkratka systému | Šířka odsazení od základny (mm) | Délka01 (mm) = Délka 8 (mm) | Delta 1 (mm) | Delta 2 (mm) = Délka 5 (mm) = Délka 6 (mm) | Dočas. šířka odsazení | Dočas. výška odsazení | Objem (m3) | Odskok – šířka | Odskok – výška = Polovina V0 (mm) | Plocha (m2) | Poloměr potrubí (mm) | Průměr vedení (mm) | Šířka potrubí (mm) | Velikost | Výška potrubí (mm) | Kód prvku | Označení | Délka 3 (mm) | Číslo 1 | Číslo 10 | Číslo 2 | Číslo 3 | Číslo 5 | Číslo 6 = Číslo 7 | Číslo 8 | Délka 1 (mm) | Délka 2 (mm) | Délka 7 (mm) | Polovina Š0 (mm)
13631329 | -1.PP_SO-102 | 500 mm × 250 mm-355 mm | 0 | -1.PP_SO-102 | 3076.47 | Čerstvý | Přívod vzduchu | ODA 1 | ODA | 3048 | 175.03 | 72.5 | 52.5 | -0.0694444 | 0.0347222 | 0.0208347 | 250 | 125 | 0.194356 | 177.5 | 355 | 500 | 500 × 250-355 | 250 | TA00.05.0137 | 0137 | 0 | 2.9 | 5.06985 | 2.9 | 5.8 | 7.00122 | 2.1 | 4.2 | 72.5 | 72.5 | 126.746 | 250
13795427 | -1.PP_SO-102 | 400 mm × 400 mm-355 mm | 0 | -1.PP_SO-102 | 3078 | Čerstvý | Přívod vzduchu | ODA 1 | ODA | 3048 | 54.3198 | 22.5 | 22.5 | -0.0555556 | 0.0555556 | 0.00726038 | 200 | 200 | 0.114207 | 177.5 | 355 | 400 | 400 × 400-355 | 400 | TA00.05.0331 | 0331 | 0 | 0.9 | 2.17279 | 0.9 | 1.8 | 2.17279 | 0.9 | 1.8 | 22.5 | 22.5 | 54.3198 | 200
13795438 | -1.PP_SO-102 | 400 mm × 400 mm-355 mm | 0 | -1.PP_SO-102 | 3100 | Čerstvý | Přívod vzduchu | ODA 2 | ODA | 3048 | 54.3198 | 22.5 | 22.5 | -0.0555556 | 0.0555556 | 0.00726038 | 200 | 200 | 0.114207 | 177.5 | 355 | 400 | 400 × 400-355 | 400 | TA00.05.0332 | 0332 | 0 | 0.9 | 2.17279 | 0.9 | 1.8 | 2.17279 | 0.9 | 1.8 | 22.5 | 22.5 | 54.3198 | 200
13796905 | 1.NP_SO-102 | 250 mm × 250 mm-160 mm | 0 | 1.NP_SO-102 | 3092.8 | Čerstvý | Přívod vzduchu | ODA 19 | ODA | 3048 | 108.64 | 45 | 45 | -0.0347222 | 0.0347222 | 0.00443996 | 125 | 125 | 0.0684022 | 80 | 160 | 250 | 250 × 250-160 | 250 | TA00.05.0333 | 0333 | 0 | 1.8 | 4.34558 | 1.8 | 3.6 | 4.34558 | 1.8 | 3.6 | 45 | 45 | 108.64 | 125
13797068 | 2.NP_SO-102 | 250 mm × 250 mm-160 mm | 0 | 2.NP_SO-102 | 3678 | Znehodnocený | Odváděný vzduch | EHA 12 | EHA | 3048 | 108.64 | 45 | 45 | -0.0347222 | 0.0347222 | 0.00443996 | 125 | 125 | 0.0684022 | 80 | 160 | 250 | 250 × 250-160 | 250 | TA00.05.0336 | 0336 | 0 | 1.8 | 4.34558 | 1.8 | 3.6 | 4.34558 | 1.8 | 3.6 | 45 | 45 | 108.64 | 125
