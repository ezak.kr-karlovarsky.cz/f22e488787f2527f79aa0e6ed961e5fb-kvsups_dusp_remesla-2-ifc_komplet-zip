Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [DesignTransferView_V1.0], RevitIdentifiers [VersionGUID: ccf4c0c1-fc8b-4dae-81f7-6ae9bd7eea91, NumberOfSaves: 164], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Vnitřní]
File name: 220055
Time: 2023-10-13T16:53:00
Written by: ODA IFC SDK 22.8
Made in: 22.1.30.34 - Exporter 22.6.0.0 - Alternate UI 22.6.0.0

# IfcProject, 220055
LongName: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; Phase: DUSP

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Text - EBC_Hlavní architekt: prof. Ing. Mgr. akad. arch. Petr Hájek; EBC_Hlavní projektant: Ing. Libor Truhelka; EBC_ID profese: D.1.4; EBC_ID projektu: KVSUPS; EBC_Nadmořská výška: 389,970; EBC_Název profese: NOUZOVÝ ZVUKOVÝ SYSTÉM; EBC_Zástupce hlavního projektanta: Ing. Miroslav Zyma; EBC_Zkratka profese: NZS; EBC_Zodpovědný projektant: Martin Frühauf; EBC_Zpracovatel části: Projekce elektro s.r.o.; EBC_Zpracovatel části adresa: II. ulice 75, 273 07 Vinařice tel.: +420 603 897 422 e-mail: mf@martinfruhauf.cz
Identifikační data - Název budovy: Budova E; Název organizace: Energy Benefit Centre a.s.; Popis organizace: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz; Projektant: Martin Frühauf, Ing. Petra Frühaufová
Jiné - Adresa projektu: Nám. 17. listopadu 710/12, Karlovy Vary – Rybáře, č. p.: 394/1 až 394/3, 395/1 až 395/5, 396, 397; Číslo projektu: 220055; Datum vydání projektu: 30.05.2023; EBC_Stavebník adresa: Závodní 353/88, 360 06 Karlovy Vary, IČ: 70891168; Jméno klienta: Karlovarský kraj; Kategorie: Informace o projektu; Název projektu: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; OBJEKT: ETAPA; PROFESNÍ ČÁST: Nouzový Zvukový Systém; Stav projektu: DUSP; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 01:41

# IfcBuilding, Budova E
LongName: Budova E
Text - EBC_Hlavní architekt: prof. Ing. Mgr. akad. arch. Petr Hájek; EBC_Hlavní projektant: Ing. Libor Truhelka; EBC_ID profese: D.1.4; EBC_ID projektu: KVSUPS; EBC_Nadmořská výška: 389,970; EBC_Název profese: NOUZOVÝ ZVUKOVÝ SYSTÉM; EBC_Zástupce hlavního projektanta: Ing. Miroslav Zyma; EBC_Zkratka profese: NZS; EBC_Zodpovědný projektant: Martin Frühauf; EBC_Zpracovatel části: Projekce elektro s.r.o.; EBC_Zpracovatel části adresa: II. ulice 75, 273 07 Vinařice tel.: +420 603 897 422 e-mail: mf@martinfruhauf.cz
Identifikační data - Název budovy: Budova E; Název organizace: Energy Benefit Centre a.s.; Popis organizace: Křenova 438/3, 162 00 Praha 6 tel.: +420 270 003 300 e-mail: kontakt@energy-benefit.cz; Projektant: Martin Frühauf, Ing. Petra Frühaufová
Jiné - Adresa projektu: Nám. 17. listopadu 710/12, Karlovy Vary – Rybáře, č. p.: 394/1 až 394/3, 395/1 až 395/5, 396, 397; Číslo projektu: 220055; Datum vydání projektu: 30.05.2023; EBC_Stavebník adresa: Závodní 353/88, 360 06 Karlovy Vary, IČ: 70891168; Jméno klienta: Karlovarský kraj; Kategorie: Informace o projektu; Název projektu: STŘEDNÍ UMĚLECKOPRŮMYSLOVÁ ŠKOLA KERAMICKÁ A SKLÁŘSKÁ KARLOVY VARY; OBJEKT: ETAPA; PROFESNÍ ČÁST: Nouzový Zvukový Systém; Stav projektu: DUSP; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.21 01:41

# IfcBuildingStorey: Podlaží:Podlaží, 2.NP_SO-102
In: Budova E
LongName: 2.NP_SO-102; Elevation: 4000 mm
Vazby - Výška: 4000 mm
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes; Název: 2.NP_SO-102
Jiné - Kategorie: Podlaží; Rodina: Podlaží; Id typu: 11292; Rodina a typ: Podlaží: Podlaží; Typ: Podlaží; UPRAVIL: Fruhauf.vinarice@seznam.cz 2022.11.01 02:32
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Symbol: Výšková kačena.CC : Výšková kačena; Symbol na konci 1 – výchozí: no; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Barva: 16711680; Vzor čáry: Čerchovaná
Identifikační data(Type) - Název typu: Podlaží
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží

# IfcBuildingStorey: Podlaží:Pomocné (5)
In: Budova E
Kóty - Výpočtová výška: 0 mm
Identifikační data - Konstrukce: no; Podlaží budovy: yes
Jiné - Id typu: 1520; Kategorie: Podlaží; Rodina: Podlaží; Rodina a typ: Podlaží: Pomocné; Typ: Pomocné
Vazby(Type) - Základní výška: Základní bod projektu
Grafika(Type) - Barva: 0; Symbol: Výšková kačena.CC : Výšková kačena; Symbol na konci 1 – výchozí: no; Symbol na konci 2 – výchozí: yes; Tloušťka čáry: 1; Vzor čáry: Tečkovaná
Identifikační data(Type) - Název typu: Pomocné
Jiné(Type) - Kategorie: Podlaží; Název rodiny: Podlaží
Name | LongName = Název | Elevation (mm) | Výška (mm) | UPRAVIL
-2.PP_SO-102 | -2.PP_SO-102 | -8000 | -8000 | Fruhauf.vinarice@seznam.cz 2022.11.01 02:32
-1.PP_SO-102 | -1.PP_SO-102 | -4000 | -4000 | Fruhauf.vinarice@seznam.cz 2022.11.01 02:32
1.NP_SO-102 | 1.NP_SO-102 | -7.27687e-10 | 0
3.NP_SO-102 | 3.NP_SO-102 | 8000 | 8000 | Fruhauf.vinarice@seznam.cz 2022.11.01 02:32
4.NP_SO-102 | 4.NP_SO-102 | 12000 | 12000 | Fruhauf.vinarice@seznam.cz 2022.11.01 02:32

# IfcBuildingElementProxy: Mikrofonní pult.CC:Mikrofonní pult.CC (2)
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - Počet fází: 1
Type - Grafika - Symbol: yes
Type - Kóty - Šířka: 100 mm; Výška pultu: 40 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.10.11.11; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: NZ03; Komentáře k typům: Komentáře k typům; Model: Model; Nadpis OmniClass: Sound and Signal Devices; Název typu: Mikrofonní pult.CC; Označení typu: 03; Popis: Mikrofonní pult; Popis sestavy: Mikrofonní pult; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Komunikační zařízení; a: 22.2222 mm; b: 35 mm; c: 25 mm; Název rodiny: Mikrofonní pult.CC
Classification: NZ03 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.0903264 m2; NetVolume: 0.000664421 m3
Text - CCI Funkční systém: P; CCI Komponenta: BXA; CCI Technický systém: MA
Vazby - Odsazení od hostitele: 0 mm; Výška od podlaží: 0 mm; Hostitel: Podlaží : 1.NP_SO-102; Podlaží: 1.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - Objem: 0.000664421 m3
Jiné - Id typu: 978209; Rodina: Mikrofonní pult.CC; Rodina a typ: Mikrofonní pult.CC: Mikrofonní pult.CC; Typ: Mikrofonní pult.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 10:02
Name (Mikrofonní pult.CC:Mikrofonní pult.CC:...) | Kód prvku | Označení
978228 | NZ03.03.0049 | 0049
979573 | NZ03.03.0247 | 0247

# IfcBuildingElementProxy: Reproduktory.CC:Nástěnný reproduktor hranatý (251)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 2500 mm
Type - Elektrotechnika - Počet fází: 1
Type - Grafika - Symbol: yes; Typ symbolu: Reproduktor nástěnný.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.10.11.14.21; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: NZ04; Komentáře k typům: nástěnný, hranatý; Model: Model; Nadpis OmniClass: Audio Reproducing Units; Název typu: Nástěnný reproduktor hranatý; Označení typu: 01; Popis: Reproduktor; Popis sestavy: Reproduktory; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Komunikační zařízení; Název rodiny: Reproduktory.CC; Typ reproduktoru: Reproduktor_nástěnný_hranatý.CC : Nástěnný reproduktor
Classification: NZ04 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.1076 m2; NetVolume: 0.0021655 m3
Text - CCI Funkční systém: P; CCI Komponenta: PJA; CCI Technický systém: MA
Vazby - Odsazení od hostitele: 2500 mm; Výška od podlaží: 2500 mm
Grafika - Posun horizontální: 0; Posun vertikální: 0; Svislá poloha: no
Kóty - Hloubka reproduktoru: 100 mm; Objem: 0.0021655 m3; Průměr reproduktoru: 150 mm
Jiné - a: 75 mm; b: 18.75 mm; c: 10 mm; ch: 225 mm; d: 5 mm; e: 40 mm; f: 40 mm; g: 10 mm; h: 5 mm; Id typu: 976682; JMENOVITÝ PŘÍKON REPRODUKTORU: 0 W; NASTAVENÝ PŘÍKON REPRODUKTORU: 0 W; Rodina: Reproduktory.CC; Rodina a typ: Reproduktory.CC: Nástěnný reproduktor hranatý; Typ: Nástěnný reproduktor hranatý; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 10:03
Name (Reproduktory.CC:Nástěnný reproduktor hranatý:...) | In | Podlaží | Hostitel | Fáze vytvoření | Kód prvku | Označení
976698 | -2.PP_SO-102 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | Fáze 1 | NZ04.01.0001 | 0001
976738 | -2.PP_SO-102 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | Fáze 1 | NZ04.01.0002 | 0002
976748 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0003 | 0003
976752 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0004 | 0004
976756 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0005 | 0005
976760 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0006 | 0006
976764 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0007 | 0007
976768 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0008 | 0008
976772 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0009 | 0009
976776 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0010 | 0010
976780 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0011 | 0011
976784 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0012 | 0012
976788 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0013 | 0013
976792 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0014 | 0014
976796 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0015 | 0015
976800 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0016 | 0016
976804 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0017 | 0017
976808 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0018 | 0018
976820 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0019 | 0019
976824 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0020 | 0020
976828 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0021 | 0021
976832 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0022 | 0022
976836 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0023 | 0023
976840 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0024 | 0024
976844 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0025 | 0025
976848 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0026 | 0026
976852 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0027 | 0027
976856 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0028 | 0028
976860 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0029 | 0029
976864 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0030 | 0030
976868 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0031 | 0031
976872 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0032 | 0032
976876 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | NZ04.01.0033 | 0033
976880 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | NZ04.01.0034 | 0034
976884 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | NZ04.01.0035 | 0035
976888 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | NZ04.01.0036 | 0036
976892 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | NZ04.01.0037 | 0037
976896 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | NZ04.01.0038 | 0038
976900 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | NZ04.01.0039 | 0039
976904 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | NZ04.01.0040 | 0040
976908 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | NZ04.01.0041 | 0041
976912 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | NZ04.01.0042 | 0042
976916 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | NZ04.01.0043 | 0043
976920 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | NZ04.01.0044 | 0044
976924 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | NZ04.01.0045 | 0045
976928 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 2 | NZ04.01.0046 | 0046
978263 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0052 | 0052
978267 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0053 | 0053
978271 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0054 | 0054
978275 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0055 | 0055
978279 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0056 | 0056
978283 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0057 | 0057
978287 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0058 | 0058
978291 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0059 | 0059
978295 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0060 | 0060
978299 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0061 | 0061
978303 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0062 | 0062
978307 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0063 | 0063
978316 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0064 | 0064
978320 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0065 | 0065
978324 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | NZ04.01.0066 | 0066
978328 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | NZ04.01.0067 | 0067
978332 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | NZ04.01.0068 | 0068
978336 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | NZ04.01.0069 | 0069
978340 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | NZ04.01.0070 | 0070
978344 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | NZ04.01.0071 | 0071
978348 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | NZ04.01.0072 | 0072
978352 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | NZ04.01.0073 | 0073
978356 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | NZ04.01.0074 | 0074
978360 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0075 | 0075
978364 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | NZ04.01.0076 | 0076
978368 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | NZ04.01.0077 | 0077
978372 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | NZ04.01.0078 | 0078
978376 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | NZ04.01.0079 | 0079
978380 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | NZ04.01.0080 | 0080
978384 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0081 | 0081
978388 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0082 | 0082
978392 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0083 | 0083
978396 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0084 | 0084
978400 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0085 | 0085
978404 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0086 | 0086
978408 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0087 | 0087
978412 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0088 | 0088
978416 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0089 | 0089
978420 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0090 | 0090
978443 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0091 | 0091
978447 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0092 | 0092
978473 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0097 | 0097
978480 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0098 | 0098
978484 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0099 | 0099
978488 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0100 | 0100
978492 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0101 | 0101
978496 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0102 | 0102
978500 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0103 | 0103
978504 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0104 | 0104
978508 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0105 | 0105
978512 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0106 | 0106
978516 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0107 | 0107
978520 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0108 | 0108
978524 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0109 | 0109
978528 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0110 | 0110
978532 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0111 | 0111
978536 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0112 | 0112
978540 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0113 | 0113
978544 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0114 | 0114
978548 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0115 | 0115
978552 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0116 | 0116
978560 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0117 | 0117
978564 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0118 | 0118
978568 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0119 | 0119
978572 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0120 | 0120
978576 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0121 | 0121
978580 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0122 | 0122
978584 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0123 | 0123
978588 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0124 | 0124
978592 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0125 | 0125
978596 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0126 | 0126
978600 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0127 | 0127
978604 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0128 | 0128
978608 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0129 | 0129
978612 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0130 | 0130
978616 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0131 | 0131
978627 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0132 | 0132
978634 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0133 | 0133
978641 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0134 | 0134
978645 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0135 | 0135
978649 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0136 | 0136
978653 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0137 | 0137
978657 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0138 | 0138
978661 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0139 | 0139
978665 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0140 | 0140
978669 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0141 | 0141
978673 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0142 | 0142
978677 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | NZ04.01.0143 | 0143
978681 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | NZ04.01.0144 | 0144
978685 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | NZ04.01.0145 | 0145
978689 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | NZ04.01.0146 | 0146
978693 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | NZ04.01.0147 | 0147
978697 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | NZ04.01.0148 | 0148
978701 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0149 | 0149
978705 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0150 | 0150
978709 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0151 | 0151
978713 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0152 | 0152
978717 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0153 | 0153
978721 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | NZ04.01.0154 | 0154
978725 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | NZ04.01.0155 | 0155
978729 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | NZ04.01.0156 | 0156
978733 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | NZ04.01.0157 | 0157
978737 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | NZ04.01.0158 | 0158
978752 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0159 | 0159
978756 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0160 | 0160
978760 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0161 | 0161
978764 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0162 | 0162
978768 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0163 | 0163
978776 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0164 | 0164
978780 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0165 | 0165
978784 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0166 | 0166
978788 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0167 | 0167
978792 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0168 | 0168
978796 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0169 | 0169
978800 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0170 | 0170
978804 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0171 | 0171
978808 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0172 | 0172
978812 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0173 | 0173
978816 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0174 | 0174
978820 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0175 | 0175
978824 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0176 | 0176
978828 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0177 | 0177
978832 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0178 | 0178
978836 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0179 | 0179
978840 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0180 | 0180
978844 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0181 | 0181
978848 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0182 | 0182
978852 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0183 | 0183
978856 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0184 | 0184
978860 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0185 | 0185
978864 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0186 | 0186
978868 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0187 | 0187
978872 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0188 | 0188
978876 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0189 | 0189
978880 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 2 | NZ04.01.0190 | 0190
978884 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0191 | 0191
978888 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0192 | 0192
978892 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0193 | 0193
978896 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0194 | 0194
978900 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0195 | 0195
978907 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0196 | 0196
978911 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0197 | 0197
978918 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0198 | 0198
978925 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0199 | 0199
978929 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | Fáze 1 | NZ04.01.0200 | 0200
978946 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0201 | 0201
978950 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0202 | 0202
978954 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0203 | 0203
978958 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0204 | 0204
978962 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0205 | 0205
978966 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0206 | 0206
978970 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0207 | 0207
978974 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0208 | 0208
978978 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0209 | 0209
978982 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0210 | 0210
978986 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0211 | 0211
978990 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0212 | 0212
978994 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0213 | 0213
978998 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | NZ04.01.0214 | 0214
979002 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | NZ04.01.0215 | 0215
979006 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | NZ04.01.0216 | 0216
979010 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | NZ04.01.0217 | 0217
979014 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | NZ04.01.0218 | 0218
979022 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | NZ04.01.0219 | 0219
979026 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | NZ04.01.0220 | 0220
979030 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | NZ04.01.0221 | 0221
979034 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | NZ04.01.0222 | 0222
979038 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | NZ04.01.0223 | 0223
979042 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0224 | 0224
979046 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0225 | 0225
979050 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0226 | 0226
979054 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0227 | 0227
979058 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0228 | 0228
979062 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0229 | 0229
979066 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0230 | 0230
979070 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0231 | 0231
979074 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0232 | 0232
979078 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | NZ04.01.0233 | 0233
979082 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | NZ04.01.0234 | 0234
979086 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | NZ04.01.0235 | 0235
979090 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | NZ04.01.0236 | 0236
979094 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | NZ04.01.0237 | 0237
979098 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0238 | 0238
979311 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0239 | 0239
979358 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0240 | 0240
979362 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0241 | 0241
979366 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0242 | 0242
979370 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0243 | 0243
979374 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0244 | 0244
979456 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | NZ04.01.0245 | 0245
979502 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0246 | 0246
979836 | -2.PP_SO-102 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | Fáze 1 | NZ04.01.0248 | 0248
979844 | -2.PP_SO-102 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | Fáze 1 | NZ04.01.0249 | 0249
979852 | -2.PP_SO-102 | -2.PP_SO-102 | Podlaží : -2.PP_SO-102 | Fáze 1 | NZ04.01.0250 | 0250
1001438 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0255 | 0255 | Fázování - Fáze demolice: Fáze 1
1001460 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0256 | 0256 | Fázování - Fáze demolice: Fáze 1
1001483 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 1 | NZ04.01.0257 | 0257 | Fázování - Fáze demolice: Fáze 1
1001517 | 2.NP_SO-102 | 2.NP_SO-102 | Podlaží : 2.NP_SO-102 | Fáze 2 | NZ04.01.0258 | 0258
1001540 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 2 | NZ04.01.0259 | 0259
1001566 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0260 | 0260 | Fázování - Fáze demolice: Fáze 1
1001590 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 1 | NZ04.01.0261 | 0261
1001627 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | Fáze 2 | NZ04.01.0262 | 0262
1003991 | 1.NP_SO-102 | 1.NP_SO-102 | Podlaží : 1.NP_SO-102 | Fáze 1 | NZ04.01.0263 | 0263 | Fázování - Fáze demolice: Fáze 1
1004024 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0264 | 0264
1004049 | 3.NP_SO-102 | 3.NP_SO-102 | Podlaží : 3.NP_SO-102 | Fáze 1 | NZ04.01.0265 | 0265 | Fázování - Fáze demolice: Fáze 1

# IfcBuildingElementProxy: Reproduktory.CC:Projektorový reproduktor (6)
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - Počet fází: 1
Type - Grafika - Symbol: yes; Typ symbolu: Reproduktor typu projektor.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.10.11.14.21; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: NZ04; Komentáře k typům: projektorový; Model: Model; Nadpis OmniClass: Audio Reproducing Units; Název typu: Projektorový reproduktor; Označení typu: 02; Popis: Reproduktor; Popis sestavy: Reproduktory; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Komunikační zařízení; Název rodiny: Reproduktory.CC; Typ reproduktoru: Reproduktor_projektor.CC : Projektorový reproduktor
Classification: NZ04 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.103942 m2; NetVolume: 0.00264034 m3
Text - CCI Funkční systém: P; CCI Komponenta: PJA; CCI Technický systém: MA
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Svislá poloha: no
Kóty - Hloubka reproduktoru: 150 mm; Objem: 0.00264034 m3; Průměr reproduktoru: 150 mm
Jiné - Rodina: Reproduktory.CC; a: 75 mm; b: 18.75 mm; c: 10 mm; ch: 225 mm; d: 5 mm; e: 40 mm; f: 60 mm; g: 10 mm; h: 5 mm; Id typu: 976678; JMENOVITÝ PŘÍKON REPRODUKTORU: 0 W; NASTAVENÝ PŘÍKON REPRODUKTORU: 0 W; Rodina a typ: Reproduktory.CC: Projektorový reproduktor; Typ: Projektorový reproduktor; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 10:54
Name (Reproduktory.CC:Projektorový reproduktor:...) | In | Podlaží | Hostitel | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
976935 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | NZ04.02.0047 | 0047
976939 | -1.PP_SO-102 | -1.PP_SO-102 | Podlaží : -1.PP_SO-102 | 2500 | NZ04.02.0048 | 0048
979876 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 0 | NZ04.02.0251 | 0251
979880 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 0 | NZ04.02.0252 | 0252
979889 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 0 | NZ04.02.0253 | 0253
979893 | 4.NP_SO-102 | 4.NP_SO-102 | Podlaží : 4.NP_SO-102 | 0 | NZ04.02.0254 | 0254

# IfcBuildingElementProxy: Reproduktory.CC:Tlakový reproduktor (6)
In: 1.NP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Elektrotechnika - Počet fází: 1
Type - Grafika - Symbol: yes; Typ symbolu: Reproduktor tlakový.CC
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.10.11.14.21; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: NZ04; Komentáře k typům: tlakový; Model: Model; Nadpis OmniClass: Audio Reproducing Units; Název typu: Tlakový reproduktor; Označení typu: 04; Popis: Reproduktor; Popis sestavy: Reproduktory; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Komunikační zařízení; Název rodiny: Reproduktory.CC; Typ reproduktoru: Reproduktor_tlakový.CC : Tlakový reproduktor
Classification: NZ04 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 0.105388 m2; NetVolume: 0.000657939 m3
Text - CCI Funkční systém: P; CCI Komponenta: PJA; CCI Technický systém: MA
Vazby - Podlaží: 1.NP_SO-102; Hostitel: Podlaží : 1.NP_SO-102
Fázování - Fáze vytvoření: Fáze 1
Grafika - Posun horizontální: 0; Posun vertikální: 0; Svislá poloha: no
Kóty - Hloubka reproduktoru: 150 mm; Objem: 0.000657939 m3; Průměr reproduktoru: 150 mm
Jiné - Rodina: Reproduktory.CC; a: 75 mm; b: 18.75 mm; c: 10 mm; ch: 225 mm; d: 5 mm; e: 40 mm; f: 60 mm; g: 10 mm; h: 5 mm; Id typu: 976676; JMENOVITÝ PŘÍKON REPRODUKTORU: 0 W; NASTAVENÝ PŘÍKON REPRODUKTORU: 0 W; Rodina a typ: Reproduktory.CC: Tlakový reproduktor; Typ: Tlakový reproduktor; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 10:04
Name (Reproduktory.CC:Tlakový reproduktor:...) | Odsazení od hostitele (mm) = Výška od podlaží (mm) | Kód prvku | Označení
978237 | 4000 | NZ04.04.0050 | 0050
978241 | 4000 | NZ04.04.0051 | 0051
978454 | 0 | NZ04.04.0093 | 0093
978458 | 0 | NZ04.04.0094 | 0094
978462 | 0 | NZ04.04.0095 | 0095
978466 | 0 | NZ04.04.0096 | 0096

# IfcBuildingElementProxy: Rozhlasová ústředna v rozvaděči rack.CC:Rozhlasová ústředna v rozvaděči rack.CC, Rozhlasová ústředna v rozvaděči rack.CC:Rozhlasová ústředna v rozvaděči rack.CC:968150
In: -2.PP_SO-102
Type - Material: <Unnamed>
Type - Vazby - Výchozí výška: 0 mm
Type - Identifikační data - Cena: 0; Číslo OmniClass: 23.85.10.00; COPYRIGHT: © cadconsulting, spol. s r.o.; Kód sestavy: NZ00; Komentáře k typům: rozhlasová, v rozvaděči, RACK; Model: Model; Nadpis OmniClass: General Information Systems; Název typu: Rozhlasová ústředna v rozvaděči rack.CC; Označení typu: 01; Popis: Ústředna; Popis sestavy: Obecný prvek; URL: www.cadconsulting.cz; Výrobce: Výrobce
Type - Jiné - Kategorie: Elektrické vybavení; Název rodiny: Rozhlasová ústředna v rozvaděči rack.CC
Classification: NZ00 Uniformat (Uniformat)
Qto_BuildingElementProxyQuantities - NetSurfaceArea: 8.63868 m2; NetVolume: 1.52275 m3
Elektroinstalace – obvody - TEPELNÁ ZTRÁTA: 0 W; Údaje k elektroinstalaci: 0 V/1-0.0 kW
Elektroinstalace - PŘÍKON: 0 W
Elektroinstalace – zatížení - PŘÍKON 2: 0 W; PŘÍKON 3: 0 W
Text - CCI Funkční systém: P; CCI Komponenta: XDC; CCI Technický systém: MA
Vazby - Hostitel: Podlaží : -2.PP_SO-102; Odsazení od hostitele: 0 mm; Podlaží: -2.PP_SO-102; Výška od podlaží: 0 mm
Fázování - Fáze vytvoření: Fáze 1
Elektrotechnika - NAPĚTÍ: 0 V; POČET FÁZÍ: 1
Grafika - Posun horizontální: 0; Posun vertikální: 0
Kóty - HLOUBKA: 960 mm; Objem: 1.52275 m3; ŠÍŘKA: 800 mm; VÝŠKA: 2000 mm
Identifikační data - Kód prvku: NZ00.01.0001; Označení: 0001
Jiné - Id typu: 968134; OH: 1000 mm; Páteřní trasa: yes; Rodina: Rozhlasová ústředna v rozvaděči rack.CC; Rodina a typ: Rozhlasová ústředna v rozvaděči rack.CC: Rozhlasová ústředna v rozvaděči rack.CC; Typ: Rozhlasová ústředna v rozvaděči rack.CC; UPRAVIL: Fruhauf.vinarice@seznam.cz 2023.06.26 10:04

# IfcDistributionPort (267)
Description: Flow; FlowDirection: SOURCEANDSINK; PredefinedType: CABLE
Name | SystemType
Port_968150_1 | VENTILATION
Port_968150_2 | ELECTRICAL
Port_976698_1 | VENTILATION
Port_976738_1 | VENTILATION
Port_976748_1 | VENTILATION
Port_976752_1 | VENTILATION
Port_976756_1 | VENTILATION
Port_976760_1 | VENTILATION
Port_976764_1 | VENTILATION
Port_976768_1 | VENTILATION
Port_976772_1 | VENTILATION
Port_976776_1 | VENTILATION
Port_976780_1 | VENTILATION
Port_976784_1 | VENTILATION
Port_976788_1 | VENTILATION
Port_976792_1 | VENTILATION
Port_976796_1 | VENTILATION
Port_976800_1 | VENTILATION
Port_976804_1 | VENTILATION
Port_976808_1 | VENTILATION
Port_976820_1 | VENTILATION
Port_976824_1 | VENTILATION
Port_976828_1 | VENTILATION
Port_976832_1 | VENTILATION
Port_976836_1 | VENTILATION
Port_976840_1 | VENTILATION
Port_976844_1 | VENTILATION
Port_976848_1 | VENTILATION
Port_976852_1 | VENTILATION
Port_976856_1 | VENTILATION
Port_976860_1 | VENTILATION
Port_976864_1 | VENTILATION
Port_976868_1 | VENTILATION
Port_976872_1 | VENTILATION
Port_976876_1 | VENTILATION
Port_976880_1 | VENTILATION
Port_976884_1 | VENTILATION
Port_976888_1 | VENTILATION
Port_976892_1 | VENTILATION
Port_976896_1 | VENTILATION
Port_976900_1 | VENTILATION
Port_976904_1 | VENTILATION
Port_976908_1 | VENTILATION
Port_976912_1 | VENTILATION
Port_976916_1 | VENTILATION
Port_976920_1 | VENTILATION
Port_976924_1 | VENTILATION
Port_976928_1 | VENTILATION
Port_976935_1 | VENTILATION
Port_976939_1 | VENTILATION
Port_978228_1 | VENTILATION
Port_978237_1 | VENTILATION
Port_978241_1 | VENTILATION
Port_978263_1 | VENTILATION
Port_978267_1 | VENTILATION
Port_978271_1 | VENTILATION
Port_978275_1 | VENTILATION
Port_978279_1 | VENTILATION
Port_978283_1 | VENTILATION
Port_978287_1 | VENTILATION
Port_978291_1 | VENTILATION
Port_978295_1 | VENTILATION
Port_978299_1 | VENTILATION
Port_978303_1 | VENTILATION
Port_978307_1 | VENTILATION
Port_978316_1 | VENTILATION
Port_978320_1 | VENTILATION
Port_978324_1 | VENTILATION
Port_978328_1 | VENTILATION
Port_978332_1 | VENTILATION
Port_978336_1 | VENTILATION
Port_978340_1 | VENTILATION
Port_978344_1 | VENTILATION
Port_978348_1 | VENTILATION
Port_978352_1 | VENTILATION
Port_978356_1 | VENTILATION
Port_978360_1 | VENTILATION
Port_978364_1 | VENTILATION
Port_978368_1 | VENTILATION
Port_978372_1 | VENTILATION
Port_978376_1 | VENTILATION
Port_978380_1 | VENTILATION
Port_978384_1 | VENTILATION
Port_978388_1 | VENTILATION
Port_978392_1 | VENTILATION
Port_978396_1 | VENTILATION
Port_978400_1 | VENTILATION
Port_978404_1 | VENTILATION
Port_978408_1 | VENTILATION
Port_978412_1 | VENTILATION
Port_978416_1 | VENTILATION
Port_978420_1 | VENTILATION
Port_978443_1 | VENTILATION
Port_978447_1 | VENTILATION
Port_978454_1 | VENTILATION
Port_978458_1 | VENTILATION
Port_978462_1 | VENTILATION
Port_978466_1 | VENTILATION
Port_978473_1 | VENTILATION
Port_978480_1 | VENTILATION
Port_978484_1 | VENTILATION
Port_978488_1 | VENTILATION
Port_978492_1 | VENTILATION
Port_978496_1 | VENTILATION
Port_978500_1 | VENTILATION
Port_978504_1 | VENTILATION
Port_978508_1 | VENTILATION
Port_978512_1 | VENTILATION
Port_978516_1 | VENTILATION
Port_978520_1 | VENTILATION
Port_978524_1 | VENTILATION
Port_978528_1 | VENTILATION
Port_978532_1 | VENTILATION
Port_978536_1 | VENTILATION
Port_978540_1 | VENTILATION
Port_978544_1 | VENTILATION
Port_978548_1 | VENTILATION
Port_978552_1 | VENTILATION
Port_978560_1 | VENTILATION
Port_978564_1 | VENTILATION
Port_978568_1 | VENTILATION
Port_978572_1 | VENTILATION
Port_978576_1 | VENTILATION
Port_978580_1 | VENTILATION
Port_978584_1 | VENTILATION
Port_978588_1 | VENTILATION
Port_978592_1 | VENTILATION
Port_978596_1 | VENTILATION
Port_978600_1 | VENTILATION
Port_978604_1 | VENTILATION
Port_978608_1 | VENTILATION
Port_978612_1 | VENTILATION
Port_978616_1 | VENTILATION
Port_978627_1 | VENTILATION
Port_978634_1 | VENTILATION
Port_978641_1 | VENTILATION
Port_978645_1 | VENTILATION
Port_978649_1 | VENTILATION
Port_978653_1 | VENTILATION
Port_978657_1 | VENTILATION
Port_978661_1 | VENTILATION
Port_978665_1 | VENTILATION
Port_978669_1 | VENTILATION
Port_978673_1 | VENTILATION
Port_978677_1 | VENTILATION
Port_978681_1 | VENTILATION
Port_978685_1 | VENTILATION
Port_978689_1 | VENTILATION
Port_978693_1 | VENTILATION
Port_978697_1 | VENTILATION
Port_978701_1 | VENTILATION
Port_978705_1 | VENTILATION
Port_978709_1 | VENTILATION
Port_978713_1 | VENTILATION
Port_978717_1 | VENTILATION
Port_978721_1 | VENTILATION
Port_978725_1 | VENTILATION
Port_978729_1 | VENTILATION
Port_978733_1 | VENTILATION
Port_978737_1 | VENTILATION
Port_978752_1 | VENTILATION
Port_978756_1 | VENTILATION
Port_978760_1 | VENTILATION
Port_978764_1 | VENTILATION
Port_978768_1 | VENTILATION
Port_978776_1 | VENTILATION
Port_978780_1 | VENTILATION
Port_978784_1 | VENTILATION
Port_978788_1 | VENTILATION
Port_978792_1 | VENTILATION
Port_978796_1 | VENTILATION
Port_978800_1 | VENTILATION
Port_978804_1 | VENTILATION
Port_978808_1 | VENTILATION
Port_978812_1 | VENTILATION
Port_978816_1 | VENTILATION
Port_978820_1 | VENTILATION
Port_978824_1 | VENTILATION
Port_978828_1 | VENTILATION
Port_978832_1 | VENTILATION
Port_978836_1 | VENTILATION
Port_978840_1 | VENTILATION
Port_978844_1 | VENTILATION
Port_978848_1 | VENTILATION
Port_978852_1 | VENTILATION
Port_978856_1 | VENTILATION
Port_978860_1 | VENTILATION
Port_978864_1 | VENTILATION
Port_978868_1 | VENTILATION
Port_978872_1 | VENTILATION
Port_978876_1 | VENTILATION
Port_978880_1 | VENTILATION
Port_978884_1 | VENTILATION
Port_978888_1 | VENTILATION
Port_978892_1 | VENTILATION
Port_978896_1 | VENTILATION
Port_978900_1 | VENTILATION
Port_978907_1 | VENTILATION
Port_978911_1 | VENTILATION
Port_978918_1 | VENTILATION
Port_978925_1 | VENTILATION
Port_978929_1 | VENTILATION
Port_978946_1 | VENTILATION
Port_978950_1 | VENTILATION
Port_978954_1 | VENTILATION
Port_978958_1 | VENTILATION
Port_978962_1 | VENTILATION
Port_978966_1 | VENTILATION
Port_978970_1 | VENTILATION
Port_978974_1 | VENTILATION
Port_978978_1 | VENTILATION
Port_978982_1 | VENTILATION
Port_978986_1 | VENTILATION
Port_978990_1 | VENTILATION
Port_978994_1 | VENTILATION
Port_978998_1 | VENTILATION
Port_979002_1 | VENTILATION
Port_979006_1 | VENTILATION
Port_979010_1 | VENTILATION
Port_979014_1 | VENTILATION
Port_979022_1 | VENTILATION
Port_979026_1 | VENTILATION
Port_979030_1 | VENTILATION
Port_979034_1 | VENTILATION
Port_979038_1 | VENTILATION
Port_979042_1 | VENTILATION
Port_979046_1 | VENTILATION
Port_979050_1 | VENTILATION
Port_979054_1 | VENTILATION
Port_979058_1 | VENTILATION
Port_979062_1 | VENTILATION
Port_979066_1 | VENTILATION
Port_979070_1 | VENTILATION
Port_979074_1 | VENTILATION
Port_979078_1 | VENTILATION
Port_979082_1 | VENTILATION
Port_979086_1 | VENTILATION
Port_979090_1 | VENTILATION
Port_979094_1 | VENTILATION
Port_979098_1 | VENTILATION
Port_979311_1 | VENTILATION
Port_979358_1 | VENTILATION
Port_979362_1 | VENTILATION
Port_979366_1 | VENTILATION
Port_979370_1 | VENTILATION
Port_979374_1 | VENTILATION
Port_979456_1 | VENTILATION
Port_979502_1 | VENTILATION
Port_979573_1 | VENTILATION
Port_979836_1 | VENTILATION
Port_979844_1 | VENTILATION
Port_979852_1 | VENTILATION
Port_979876_1 | VENTILATION
Port_979880_1 | VENTILATION
Port_979889_1 | VENTILATION
Port_979893_1 | VENTILATION
Port_1001438_1 | VENTILATION
Port_1001460_1 | VENTILATION
Port_1001483_1 | VENTILATION
Port_1001517_1 | VENTILATION
Port_1001540_1 | VENTILATION
Port_1001566_1 | VENTILATION
Port_1001590_1 | VENTILATION
Port_1001627_1 | VENTILATION
Port_1003991_1 | VENTILATION
Port_1004024_1 | VENTILATION
Port_1004049_1 | VENTILATION
